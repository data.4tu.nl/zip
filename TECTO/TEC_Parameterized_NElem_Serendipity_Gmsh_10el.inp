12615, 0.79166666666667, 1.375, 0.5
12616, 0.83333333333333, 1.375, 0.5
12617, 0.875, 1.375, 0.5
12618, 0.91666666666667, 1.375, 0.5
12619, 0.95833333333333, 1.375, 0.5
12620, 0, 1.375, 0.041666666666667
12621, 0, 1.375, 0.083333333333333
12622, 0, 1.375, 0.125
12623, 0, 1.375, 0.16666666666667
12624, 0, 1.375, 0.20833333333333
12625, 0, 1.375, 0.25
12626, 0, 1.375, 0.29166666666667
12627, 0, 1.375, 0.33333333333333
12628, 0, 1.375, 0.375
12629, 0, 1.375, 0.41666666666667
12630, 0, 1.375, 0.45833333333333
12631, 0.041666666666667, 1.4, 0.041666666666667
12632, 0.041666666666667, 1.4, 0.083333333333333
12633, 0.041666666666667, 1.4, 0.125
12634, 0.041666666666667, 1.4, 0.16666666666667
12635, 0.041666666666667, 1.4, 0.20833333333333
12636, 0.041666666666667, 1.4, 0.25
12637, 0.041666666666667, 1.4, 0.29166666666667
12638, 0.041666666666667, 1.4, 0.33333333333333
12639, 0.041666666666667, 1.4, 0.375
12640, 0.041666666666667, 1.4, 0.41666666666667
12641, 0.041666666666667, 1.4, 0.45833333333333
12642, 0.083333333333333, 1.4, 0.041666666666667
12643, 0.083333333333333, 1.4, 0.083333333333333
12644, 0.083333333333333, 1.4, 0.125
12645, 0.083333333333333, 1.4, 0.16666666666667
12646, 0.083333333333333, 1.4, 0.20833333333333
12647, 0.083333333333333, 1.4, 0.25
12648, 0.083333333333333, 1.4, 0.29166666666667
12649, 0.083333333333333, 1.4, 0.33333333333333
12650, 0.083333333333333, 1.4, 0.375
12651, 0.083333333333333, 1.4, 0.41666666666667
12652, 0.083333333333333, 1.4, 0.45833333333333
12653, 0.125, 1.4, 0.041666666666667
12654, 0.125, 1.4, 0.083333333333333
12655, 0.125, 1.4, 0.125
12656, 0.125, 1.4, 0.16666666666667
12657, 0.125, 1.4, 0.20833333333333
12658, 0.125, 1.4, 0.25
12659, 0.125, 1.4, 0.29166666666667
12660, 0.125, 1.4, 0.33333333333333
12661, 0.125, 1.4, 0.375
12662, 0.125, 1.4, 0.41666666666667
12663, 0.125, 1.4, 0.45833333333333
12664, 0.16666666666667, 1.4, 0.041666666666667
12665, 0.16666666666667, 1.4, 0.083333333333333
12666, 0.16666666666667, 1.4, 0.125
12667, 0.16666666666667, 1.4, 0.16666666666667
12668, 0.16666666666667, 1.4, 0.20833333333333
12669, 0.16666666666667, 1.4, 0.25
12670, 0.16666666666667, 1.4, 0.29166666666667
12671, 0.16666666666667, 1.4, 0.33333333333333
12672, 0.16666666666667, 1.4, 0.375
12673, 0.16666666666667, 1.4, 0.41666666666667
12674, 0.16666666666667, 1.4, 0.45833333333333
12675, 0.20833333333333, 1.4, 0.041666666666667
12676, 0.20833333333333, 1.4, 0.083333333333333
12677, 0.20833333333333, 1.4, 0.125
12678, 0.20833333333333, 1.4, 0.16666666666667
12679, 0.20833333333333, 1.4, 0.20833333333333
12680, 0.20833333333333, 1.4, 0.25
12681, 0.20833333333333, 1.4, 0.29166666666667
12682, 0.20833333333333, 1.4, 0.33333333333333
12683, 0.20833333333333, 1.4, 0.375
12684, 0.20833333333333, 1.4, 0.41666666666667
12685, 0.20833333333333, 1.4, 0.45833333333333
12686, 0.25, 1.4, 0.041666666666667
12687, 0.25, 1.4, 0.083333333333333
12688, 0.25, 1.4, 0.125
12689, 0.25, 1.4, 0.16666666666667
12690, 0.25, 1.4, 0.20833333333333
12691, 0.25, 1.4, 0.25
12692, 0.25, 1.4, 0.29166666666667
12693, 0.25, 1.4, 0.33333333333333
12694, 0.25, 1.4, 0.375
12695, 0.25, 1.4, 0.41666666666667
12696, 0.25, 1.4, 0.45833333333333
12697, 0.29166666666667, 1.4, 0.041666666666667
12698, 0.29166666666667, 1.4, 0.083333333333333
12699, 0.29166666666667, 1.4, 0.125
12700, 0.29166666666667, 1.4, 0.16666666666667
12701, 0.29166666666667, 1.4, 0.20833333333333
12702, 0.29166666666667, 1.4, 0.25
12703, 0.29166666666667, 1.4, 0.29166666666667
12704, 0.29166666666667, 1.4, 0.33333333333333
12705, 0.29166666666667, 1.4, 0.375
12706, 0.29166666666667, 1.4, 0.41666666666667
12707, 0.29166666666667, 1.4, 0.45833333333333
12708, 0.33333333333333, 1.4, 0.041666666666667
12709, 0.33333333333333, 1.4, 0.083333333333333
12710, 0.33333333333333, 1.4, 0.125
12711, 0.33333333333333, 1.4, 0.16666666666667
12712, 0.33333333333333, 1.4, 0.20833333333333
12713, 0.33333333333333, 1.4, 0.25
12714, 0.33333333333333, 1.4, 0.29166666666667
12715, 0.33333333333333, 1.4, 0.33333333333333
12716, 0.33333333333333, 1.4, 0.375
12717, 0.33333333333333, 1.4, 0.41666666666667
12718, 0.33333333333333, 1.4, 0.45833333333333
12719, 0.375, 1.4, 0.041666666666667
12720, 0.375, 1.4, 0.083333333333333
12721, 0.375, 1.4, 0.125
12722, 0.375, 1.4, 0.16666666666667
12723, 0.375, 1.4, 0.20833333333333
12724, 0.375, 1.4, 0.25
12725, 0.375, 1.4, 0.29166666666667
12726, 0.375, 1.4, 0.33333333333333
12727, 0.375, 1.4, 0.375
12728, 0.375, 1.4, 0.41666666666667
12729, 0.375, 1.4, 0.45833333333333
12730, 0.41666666666667, 1.4, 0.041666666666667
12731, 0.41666666666667, 1.4, 0.083333333333333
12732, 0.41666666666667, 1.4, 0.125
12733, 0.41666666666667, 1.4, 0.16666666666667
12734, 0.41666666666667, 1.4, 0.20833333333333
12735, 0.41666666666667, 1.4, 0.25
12736, 0.41666666666667, 1.4, 0.29166666666667
12737, 0.41666666666667, 1.4, 0.33333333333333
12738, 0.41666666666667, 1.4, 0.375
12739, 0.41666666666667, 1.4, 0.41666666666667
12740, 0.41666666666667, 1.4, 0.45833333333333
12741, 0.45833333333333, 1.4, 0.041666666666667
12742, 0.45833333333333, 1.4, 0.083333333333333
12743, 0.45833333333333, 1.4, 0.125
12744, 0.45833333333333, 1.4, 0.16666666666667
12745, 0.45833333333333, 1.4, 0.20833333333333
12746, 0.45833333333333, 1.4, 0.25
12747, 0.45833333333333, 1.4, 0.29166666666667
12748, 0.45833333333333, 1.4, 0.33333333333333
12749, 0.45833333333333, 1.4, 0.375
12750, 0.45833333333333, 1.4, 0.41666666666667
12751, 0.45833333333333, 1.4, 0.45833333333333
12752, 0.5, 1.4, 0.041666666666667
12753, 0.5, 1.4, 0.083333333333333
12754, 0.5, 1.4, 0.125
12755, 0.5, 1.4, 0.16666666666667
12756, 0.5, 1.4, 0.20833333333333
12757, 0.5, 1.4, 0.25
12758, 0.5, 1.4, 0.29166666666667
12759, 0.5, 1.4, 0.33333333333333
12760, 0.5, 1.4, 0.375
12761, 0.5, 1.4, 0.41666666666667
12762, 0.5, 1.4, 0.45833333333333
12763, 0.54166666666667, 1.4, 0.041666666666667
12764, 0.54166666666667, 1.4, 0.083333333333333
12765, 0.54166666666667, 1.4, 0.125
12766, 0.54166666666667, 1.4, 0.16666666666667
12767, 0.54166666666667, 1.4, 0.20833333333333
12768, 0.54166666666667, 1.4, 0.25
12769, 0.54166666666667, 1.4, 0.29166666666667
12770, 0.54166666666667, 1.4, 0.33333333333333
12771, 0.54166666666667, 1.4, 0.375
12772, 0.54166666666667, 1.4, 0.41666666666667
12773, 0.54166666666667, 1.4, 0.45833333333333
12774, 0.58333333333333, 1.4, 0.041666666666667
12775, 0.58333333333333, 1.4, 0.083333333333333
12776, 0.58333333333333, 1.4, 0.125
12777, 0.58333333333333, 1.4, 0.16666666666667
12778, 0.58333333333333, 1.4, 0.20833333333333
12779, 0.58333333333333, 1.4, 0.25
12780, 0.58333333333333, 1.4, 0.29166666666667
12781, 0.58333333333333, 1.4, 0.33333333333333
12782, 0.58333333333333, 1.4, 0.375
12783, 0.58333333333333, 1.4, 0.41666666666667
12784, 0.58333333333333, 1.4, 0.45833333333333
12785, 0.625, 1.4, 0.041666666666667
12786, 0.625, 1.4, 0.083333333333333
12787, 0.625, 1.4, 0.125
12788, 0.625, 1.4, 0.16666666666667
12789, 0.625, 1.4, 0.20833333333333
12790, 0.625, 1.4, 0.25
12791, 0.625, 1.4, 0.29166666666667
12792, 0.625, 1.4, 0.33333333333333
12793, 0.625, 1.4, 0.375
12794, 0.625, 1.4, 0.41666666666667
12795, 0.625, 1.4, 0.45833333333333
12796, 0.66666666666667, 1.4, 0.041666666666667
12797, 0.66666666666667, 1.4, 0.083333333333333
12798, 0.66666666666667, 1.4, 0.125
12799, 0.66666666666667, 1.4, 0.16666666666667
12800, 0.66666666666667, 1.4, 0.20833333333333
12801, 0.66666666666667, 1.4, 0.25
12802, 0.66666666666667, 1.4, 0.29166666666667
12803, 0.66666666666667, 1.4, 0.33333333333333
12804, 0.66666666666667, 1.4, 0.375
12805, 0.66666666666667, 1.4, 0.41666666666667
12806, 0.66666666666667, 1.4, 0.45833333333333
12807, 0.70833333333333, 1.4, 0.041666666666667
12808, 0.70833333333333, 1.4, 0.083333333333333
12809, 0.70833333333333, 1.4, 0.125
12810, 0.70833333333333, 1.4, 0.16666666666667
12811, 0.70833333333333, 1.4, 0.20833333333333
12812, 0.70833333333333, 1.4, 0.25
12813, 0.70833333333333, 1.4, 0.29166666666667
12814, 0.70833333333333, 1.4, 0.33333333333333
12815, 0.70833333333333, 1.4, 0.375
12816, 0.70833333333333, 1.4, 0.41666666666667
12817, 0.70833333333333, 1.4, 0.45833333333333
12818, 0.75, 1.4, 0.041666666666667
12819, 0.75, 1.4, 0.083333333333333
12820, 0.75, 1.4, 0.125
12821, 0.75, 1.4, 0.16666666666667
12822, 0.75, 1.4, 0.20833333333333
12823, 0.75, 1.4, 0.25
12824, 0.75, 1.4, 0.29166666666667
12825, 0.75, 1.4, 0.33333333333333
12826, 0.75, 1.4, 0.375
12827, 0.75, 1.4, 0.41666666666667
12828, 0.75, 1.4, 0.45833333333333
12829, 0.79166666666667, 1.4, 0.041666666666667
12830, 0.79166666666667, 1.4, 0.083333333333333
12831, 0.79166666666667, 1.4, 0.125
12832, 0.79166666666667, 1.4, 0.16666666666667
12833, 0.79166666666667, 1.4, 0.20833333333333
12834, 0.79166666666667, 1.4, 0.25
12835, 0.79166666666667, 1.4, 0.29166666666667
12836, 0.79166666666667, 1.4, 0.33333333333333
12837, 0.79166666666667, 1.4, 0.375
12838, 0.79166666666667, 1.4, 0.41666666666667
12839, 0.79166666666667, 1.4, 0.45833333333333
12840, 0.83333333333333, 1.4, 0.041666666666667
12841, 0.83333333333333, 1.4, 0.083333333333333
12842, 0.83333333333333, 1.4, 0.125
12843, 0.83333333333333, 1.4, 0.16666666666667
12844, 0.83333333333333, 1.4, 0.20833333333333
12845, 0.83333333333333, 1.4, 0.25
12846, 0.83333333333333, 1.4, 0.29166666666667
12847, 0.83333333333333, 1.4, 0.33333333333333
12848, 0.83333333333333, 1.4, 0.375
12849, 0.83333333333333, 1.4, 0.41666666666667
12850, 0.83333333333333, 1.4, 0.45833333333333
12851, 0.875, 1.4, 0.041666666666667
12852, 0.875, 1.4, 0.083333333333333
12853, 0.875, 1.4, 0.125
12854, 0.875, 1.4, 0.16666666666667
12855, 0.875, 1.4, 0.20833333333333
12856, 0.875, 1.4, 0.25
12857, 0.875, 1.4, 0.29166666666667
12858, 0.875, 1.4, 0.33333333333333
12859, 0.875, 1.4, 0.375
12860, 0.875, 1.4, 0.41666666666667
12861, 0.875, 1.4, 0.45833333333333
12862, 0.91666666666667, 1.4, 0.041666666666667
12863, 0.91666666666667, 1.4, 0.083333333333333
12864, 0.91666666666667, 1.4, 0.125
12865, 0.91666666666667, 1.4, 0.16666666666667
12866, 0.91666666666667, 1.4, 0.20833333333333
12867, 0.91666666666667, 1.4, 0.25
12868, 0.91666666666667, 1.4, 0.29166666666667
12869, 0.91666666666667, 1.4, 0.33333333333333
12870, 0.91666666666667, 1.4, 0.375
12871, 0.91666666666667, 1.4, 0.41666666666667
12872, 0.91666666666667, 1.4, 0.45833333333333
12873, 0.95833333333333, 1.4, 0.041666666666667
12874, 0.95833333333333, 1.4, 0.083333333333333
12875, 0.95833333333333, 1.4, 0.125
12876, 0.95833333333333, 1.4, 0.16666666666667
12877, 0.95833333333333, 1.4, 0.20833333333333
12878, 0.95833333333333, 1.4, 0.25
12879, 0.95833333333333, 1.4, 0.29166666666667
12880, 0.95833333333333, 1.4, 0.33333333333333
12881, 0.95833333333333, 1.4, 0.375
12882, 0.95833333333333, 1.4, 0.41666666666667
12883, 0.95833333333333, 1.4, 0.45833333333333
12884, 0.020833333333333, 1.4, 0.041666666666667
12885, 0.041666666666667, 1.4, 0.020833333333333
12886, 0.020833333333333, 1.4, 0.083333333333333
12887, 0.041666666666667, 1.4, 0.0625
12888, 0.020833333333333, 1.4, 0.125
12889, 0.041666666666667, 1.4, 0.10416666666667
12890, 0.020833333333333, 1.4, 0.16666666666667
12891, 0.041666666666667, 1.4, 0.14583333333333
12892, 0.020833333333333, 1.4, 0.20833333333333
12893, 0.041666666666667, 1.4, 0.1875
12894, 0.020833333333333, 1.4, 0.25
12895, 0.041666666666667, 1.4, 0.22916666666667
12896, 0.020833333333333, 1.4, 0.29166666666667
12897, 0.041666666666667, 1.4, 0.27083333333333
12898, 0.020833333333333, 1.4, 0.33333333333333
12899, 0.041666666666667, 1.4, 0.3125
12900, 0.020833333333333, 1.4, 0.375
12901, 0.041666666666667, 1.4, 0.35416666666667
12902, 0.020833333333333, 1.4, 0.41666666666667
12903, 0.041666666666667, 1.4, 0.39583333333333
12904, 0.020833333333333, 1.4, 0.45833333333333
12905, 0.041666666666667, 1.4, 0.4375
12906, 0.041666666666667, 1.4, 0.47916666666667
12907, 0.0625, 1.4, 0.041666666666667
12908, 0.083333333333333, 1.4, 0.020833333333333
12909, 0.0625, 1.4, 0.083333333333333
12910, 0.083333333333333, 1.4, 0.0625
12911, 0.0625, 1.4, 0.125
12912, 0.083333333333333, 1.4, 0.10416666666667
12913, 0.0625, 1.4, 0.16666666666667
12914, 0.083333333333333, 1.4, 0.14583333333333
12915, 0.0625, 1.4, 0.20833333333333
12916, 0.083333333333333, 1.4, 0.1875
12917, 0.0625, 1.4, 0.25
12918, 0.083333333333333, 1.4, 0.22916666666667
12919, 0.0625, 1.4, 0.29166666666667
12920, 0.083333333333333, 1.4, 0.27083333333333
12921, 0.0625, 1.4, 0.33333333333333
12922, 0.083333333333333, 1.4, 0.3125
12923, 0.0625, 1.4, 0.375
12924, 0.083333333333333, 1.4, 0.35416666666667
12925, 0.0625, 1.4, 0.41666666666667
12926, 0.083333333333333, 1.4, 0.39583333333333
12927, 0.0625, 1.4, 0.45833333333333
12928, 0.083333333333333, 1.4, 0.4375
12929, 0.083333333333333, 1.4, 0.47916666666667
12930, 0.10416666666667, 1.4, 0.041666666666667
12931, 0.125, 1.4, 0.020833333333333
12932, 0.10416666666667, 1.4, 0.083333333333333
12933, 0.125, 1.4, 0.0625
12934, 0.10416666666667, 1.4, 0.125
12935, 0.125, 1.4, 0.10416666666667
12936, 0.10416666666667, 1.4, 0.16666666666667
12937, 0.125, 1.4, 0.14583333333333
12938, 0.10416666666667, 1.4, 0.20833333333333
12939, 0.125, 1.4, 0.1875
12940, 0.10416666666667, 1.4, 0.25
12941, 0.125, 1.4, 0.22916666666667
12942, 0.10416666666667, 1.4, 0.29166666666667
12943, 0.125, 1.4, 0.27083333333333
12944, 0.10416666666667, 1.4, 0.33333333333333
12945, 0.125, 1.4, 0.3125
12946, 0.10416666666667, 1.4, 0.375
12947, 0.125, 1.4, 0.35416666666667
12948, 0.10416666666667, 1.4, 0.41666666666667
12949, 0.125, 1.4, 0.39583333333333
12950, 0.10416666666667, 1.4, 0.45833333333333
12951, 0.125, 1.4, 0.4375
12952, 0.125, 1.4, 0.47916666666667
12953, 0.14583333333333, 1.4, 0.041666666666667
12954, 0.16666666666667, 1.4, 0.020833333333333
12955, 0.14583333333333, 1.4, 0.083333333333333
12956, 0.16666666666667, 1.4, 0.0625
12957, 0.14583333333333, 1.4, 0.125
12958, 0.16666666666667, 1.4, 0.10416666666667
12959, 0.14583333333333, 1.4, 0.16666666666667
12960, 0.16666666666667, 1.4, 0.14583333333333
12961, 0.14583333333333, 1.4, 0.20833333333333
12962, 0.16666666666667, 1.4, 0.1875
12963, 0.14583333333333, 1.4, 0.25
12964, 0.16666666666667, 1.4, 0.22916666666667
12965, 0.14583333333333, 1.4, 0.29166666666667
12966, 0.16666666666667, 1.4, 0.27083333333333
12967, 0.14583333333333, 1.4, 0.33333333333333
12968, 0.16666666666667, 1.4, 0.3125
12969, 0.14583333333333, 1.4, 0.375
12970, 0.16666666666667, 1.4, 0.35416666666667
12971, 0.14583333333333, 1.4, 0.41666666666667
12972, 0.16666666666667, 1.4, 0.39583333333333
12973, 0.14583333333333, 1.4, 0.45833333333333
12974, 0.16666666666667, 1.4, 0.4375
12975, 0.16666666666667, 1.4, 0.47916666666667
12976, 0.1875, 1.4, 0.041666666666667
12977, 0.20833333333333, 1.4, 0.020833333333333
12978, 0.1875, 1.4, 0.083333333333333
12979, 0.20833333333333, 1.4, 0.0625
12980, 0.1875, 1.4, 0.125
12981, 0.20833333333333, 1.4, 0.10416666666667
12982, 0.1875, 1.4, 0.16666666666667
12983, 0.20833333333333, 1.4, 0.14583333333333
12984, 0.1875, 1.4, 0.20833333333333
12985, 0.20833333333333, 1.4, 0.1875
12986, 0.1875, 1.4, 0.25
12987, 0.20833333333333, 1.4, 0.22916666666667
12988, 0.1875, 1.4, 0.29166666666667
12989, 0.20833333333333, 1.4, 0.27083333333333
12990, 0.1875, 1.4, 0.33333333333333
12991, 0.20833333333333, 1.4, 0.3125
12992, 0.1875, 1.4, 0.375
12993, 0.20833333333333, 1.4, 0.35416666666667
12994, 0.1875, 1.4, 0.41666666666667
12995, 0.20833333333333, 1.4, 0.39583333333333
12996, 0.1875, 1.4, 0.45833333333333
12997, 0.20833333333333, 1.4, 0.4375
12998, 0.20833333333333, 1.4, 0.47916666666667
12999, 0.22916666666667, 1.4, 0.041666666666667
13000, 0.25, 1.4, 0.020833333333333
13001, 0.22916666666667, 1.4, 0.083333333333333
13002, 0.25, 1.4, 0.0625
13003, 0.22916666666667, 1.4, 0.125
13004, 0.25, 1.4, 0.10416666666667
13005, 0.22916666666667, 1.4, 0.16666666666667
13006, 0.25, 1.4, 0.14583333333333
13007, 0.22916666666667, 1.4, 0.20833333333333
13008, 0.25, 1.4, 0.1875
13009, 0.22916666666667, 1.4, 0.25
13010, 0.25, 1.4, 0.22916666666667
13011, 0.22916666666667, 1.4, 0.29166666666667
13012, 0.25, 1.4, 0.27083333333333
13013, 0.22916666666667, 1.4, 0.33333333333333
13014, 0.25, 1.4, 0.3125
13015, 0.22916666666667, 1.4, 0.375
13016, 0.25, 1.4, 0.35416666666667
13017, 0.22916666666667, 1.4, 0.41666666666667
13018, 0.25, 1.4, 0.39583333333333
13019, 0.22916666666667, 1.4, 0.45833333333333
13020, 0.25, 1.4, 0.4375
13021, 0.25, 1.4, 0.47916666666667
13022, 0.27083333333333, 1.4, 0.041666666666667
13023, 0.29166666666667, 1.4, 0.020833333333333
13024, 0.27083333333333, 1.4, 0.083333333333333
13025, 0.29166666666667, 1.4, 0.0625
13026, 0.27083333333333, 1.4, 0.125
13027, 0.29166666666667, 1.4, 0.10416666666667
13028, 0.27083333333333, 1.4, 0.16666666666667
13029, 0.29166666666667, 1.4, 0.14583333333333
13030, 0.27083333333333, 1.4, 0.20833333333333
13031, 0.29166666666667, 1.4, 0.1875
13032, 0.27083333333333, 1.4, 0.25
13033, 0.29166666666667, 1.4, 0.22916666666667
13034, 0.27083333333333, 1.4, 0.29166666666667
13035, 0.29166666666667, 1.4, 0.27083333333333
13036, 0.27083333333333, 1.4, 0.33333333333333
13037, 0.29166666666667, 1.4, 0.3125
13038, 0.27083333333333, 1.4, 0.375
13039, 0.29166666666667, 1.4, 0.35416666666667
13040, 0.27083333333333, 1.4, 0.41666666666667
13041, 0.29166666666667, 1.4, 0.39583333333333
13042, 0.27083333333333, 1.4, 0.45833333333333
13043, 0.29166666666667, 1.4, 0.4375
13044, 0.29166666666667, 1.4, 0.47916666666667
13045, 0.3125, 1.4, 0.041666666666667
13046, 0.33333333333333, 1.4, 0.020833333333333
13047, 0.3125, 1.4, 0.083333333333333
13048, 0.33333333333333, 1.4, 0.0625
13049, 0.3125, 1.4, 0.125
13050, 0.33333333333333, 1.4, 0.10416666666667
13051, 0.3125, 1.4, 0.16666666666667
13052, 0.33333333333333, 1.4, 0.14583333333333
13053, 0.3125, 1.4, 0.20833333333333
13054, 0.33333333333333, 1.4, 0.1875
13055, 0.3125, 1.4, 0.25
13056, 0.33333333333333, 1.4, 0.22916666666667
13057, 0.3125, 1.4, 0.29166666666667
13058, 0.33333333333333, 1.4, 0.27083333333333
13059, 0.3125, 1.4, 0.33333333333333
13060, 0.33333333333333, 1.4, 0.3125
13061, 0.3125, 1.4, 0.375
13062, 0.33333333333333, 1.4, 0.35416666666667
13063, 0.3125, 1.4, 0.41666666666667
13064, 0.33333333333333, 1.4, 0.39583333333333
13065, 0.3125, 1.4, 0.45833333333333
13066, 0.33333333333333, 1.4, 0.4375
13067, 0.33333333333333, 1.4, 0.47916666666667
13068, 0.35416666666667, 1.4, 0.041666666666667
13069, 0.375, 1.4, 0.020833333333333
13070, 0.35416666666667, 1.4, 0.083333333333333
13071, 0.375, 1.4, 0.0625
13072, 0.35416666666667, 1.4, 0.125
13073, 0.375, 1.4, 0.10416666666667
13074, 0.35416666666667, 1.4, 0.16666666666667
13075, 0.375, 1.4, 0.14583333333333
13076, 0.35416666666667, 1.4, 0.20833333333333
13077, 0.375, 1.4, 0.1875
13078, 0.35416666666667, 1.4, 0.25
13079, 0.375, 1.4, 0.22916666666667
13080, 0.35416666666667, 1.4, 0.29166666666667
13081, 0.375, 1.4, 0.27083333333333
13082, 0.35416666666667, 1.4, 0.33333333333333
13083, 0.375, 1.4, 0.3125
13084, 0.35416666666667, 1.4, 0.375
13085, 0.375, 1.4, 0.35416666666667
13086, 0.35416666666667, 1.4, 0.41666666666667
13087, 0.375, 1.4, 0.39583333333333
13088, 0.35416666666667, 1.4, 0.45833333333333
13089, 0.375, 1.4, 0.4375
13090, 0.375, 1.4, 0.47916666666667
13091, 0.39583333333333, 1.4, 0.041666666666667
13092, 0.41666666666667, 1.4, 0.020833333333333
13093, 0.39583333333333, 1.4, 0.083333333333333
13094, 0.41666666666667, 1.4, 0.0625
13095, 0.39583333333333, 1.4, 0.125
13096, 0.41666666666667, 1.4, 0.10416666666667
13097, 0.39583333333333, 1.4, 0.16666666666667
13098, 0.41666666666667, 1.4, 0.14583333333333
13099, 0.39583333333333, 1.4, 0.20833333333333
13100, 0.41666666666667, 1.4, 0.1875
13101, 0.39583333333333, 1.4, 0.25
13102, 0.41666666666667, 1.4, 0.22916666666667
13103, 0.39583333333333, 1.4, 0.29166666666667
13104, 0.41666666666667, 1.4, 0.27083333333333
13105, 0.39583333333333, 1.4, 0.33333333333333
13106, 0.41666666666667, 1.4, 0.3125
13107, 0.39583333333333, 1.4, 0.375
13108, 0.41666666666667, 1.4, 0.35416666666667
13109, 0.39583333333333, 1.4, 0.41666666666667
13110, 0.41666666666667, 1.4, 0.39583333333333
13111, 0.39583333333333, 1.4, 0.45833333333333
13112, 0.41666666666667, 1.4, 0.4375
13113, 0.41666666666667, 1.4, 0.47916666666667
13114, 0.4375, 1.4, 0.041666666666667
13115, 0.45833333333333, 1.4, 0.020833333333333
13116, 0.4375, 1.4, 0.083333333333333
13117, 0.45833333333333, 1.4, 0.0625
13118, 0.4375, 1.4, 0.125
13119, 0.45833333333333, 1.4, 0.10416666666667
13120, 0.4375, 1.4, 0.16666666666667
13121, 0.45833333333333, 1.4, 0.14583333333333
13122, 0.4375, 1.4, 0.20833333333333
13123, 0.45833333333333, 1.4, 0.1875
13124, 0.4375, 1.4, 0.25
13125, 0.45833333333333, 1.4, 0.22916666666667
13126, 0.4375, 1.4, 0.29166666666667
13127, 0.45833333333333, 1.4, 0.27083333333333
13128, 0.4375, 1.4, 0.33333333333333
13129, 0.45833333333333, 1.4, 0.3125
13130, 0.4375, 1.4, 0.375
13131, 0.45833333333333, 1.4, 0.35416666666667
13132, 0.4375, 1.4, 0.41666666666667
13133, 0.45833333333333, 1.4, 0.39583333333333
13134, 0.4375, 1.4, 0.45833333333333
13135, 0.45833333333333, 1.4, 0.4375
13136, 0.45833333333333, 1.4, 0.47916666666667
13137, 0.47916666666667, 1.4, 0.041666666666667
13138, 0.5, 1.4, 0.020833333333333
13139, 0.47916666666667, 1.4, 0.083333333333333
13140, 0.5, 1.4, 0.0625
13141, 0.47916666666667, 1.4, 0.125
13142, 0.5, 1.4, 0.10416666666667
13143, 0.47916666666667, 1.4, 0.16666666666667
13144, 0.5, 1.4, 0.14583333333333
13145, 0.47916666666667, 1.4, 0.20833333333333
13146, 0.5, 1.4, 0.1875
13147, 0.47916666666667, 1.4, 0.25
13148, 0.5, 1.4, 0.22916666666667
13149, 0.47916666666667, 1.4, 0.29166666666667
13150, 0.5, 1.4, 0.27083333333333
13151, 0.47916666666667, 1.4, 0.33333333333333
13152, 0.5, 1.4, 0.3125
13153, 0.47916666666667, 1.4, 0.375
13154, 0.5, 1.4, 0.35416666666667
13155, 0.47916666666667, 1.4, 0.41666666666667
13156, 0.5, 1.4, 0.39583333333333
13157, 0.47916666666667, 1.4, 0.45833333333333
13158, 0.5, 1.4, 0.4375
13159, 0.5, 1.4, 0.47916666666667
13160, 0.52083333333333, 1.4, 0.041666666666667
13161, 0.54166666666667, 1.4, 0.020833333333333
13162, 0.52083333333333, 1.4, 0.083333333333333
13163, 0.54166666666667, 1.4, 0.0625
13164, 0.52083333333333, 1.4, 0.125
13165, 0.54166666666667, 1.4, 0.10416666666667
13166, 0.52083333333333, 1.4, 0.16666666666667
13167, 0.54166666666667, 1.4, 0.14583333333333
13168, 0.52083333333333, 1.4, 0.20833333333333
13169, 0.54166666666667, 1.4, 0.1875
13170, 0.52083333333333, 1.4, 0.25
13171, 0.54166666666667, 1.4, 0.22916666666667
13172, 0.52083333333333, 1.4, 0.29166666666667
13173, 0.54166666666667, 1.4, 0.27083333333333
13174, 0.52083333333333, 1.4, 0.33333333333333
13175, 0.54166666666667, 1.4, 0.3125
13176, 0.52083333333333, 1.4, 0.375
13177, 0.54166666666667, 1.4, 0.35416666666667
13178, 0.52083333333333, 1.4, 0.41666666666667
13179, 0.54166666666667, 1.4, 0.39583333333333
13180, 0.52083333333333, 1.4, 0.45833333333333
13181, 0.54166666666667, 1.4, 0.4375
13182, 0.54166666666667, 1.4, 0.47916666666667
13183, 0.5625, 1.4, 0.041666666666667
13184, 0.58333333333333, 1.4, 0.020833333333333
13185, 0.5625, 1.4, 0.083333333333333
13186, 0.58333333333333, 1.4, 0.0625
13187, 0.5625, 1.4, 0.125
13188, 0.58333333333333, 1.4, 0.10416666666667
13189, 0.5625, 1.4, 0.16666666666667
13190, 0.58333333333333, 1.4, 0.14583333333333
13191, 0.5625, 1.4, 0.20833333333333
13192, 0.58333333333333, 1.4, 0.1875
13193, 0.5625, 1.4, 0.25
13194, 0.58333333333333, 1.4, 0.22916666666667
13195, 0.5625, 1.4, 0.29166666666667
13196, 0.58333333333333, 1.4, 0.27083333333333
13197, 0.5625, 1.4, 0.33333333333333
13198, 0.58333333333333, 1.4, 0.3125
13199, 0.5625, 1.4, 0.375
13200, 0.58333333333333, 1.4, 0.35416666666667
13201, 0.5625, 1.4, 0.41666666666667
13202, 0.58333333333333, 1.4, 0.39583333333333
13203, 0.5625, 1.4, 0.45833333333333
13204, 0.58333333333333, 1.4, 0.4375
13205, 0.58333333333333, 1.4, 0.47916666666667
13206, 0.60416666666667, 1.4, 0.041666666666667
13207, 0.625, 1.4, 0.020833333333333
13208, 0.60416666666667, 1.4, 0.083333333333333
13209, 0.625, 1.4, 0.0625
13210, 0.60416666666667, 1.4, 0.125
13211, 0.625, 1.4, 0.10416666666667
13212, 0.60416666666667, 1.4, 0.16666666666667
13213, 0.625, 1.4, 0.14583333333333
13214, 0.60416666666667, 1.4, 0.20833333333333
13215, 0.625, 1.4, 0.1875
13216, 0.60416666666667, 1.4, 0.25
13217, 0.625, 1.4, 0.22916666666667
13218, 0.60416666666667, 1.4, 0.29166666666667
13219, 0.625, 1.4, 0.27083333333333
13220, 0.60416666666667, 1.4, 0.33333333333333
13221, 0.625, 1.4, 0.3125
13222, 0.60416666666667, 1.4, 0.375
13223, 0.625, 1.4, 0.35416666666667
13224, 0.60416666666667, 1.4, 0.41666666666667
13225, 0.625, 1.4, 0.39583333333333
13226, 0.60416666666667, 1.4, 0.45833333333333
13227, 0.625, 1.4, 0.4375
13228, 0.625, 1.4, 0.47916666666667
13229, 0.64583333333333, 1.4, 0.041666666666667
13230, 0.66666666666667, 1.4, 0.020833333333333
13231, 0.64583333333333, 1.4, 0.083333333333333
13232, 0.66666666666667, 1.4, 0.0625
13233, 0.64583333333333, 1.4, 0.125
13234, 0.66666666666667, 1.4, 0.10416666666667
13235, 0.64583333333333, 1.4, 0.16666666666667
13236, 0.66666666666667, 1.4, 0.14583333333333
13237, 0.64583333333333, 1.4, 0.20833333333333
13238, 0.66666666666667, 1.4, 0.1875
13239, 0.64583333333333, 1.4, 0.25
13240, 0.66666666666667, 1.4, 0.22916666666667
13241, 0.64583333333333, 1.4, 0.29166666666667
13242, 0.66666666666667, 1.4, 0.27083333333333
13243, 0.64583333333333, 1.4, 0.33333333333333
13244, 0.66666666666667, 1.4, 0.3125
13245, 0.64583333333333, 1.4, 0.375
13246, 0.66666666666667, 1.4, 0.35416666666667
13247, 0.64583333333333, 1.4, 0.41666666666667
13248, 0.66666666666667, 1.4, 0.39583333333333
13249, 0.64583333333333, 1.4, 0.45833333333333
13250, 0.66666666666667, 1.4, 0.4375
13251, 0.66666666666667, 1.4, 0.47916666666667
13252, 0.6875, 1.4, 0.041666666666667
13253, 0.70833333333333, 1.4, 0.020833333333333
13254, 0.6875, 1.4, 0.083333333333333
13255, 0.70833333333333, 1.4, 0.0625
13256, 0.6875, 1.4, 0.125
13257, 0.70833333333333, 1.4, 0.10416666666667
13258, 0.6875, 1.4, 0.16666666666667
13259, 0.70833333333333, 1.4, 0.14583333333333
13260, 0.6875, 1.4, 0.20833333333333
13261, 0.70833333333333, 1.4, 0.1875
13262, 0.6875, 1.4, 0.25
13263, 0.70833333333333, 1.4, 0.22916666666667
13264, 0.6875, 1.4, 0.29166666666667
13265, 0.70833333333333, 1.4, 0.27083333333333
13266, 0.6875, 1.4, 0.33333333333333
13267, 0.70833333333333, 1.4, 0.3125
13268, 0.6875, 1.4, 0.375
13269, 0.70833333333333, 1.4, 0.35416666666667
13270, 0.6875, 1.4, 0.41666666666667
13271, 0.70833333333333, 1.4, 0.39583333333333
13272, 0.6875, 1.4, 0.45833333333333
13273, 0.70833333333333, 1.4, 0.4375
13274, 0.70833333333333, 1.4, 0.47916666666667
13275, 0.72916666666667, 1.4, 0.041666666666667
13276, 0.75, 1.4, 0.020833333333333
13277, 0.72916666666667, 1.4, 0.083333333333333
13278, 0.75, 1.4, 0.0625
13279, 0.72916666666667, 1.4, 0.125
13280, 0.75, 1.4, 0.10416666666667
13281, 0.72916666666667, 1.4, 0.16666666666667
13282, 0.75, 1.4, 0.14583333333333
13283, 0.72916666666667, 1.4, 0.20833333333333
13284, 0.75, 1.4, 0.1875
13285, 0.72916666666667, 1.4, 0.25
13286, 0.75, 1.4, 0.22916666666667
13287, 0.72916666666667, 1.4, 0.29166666666667
13288, 0.75, 1.4, 0.27083333333333
13289, 0.72916666666667, 1.4, 0.33333333333333
13290, 0.75, 1.4, 0.3125
13291, 0.72916666666667, 1.4, 0.375
13292, 0.75, 1.4, 0.35416666666667
13293, 0.72916666666667, 1.4, 0.41666666666667
13294, 0.75, 1.4, 0.39583333333333
13295, 0.72916666666667, 1.4, 0.45833333333333
13296, 0.75, 1.4, 0.4375
13297, 0.75, 1.4, 0.47916666666667
13298, 0.77083333333333, 1.4, 0.041666666666667
13299, 0.79166666666667, 1.4, 0.020833333333333
13300, 0.77083333333333, 1.4, 0.083333333333333
13301, 0.79166666666667, 1.4, 0.0625
13302, 0.77083333333333, 1.4, 0.125
13303, 0.79166666666667, 1.4, 0.10416666666667
13304, 0.77083333333333, 1.4, 0.16666666666667
13305, 0.79166666666667, 1.4, 0.14583333333333
13306, 0.77083333333333, 1.4, 0.20833333333333
13307, 0.79166666666667, 1.4, 0.1875
13308, 0.77083333333333, 1.4, 0.25
13309, 0.79166666666667, 1.4, 0.22916666666667
13310, 0.77083333333333, 1.4, 0.29166666666667
13311, 0.79166666666667, 1.4, 0.27083333333333
13312, 0.77083333333333, 1.4, 0.33333333333333
13313, 0.79166666666667, 1.4, 0.3125
13314, 0.77083333333333, 1.4, 0.375
13315, 0.79166666666667, 1.4, 0.35416666666667
13316, 0.77083333333333, 1.4, 0.41666666666667
13317, 0.79166666666667, 1.4, 0.39583333333333
13318, 0.77083333333333, 1.4, 0.45833333333333
13319, 0.79166666666667, 1.4, 0.4375
13320, 0.79166666666667, 1.4, 0.47916666666667
13321, 0.8125, 1.4, 0.041666666666667
13322, 0.83333333333333, 1.4, 0.020833333333333
13323, 0.8125, 1.4, 0.083333333333333
13324, 0.83333333333333, 1.4, 0.0625
13325, 0.8125, 1.4, 0.125
13326, 0.83333333333333, 1.4, 0.10416666666667
13327, 0.8125, 1.4, 0.16666666666667
13328, 0.83333333333333, 1.4, 0.14583333333333
13329, 0.8125, 1.4, 0.20833333333333
13330, 0.83333333333333, 1.4, 0.1875
13331, 0.8125, 1.4, 0.25
13332, 0.83333333333333, 1.4, 0.22916666666667
13333, 0.8125, 1.4, 0.29166666666667
13334, 0.83333333333333, 1.4, 0.27083333333333
13335, 0.8125, 1.4, 0.33333333333333
13336, 0.83333333333333, 1.4, 0.3125
13337, 0.8125, 1.4, 0.375
13338, 0.83333333333333, 1.4, 0.35416666666667
13339, 0.8125, 1.4, 0.41666666666667
13340, 0.83333333333333, 1.4, 0.39583333333333
13341, 0.8125, 1.4, 0.45833333333333
13342, 0.83333333333333, 1.4, 0.4375
13343, 0.83333333333333, 1.4, 0.47916666666667
13344, 0.85416666666667, 1.4, 0.041666666666667
13345, 0.875, 1.4, 0.020833333333333
13346, 0.85416666666667, 1.4, 0.083333333333333
13347, 0.875, 1.4, 0.0625
13348, 0.85416666666667, 1.4, 0.125
13349, 0.875, 1.4, 0.10416666666667
13350, 0.85416666666667, 1.4, 0.16666666666667
13351, 0.875, 1.4, 0.14583333333333
13352, 0.85416666666667, 1.4, 0.20833333333333
13353, 0.875, 1.4, 0.1875
13354, 0.85416666666667, 1.4, 0.25
13355, 0.875, 1.4, 0.22916666666667
13356, 0.85416666666667, 1.4, 0.29166666666667
13357, 0.875, 1.4, 0.27083333333333
13358, 0.85416666666667, 1.4, 0.33333333333333
13359, 0.875, 1.4, 0.3125
13360, 0.85416666666667, 1.4, 0.375
13361, 0.875, 1.4, 0.35416666666667
13362, 0.85416666666667, 1.4, 0.41666666666667
13363, 0.875, 1.4, 0.39583333333333
13364, 0.85416666666667, 1.4, 0.45833333333333
13365, 0.875, 1.4, 0.4375
13366, 0.875, 1.4, 0.47916666666667
13367, 0.89583333333333, 1.4, 0.041666666666667
13368, 0.91666666666667, 1.4, 0.020833333333333
13369, 0.89583333333333, 1.4, 0.083333333333333
13370, 0.91666666666667, 1.4, 0.0625
13371, 0.89583333333333, 1.4, 0.125
13372, 0.91666666666667, 1.4, 0.10416666666667
13373, 0.89583333333333, 1.4, 0.16666666666667
13374, 0.91666666666667, 1.4, 0.14583333333333
13375, 0.89583333333333, 1.4, 0.20833333333333
13376, 0.91666666666667, 1.4, 0.1875
13377, 0.89583333333333, 1.4, 0.25
13378, 0.91666666666667, 1.4, 0.22916666666667
13379, 0.89583333333333, 1.4, 0.29166666666667
13380, 0.91666666666667, 1.4, 0.27083333333333
13381, 0.89583333333333, 1.4, 0.33333333333333
13382, 0.91666666666667, 1.4, 0.3125
13383, 0.89583333333333, 1.4, 0.375
13384, 0.91666666666667, 1.4, 0.35416666666667
13385, 0.89583333333333, 1.4, 0.41666666666667
13386, 0.91666666666667, 1.4, 0.39583333333333
13387, 0.89583333333333, 1.4, 0.45833333333333
13388, 0.91666666666667, 1.4, 0.4375
13389, 0.91666666666667, 1.4, 0.47916666666667
13390, 0.9375, 1.4, 0.041666666666667
13391, 0.95833333333333, 1.4, 0.020833333333333
13392, 0.9375, 1.4, 0.083333333333333
13393, 0.95833333333333, 1.4, 0.0625
13394, 0.9375, 1.4, 0.125
13395, 0.95833333333333, 1.4, 0.10416666666667
13396, 0.9375, 1.4, 0.16666666666667
13397, 0.95833333333333, 1.4, 0.14583333333333
13398, 0.9375, 1.4, 0.20833333333333
13399, 0.95833333333333, 1.4, 0.1875
13400, 0.9375, 1.4, 0.25
13401, 0.95833333333333, 1.4, 0.22916666666667
13402, 0.9375, 1.4, 0.29166666666667
13403, 0.95833333333333, 1.4, 0.27083333333333
13404, 0.9375, 1.4, 0.33333333333333
13405, 0.95833333333333, 1.4, 0.3125
13406, 0.9375, 1.4, 0.375
13407, 0.95833333333333, 1.4, 0.35416666666667
13408, 0.9375, 1.4, 0.41666666666667
13409, 0.95833333333333, 1.4, 0.39583333333333
13410, 0.9375, 1.4, 0.45833333333333
13411, 0.95833333333333, 1.4, 0.4375
13412, 0.95833333333333, 1.4, 0.47916666666667
13413, 0.97916666666667, 1.4, 0.041666666666667
13414, 0.97916666666667, 1.4, 0.083333333333333
13415, 0.97916666666667, 1.4, 0.125
13416, 0.97916666666667, 1.4, 0.16666666666667
13417, 0.97916666666667, 1.4, 0.20833333333333
13418, 0.97916666666667, 1.4, 0.25
13419, 0.97916666666667, 1.4, 0.29166666666667
13420, 0.97916666666667, 1.4, 0.33333333333333
13421, 0.97916666666667, 1.4, 0.375
13422, 0.97916666666667, 1.4, 0.41666666666667
13423, 0.97916666666667, 1.4, 0.45833333333333
13424, 0.041666666666667, 1.4333333333333, 0
13425, 0.041666666666667, 1.4666666666667, 0
13426, 0.083333333333333, 1.4333333333333, 0
13427, 0.083333333333333, 1.4666666666667, 0
13428, 0.125, 1.4333333333333, 0
13429, 0.125, 1.4666666666667, 0
13430, 0.16666666666667, 1.4333333333333, 0
13431, 0.16666666666667, 1.4666666666667, 0
13432, 0.20833333333333, 1.4333333333333, 0
13433, 0.20833333333333, 1.4666666666667, 0
13434, 0.25, 1.4333333333333, 0
13435, 0.25, 1.4666666666667, 0
13436, 0.29166666666667, 1.4333333333333, 0
13437, 0.29166666666667, 1.4666666666667, 0
13438, 0.33333333333333, 1.4333333333333, 0
13439, 0.33333333333333, 1.4666666666667, 0
13440, 0.375, 1.4333333333333, 0
13441, 0.375, 1.4666666666667, 0
13442, 0.41666666666667, 1.4333333333333, 0
13443, 0.41666666666667, 1.4666666666667, 0
13444, 0.45833333333333, 1.4333333333333, 0
13445, 0.45833333333333, 1.4666666666667, 0
13446, 0.5, 1.4333333333333, 0
13447, 0.5, 1.4666666666667, 0
13448, 0.54166666666667, 1.4333333333333, 0
13449, 0.54166666666667, 1.4666666666667, 0
13450, 0.58333333333333, 1.4333333333333, 0
13451, 0.58333333333333, 1.4666666666667, 0
13452, 0.625, 1.4333333333333, 0
13453, 0.625, 1.4666666666667, 0
13454, 0.66666666666667, 1.4333333333333, 0
13455, 0.66666666666667, 1.4666666666667, 0
13456, 0.70833333333333, 1.4333333333333, 0
13457, 0.70833333333333, 1.4666666666667, 0
13458, 0.75, 1.4333333333333, 0
13459, 0.75, 1.4666666666667, 0
13460, 0.79166666666667, 1.4333333333333, 0
13461, 0.79166666666667, 1.4666666666667, 0
13462, 0.83333333333333, 1.4333333333333, 0
13463, 0.83333333333333, 1.4666666666667, 0
13464, 0.875, 1.4333333333333, 0
13465, 0.875, 1.4666666666667, 0
13466, 0.91666666666667, 1.4333333333333, 0
13467, 0.91666666666667, 1.4666666666667, 0
13468, 0.95833333333333, 1.4333333333333, 0
13469, 0.95833333333333, 1.4666666666667, 0
13470, 0.020833333333333, 1.4333333333333, 0
13471, 0.041666666666667, 1.4166666666667, 0
13472, 0.020833333333333, 1.4666666666667, 0
13473, 0.041666666666667, 1.45, 0
13474, 0.041666666666667, 1.4833333333333, 0
13475, 0.0625, 1.4333333333333, 0
13476, 0.083333333333333, 1.4166666666667, 0
13477, 0.0625, 1.4666666666667, 0
13478, 0.083333333333333, 1.45, 0
13479, 0.083333333333333, 1.4833333333333, 0
13480, 0.10416666666667, 1.4333333333333, 0
13481, 0.125, 1.4166666666667, 0
13482, 0.10416666666667, 1.4666666666667, 0
13483, 0.125, 1.45, 0
13484, 0.125, 1.4833333333333, 0
13485, 0.14583333333333, 1.4333333333333, 0
13486, 0.16666666666667, 1.4166666666667, 0
13487, 0.14583333333333, 1.4666666666667, 0
13488, 0.16666666666667, 1.45, 0
13489, 0.16666666666667, 1.4833333333333, 0
13490, 0.1875, 1.4333333333333, 0
13491, 0.20833333333333, 1.4166666666667, 0
13492, 0.1875, 1.4666666666667, 0
13493, 0.20833333333333, 1.45, 0
13494, 0.20833333333333, 1.4833333333333, 0
13495, 0.22916666666667, 1.4333333333333, 0
13496, 0.25, 1.4166666666667, 0
13497, 0.22916666666667, 1.4666666666667, 0
13498, 0.25, 1.45, 0
13499, 0.25, 1.4833333333333, 0
13500, 0.27083333333333, 1.4333333333333, 0
13501, 0.29166666666667, 1.4166666666667, 0
13502, 0.27083333333333, 1.4666666666667, 0
13503, 0.29166666666667, 1.45, 0
13504, 0.29166666666667, 1.4833333333333, 0
13505, 0.3125, 1.4333333333333, 0
13506, 0.33333333333333, 1.4166666666667, 0
13507, 0.3125, 1.4666666666667, 0
13508, 0.33333333333333, 1.45, 0
13509, 0.33333333333333, 1.4833333333333, 0
13510, 0.35416666666667, 1.4333333333333, 0
13511, 0.375, 1.4166666666667, 0
13512, 0.35416666666667, 1.4666666666667, 0
13513, 0.375, 1.45, 0
13514, 0.375, 1.4833333333333, 0
13515, 0.39583333333333, 1.4333333333333, 0
13516, 0.41666666666667, 1.4166666666667, 0
13517, 0.39583333333333, 1.4666666666667, 0
13518, 0.41666666666667, 1.45, 0
13519, 0.41666666666667, 1.4833333333333, 0
13520, 0.4375, 1.4333333333333, 0
13521, 0.45833333333333, 1.4166666666667, 0
13522, 0.4375, 1.4666666666667, 0
13523, 0.45833333333333, 1.45, 0
13524, 0.45833333333333, 1.4833333333333, 0
13525, 0.47916666666667, 1.4333333333333, 0
13526, 0.5, 1.4166666666667, 0
13527, 0.47916666666667, 1.4666666666667, 0
13528, 0.5, 1.45, 0
13529, 0.5, 1.4833333333333, 0
13530, 0.52083333333333, 1.4333333333333, 0
13531, 0.54166666666667, 1.4166666666667, 0
13532, 0.52083333333333, 1.4666666666667, 0
13533, 0.54166666666667, 1.45, 0
13534, 0.54166666666667, 1.4833333333333, 0
13535, 0.5625, 1.4333333333333, 0
13536, 0.58333333333333, 1.4166666666667, 0
13537, 0.5625, 1.4666666666667, 0
13538, 0.58333333333333, 1.45, 0
13539, 0.58333333333333, 1.4833333333333, 0
13540, 0.60416666666667, 1.4333333333333, 0
13541, 0.625, 1.4166666666667, 0
13542, 0.60416666666667, 1.4666666666667, 0
13543, 0.625, 1.45, 0
13544, 0.625, 1.4833333333333, 0
13545, 0.64583333333333, 1.4333333333333, 0
13546, 0.66666666666667, 1.4166666666667, 0
13547, 0.64583333333333, 1.4666666666667, 0
13548, 0.66666666666667, 1.45, 0
13549, 0.66666666666667, 1.4833333333333, 0
13550, 0.6875, 1.4333333333333, 0
13551, 0.70833333333333, 1.4166666666667, 0
13552, 0.6875, 1.4666666666667, 0
13553, 0.70833333333333, 1.45, 0
13554, 0.70833333333333, 1.4833333333333, 0
13555, 0.72916666666667, 1.4333333333333, 0
13556, 0.75, 1.4166666666667, 0
13557, 0.72916666666667, 1.4666666666667, 0
13558, 0.75, 1.45, 0
13559, 0.75, 1.4833333333333, 0
13560, 0.77083333333333, 1.4333333333333, 0
13561, 0.79166666666667, 1.4166666666667, 0
13562, 0.77083333333333, 1.4666666666667, 0
13563, 0.79166666666667, 1.45, 0
13564, 0.79166666666667, 1.4833333333333, 0
13565, 0.8125, 1.4333333333333, 0
13566, 0.83333333333333, 1.4166666666667, 0
13567, 0.8125, 1.4666666666667, 0
13568, 0.83333333333333, 1.45, 0
13569, 0.83333333333333, 1.4833333333333, 0
13570, 0.85416666666667, 1.4333333333333, 0
13571, 0.875, 1.4166666666667, 0
13572, 0.85416666666667, 1.4666666666667, 0
13573, 0.875, 1.45, 0
13574, 0.875, 1.4833333333333, 0
13575, 0.89583333333333, 1.4333333333333, 0
13576, 0.91666666666667, 1.4166666666667, 0
13577, 0.89583333333333, 1.4666666666667, 0
13578, 0.91666666666667, 1.45, 0
13579, 0.91666666666667, 1.4833333333333, 0
13580, 0.9375, 1.4333333333333, 0
13581, 0.95833333333333, 1.4166666666667, 0
13582, 0.9375, 1.4666666666667, 0
13583, 0.95833333333333, 1.45, 0
13584, 0.95833333333333, 1.4833333333333, 0
13585, 0.97916666666667, 1.4333333333333, 0
13586, 0.97916666666667, 1.4666666666667, 0
13587, 1, 1.4333333333333, 0.041666666666667
13588, 1, 1.4666666666667, 0.041666666666667
13589, 1, 1.4333333333333, 0.083333333333333
13590, 1, 1.4666666666667, 0.083333333333333
13591, 1, 1.4333333333333, 0.125
13592, 1, 1.4666666666667, 0.125
13593, 1, 1.4333333333333, 0.16666666666667
13594, 1, 1.4666666666667, 0.16666666666667
13595, 1, 1.4333333333333, 0.20833333333333
13596, 1, 1.4666666666667, 0.20833333333333
13597, 1, 1.4333333333333, 0.25
13598, 1, 1.4666666666667, 0.25
13599, 1, 1.4333333333333, 0.29166666666667
13600, 1, 1.4666666666667, 0.29166666666667
13601, 1, 1.4333333333333, 0.33333333333333
13602, 1, 1.4666666666667, 0.33333333333333
13603, 1, 1.4333333333333, 0.375
13604, 1, 1.4666666666667, 0.375
13605, 1, 1.4333333333333, 0.41666666666667
13606, 1, 1.4666666666667, 0.41666666666667
13607, 1, 1.4333333333333, 0.45833333333333
13608, 1, 1.4666666666667, 0.45833333333333
13609, 1, 1.4333333333333, 0.020833333333333
13610, 1, 1.4166666666667, 0.041666666666667
13611, 1, 1.4666666666667, 0.020833333333333
13612, 1, 1.45, 0.041666666666667
13613, 1, 1.4833333333333, 0.041666666666667
13614, 1, 1.4333333333333, 0.0625
13615, 1, 1.4166666666667, 0.083333333333333
13616, 1, 1.4666666666667, 0.0625
13617, 1, 1.45, 0.083333333333333
13618, 1, 1.4833333333333, 0.083333333333333
13619, 1, 1.4333333333333, 0.10416666666667
13620, 1, 1.4166666666667, 0.125
13621, 1, 1.4666666666667, 0.10416666666667
13622, 1, 1.45, 0.125
13623, 1, 1.4833333333333, 0.125
13624, 1, 1.4333333333333, 0.14583333333333
13625, 1, 1.4166666666667, 0.16666666666667
13626, 1, 1.4666666666667, 0.14583333333333
13627, 1, 1.45, 0.16666666666667
13628, 1, 1.4833333333333, 0.16666666666667
13629, 1, 1.4333333333333, 0.1875
13630, 1, 1.4166666666667, 0.20833333333333
13631, 1, 1.4666666666667, 0.1875
13632, 1, 1.45, 0.20833333333333
13633, 1, 1.4833333333333, 0.20833333333333
13634, 1, 1.4333333333333, 0.22916666666667
13635, 1, 1.4166666666667, 0.25
13636, 1, 1.4666666666667, 0.22916666666667
13637, 1, 1.45, 0.25
13638, 1, 1.4833333333333, 0.25
13639, 1, 1.4333333333333, 0.27083333333333
13640, 1, 1.4166666666667, 0.29166666666667
13641, 1, 1.4666666666667, 0.27083333333333
13642, 1, 1.45, 0.29166666666667
13643, 1, 1.4833333333333, 0.29166666666667
13644, 1, 1.4333333333333, 0.3125
13645, 1, 1.4166666666667, 0.33333333333333
13646, 1, 1.4666666666667, 0.3125
13647, 1, 1.45, 0.33333333333333
13648, 1, 1.4833333333333, 0.33333333333333
13649, 1, 1.4333333333333, 0.35416666666667
13650, 1, 1.4166666666667, 0.375
13651, 1, 1.4666666666667, 0.35416666666667
13652, 1, 1.45, 0.375
13653, 1, 1.4833333333333, 0.375
13654, 1, 1.4333333333333, 0.39583333333333
13655, 1, 1.4166666666667, 0.41666666666667
13656, 1, 1.4666666666667, 0.39583333333333
13657, 1, 1.45, 0.41666666666667
13658, 1, 1.4833333333333, 0.41666666666667
13659, 1, 1.4333333333333, 0.4375
13660, 1, 1.4166666666667, 0.45833333333333
13661, 1, 1.4666666666667, 0.4375
13662, 1, 1.45, 0.45833333333333
13663, 1, 1.4833333333333, 0.45833333333333
13664, 1, 1.4333333333333, 0.47916666666667
13665, 1, 1.4666666666667, 0.47916666666667
13666, 0.041666666666667, 1.4333333333333, 0.5
13667, 0.041666666666667, 1.4666666666667, 0.5
13668, 0.083333333333333, 1.4333333333333, 0.5
13669, 0.083333333333333, 1.4666666666667, 0.5
13670, 0.125, 1.4333333333333, 0.5
13671, 0.125, 1.4666666666667, 0.5
13672, 0.16666666666667, 1.4333333333333, 0.5
13673, 0.16666666666667, 1.4666666666667, 0.5
13674, 0.20833333333333, 1.4333333333333, 0.5
13675, 0.20833333333333, 1.4666666666667, 0.5
13676, 0.25, 1.4333333333333, 0.5
13677, 0.25, 1.4666666666667, 0.5
13678, 0.29166666666667, 1.4333333333333, 0.5
13679, 0.29166666666667, 1.4666666666667, 0.5
13680, 0.33333333333333, 1.4333333333333, 0.5
13681, 0.33333333333333, 1.4666666666667, 0.5
13682, 0.375, 1.4333333333333, 0.5
13683, 0.375, 1.4666666666667, 0.5
13684, 0.41666666666667, 1.4333333333333, 0.5
13685, 0.41666666666667, 1.4666666666667, 0.5
13686, 0.45833333333333, 1.4333333333333, 0.5
13687, 0.45833333333333, 1.4666666666667, 0.5
13688, 0.5, 1.4333333333333, 0.5
13689, 0.5, 1.4666666666667, 0.5
13690, 0.54166666666667, 1.4333333333333, 0.5
13691, 0.54166666666667, 1.4666666666667, 0.5
13692, 0.58333333333333, 1.4333333333333, 0.5
13693, 0.58333333333333, 1.4666666666667, 0.5
13694, 0.625, 1.4333333333333, 0.5
13695, 0.625, 1.4666666666667, 0.5
13696, 0.66666666666667, 1.4333333333333, 0.5
13697, 0.66666666666667, 1.4666666666667, 0.5
13698, 0.70833333333333, 1.4333333333333, 0.5
13699, 0.70833333333333, 1.4666666666667, 0.5
13700, 0.75, 1.4333333333333, 0.5
13701, 0.75, 1.4666666666667, 0.5
13702, 0.79166666666667, 1.4333333333333, 0.5
13703, 0.79166666666667, 1.4666666666667, 0.5
13704, 0.83333333333333, 1.4333333333333, 0.5
13705, 0.83333333333333, 1.4666666666667, 0.5
13706, 0.875, 1.4333333333333, 0.5
13707, 0.875, 1.4666666666667, 0.5
13708, 0.91666666666667, 1.4333333333333, 0.5
13709, 0.91666666666667, 1.4666666666667, 0.5
13710, 0.95833333333333, 1.4333333333333, 0.5
13711, 0.95833333333333, 1.4666666666667, 0.5
13712, 0.041666666666667, 1.4166666666667, 0.5
13713, 0.020833333333333, 1.4333333333333, 0.5
13714, 0.041666666666667, 1.45, 0.5
13715, 0.020833333333333, 1.4666666666667, 0.5
13716, 0.041666666666667, 1.4833333333333, 0.5
13717, 0.083333333333333, 1.4166666666667, 0.5
13718, 0.0625, 1.4333333333333, 0.5
13719, 0.083333333333333, 1.45, 0.5
13720, 0.0625, 1.4666666666667, 0.5
13721, 0.083333333333333, 1.4833333333333, 0.5
13722, 0.125, 1.4166666666667, 0.5
13723, 0.10416666666667, 1.4333333333333, 0.5
13724, 0.125, 1.45, 0.5
13725, 0.10416666666667, 1.4666666666667, 0.5
13726, 0.125, 1.4833333333333, 0.5
13727, 0.16666666666667, 1.4166666666667, 0.5
13728, 0.14583333333333, 1.4333333333333, 0.5
13729, 0.16666666666667, 1.45, 0.5
13730, 0.14583333333333, 1.4666666666667, 0.5
13731, 0.16666666666667, 1.4833333333333, 0.5
13732, 0.20833333333333, 1.4166666666667, 0.5
13733, 0.1875, 1.4333333333333, 0.5
13734, 0.20833333333333, 1.45, 0.5
13735, 0.1875, 1.4666666666667, 0.5
13736, 0.20833333333333, 1.4833333333333, 0.5
13737, 0.25, 1.4166666666667, 0.5
13738, 0.22916666666667, 1.4333333333333, 0.5
13739, 0.25, 1.45, 0.5
13740, 0.22916666666667, 1.4666666666667, 0.5
13741, 0.25, 1.4833333333333, 0.5
13742, 0.29166666666667, 1.4166666666667, 0.5
13743, 0.27083333333333, 1.4333333333333, 0.5
13744, 0.29166666666667, 1.45, 0.5
13745, 0.27083333333333, 1.4666666666667, 0.5
13746, 0.29166666666667, 1.4833333333333, 0.5
13747, 0.33333333333333, 1.4166666666667, 0.5
13748, 0.3125, 1.4333333333333, 0.5
13749, 0.33333333333333, 1.45, 0.5
13750, 0.3125, 1.4666666666667, 0.5
13751, 0.33333333333333, 1.4833333333333, 0.5
13752, 0.375, 1.4166666666667, 0.5
13753, 0.35416666666667, 1.4333333333333, 0.5
13754, 0.375, 1.45, 0.5
13755, 0.35416666666667, 1.4666666666667, 0.5
13756, 0.375, 1.4833333333333, 0.5
13757, 0.41666666666667, 1.4166666666667, 0.5
13758, 0.39583333333333, 1.4333333333333, 0.5
13759, 0.41666666666667, 1.45, 0.5
13760, 0.39583333333333, 1.4666666666667, 0.5
13761, 0.41666666666667, 1.4833333333333, 0.5
13762, 0.45833333333333, 1.4166666666667, 0.5
13763, 0.4375, 1.4333333333333, 0.5
13764, 0.45833333333333, 1.45, 0.5
13765, 0.4375, 1.4666666666667, 0.5
13766, 0.45833333333333, 1.4833333333333, 0.5
13767, 0.5, 1.4166666666667, 0.5
13768, 0.47916666666667, 1.4333333333333, 0.5
13769, 0.5, 1.45, 0.5
13770, 0.47916666666667, 1.4666666666667, 0.5
13771, 0.5, 1.4833333333333, 0.5
13772, 0.54166666666667, 1.4166666666667, 0.5
13773, 0.52083333333333, 1.4333333333333, 0.5
13774, 0.54166666666667, 1.45, 0.5
13775, 0.52083333333333, 1.4666666666667, 0.5
13776, 0.54166666666667, 1.4833333333333, 0.5
13777, 0.58333333333333, 1.4166666666667, 0.5
13778, 0.5625, 1.4333333333333, 0.5
13779, 0.58333333333333, 1.45, 0.5
13780, 0.5625, 1.4666666666667, 0.5
13781, 0.58333333333333, 1.4833333333333, 0.5
13782, 0.625, 1.4166666666667, 0.5
13783, 0.60416666666667, 1.4333333333333, 0.5
13784, 0.625, 1.45, 0.5
13785, 0.60416666666667, 1.4666666666667, 0.5
13786, 0.625, 1.4833333333333, 0.5
13787, 0.66666666666667, 1.4166666666667, 0.5
13788, 0.64583333333333, 1.4333333333333, 0.5
13789, 0.66666666666667, 1.45, 0.5
13790, 0.64583333333333, 1.4666666666667, 0.5
13791, 0.66666666666667, 1.4833333333333, 0.5
13792, 0.70833333333333, 1.4166666666667, 0.5
13793, 0.6875, 1.4333333333333, 0.5
13794, 0.70833333333333, 1.45, 0.5
13795, 0.6875, 1.4666666666667, 0.5
13796, 0.70833333333333, 1.4833333333333, 0.5
13797, 0.75, 1.4166666666667, 0.5
13798, 0.72916666666667, 1.4333333333333, 0.5
13799, 0.75, 1.45, 0.5
13800, 0.72916666666667, 1.4666666666667, 0.5
13801, 0.75, 1.4833333333333, 0.5
13802, 0.79166666666667, 1.4166666666667, 0.5
13803, 0.77083333333333, 1.4333333333333, 0.5
13804, 0.79166666666667, 1.45, 0.5
13805, 0.77083333333333, 1.4666666666667, 0.5
13806, 0.79166666666667, 1.4833333333333, 0.5
13807, 0.83333333333333, 1.4166666666667, 0.5
13808, 0.8125, 1.4333333333333, 0.5
13809, 0.83333333333333, 1.45, 0.5
13810, 0.8125, 1.4666666666667, 0.5
13811, 0.83333333333333, 1.4833333333333, 0.5
13812, 0.875, 1.4166666666667, 0.5
13813, 0.85416666666667, 1.4333333333333, 0.5
13814, 0.875, 1.45, 0.5
13815, 0.85416666666667, 1.4666666666667, 0.5
13816, 0.875, 1.4833333333333, 0.5
13817, 0.91666666666667, 1.4166666666667, 0.5
13818, 0.89583333333333, 1.4333333333333, 0.5
13819, 0.91666666666667, 1.45, 0.5
13820, 0.89583333333333, 1.4666666666667, 0.5
13821, 0.91666666666667, 1.4833333333333, 0.5
13822, 0.95833333333333, 1.4166666666667, 0.5
13823, 0.9375, 1.4333333333333, 0.5
13824, 0.95833333333333, 1.45, 0.5
13825, 0.9375, 1.4666666666667, 0.5
13826, 0.95833333333333, 1.4833333333333, 0.5
13827, 0.97916666666667, 1.4333333333333, 0.5
13828, 0.97916666666667, 1.4666666666667, 0.5
13829, 0, 1.4333333333333, 0.041666666666667
13830, 0, 1.4666666666667, 0.041666666666667
13831, 0, 1.4333333333333, 0.083333333333333
13832, 0, 1.4666666666667, 0.083333333333333
13833, 0, 1.4333333333333, 0.125
13834, 0, 1.4666666666667, 0.125
13835, 0, 1.4333333333333, 0.16666666666667
13836, 0, 1.4666666666667, 0.16666666666667
13837, 0, 1.4333333333333, 0.20833333333333
13838, 0, 1.4666666666667, 0.20833333333333
13839, 0, 1.4333333333333, 0.25
13840, 0, 1.4666666666667, 0.25
13841, 0, 1.4333333333333, 0.29166666666667
13842, 0, 1.4666666666667, 0.29166666666667
13843, 0, 1.4333333333333, 0.33333333333333
13844, 0, 1.4666666666667, 0.33333333333333
13845, 0, 1.4333333333333, 0.375
13846, 0, 1.4666666666667, 0.375
13847, 0, 1.4333333333333, 0.41666666666667
13848, 0, 1.4666666666667, 0.41666666666667
13849, 0, 1.4333333333333, 0.45833333333333
13850, 0, 1.4666666666667, 0.45833333333333
13851, 0, 1.4166666666667, 0.041666666666667
13852, 0, 1.4333333333333, 0.020833333333333
13853, 0, 1.45, 0.041666666666667
13854, 0, 1.4666666666667, 0.020833333333333
13855, 0, 1.4833333333333, 0.041666666666667
13856, 0, 1.4166666666667, 0.083333333333333
13857, 0, 1.4333333333333, 0.0625
13858, 0, 1.45, 0.083333333333333
13859, 0, 1.4666666666667, 0.0625
13860, 0, 1.4833333333333, 0.083333333333333
13861, 0, 1.4166666666667, 0.125
13862, 0, 1.4333333333333, 0.10416666666667
13863, 0, 1.45, 0.125
13864, 0, 1.4666666666667, 0.10416666666667
13865, 0, 1.4833333333333, 0.125
13866, 0, 1.4166666666667, 0.16666666666667
13867, 0, 1.4333333333333, 0.14583333333333
13868, 0, 1.45, 0.16666666666667
13869, 0, 1.4666666666667, 0.14583333333333
13870, 0, 1.4833333333333, 0.16666666666667
13871, 0, 1.4166666666667, 0.20833333333333
13872, 0, 1.4333333333333, 0.1875
13873, 0, 1.45, 0.20833333333333
13874, 0, 1.4666666666667, 0.1875
13875, 0, 1.4833333333333, 0.20833333333333
13876, 0, 1.4166666666667, 0.25
13877, 0, 1.4333333333333, 0.22916666666667
13878, 0, 1.45, 0.25
13879, 0, 1.4666666666667, 0.22916666666667
13880, 0, 1.4833333333333, 0.25
13881, 0, 1.4166666666667, 0.29166666666667
13882, 0, 1.4333333333333, 0.27083333333333
13883, 0, 1.45, 0.29166666666667
13884, 0, 1.4666666666667, 0.27083333333333
13885, 0, 1.4833333333333, 0.29166666666667
13886, 0, 1.4166666666667, 0.33333333333333
13887, 0, 1.4333333333333, 0.3125
13888, 0, 1.45, 0.33333333333333
13889, 0, 1.4666666666667, 0.3125
13890, 0, 1.4833333333333, 0.33333333333333
13891, 0, 1.4166666666667, 0.375
13892, 0, 1.4333333333333, 0.35416666666667
13893, 0, 1.45, 0.375
13894, 0, 1.4666666666667, 0.35416666666667
13895, 0, 1.4833333333333, 0.375
13896, 0, 1.4166666666667, 0.41666666666667
13897, 0, 1.4333333333333, 0.39583333333333
13898, 0, 1.45, 0.41666666666667
13899, 0, 1.4666666666667, 0.39583333333333
13900, 0, 1.4833333333333, 0.41666666666667
13901, 0, 1.4166666666667, 0.45833333333333
13902, 0, 1.4333333333333, 0.4375
13903, 0, 1.45, 0.45833333333333
13904, 0, 1.4666666666667, 0.4375
13905, 0, 1.4833333333333, 0.45833333333333
13906, 0, 1.4333333333333, 0.47916666666667
13907, 0, 1.4666666666667, 0.47916666666667
13908, 0.041666666666667, 1.5, 0.041666666666667
13909, 0.041666666666667, 1.5, 0.083333333333333
13910, 0.041666666666667, 1.5, 0.125
13911, 0.041666666666667, 1.5, 0.16666666666667
13912, 0.041666666666667, 1.5, 0.20833333333333
13913, 0.041666666666667, 1.5, 0.25
13914, 0.041666666666667, 1.5, 0.29166666666667
13915, 0.041666666666667, 1.5, 0.33333333333333
13916, 0.041666666666667, 1.5, 0.375
13917, 0.041666666666667, 1.5, 0.41666666666667
13918, 0.041666666666667, 1.5, 0.45833333333333
13919, 0.083333333333333, 1.5, 0.041666666666667
13920, 0.083333333333333, 1.5, 0.083333333333333
13921, 0.083333333333333, 1.5, 0.125
13922, 0.083333333333333, 1.5, 0.16666666666667
13923, 0.083333333333333, 1.5, 0.20833333333333
13924, 0.083333333333333, 1.5, 0.25
13925, 0.083333333333333, 1.5, 0.29166666666667
13926, 0.083333333333333, 1.5, 0.33333333333333
13927, 0.083333333333333, 1.5, 0.375
13928, 0.083333333333333, 1.5, 0.41666666666667
13929, 0.083333333333333, 1.5, 0.45833333333333
13930, 0.125, 1.5, 0.041666666666667
13931, 0.125, 1.5, 0.083333333333333
13932, 0.125, 1.5, 0.125
13933, 0.125, 1.5, 0.16666666666667
13934, 0.125, 1.5, 0.20833333333333
13935, 0.125, 1.5, 0.25
13936, 0.125, 1.5, 0.29166666666667
13937, 0.125, 1.5, 0.33333333333333
13938, 0.125, 1.5, 0.375
13939, 0.125, 1.5, 0.41666666666667
13940, 0.125, 1.5, 0.45833333333333
13941, 0.16666666666667, 1.5, 0.041666666666667
13942, 0.16666666666667, 1.5, 0.083333333333333
13943, 0.16666666666667, 1.5, 0.125
13944, 0.16666666666667, 1.5, 0.16666666666667
13945, 0.16666666666667, 1.5, 0.20833333333333
13946, 0.16666666666667, 1.5, 0.25
13947, 0.16666666666667, 1.5, 0.29166666666667
13948, 0.16666666666667, 1.5, 0.33333333333333
13949, 0.16666666666667, 1.5, 0.375
13950, 0.16666666666667, 1.5, 0.41666666666667
13951, 0.16666666666667, 1.5, 0.45833333333333
13952, 0.20833333333333, 1.5, 0.041666666666667
13953, 0.20833333333333, 1.5, 0.083333333333333
13954, 0.20833333333333, 1.5, 0.125
13955, 0.20833333333333, 1.5, 0.16666666666667
13956, 0.20833333333333, 1.5, 0.20833333333333
13957, 0.20833333333333, 1.5, 0.25
13958, 0.20833333333333, 1.5, 0.29166666666667
13959, 0.20833333333333, 1.5, 0.33333333333333
13960, 0.20833333333333, 1.5, 0.375
13961, 0.20833333333333, 1.5, 0.41666666666667
13962, 0.20833333333333, 1.5, 0.45833333333333
13963, 0.25, 1.5, 0.041666666666667
13964, 0.25, 1.5, 0.083333333333333
13965, 0.25, 1.5, 0.125
13966, 0.25, 1.5, 0.16666666666667
13967, 0.25, 1.5, 0.20833333333333
13968, 0.25, 1.5, 0.25
13969, 0.25, 1.5, 0.29166666666667
13970, 0.25, 1.5, 0.33333333333333
13971, 0.25, 1.5, 0.375
13972, 0.25, 1.5, 0.41666666666667
13973, 0.25, 1.5, 0.45833333333333
13974, 0.29166666666667, 1.5, 0.041666666666667
13975, 0.29166666666667, 1.5, 0.083333333333333
13976, 0.29166666666667, 1.5, 0.125
13977, 0.29166666666667, 1.5, 0.16666666666667
13978, 0.29166666666667, 1.5, 0.20833333333333
13979, 0.29166666666667, 1.5, 0.25
13980, 0.29166666666667, 1.5, 0.29166666666667
13981, 0.29166666666667, 1.5, 0.33333333333333
13982, 0.29166666666667, 1.5, 0.375
13983, 0.29166666666667, 1.5, 0.41666666666667
13984, 0.29166666666667, 1.5, 0.45833333333333
13985, 0.33333333333333, 1.5, 0.041666666666667
13986, 0.33333333333333, 1.5, 0.083333333333333
13987, 0.33333333333333, 1.5, 0.125
13988, 0.33333333333333, 1.5, 0.16666666666667
13989, 0.33333333333333, 1.5, 0.20833333333333
13990, 0.33333333333333, 1.5, 0.25
13991, 0.33333333333333, 1.5, 0.29166666666667
13992, 0.33333333333333, 1.5, 0.33333333333333
13993, 0.33333333333333, 1.5, 0.375
13994, 0.33333333333333, 1.5, 0.41666666666667
13995, 0.33333333333333, 1.5, 0.45833333333333
13996, 0.375, 1.5, 0.041666666666667
13997, 0.375, 1.5, 0.083333333333333
13998, 0.375, 1.5, 0.125
13999, 0.375, 1.5, 0.16666666666667
14000, 0.375, 1.5, 0.20833333333333
14001, 0.375, 1.5, 0.25
14002, 0.375, 1.5, 0.29166666666667
14003, 0.375, 1.5, 0.33333333333333
14004, 0.375, 1.5, 0.375
14005, 0.375, 1.5, 0.41666666666667
14006, 0.375, 1.5, 0.45833333333333
14007, 0.41666666666667, 1.5, 0.041666666666667
14008, 0.41666666666667, 1.5, 0.083333333333333
14009, 0.41666666666667, 1.5, 0.125
14010, 0.41666666666667, 1.5, 0.16666666666667
14011, 0.41666666666667, 1.5, 0.20833333333333
14012, 0.41666666666667, 1.5, 0.25
14013, 0.41666666666667, 1.5, 0.29166666666667
14014, 0.41666666666667, 1.5, 0.33333333333333
14015, 0.41666666666667, 1.5, 0.375
14016, 0.41666666666667, 1.5, 0.41666666666667
14017, 0.41666666666667, 1.5, 0.45833333333333
14018, 0.45833333333333, 1.5, 0.041666666666667
14019, 0.45833333333333, 1.5, 0.083333333333333
14020, 0.45833333333333, 1.5, 0.125
14021, 0.45833333333333, 1.5, 0.16666666666667
14022, 0.45833333333333, 1.5, 0.20833333333333
14023, 0.45833333333333, 1.5, 0.25
14024, 0.45833333333333, 1.5, 0.29166666666667
14025, 0.45833333333333, 1.5, 0.33333333333333
14026, 0.45833333333333, 1.5, 0.375
14027, 0.45833333333333, 1.5, 0.41666666666667
14028, 0.45833333333333, 1.5, 0.45833333333333
14029, 0.5, 1.5, 0.041666666666667
14030, 0.5, 1.5, 0.083333333333333
14031, 0.5, 1.5, 0.125
14032, 0.5, 1.5, 0.16666666666667
14033, 0.5, 1.5, 0.20833333333333
14034, 0.5, 1.5, 0.25
14035, 0.5, 1.5, 0.29166666666667
14036, 0.5, 1.5, 0.33333333333333
14037, 0.5, 1.5, 0.375
14038, 0.5, 1.5, 0.41666666666667
14039, 0.5, 1.5, 0.45833333333333
14040, 0.54166666666667, 1.5, 0.041666666666667
14041, 0.54166666666667, 1.5, 0.083333333333333
14042, 0.54166666666667, 1.5, 0.125
14043, 0.54166666666667, 1.5, 0.16666666666667
14044, 0.54166666666667, 1.5, 0.20833333333333
14045, 0.54166666666667, 1.5, 0.25
14046, 0.54166666666667, 1.5, 0.29166666666667
14047, 0.54166666666667, 1.5, 0.33333333333333
14048, 0.54166666666667, 1.5, 0.375
14049, 0.54166666666667, 1.5, 0.41666666666667
14050, 0.54166666666667, 1.5, 0.45833333333333
14051, 0.58333333333333, 1.5, 0.041666666666667
14052, 0.58333333333333, 1.5, 0.083333333333333
14053, 0.58333333333333, 1.5, 0.125
14054, 0.58333333333333, 1.5, 0.16666666666667
14055, 0.58333333333333, 1.5, 0.20833333333333
14056, 0.58333333333333, 1.5, 0.25
14057, 0.58333333333333, 1.5, 0.29166666666667
14058, 0.58333333333333, 1.5, 0.33333333333333
14059, 0.58333333333333, 1.5, 0.375
14060, 0.58333333333333, 1.5, 0.41666666666667
14061, 0.58333333333333, 1.5, 0.45833333333333
14062, 0.625, 1.5, 0.041666666666667
14063, 0.625, 1.5, 0.083333333333333
14064, 0.625, 1.5, 0.125
14065, 0.625, 1.5, 0.16666666666667
14066, 0.625, 1.5, 0.20833333333333
14067, 0.625, 1.5, 0.25
14068, 0.625, 1.5, 0.29166666666667
14069, 0.625, 1.5, 0.33333333333333
14070, 0.625, 1.5, 0.375
14071, 0.625, 1.5, 0.41666666666667
14072, 0.625, 1.5, 0.45833333333333
14073, 0.66666666666667, 1.5, 0.041666666666667
14074, 0.66666666666667, 1.5, 0.083333333333333
14075, 0.66666666666667, 1.5, 0.125
14076, 0.66666666666667, 1.5, 0.16666666666667
14077, 0.66666666666667, 1.5, 0.20833333333333
14078, 0.66666666666667, 1.5, 0.25
14079, 0.66666666666667, 1.5, 0.29166666666667
14080, 0.66666666666667, 1.5, 0.33333333333333
14081, 0.66666666666667, 1.5, 0.375
14082, 0.66666666666667, 1.5, 0.41666666666667
14083, 0.66666666666667, 1.5, 0.45833333333333
14084, 0.70833333333333, 1.5, 0.041666666666667
14085, 0.70833333333333, 1.5, 0.083333333333333
14086, 0.70833333333333, 1.5, 0.125
14087, 0.70833333333333, 1.5, 0.16666666666667
14088, 0.70833333333333, 1.5, 0.20833333333333
14089, 0.70833333333333, 1.5, 0.25
14090, 0.70833333333333, 1.5, 0.29166666666667
14091, 0.70833333333333, 1.5, 0.33333333333333
14092, 0.70833333333333, 1.5, 0.375
14093, 0.70833333333333, 1.5, 0.41666666666667
14094, 0.70833333333333, 1.5, 0.45833333333333
14095, 0.75, 1.5, 0.041666666666667
14096, 0.75, 1.5, 0.083333333333333
14097, 0.75, 1.5, 0.125
14098, 0.75, 1.5, 0.16666666666667
14099, 0.75, 1.5, 0.20833333333333
14100, 0.75, 1.5, 0.25
14101, 0.75, 1.5, 0.29166666666667
14102, 0.75, 1.5, 0.33333333333333
14103, 0.75, 1.5, 0.375
14104, 0.75, 1.5, 0.41666666666667
14105, 0.75, 1.5, 0.45833333333333
14106, 0.79166666666667, 1.5, 0.041666666666667
14107, 0.79166666666667, 1.5, 0.083333333333333
14108, 0.79166666666667, 1.5, 0.125
14109, 0.79166666666667, 1.5, 0.16666666666667
14110, 0.79166666666667, 1.5, 0.20833333333333
14111, 0.79166666666667, 1.5, 0.25
14112, 0.79166666666667, 1.5, 0.29166666666667
14113, 0.79166666666667, 1.5, 0.33333333333333
14114, 0.79166666666667, 1.5, 0.375
14115, 0.79166666666667, 1.5, 0.41666666666667
14116, 0.79166666666667, 1.5, 0.45833333333333
14117, 0.83333333333333, 1.5, 0.041666666666667
14118, 0.83333333333333, 1.5, 0.083333333333333
14119, 0.83333333333333, 1.5, 0.125
14120, 0.83333333333333, 1.5, 0.16666666666667
14121, 0.83333333333333, 1.5, 0.20833333333333
14122, 0.83333333333333, 1.5, 0.25
14123, 0.83333333333333, 1.5, 0.29166666666667
14124, 0.83333333333333, 1.5, 0.33333333333333
14125, 0.83333333333333, 1.5, 0.375
14126, 0.83333333333333, 1.5, 0.41666666666667
14127, 0.83333333333333, 1.5, 0.45833333333333
14128, 0.875, 1.5, 0.041666666666667
14129, 0.875, 1.5, 0.083333333333333
14130, 0.875, 1.5, 0.125
14131, 0.875, 1.5, 0.16666666666667
14132, 0.875, 1.5, 0.20833333333333
14133, 0.875, 1.5, 0.25
14134, 0.875, 1.5, 0.29166666666667
14135, 0.875, 1.5, 0.33333333333333
14136, 0.875, 1.5, 0.375
14137, 0.875, 1.5, 0.41666666666667
14138, 0.875, 1.5, 0.45833333333333
14139, 0.91666666666667, 1.5, 0.041666666666667
14140, 0.91666666666667, 1.5, 0.083333333333333
14141, 0.91666666666667, 1.5, 0.125
14142, 0.91666666666667, 1.5, 0.16666666666667
14143, 0.91666666666667, 1.5, 0.20833333333333
14144, 0.91666666666667, 1.5, 0.25
14145, 0.91666666666667, 1.5, 0.29166666666667
14146, 0.91666666666667, 1.5, 0.33333333333333
14147, 0.91666666666667, 1.5, 0.375
14148, 0.91666666666667, 1.5, 0.41666666666667
14149, 0.91666666666667, 1.5, 0.45833333333333
14150, 0.95833333333333, 1.5, 0.041666666666667
14151, 0.95833333333333, 1.5, 0.083333333333333
14152, 0.95833333333333, 1.5, 0.125
14153, 0.95833333333333, 1.5, 0.16666666666667
14154, 0.95833333333333, 1.5, 0.20833333333333
14155, 0.95833333333333, 1.5, 0.25
14156, 0.95833333333333, 1.5, 0.29166666666667
14157, 0.95833333333333, 1.5, 0.33333333333333
14158, 0.95833333333333, 1.5, 0.375
14159, 0.95833333333333, 1.5, 0.41666666666667
14160, 0.95833333333333, 1.5, 0.45833333333333
14161, 0.020833333333333, 1.5, 0.041666666666667
14162, 0.041666666666667, 1.5, 0.020833333333333
14163, 0.020833333333333, 1.5, 0.083333333333333
14164, 0.041666666666667, 1.5, 0.0625
14165, 0.020833333333333, 1.5, 0.125
14166, 0.041666666666667, 1.5, 0.10416666666667
14167, 0.020833333333333, 1.5, 0.16666666666667
14168, 0.041666666666667, 1.5, 0.14583333333333
14169, 0.020833333333333, 1.5, 0.20833333333333
14170, 0.041666666666667, 1.5, 0.1875
14171, 0.020833333333333, 1.5, 0.25
14172, 0.041666666666667, 1.5, 0.22916666666667
14173, 0.020833333333333, 1.5, 0.29166666666667
14174, 0.041666666666667, 1.5, 0.27083333333333
14175, 0.020833333333333, 1.5, 0.33333333333333
14176, 0.041666666666667, 1.5, 0.3125
14177, 0.020833333333333, 1.5, 0.375
14178, 0.041666666666667, 1.5, 0.35416666666667
14179, 0.020833333333333, 1.5, 0.41666666666667
14180, 0.041666666666667, 1.5, 0.39583333333333
14181, 0.020833333333333, 1.5, 0.45833333333333
14182, 0.041666666666667, 1.5, 0.4375
14183, 0.041666666666667, 1.5, 0.47916666666667
14184, 0.0625, 1.5, 0.041666666666667
14185, 0.083333333333333, 1.5, 0.020833333333333
14186, 0.0625, 1.5, 0.083333333333333
14187, 0.083333333333333, 1.5, 0.0625
14188, 0.0625, 1.5, 0.125
14189, 0.083333333333333, 1.5, 0.10416666666667
14190, 0.0625, 1.5, 0.16666666666667
14191, 0.083333333333333, 1.5, 0.14583333333333
14192, 0.0625, 1.5, 0.20833333333333
14193, 0.083333333333333, 1.5, 0.1875
14194, 0.0625, 1.5, 0.25
14195, 0.083333333333333, 1.5, 0.22916666666667
14196, 0.0625, 1.5, 0.29166666666667
14197, 0.083333333333333, 1.5, 0.27083333333333
14198, 0.0625, 1.5, 0.33333333333333
14199, 0.083333333333333, 1.5, 0.3125
14200, 0.0625, 1.5, 0.375
14201, 0.083333333333333, 1.5, 0.35416666666667
14202, 0.0625, 1.5, 0.41666666666667
14203, 0.083333333333333, 1.5, 0.39583333333333
14204, 0.0625, 1.5, 0.45833333333333
14205, 0.083333333333333, 1.5, 0.4375
14206, 0.083333333333333, 1.5, 0.47916666666667
14207, 0.10416666666667, 1.5, 0.041666666666667
14208, 0.125, 1.5, 0.020833333333333
14209, 0.10416666666667, 1.5, 0.083333333333333
14210, 0.125, 1.5, 0.0625
14211, 0.10416666666667, 1.5, 0.125
14212, 0.125, 1.5, 0.10416666666667
14213, 0.10416666666667, 1.5, 0.16666666666667
14214, 0.125, 1.5, 0.14583333333333
14215, 0.10416666666667, 1.5, 0.20833333333333
14216, 0.125, 1.5, 0.1875
14217, 0.10416666666667, 1.5, 0.25
14218, 0.125, 1.5, 0.22916666666667
14219, 0.10416666666667, 1.5, 0.29166666666667
14220, 0.125, 1.5, 0.27083333333333
14221, 0.10416666666667, 1.5, 0.33333333333333
14222, 0.125, 1.5, 0.3125
14223, 0.10416666666667, 1.5, 0.375
14224, 0.125, 1.5, 0.35416666666667
14225, 0.10416666666667, 1.5, 0.41666666666667
14226, 0.125, 1.5, 0.39583333333333
14227, 0.10416666666667, 1.5, 0.45833333333333
14228, 0.125, 1.5, 0.4375
14229, 0.125, 1.5, 0.47916666666667
14230, 0.14583333333333, 1.5, 0.041666666666667
14231, 0.16666666666667, 1.5, 0.020833333333333
14232, 0.14583333333333, 1.5, 0.083333333333333
14233, 0.16666666666667, 1.5, 0.0625
14234, 0.14583333333333, 1.5, 0.125
14235, 0.16666666666667, 1.5, 0.10416666666667
14236, 0.14583333333333, 1.5, 0.16666666666667
14237, 0.16666666666667, 1.5, 0.14583333333333
14238, 0.14583333333333, 1.5, 0.20833333333333
14239, 0.16666666666667, 1.5, 0.1875
14240, 0.14583333333333, 1.5, 0.25
14241, 0.16666666666667, 1.5, 0.22916666666667
14242, 0.14583333333333, 1.5, 0.29166666666667
14243, 0.16666666666667, 1.5, 0.27083333333333
14244, 0.14583333333333, 1.5, 0.33333333333333
14245, 0.16666666666667, 1.5, 0.3125
14246, 0.14583333333333, 1.5, 0.375
14247, 0.16666666666667, 1.5, 0.35416666666667
14248, 0.14583333333333, 1.5, 0.41666666666667
14249, 0.16666666666667, 1.5, 0.39583333333333
14250, 0.14583333333333, 1.5, 0.45833333333333
14251, 0.16666666666667, 1.5, 0.4375
14252, 0.16666666666667, 1.5, 0.47916666666667
14253, 0.1875, 1.5, 0.041666666666667
14254, 0.20833333333333, 1.5, 0.020833333333333
14255, 0.1875, 1.5, 0.083333333333333
14256, 0.20833333333333, 1.5, 0.0625
14257, 0.1875, 1.5, 0.125
14258, 0.20833333333333, 1.5, 0.10416666666667
14259, 0.1875, 1.5, 0.16666666666667
14260, 0.20833333333333, 1.5, 0.14583333333333
14261, 0.1875, 1.5, 0.20833333333333
14262, 0.20833333333333, 1.5, 0.1875
14263, 0.1875, 1.5, 0.25
14264, 0.20833333333333, 1.5, 0.22916666666667
14265, 0.1875, 1.5, 0.29166666666667
14266, 0.20833333333333, 1.5, 0.27083333333333
14267, 0.1875, 1.5, 0.33333333333333
14268, 0.20833333333333, 1.5, 0.3125
14269, 0.1875, 1.5, 0.375
14270, 0.20833333333333, 1.5, 0.35416666666667
14271, 0.1875, 1.5, 0.41666666666667
14272, 0.20833333333333, 1.5, 0.39583333333333
14273, 0.1875, 1.5, 0.45833333333333
14274, 0.20833333333333, 1.5, 0.4375
14275, 0.20833333333333, 1.5, 0.47916666666667
14276, 0.22916666666667, 1.5, 0.041666666666667
14277, 0.25, 1.5, 0.020833333333333
14278, 0.22916666666667, 1.5, 0.083333333333333
14279, 0.25, 1.5, 0.0625
14280, 0.22916666666667, 1.5, 0.125
14281, 0.25, 1.5, 0.10416666666667
14282, 0.22916666666667, 1.5, 0.16666666666667
14283, 0.25, 1.5, 0.14583333333333
14284, 0.22916666666667, 1.5, 0.20833333333333
14285, 0.25, 1.5, 0.1875
14286, 0.22916666666667, 1.5, 0.25
14287, 0.25, 1.5, 0.22916666666667
14288, 0.22916666666667, 1.5, 0.29166666666667
14289, 0.25, 1.5, 0.27083333333333
14290, 0.22916666666667, 1.5, 0.33333333333333
14291, 0.25, 1.5, 0.3125
14292, 0.22916666666667, 1.5, 0.375
14293, 0.25, 1.5, 0.35416666666667
14294, 0.22916666666667, 1.5, 0.41666666666667
14295, 0.25, 1.5, 0.39583333333333
14296, 0.22916666666667, 1.5, 0.45833333333333
14297, 0.25, 1.5, 0.4375
14298, 0.25, 1.5, 0.47916666666667
14299, 0.27083333333333, 1.5, 0.041666666666667
14300, 0.29166666666667, 1.5, 0.020833333333333
14301, 0.27083333333333, 1.5, 0.083333333333333
14302, 0.29166666666667, 1.5, 0.0625
14303, 0.27083333333333, 1.5, 0.125
14304, 0.29166666666667, 1.5, 0.10416666666667
14305, 0.27083333333333, 1.5, 0.16666666666667
14306, 0.29166666666667, 1.5, 0.14583333333333
14307, 0.27083333333333, 1.5, 0.20833333333333
14308, 0.29166666666667, 1.5, 0.1875
14309, 0.27083333333333, 1.5, 0.25
14310, 0.29166666666667, 1.5, 0.22916666666667
14311, 0.27083333333333, 1.5, 0.29166666666667
14312, 0.29166666666667, 1.5, 0.27083333333333
14313, 0.27083333333333, 1.5, 0.33333333333333
14314, 0.29166666666667, 1.5, 0.3125
14315, 0.27083333333333, 1.5, 0.375
14316, 0.29166666666667, 1.5, 0.35416666666667
14317, 0.27083333333333, 1.5, 0.41666666666667
14318, 0.29166666666667, 1.5, 0.39583333333333
14319, 0.27083333333333, 1.5, 0.45833333333333
14320, 0.29166666666667, 1.5, 0.4375
14321, 0.29166666666667, 1.5, 0.47916666666667
14322, 0.3125, 1.5, 0.041666666666667
14323, 0.33333333333333, 1.5, 0.020833333333333
14324, 0.3125, 1.5, 0.083333333333333
14325, 0.33333333333333, 1.5, 0.0625
14326, 0.3125, 1.5, 0.125
14327, 0.33333333333333, 1.5, 0.10416666666667
14328, 0.3125, 1.5, 0.16666666666667
14329, 0.33333333333333, 1.5, 0.14583333333333
14330, 0.3125, 1.5, 0.20833333333333
14331, 0.33333333333333, 1.5, 0.1875
14332, 0.3125, 1.5, 0.25
14333, 0.33333333333333, 1.5, 0.22916666666667
14334, 0.3125, 1.5, 0.29166666666667
14335, 0.33333333333333, 1.5, 0.27083333333333
14336, 0.3125, 1.5, 0.33333333333333
14337, 0.33333333333333, 1.5, 0.3125
14338, 0.3125, 1.5, 0.375
14339, 0.33333333333333, 1.5, 0.35416666666667
14340, 0.3125, 1.5, 0.41666666666667
14341, 0.33333333333333, 1.5, 0.39583333333333
14342, 0.3125, 1.5, 0.45833333333333
14343, 0.33333333333333, 1.5, 0.4375
14344, 0.33333333333333, 1.5, 0.47916666666667
14345, 0.35416666666667, 1.5, 0.041666666666667
14346, 0.375, 1.5, 0.020833333333333
14347, 0.35416666666667, 1.5, 0.083333333333333
14348, 0.375, 1.5, 0.0625
14349, 0.35416666666667, 1.5, 0.125
14350, 0.375, 1.5, 0.10416666666667
14351, 0.35416666666667, 1.5, 0.16666666666667
14352, 0.375, 1.5, 0.14583333333333
14353, 0.35416666666667, 1.5, 0.20833333333333
14354, 0.375, 1.5, 0.1875
14355, 0.35416666666667, 1.5, 0.25
14356, 0.375, 1.5, 0.22916666666667
14357, 0.35416666666667, 1.5, 0.29166666666667
14358, 0.375, 1.5, 0.27083333333333
14359, 0.35416666666667, 1.5, 0.33333333333333
14360, 0.375, 1.5, 0.3125
14361, 0.35416666666667, 1.5, 0.375
14362, 0.375, 1.5, 0.35416666666667
14363, 0.35416666666667, 1.5, 0.41666666666667
14364, 0.375, 1.5, 0.39583333333333
14365, 0.35416666666667, 1.5, 0.45833333333333
14366, 0.375, 1.5, 0.4375
14367, 0.375, 1.5, 0.47916666666667
14368, 0.39583333333333, 1.5, 0.041666666666667
14369, 0.41666666666667, 1.5, 0.020833333333333
14370, 0.39583333333333, 1.5, 0.083333333333333
14371, 0.41666666666667, 1.5, 0.0625
14372, 0.39583333333333, 1.5, 0.125
14373, 0.41666666666667, 1.5, 0.10416666666667
14374, 0.39583333333333, 1.5, 0.16666666666667
14375, 0.41666666666667, 1.5, 0.14583333333333
14376, 0.39583333333333, 1.5, 0.20833333333333
14377, 0.41666666666667, 1.5, 0.1875
14378, 0.39583333333333, 1.5, 0.25
14379, 0.41666666666667, 1.5, 0.22916666666667
14380, 0.39583333333333, 1.5, 0.29166666666667
14381, 0.41666666666667, 1.5, 0.27083333333333
14382, 0.39583333333333, 1.5, 0.33333333333333
14383, 0.41666666666667, 1.5, 0.3125
14384, 0.39583333333333, 1.5, 0.375
14385, 0.41666666666667, 1.5, 0.35416666666667
14386, 0.39583333333333, 1.5, 0.41666666666667
14387, 0.41666666666667, 1.5, 0.39583333333333
14388, 0.39583333333333, 1.5, 0.45833333333333
14389, 0.41666666666667, 1.5, 0.4375
14390, 0.41666666666667, 1.5, 0.47916666666667
14391, 0.4375, 1.5, 0.041666666666667
14392, 0.45833333333333, 1.5, 0.020833333333333
14393, 0.4375, 1.5, 0.083333333333333
14394, 0.45833333333333, 1.5, 0.0625
14395, 0.4375, 1.5, 0.125
14396, 0.45833333333333, 1.5, 0.10416666666667
14397, 0.4375, 1.5, 0.16666666666667
14398, 0.45833333333333, 1.5, 0.14583333333333
14399, 0.4375, 1.5, 0.20833333333333
14400, 0.45833333333333, 1.5, 0.1875
14401, 0.4375, 1.5, 0.25
14402, 0.45833333333333, 1.5, 0.22916666666667
14403, 0.4375, 1.5, 0.29166666666667
14404, 0.45833333333333, 1.5, 0.27083333333333
14405, 0.4375, 1.5, 0.33333333333333
14406, 0.45833333333333, 1.5, 0.3125
14407, 0.4375, 1.5, 0.375
14408, 0.45833333333333, 1.5, 0.35416666666667
14409, 0.4375, 1.5, 0.41666666666667
14410, 0.45833333333333, 1.5, 0.39583333333333
14411, 0.4375, 1.5, 0.45833333333333
14412, 0.45833333333333, 1.5, 0.4375
14413, 0.45833333333333, 1.5, 0.47916666666667
14414, 0.47916666666667, 1.5, 0.041666666666667
14415, 0.5, 1.5, 0.020833333333333
14416, 0.47916666666667, 1.5, 0.083333333333333
14417, 0.5, 1.5, 0.0625
14418, 0.47916666666667, 1.5, 0.125
14419, 0.5, 1.5, 0.10416666666667
14420, 0.47916666666667, 1.5, 0.16666666666667
14421, 0.5, 1.5, 0.14583333333333
14422, 0.47916666666667, 1.5, 0.20833333333333
14423, 0.5, 1.5, 0.1875
14424, 0.47916666666667, 1.5, 0.25
14425, 0.5, 1.5, 0.22916666666667
14426, 0.47916666666667, 1.5, 0.29166666666667
14427, 0.5, 1.5, 0.27083333333333
14428, 0.47916666666667, 1.5, 0.33333333333333
14429, 0.5, 1.5, 0.3125
14430, 0.47916666666667, 1.5, 0.375
14431, 0.5, 1.5, 0.35416666666667
14432, 0.47916666666667, 1.5, 0.41666666666667
14433, 0.5, 1.5, 0.39583333333333
14434, 0.47916666666667, 1.5, 0.45833333333333
14435, 0.5, 1.5, 0.4375
14436, 0.5, 1.5, 0.47916666666667
14437, 0.52083333333333, 1.5, 0.041666666666667
14438, 0.54166666666667, 1.5, 0.020833333333333
14439, 0.52083333333333, 1.5, 0.083333333333333
14440, 0.54166666666667, 1.5, 0.0625
14441, 0.52083333333333, 1.5, 0.125
14442, 0.54166666666667, 1.5, 0.10416666666667
14443, 0.52083333333333, 1.5, 0.16666666666667
14444, 0.54166666666667, 1.5, 0.14583333333333
14445, 0.52083333333333, 1.5, 0.20833333333333
14446, 0.54166666666667, 1.5, 0.1875
14447, 0.52083333333333, 1.5, 0.25
14448, 0.54166666666667, 1.5, 0.22916666666667
14449, 0.52083333333333, 1.5, 0.29166666666667
14450, 0.54166666666667, 1.5, 0.27083333333333
14451, 0.52083333333333, 1.5, 0.33333333333333
14452, 0.54166666666667, 1.5, 0.3125
14453, 0.52083333333333, 1.5, 0.375
14454, 0.54166666666667, 1.5, 0.35416666666667
14455, 0.52083333333333, 1.5, 0.41666666666667
14456, 0.54166666666667, 1.5, 0.39583333333333
14457, 0.52083333333333, 1.5, 0.45833333333333
14458, 0.54166666666667, 1.5, 0.4375
14459, 0.54166666666667, 1.5, 0.47916666666667
14460, 0.5625, 1.5, 0.041666666666667
14461, 0.58333333333333, 1.5, 0.020833333333333
14462, 0.5625, 1.5, 0.083333333333333
14463, 0.58333333333333, 1.5, 0.0625
14464, 0.5625, 1.5, 0.125
14465, 0.58333333333333, 1.5, 0.10416666666667
14466, 0.5625, 1.5, 0.16666666666667
14467, 0.58333333333333, 1.5, 0.14583333333333
14468, 0.5625, 1.5, 0.20833333333333
14469, 0.58333333333333, 1.5, 0.1875
14470, 0.5625, 1.5, 0.25
14471, 0.58333333333333, 1.5, 0.22916666666667
14472, 0.5625, 1.5, 0.29166666666667
14473, 0.58333333333333, 1.5, 0.27083333333333
14474, 0.5625, 1.5, 0.33333333333333
14475, 0.58333333333333, 1.5, 0.3125
14476, 0.5625, 1.5, 0.375
14477, 0.58333333333333, 1.5, 0.35416666666667
14478, 0.5625, 1.5, 0.41666666666667
14479, 0.58333333333333, 1.5, 0.39583333333333
14480, 0.5625, 1.5, 0.45833333333333
14481, 0.58333333333333, 1.5, 0.4375
14482, 0.58333333333333, 1.5, 0.47916666666667
14483, 0.60416666666667, 1.5, 0.041666666666667
14484, 0.625, 1.5, 0.020833333333333
14485, 0.60416666666667, 1.5, 0.083333333333333
14486, 0.625, 1.5, 0.0625
14487, 0.60416666666667, 1.5, 0.125
14488, 0.625, 1.5, 0.10416666666667
14489, 0.60416666666667, 1.5, 0.16666666666667
14490, 0.625, 1.5, 0.14583333333333
14491, 0.60416666666667, 1.5, 0.20833333333333
14492, 0.625, 1.5, 0.1875
14493, 0.60416666666667, 1.5, 0.25
14494, 0.625, 1.5, 0.22916666666667
14495, 0.60416666666667, 1.5, 0.29166666666667
14496, 0.625, 1.5, 0.27083333333333
14497, 0.60416666666667, 1.5, 0.33333333333333
14498, 0.625, 1.5, 0.3125
14499, 0.60416666666667, 1.5, 0.375
14500, 0.625, 1.5, 0.35416666666667
14501, 0.60416666666667, 1.5, 0.41666666666667
14502, 0.625, 1.5, 0.39583333333333
14503, 0.60416666666667, 1.5, 0.45833333333333
14504, 0.625, 1.5, 0.4375
14505, 0.625, 1.5, 0.47916666666667
14506, 0.64583333333333, 1.5, 0.041666666666667
14507, 0.66666666666667, 1.5, 0.020833333333333
14508, 0.64583333333333, 1.5, 0.083333333333333
14509, 0.66666666666667, 1.5, 0.0625
14510, 0.64583333333333, 1.5, 0.125
14511, 0.66666666666667, 1.5, 0.10416666666667
14512, 0.64583333333333, 1.5, 0.16666666666667
14513, 0.66666666666667, 1.5, 0.14583333333333
14514, 0.64583333333333, 1.5, 0.20833333333333
14515, 0.66666666666667, 1.5, 0.1875
14516, 0.64583333333333, 1.5, 0.25
14517, 0.66666666666667, 1.5, 0.22916666666667
14518, 0.64583333333333, 1.5, 0.29166666666667
14519, 0.66666666666667, 1.5, 0.27083333333333
14520, 0.64583333333333, 1.5, 0.33333333333333
14521, 0.66666666666667, 1.5, 0.3125
14522, 0.64583333333333, 1.5, 0.375
14523, 0.66666666666667, 1.5, 0.35416666666667
14524, 0.64583333333333, 1.5, 0.41666666666667
14525, 0.66666666666667, 1.5, 0.39583333333333
14526, 0.64583333333333, 1.5, 0.45833333333333
14527, 0.66666666666667, 1.5, 0.4375
14528, 0.66666666666667, 1.5, 0.47916666666667
14529, 0.6875, 1.5, 0.041666666666667
14530, 0.70833333333333, 1.5, 0.020833333333333
14531, 0.6875, 1.5, 0.083333333333333
14532, 0.70833333333333, 1.5, 0.0625
14533, 0.6875, 1.5, 0.125
14534, 0.70833333333333, 1.5, 0.10416666666667
14535, 0.6875, 1.5, 0.16666666666667
14536, 0.70833333333333, 1.5, 0.14583333333333
14537, 0.6875, 1.5, 0.20833333333333
14538, 0.70833333333333, 1.5, 0.1875
14539, 0.6875, 1.5, 0.25
14540, 0.70833333333333, 1.5, 0.22916666666667
14541, 0.6875, 1.5, 0.29166666666667
14542, 0.70833333333333, 1.5, 0.27083333333333
14543, 0.6875, 1.5, 0.33333333333333
14544, 0.70833333333333, 1.5, 0.3125
14545, 0.6875, 1.5, 0.375
14546, 0.70833333333333, 1.5, 0.35416666666667
14547, 0.6875, 1.5, 0.41666666666667
14548, 0.70833333333333, 1.5, 0.39583333333333
14549, 0.6875, 1.5, 0.45833333333333
14550, 0.70833333333333, 1.5, 0.4375
14551, 0.70833333333333, 1.5, 0.47916666666667
14552, 0.72916666666667, 1.5, 0.041666666666667
14553, 0.75, 1.5, 0.020833333333333
14554, 0.72916666666667, 1.5, 0.083333333333333
14555, 0.75, 1.5, 0.0625
14556, 0.72916666666667, 1.5, 0.125
14557, 0.75, 1.5, 0.10416666666667
14558, 0.72916666666667, 1.5, 0.16666666666667
14559, 0.75, 1.5, 0.14583333333333
14560, 0.72916666666667, 1.5, 0.20833333333333
14561, 0.75, 1.5, 0.1875
14562, 0.72916666666667, 1.5, 0.25
14563, 0.75, 1.5, 0.22916666666667
14564, 0.72916666666667, 1.5, 0.29166666666667
14565, 0.75, 1.5, 0.27083333333333
14566, 0.72916666666667, 1.5, 0.33333333333333
14567, 0.75, 1.5, 0.3125
14568, 0.72916666666667, 1.5, 0.375
14569, 0.75, 1.5, 0.35416666666667
14570, 0.72916666666667, 1.5, 0.41666666666667
14571, 0.75, 1.5, 0.39583333333333
14572, 0.72916666666667, 1.5, 0.45833333333333
14573, 0.75, 1.5, 0.4375
14574, 0.75, 1.5, 0.47916666666667
14575, 0.77083333333333, 1.5, 0.041666666666667
14576, 0.79166666666667, 1.5, 0.020833333333333
14577, 0.77083333333333, 1.5, 0.083333333333333
14578, 0.79166666666667, 1.5, 0.0625
14579, 0.77083333333333, 1.5, 0.125
14580, 0.79166666666667, 1.5, 0.10416666666667
14581, 0.77083333333333, 1.5, 0.16666666666667
14582, 0.79166666666667, 1.5, 0.14583333333333
14583, 0.77083333333333, 1.5, 0.20833333333333
14584, 0.79166666666667, 1.5, 0.1875
14585, 0.77083333333333, 1.5, 0.25
14586, 0.79166666666667, 1.5, 0.22916666666667
14587, 0.77083333333333, 1.5, 0.29166666666667
14588, 0.79166666666667, 1.5, 0.27083333333333
14589, 0.77083333333333, 1.5, 0.33333333333333
14590, 0.79166666666667, 1.5, 0.3125
14591, 0.77083333333333, 1.5, 0.375
14592, 0.79166666666667, 1.5, 0.35416666666667
14593, 0.77083333333333, 1.5, 0.41666666666667
14594, 0.79166666666667, 1.5, 0.39583333333333
14595, 0.77083333333333, 1.5, 0.45833333333333
14596, 0.79166666666667, 1.5, 0.4375
14597, 0.79166666666667, 1.5, 0.47916666666667
14598, 0.8125, 1.5, 0.041666666666667
14599, 0.83333333333333, 1.5, 0.020833333333333
14600, 0.8125, 1.5, 0.083333333333333
14601, 0.83333333333333, 1.5, 0.0625
14602, 0.8125, 1.5, 0.125
14603, 0.83333333333333, 1.5, 0.10416666666667
14604, 0.8125, 1.5, 0.16666666666667
14605, 0.83333333333333, 1.5, 0.14583333333333
14606, 0.8125, 1.5, 0.20833333333333
14607, 0.83333333333333, 1.5, 0.1875
14608, 0.8125, 1.5, 0.25
14609, 0.83333333333333, 1.5, 0.22916666666667
14610, 0.8125, 1.5, 0.29166666666667
14611, 0.83333333333333, 1.5, 0.27083333333333
14612, 0.8125, 1.5, 0.33333333333333
14613, 0.83333333333333, 1.5, 0.3125
14614, 0.8125, 1.5, 0.375
14615, 0.83333333333333, 1.5, 0.35416666666667
14616, 0.8125, 1.5, 0.41666666666667
14617, 0.83333333333333, 1.5, 0.39583333333333
14618, 0.8125, 1.5, 0.45833333333333
14619, 0.83333333333333, 1.5, 0.4375
14620, 0.83333333333333, 1.5, 0.47916666666667
14621, 0.85416666666667, 1.5, 0.041666666666667
14622, 0.875, 1.5, 0.020833333333333
14623, 0.85416666666667, 1.5, 0.083333333333333
14624, 0.875, 1.5, 0.0625
14625, 0.85416666666667, 1.5, 0.125
14626, 0.875, 1.5, 0.10416666666667
14627, 0.85416666666667, 1.5, 0.16666666666667
14628, 0.875, 1.5, 0.14583333333333
14629, 0.85416666666667, 1.5, 0.20833333333333
14630, 0.875, 1.5, 0.1875
14631, 0.85416666666667, 1.5, 0.25
14632, 0.875, 1.5, 0.22916666666667
14633, 0.85416666666667, 1.5, 0.29166666666667
14634, 0.875, 1.5, 0.27083333333333
14635, 0.85416666666667, 1.5, 0.33333333333333
14636, 0.875, 1.5, 0.3125
14637, 0.85416666666667, 1.5, 0.375
14638, 0.875, 1.5, 0.35416666666667
14639, 0.85416666666667, 1.5, 0.41666666666667
14640, 0.875, 1.5, 0.39583333333333
14641, 0.85416666666667, 1.5, 0.45833333333333
14642, 0.875, 1.5, 0.4375
14643, 0.875, 1.5, 0.47916666666667
14644, 0.89583333333333, 1.5, 0.041666666666667
14645, 0.91666666666667, 1.5, 0.020833333333333
14646, 0.89583333333333, 1.5, 0.083333333333333
14647, 0.91666666666667, 1.5, 0.0625
14648, 0.89583333333333, 1.5, 0.125
14649, 0.91666666666667, 1.5, 0.10416666666667
14650, 0.89583333333333, 1.5, 0.16666666666667
14651, 0.91666666666667, 1.5, 0.14583333333333
14652, 0.89583333333333, 1.5, 0.20833333333333
14653, 0.91666666666667, 1.5, 0.1875
14654, 0.89583333333333, 1.5, 0.25
14655, 0.91666666666667, 1.5, 0.22916666666667
14656, 0.89583333333333, 1.5, 0.29166666666667
14657, 0.91666666666667, 1.5, 0.27083333333333
14658, 0.89583333333333, 1.5, 0.33333333333333
14659, 0.91666666666667, 1.5, 0.3125
14660, 0.89583333333333, 1.5, 0.375
14661, 0.91666666666667, 1.5, 0.35416666666667
14662, 0.89583333333333, 1.5, 0.41666666666667
14663, 0.91666666666667, 1.5, 0.39583333333333
14664, 0.89583333333333, 1.5, 0.45833333333333
14665, 0.91666666666667, 1.5, 0.4375
14666, 0.91666666666667, 1.5, 0.47916666666667
14667, 0.9375, 1.5, 0.041666666666667
14668, 0.95833333333333, 1.5, 0.020833333333333
14669, 0.9375, 1.5, 0.083333333333333
14670, 0.95833333333333, 1.5, 0.0625
14671, 0.9375, 1.5, 0.125
14672, 0.95833333333333, 1.5, 0.10416666666667
14673, 0.9375, 1.5, 0.16666666666667
14674, 0.95833333333333, 1.5, 0.14583333333333
14675, 0.9375, 1.5, 0.20833333333333
14676, 0.95833333333333, 1.5, 0.1875
14677, 0.9375, 1.5, 0.25
14678, 0.95833333333333, 1.5, 0.22916666666667
14679, 0.9375, 1.5, 0.29166666666667
14680, 0.95833333333333, 1.5, 0.27083333333333
14681, 0.9375, 1.5, 0.33333333333333
14682, 0.95833333333333, 1.5, 0.3125
14683, 0.9375, 1.5, 0.375
14684, 0.95833333333333, 1.5, 0.35416666666667
14685, 0.9375, 1.5, 0.41666666666667
14686, 0.95833333333333, 1.5, 0.39583333333333
14687, 0.9375, 1.5, 0.45833333333333
14688, 0.95833333333333, 1.5, 0.4375
14689, 0.95833333333333, 1.5, 0.47916666666667
14690, 0.97916666666667, 1.5, 0.041666666666667
14691, 0.97916666666667, 1.5, 0.083333333333333
14692, 0.97916666666667, 1.5, 0.125
14693, 0.97916666666667, 1.5, 0.16666666666667
14694, 0.97916666666667, 1.5, 0.20833333333333
14695, 0.97916666666667, 1.5, 0.25
14696, 0.97916666666667, 1.5, 0.29166666666667
14697, 0.97916666666667, 1.5, 0.33333333333333
14698, 0.97916666666667, 1.5, 0.375
14699, 0.97916666666667, 1.5, 0.41666666666667
14700, 0.97916666666667, 1.5, 0.45833333333333
14701, 1.04, 1.4333333333333, 0.5
14702, 1.08, 1.4333333333333, 0.5
14703, 1.12, 1.4333333333333, 0.5
14704, 1.16, 1.4333333333333, 0.5
14705, 1.04, 1.4666666666667, 0.5
14706, 1.08, 1.4666666666667, 0.5
14707, 1.12, 1.4666666666667, 0.5
14708, 1.16, 1.4666666666667, 0.5
14709, 1.04, 1.4166666666667, 0.5
14710, 1.02, 1.4333333333333, 0.5
14711, 1.08, 1.4166666666667, 0.5
14712, 1.06, 1.4333333333333, 0.5
14713, 1.12, 1.4166666666667, 0.5
14714, 1.1, 1.4333333333333, 0.5
14715, 1.16, 1.4166666666667, 0.5
14716, 1.14, 1.4333333333333, 0.5
14717, 1.18, 1.4333333333333, 0.5
14718, 1.04, 1.45, 0.5
14719, 1.02, 1.4666666666667, 0.5
14720, 1.08, 1.45, 0.5
14721, 1.06, 1.4666666666667, 0.5
14722, 1.12, 1.45, 0.5
14723, 1.1, 1.4666666666667, 0.5
14724, 1.16, 1.45, 0.5
14725, 1.14, 1.4666666666667, 0.5
14726, 1.18, 1.4666666666667, 0.5
14727, 1.04, 1.4833333333333, 0.5
14728, 1.08, 1.4833333333333, 0.5
14729, 1.12, 1.4833333333333, 0.5
14730, 1.16, 1.4833333333333, 0.5
14731, 1.04, 1.4333333333333, 0
14732, 1.08, 1.4333333333333, 0
14733, 1.12, 1.4333333333333, 0
14734, 1.16, 1.4333333333333, 0
14735, 1.04, 1.4666666666667, 0
14736, 1.08, 1.4666666666667, 0
14737, 1.12, 1.4666666666667, 0
14738, 1.16, 1.4666666666667, 0
14739, 1.02, 1.4333333333333, 0
14740, 1.04, 1.4166666666667, 0
14741, 1.06, 1.4333333333333, 0
14742, 1.08, 1.4166666666667, 0
14743, 1.1, 1.4333333333333, 0
14744, 1.12, 1.4166666666667, 0
14745, 1.14, 1.4333333333333, 0
14746, 1.16, 1.4166666666667, 0
14747, 1.18, 1.4333333333333, 0
14748, 1.02, 1.4666666666667, 0
14749, 1.04, 1.45, 0
14750, 1.06, 1.4666666666667, 0
14751, 1.08, 1.45, 0
14752, 1.1, 1.4666666666667, 0
14753, 1.12, 1.45, 0
14754, 1.14, 1.4666666666667, 0
14755, 1.16, 1.45, 0
14756, 1.18, 1.4666666666667, 0
14757, 1.04, 1.4833333333333, 0
14758, 1.08, 1.4833333333333, 0
14759, 1.12, 1.4833333333333, 0
14760, 1.16, 1.4833333333333, 0
14761, 1.04, 1.4, 0.041666666666667
14762, 1.08, 1.4, 0.041666666666667
14763, 1.12, 1.4, 0.041666666666667
14764, 1.16, 1.4, 0.041666666666667
14765, 1.04, 1.4, 0.083333333333333
14766, 1.08, 1.4, 0.083333333333333
14767, 1.12, 1.4, 0.083333333333333
14768, 1.16, 1.4, 0.083333333333333
14769, 1.04, 1.4, 0.125
14770, 1.08, 1.4, 0.125
14771, 1.12, 1.4, 0.125
14772, 1.16, 1.4, 0.125
14773, 1.04, 1.4, 0.16666666666667
14774, 1.08, 1.4, 0.16666666666667
14775, 1.12, 1.4, 0.16666666666667
14776, 1.16, 1.4, 0.16666666666667
14777, 1.04, 1.4, 0.20833333333333
14778, 1.08, 1.4, 0.20833333333333
14779, 1.12, 1.4, 0.20833333333333
14780, 1.16, 1.4, 0.20833333333333
14781, 1.04, 1.4, 0.25
14782, 1.08, 1.4, 0.25
14783, 1.12, 1.4, 0.25
14784, 1.16, 1.4, 0.25
14785, 1.04, 1.4, 0.29166666666667
14786, 1.08, 1.4, 0.29166666666667
14787, 1.12, 1.4, 0.29166666666667
14788, 1.16, 1.4, 0.29166666666667
14789, 1.04, 1.4, 0.33333333333333
14790, 1.08, 1.4, 0.33333333333333
14791, 1.12, 1.4, 0.33333333333333
14792, 1.16, 1.4, 0.33333333333333
14793, 1.04, 1.4, 0.375
14794, 1.08, 1.4, 0.375
14795, 1.12, 1.4, 0.375
14796, 1.16, 1.4, 0.375
14797, 1.04, 1.4, 0.41666666666667
14798, 1.08, 1.4, 0.41666666666667
14799, 1.12, 1.4, 0.41666666666667
14800, 1.16, 1.4, 0.41666666666667
14801, 1.04, 1.4, 0.45833333333333
14802, 1.08, 1.4, 0.45833333333333
14803, 1.12, 1.4, 0.45833333333333
14804, 1.16, 1.4, 0.45833333333333
14805, 1.04, 1.4, 0.020833333333333
14806, 1.02, 1.4, 0.041666666666667
14807, 1.08, 1.4, 0.020833333333333
14808, 1.06, 1.4, 0.041666666666667
14809, 1.12, 1.4, 0.020833333333333
14810, 1.1, 1.4, 0.041666666666667
14811, 1.16, 1.4, 0.020833333333333
14812, 1.14, 1.4, 0.041666666666667
14813, 1.18, 1.4, 0.041666666666667
14814, 1.04, 1.4, 0.0625
14815, 1.02, 1.4, 0.083333333333333
14816, 1.08, 1.4, 0.0625
14817, 1.06, 1.4, 0.083333333333333
14818, 1.12, 1.4, 0.0625
14819, 1.1, 1.4, 0.083333333333333
14820, 1.16, 1.4, 0.0625
14821, 1.14, 1.4, 0.083333333333333
14822, 1.18, 1.4, 0.083333333333333
14823, 1.04, 1.4, 0.10416666666667
14824, 1.02, 1.4, 0.125
14825, 1.08, 1.4, 0.10416666666667
14826, 1.06, 1.4, 0.125
14827, 1.12, 1.4, 0.10416666666667
14828, 1.1, 1.4, 0.125
14829, 1.16, 1.4, 0.10416666666667
14830, 1.14, 1.4, 0.125
14831, 1.18, 1.4, 0.125
14832, 1.04, 1.4, 0.14583333333333
14833, 1.02, 1.4, 0.16666666666667
14834, 1.08, 1.4, 0.14583333333333
14835, 1.06, 1.4, 0.16666666666667
14836, 1.12, 1.4, 0.14583333333333
14837, 1.1, 1.4, 0.16666666666667
14838, 1.16, 1.4, 0.14583333333333
14839, 1.14, 1.4, 0.16666666666667
14840, 1.18, 1.4, 0.16666666666667
14841, 1.04, 1.4, 0.1875
14842, 1.02, 1.4, 0.20833333333333
14843, 1.08, 1.4, 0.1875
14844, 1.06, 1.4, 0.20833333333333
14845, 1.12, 1.4, 0.1875
14846, 1.1, 1.4, 0.20833333333333
14847, 1.16, 1.4, 0.1875
14848, 1.14, 1.4, 0.20833333333333
14849, 1.18, 1.4, 0.20833333333333
14850, 1.04, 1.4, 0.22916666666667
14851, 1.02, 1.4, 0.25
14852, 1.08, 1.4, 0.22916666666667
14853, 1.06, 1.4, 0.25
14854, 1.12, 1.4, 0.22916666666667
14855, 1.1, 1.4, 0.25
14856, 1.16, 1.4, 0.22916666666667
14857, 1.14, 1.4, 0.25
14858, 1.18, 1.4, 0.25
14859, 1.04, 1.4, 0.27083333333333
14860, 1.02, 1.4, 0.29166666666667
14861, 1.08, 1.4, 0.27083333333333
14862, 1.06, 1.4, 0.29166666666667
14863, 1.12, 1.4, 0.27083333333333
14864, 1.1, 1.4, 0.29166666666667
14865, 1.16, 1.4, 0.27083333333333
14866, 1.14, 1.4, 0.29166666666667
14867, 1.18, 1.4, 0.29166666666667
14868, 1.04, 1.4, 0.3125
14869, 1.02, 1.4, 0.33333333333333
14870, 1.08, 1.4, 0.3125
14871, 1.06, 1.4, 0.33333333333333
14872, 1.12, 1.4, 0.3125
14873, 1.1, 1.4, 0.33333333333333
14874, 1.16, 1.4, 0.3125
14875, 1.14, 1.4, 0.33333333333333
14876, 1.18, 1.4, 0.33333333333333
14877, 1.04, 1.4, 0.35416666666667
14878, 1.02, 1.4, 0.375
14879, 1.08, 1.4, 0.35416666666667
14880, 1.06, 1.4, 0.375
14881, 1.12, 1.4, 0.35416666666667
14882, 1.1, 1.4, 0.375
14883, 1.16, 1.4, 0.35416666666667
14884, 1.14, 1.4, 0.375
14885, 1.18, 1.4, 0.375
14886, 1.04, 1.4, 0.39583333333333
14887, 1.02, 1.4, 0.41666666666667
14888, 1.08, 1.4, 0.39583333333333
14889, 1.06, 1.4, 0.41666666666667
14890, 1.12, 1.4, 0.39583333333333
14891, 1.1, 1.4, 0.41666666666667
14892, 1.16, 1.4, 0.39583333333333
14893, 1.14, 1.4, 0.41666666666667
14894, 1.18, 1.4, 0.41666666666667
14895, 1.04, 1.4, 0.4375
14896, 1.02, 1.4, 0.45833333333333
14897, 1.08, 1.4, 0.4375
14898, 1.06, 1.4, 0.45833333333333
14899, 1.12, 1.4, 0.4375
14900, 1.1, 1.4, 0.45833333333333
14901, 1.16, 1.4, 0.4375
14902, 1.14, 1.4, 0.45833333333333
14903, 1.18, 1.4, 0.45833333333333
14904, 1.04, 1.4, 0.47916666666667
14905, 1.08, 1.4, 0.47916666666667
14906, 1.12, 1.4, 0.47916666666667
14907, 1.16, 1.4, 0.47916666666667
14908, 1.04, 1.5, 0.041666666666667
14909, 1.08, 1.5, 0.041666666666667
14910, 1.12, 1.5, 0.041666666666667
14911, 1.16, 1.5, 0.041666666666667
14912, 1.04, 1.5, 0.083333333333333
14913, 1.08, 1.5, 0.083333333333333
14914, 1.12, 1.5, 0.083333333333333
14915, 1.16, 1.5, 0.083333333333333
14916, 1.04, 1.5, 0.125
14917, 1.08, 1.5, 0.125
14918, 1.12, 1.5, 0.125
14919, 1.16, 1.5, 0.125
14920, 1.04, 1.5, 0.16666666666667
14921, 1.08, 1.5, 0.16666666666667
14922, 1.12, 1.5, 0.16666666666667
14923, 1.16, 1.5, 0.16666666666667
14924, 1.04, 1.5, 0.20833333333333
14925, 1.08, 1.5, 0.20833333333333
14926, 1.12, 1.5, 0.20833333333333
14927, 1.16, 1.5, 0.20833333333333
14928, 1.04, 1.5, 0.25
14929, 1.08, 1.5, 0.25
14930, 1.12, 1.5, 0.25
14931, 1.16, 1.5, 0.25
14932, 1.04, 1.5, 0.29166666666667
14933, 1.08, 1.5, 0.29166666666667
14934, 1.12, 1.5, 0.29166666666667
14935, 1.16, 1.5, 0.29166666666667
14936, 1.04, 1.5, 0.33333333333333
14937, 1.08, 1.5, 0.33333333333333
14938, 1.12, 1.5, 0.33333333333333
14939, 1.16, 1.5, 0.33333333333333
14940, 1.04, 1.5, 0.375
14941, 1.08, 1.5, 0.375
14942, 1.12, 1.5, 0.375
14943, 1.16, 1.5, 0.375
14944, 1.04, 1.5, 0.41666666666667
14945, 1.08, 1.5, 0.41666666666667
14946, 1.12, 1.5, 0.41666666666667
14947, 1.16, 1.5, 0.41666666666667
14948, 1.04, 1.5, 0.45833333333333
14949, 1.08, 1.5, 0.45833333333333
14950, 1.12, 1.5, 0.45833333333333
14951, 1.16, 1.5, 0.45833333333333
14952, 1.02, 1.5, 0.041666666666667
14953, 1.04, 1.5, 0.020833333333333
14954, 1.06, 1.5, 0.041666666666667
14955, 1.08, 1.5, 0.020833333333333
14956, 1.1, 1.5, 0.041666666666667
14957, 1.12, 1.5, 0.020833333333333
14958, 1.14, 1.5, 0.041666666666667
14959, 1.16, 1.5, 0.020833333333333
14960, 1.18, 1.5, 0.041666666666667
14961, 1.02, 1.5, 0.083333333333333
14962, 1.04, 1.5, 0.0625
14963, 1.06, 1.5, 0.083333333333333
14964, 1.08, 1.5, 0.0625
14965, 1.1, 1.5, 0.083333333333333
14966, 1.12, 1.5, 0.0625
14967, 1.14, 1.5, 0.083333333333333
14968, 1.16, 1.5, 0.0625
14969, 1.18, 1.5, 0.083333333333333
14970, 1.02, 1.5, 0.125
14971, 1.04, 1.5, 0.10416666666667
14972, 1.06, 1.5, 0.125
14973, 1.08, 1.5, 0.10416666666667
14974, 1.1, 1.5, 0.125
14975, 1.12, 1.5, 0.10416666666667
14976, 1.14, 1.5, 0.125
14977, 1.16, 1.5, 0.10416666666667
14978, 1.18, 1.5, 0.125
14979, 1.02, 1.5, 0.16666666666667
14980, 1.04, 1.5, 0.14583333333333
14981, 1.06, 1.5, 0.16666666666667
14982, 1.08, 1.5, 0.14583333333333
14983, 1.1, 1.5, 0.16666666666667
14984, 1.12, 1.5, 0.14583333333333
14985, 1.14, 1.5, 0.16666666666667
14986, 1.16, 1.5, 0.14583333333333
14987, 1.18, 1.5, 0.16666666666667
14988, 1.02, 1.5, 0.20833333333333
14989, 1.04, 1.5, 0.1875
14990, 1.06, 1.5, 0.20833333333333
14991, 1.08, 1.5, 0.1875
14992, 1.1, 1.5, 0.20833333333333
14993, 1.12, 1.5, 0.1875
14994, 1.14, 1.5, 0.20833333333333
14995, 1.16, 1.5, 0.1875
14996, 1.18, 1.5, 0.20833333333333
14997, 1.02, 1.5, 0.25
14998, 1.04, 1.5, 0.22916666666667
14999, 1.06, 1.5, 0.25
15000, 1.08, 1.5, 0.22916666666667
15001, 1.1, 1.5, 0.25
15002, 1.12, 1.5, 0.22916666666667
15003, 1.14, 1.5, 0.25
15004, 1.16, 1.5, 0.22916666666667
15005, 1.18, 1.5, 0.25
15006, 1.02, 1.5, 0.29166666666667
15007, 1.04, 1.5, 0.27083333333333
15008, 1.06, 1.5, 0.29166666666667
15009, 1.08, 1.5, 0.27083333333333
15010, 1.1, 1.5, 0.29166666666667
15011, 1.12, 1.5, 0.27083333333333
15012, 1.14, 1.5, 0.29166666666667
15013, 1.16, 1.5, 0.27083333333333
15014, 1.18, 1.5, 0.29166666666667
15015, 1.02, 1.5, 0.33333333333333
15016, 1.04, 1.5, 0.3125
15017, 1.06, 1.5, 0.33333333333333
15018, 1.08, 1.5, 0.3125
15019, 1.1, 1.5, 0.33333333333333
15020, 1.12, 1.5, 0.3125
15021, 1.14, 1.5, 0.33333333333333
15022, 1.16, 1.5, 0.3125
15023, 1.18, 1.5, 0.33333333333333
15024, 1.02, 1.5, 0.375
15025, 1.04, 1.5, 0.35416666666667
15026, 1.06, 1.5, 0.375
15027, 1.08, 1.5, 0.35416666666667
15028, 1.1, 1.5, 0.375
15029, 1.12, 1.5, 0.35416666666667
15030, 1.14, 1.5, 0.375
15031, 1.16, 1.5, 0.35416666666667
15032, 1.18, 1.5, 0.375
15033, 1.02, 1.5, 0.41666666666667
15034, 1.04, 1.5, 0.39583333333333
15035, 1.06, 1.5, 0.41666666666667
15036, 1.08, 1.5, 0.39583333333333
15037, 1.1, 1.5, 0.41666666666667
15038, 1.12, 1.5, 0.39583333333333
15039, 1.14, 1.5, 0.41666666666667
15040, 1.16, 1.5, 0.39583333333333
15041, 1.18, 1.5, 0.41666666666667
15042, 1.02, 1.5, 0.45833333333333
15043, 1.04, 1.5, 0.4375
15044, 1.06, 1.5, 0.45833333333333
15045, 1.08, 1.5, 0.4375
15046, 1.1, 1.5, 0.45833333333333
15047, 1.12, 1.5, 0.4375
15048, 1.14, 1.5, 0.45833333333333
15049, 1.16, 1.5, 0.4375
15050, 1.18, 1.5, 0.45833333333333
15051, 1.04, 1.5, 0.47916666666667
15052, 1.08, 1.5, 0.47916666666667
15053, 1.12, 1.5, 0.47916666666667
15054, 1.16, 1.5, 0.47916666666667
15055, 1.2, 1.4333333333333, 0.041666666666667
15056, 1.2, 1.4666666666667, 0.041666666666667
15057, 1.2, 1.4333333333333, 0.083333333333333
15058, 1.2, 1.4666666666667, 0.083333333333333
15059, 1.2, 1.4333333333333, 0.125
15060, 1.2, 1.4666666666667, 0.125
15061, 1.2, 1.4333333333333, 0.16666666666667
15062, 1.2, 1.4666666666667, 0.16666666666667
15063, 1.2, 1.4333333333333, 0.20833333333333
15064, 1.2, 1.4666666666667, 0.20833333333333
15065, 1.2, 1.4333333333333, 0.25
15066, 1.2, 1.4666666666667, 0.25
15067, 1.2, 1.4333333333333, 0.29166666666667
15068, 1.2, 1.4666666666667, 0.29166666666667
15069, 1.2, 1.4333333333333, 0.33333333333333
15070, 1.2, 1.4666666666667, 0.33333333333333
15071, 1.2, 1.4333333333333, 0.375
15072, 1.2, 1.4666666666667, 0.375
15073, 1.2, 1.4333333333333, 0.41666666666667
15074, 1.2, 1.4666666666667, 0.41666666666667
15075, 1.2, 1.4333333333333, 0.45833333333333
15076, 1.2, 1.4666666666667, 0.45833333333333
15077, 1.2, 1.4333333333333, 0.020833333333333
15078, 1.2, 1.4166666666667, 0.041666666666667
15079, 1.2, 1.4666666666667, 0.020833333333333
15080, 1.2, 1.45, 0.041666666666667
15081, 1.2, 1.4833333333333, 0.041666666666667
15082, 1.2, 1.4333333333333, 0.0625
15083, 1.2, 1.4166666666667, 0.083333333333333
15084, 1.2, 1.4666666666667, 0.0625
15085, 1.2, 1.45, 0.083333333333333
15086, 1.2, 1.4833333333333, 0.083333333333333
15087, 1.2, 1.4333333333333, 0.10416666666667
15088, 1.2, 1.4166666666667, 0.125
15089, 1.2, 1.4666666666667, 0.10416666666667
15090, 1.2, 1.45, 0.125
15091, 1.2, 1.4833333333333, 0.125
15092, 1.2, 1.4333333333333, 0.14583333333333
15093, 1.2, 1.4166666666667, 0.16666666666667
15094, 1.2, 1.4666666666667, 0.14583333333333
15095, 1.2, 1.45, 0.16666666666667
15096, 1.2, 1.4833333333333, 0.16666666666667
15097, 1.2, 1.4333333333333, 0.1875
15098, 1.2, 1.4166666666667, 0.20833333333333
15099, 1.2, 1.4666666666667, 0.1875
15100, 1.2, 1.45, 0.20833333333333
15101, 1.2, 1.4833333333333, 0.20833333333333
15102, 1.2, 1.4333333333333, 0.22916666666667
15103, 1.2, 1.4166666666667, 0.25
15104, 1.2, 1.4666666666667, 0.22916666666667
15105, 1.2, 1.45, 0.25
15106, 1.2, 1.4833333333333, 0.25
15107, 1.2, 1.4333333333333, 0.27083333333333
15108, 1.2, 1.4166666666667, 0.29166666666667
15109, 1.2, 1.4666666666667, 0.27083333333333
15110, 1.2, 1.45, 0.29166666666667
15111, 1.2, 1.4833333333333, 0.29166666666667
15112, 1.2, 1.4333333333333, 0.3125
15113, 1.2, 1.4166666666667, 0.33333333333333
15114, 1.2, 1.4666666666667, 0.3125
15115, 1.2, 1.45, 0.33333333333333
15116, 1.2, 1.4833333333333, 0.33333333333333
15117, 1.2, 1.4333333333333, 0.35416666666667
15118, 1.2, 1.4166666666667, 0.375
15119, 1.2, 1.4666666666667, 0.35416666666667
15120, 1.2, 1.45, 0.375
15121, 1.2, 1.4833333333333, 0.375
15122, 1.2, 1.4333333333333, 0.39583333333333
15123, 1.2, 1.4166666666667, 0.41666666666667
15124, 1.2, 1.4666666666667, 0.39583333333333
15125, 1.2, 1.45, 0.41666666666667
15126, 1.2, 1.4833333333333, 0.41666666666667
15127, 1.2, 1.4333333333333, 0.4375
15128, 1.2, 1.4166666666667, 0.45833333333333
15129, 1.2, 1.4666666666667, 0.4375
15130, 1.2, 1.45, 0.45833333333333
15131, 1.2, 1.4833333333333, 0.45833333333333
15132, 1.2, 1.4333333333333, 0.47916666666667
15133, 1.2, 1.4666666666667, 0.47916666666667
15134, 1.2416666666667, 1.4333333333333, 0.5
15135, 1.2833333333333, 1.4333333333333, 0.5
15136, 1.325, 1.4333333333333, 0.5
15137, 1.3666666666667, 1.4333333333333, 0.5
15138, 1.4083333333333, 1.4333333333333, 0.5
15139, 1.45, 1.4333333333333, 0.5
15140, 1.4916666666667, 1.4333333333333, 0.5
15141, 1.5333333333333, 1.4333333333333, 0.5
15142, 1.575, 1.4333333333333, 0.5
15143, 1.6166666666667, 1.4333333333333, 0.5
15144, 1.6583333333333, 1.4333333333333, 0.5
15145, 1.7, 1.4333333333333, 0.5
15146, 1.7416666666667, 1.4333333333333, 0.5
15147, 1.7833333333333, 1.4333333333333, 0.5
15148, 1.825, 1.4333333333333, 0.5
15149, 1.8666666666667, 1.4333333333333, 0.5
15150, 1.9083333333333, 1.4333333333333, 0.5
15151, 1.95, 1.4333333333333, 0.5
15152, 1.9916666666667, 1.4333333333333, 0.5
15153, 2.0333333333333, 1.4333333333333, 0.5
15154, 2.075, 1.4333333333333, 0.5
15155, 2.1166666666667, 1.4333333333333, 0.5
15156, 2.1583333333333, 1.4333333333333, 0.5
15157, 1.2416666666667, 1.4666666666667, 0.5
15158, 1.2833333333333, 1.4666666666667, 0.5
15159, 1.325, 1.4666666666667, 0.5
15160, 1.3666666666667, 1.4666666666667, 0.5
15161, 1.4083333333333, 1.4666666666667, 0.5
15162, 1.45, 1.4666666666667, 0.5
15163, 1.4916666666667, 1.4666666666667, 0.5
