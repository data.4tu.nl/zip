94844, 2.1583333333333, 1.025, 0.45833333333333
94845, 2.1583333333333, 1, 0.4375
94846, 2.1375, 1, 0.45833333333333
94847, 2.1583333333333, 0.975, 0.45833333333333
94848, 2.1583333333333, 0.95, 0.4375
94849, 2.1375, 0.95, 0.45833333333333
94850, 2.1583333333333, 0.925, 0.45833333333333
94851, 2.1583333333333, 0.9, 0.4375
94852, 2.1375, 0.9, 0.45833333333333
94853, 2.1583333333333, 0.875, 0.45833333333333
94854, 2.1583333333333, 0.85, 0.4375
94855, 2.1375, 0.85, 0.45833333333333
94856, 2.1583333333333, 0.825, 0.45833333333333
94857, 2.1583333333333, 0.8, 0.4375
94858, 2.1375, 0.8, 0.45833333333333
94859, 2.1583333333333, 0.775, 0.45833333333333
94860, 2.1583333333333, 0.75, 0.4375
94861, 2.1375, 0.75, 0.45833333333333
94862, 2.1583333333333, 0.725, 0.45833333333333
94863, 2.1583333333333, 0.7, 0.4375
94864, 2.1375, 0.7, 0.45833333333333
94865, 2.1583333333333, 0.675, 0.45833333333333
94866, 2.1583333333333, 0.65, 0.4375
94867, 2.1375, 0.65, 0.45833333333333
94868, 2.1583333333333, 0.625, 0.45833333333333
94869, 2.1583333333333, 0.6, 0.4375
94870, 2.1375, 0.6, 0.45833333333333
94871, 2.1583333333333, 0.575, 0.45833333333333
94872, 2.1583333333333, 0.55, 0.4375
94873, 2.1375, 0.55, 0.45833333333333
94874, 2.1583333333333, 0.525, 0.45833333333333
94875, 2.1583333333333, 0.5, 0.4375
94876, 2.1375, 0.5, 0.45833333333333
94877, 2.1583333333333, 0.475, 0.45833333333333
94878, 2.1583333333333, 0.45, 0.4375
94879, 2.1375, 0.45, 0.45833333333333
94880, 2.1583333333333, 0.425, 0.45833333333333
94881, 2.1583333333333, 0.4, 0.4375
94882, 2.1375, 0.4, 0.45833333333333
94883, 2.1583333333333, 0.375, 0.45833333333333
94884, 2.1583333333333, 0.35, 0.4375
94885, 2.1375, 0.35, 0.45833333333333
94886, 2.1583333333333, 0.325, 0.45833333333333
94887, 2.1583333333333, 0.3, 0.4375
94888, 2.1375, 0.3, 0.45833333333333
94889, 2.1583333333333, 0.275, 0.45833333333333
94890, 2.1583333333333, 0.25, 0.4375
94891, 2.1375, 0.25, 0.45833333333333
94892, 2.1583333333333, 0.225, 0.45833333333333
94893, 2.1583333333333, 0.2, 0.4375
94894, 2.1375, 0.2, 0.45833333333333
94895, 2.1583333333333, 0.175, 0.45833333333333
94896, 2.1791666666667, 1.3, 0.45833333333333
94897, 2.1791666666667, 1.25, 0.45833333333333
94898, 2.1791666666667, 1.2, 0.45833333333333
94899, 2.1791666666667, 1.15, 0.45833333333333
94900, 2.1791666666667, 1.1, 0.45833333333333
94901, 2.1791666666667, 1.05, 0.45833333333333
94902, 2.1791666666667, 1, 0.45833333333333
94903, 2.1791666666667, 0.95, 0.45833333333333
94904, 2.1791666666667, 0.9, 0.45833333333333
94905, 2.1791666666667, 0.85, 0.45833333333333
94906, 2.1791666666667, 0.8, 0.45833333333333
94907, 2.1791666666667, 0.75, 0.45833333333333
94908, 2.1791666666667, 0.7, 0.45833333333333
94909, 2.1791666666667, 0.65, 0.45833333333333
94910, 2.1791666666667, 0.6, 0.45833333333333
94911, 2.1791666666667, 0.55, 0.45833333333333
94912, 2.1791666666667, 0.5, 0.45833333333333
94913, 2.1791666666667, 0.45, 0.45833333333333
94914, 2.1791666666667, 0.4, 0.45833333333333
94915, 2.1791666666667, 0.35, 0.45833333333333
94916, 2.1791666666667, 0.3, 0.45833333333333
94917, 2.1791666666667, 0.25, 0.45833333333333
94918, 2.1791666666667, 0.2, 0.45833333333333
94919, 1.2416666666667, 1.3, 0.47916666666667
94920, 1.2416666666667, 1.25, 0.47916666666667
94921, 1.2416666666667, 1.2, 0.47916666666667
94922, 1.2416666666667, 1.15, 0.47916666666667
94923, 1.2416666666667, 1.1, 0.47916666666667
94924, 1.2416666666667, 1.05, 0.47916666666667
94925, 1.2416666666667, 1, 0.47916666666667
94926, 1.2416666666667, 0.95, 0.47916666666667
94927, 1.2416666666667, 0.9, 0.47916666666667
94928, 1.2416666666667, 0.85, 0.47916666666667
94929, 1.2416666666667, 0.8, 0.47916666666667
94930, 1.2416666666667, 0.75, 0.47916666666667
94931, 1.2416666666667, 0.7, 0.47916666666667
94932, 1.2416666666667, 0.65, 0.47916666666667
94933, 1.2416666666667, 0.6, 0.47916666666667
94934, 1.2416666666667, 0.55, 0.47916666666667
94935, 1.2416666666667, 0.5, 0.47916666666667
94936, 1.2416666666667, 0.45, 0.47916666666667
94937, 1.2416666666667, 0.4, 0.47916666666667
94938, 1.2416666666667, 0.35, 0.47916666666667
94939, 1.2416666666667, 0.3, 0.47916666666667
94940, 1.2416666666667, 0.25, 0.47916666666667
94941, 1.2416666666667, 0.2, 0.47916666666667
94942, 1.2833333333333, 1.3, 0.47916666666667
94943, 1.2833333333333, 1.25, 0.47916666666667
94944, 1.2833333333333, 1.2, 0.47916666666667
94945, 1.2833333333333, 1.15, 0.47916666666667
94946, 1.2833333333333, 1.1, 0.47916666666667
94947, 1.2833333333333, 1.05, 0.47916666666667
94948, 1.2833333333333, 1, 0.47916666666667
94949, 1.2833333333333, 0.95, 0.47916666666667
94950, 1.2833333333333, 0.9, 0.47916666666667
94951, 1.2833333333333, 0.85, 0.47916666666667
94952, 1.2833333333333, 0.8, 0.47916666666667
94953, 1.2833333333333, 0.75, 0.47916666666667
94954, 1.2833333333333, 0.7, 0.47916666666667
94955, 1.2833333333333, 0.65, 0.47916666666667
94956, 1.2833333333333, 0.6, 0.47916666666667
94957, 1.2833333333333, 0.55, 0.47916666666667
94958, 1.2833333333333, 0.5, 0.47916666666667
94959, 1.2833333333333, 0.45, 0.47916666666667
94960, 1.2833333333333, 0.4, 0.47916666666667
94961, 1.2833333333333, 0.35, 0.47916666666667
94962, 1.2833333333333, 0.3, 0.47916666666667
94963, 1.2833333333333, 0.25, 0.47916666666667
94964, 1.2833333333333, 0.2, 0.47916666666667
94965, 1.325, 1.3, 0.47916666666667
94966, 1.325, 1.25, 0.47916666666667
94967, 1.325, 1.2, 0.47916666666667
94968, 1.325, 1.15, 0.47916666666667
94969, 1.325, 1.1, 0.47916666666667
94970, 1.325, 1.05, 0.47916666666667
94971, 1.325, 1, 0.47916666666667
94972, 1.325, 0.95, 0.47916666666667
94973, 1.325, 0.9, 0.47916666666667
94974, 1.325, 0.85, 0.47916666666667
94975, 1.325, 0.8, 0.47916666666667
94976, 1.325, 0.75, 0.47916666666667
94977, 1.325, 0.7, 0.47916666666667
94978, 1.325, 0.65, 0.47916666666667
94979, 1.325, 0.6, 0.47916666666667
94980, 1.325, 0.55, 0.47916666666667
94981, 1.325, 0.5, 0.47916666666667
94982, 1.325, 0.45, 0.47916666666667
94983, 1.325, 0.4, 0.47916666666667
94984, 1.325, 0.35, 0.47916666666667
94985, 1.325, 0.3, 0.47916666666667
94986, 1.325, 0.25, 0.47916666666667
94987, 1.325, 0.2, 0.47916666666667
94988, 1.3666666666667, 1.3, 0.47916666666667
94989, 1.3666666666667, 1.25, 0.47916666666667
94990, 1.3666666666667, 1.2, 0.47916666666667
94991, 1.3666666666667, 1.15, 0.47916666666667
94992, 1.3666666666667, 1.1, 0.47916666666667
94993, 1.3666666666667, 1.05, 0.47916666666667
94994, 1.3666666666667, 1, 0.47916666666667
94995, 1.3666666666667, 0.95, 0.47916666666667
94996, 1.3666666666667, 0.9, 0.47916666666667
94997, 1.3666666666667, 0.85, 0.47916666666667
94998, 1.3666666666667, 0.8, 0.47916666666667
94999, 1.3666666666667, 0.75, 0.47916666666667
95000, 1.3666666666667, 0.7, 0.47916666666667
95001, 1.3666666666667, 0.65, 0.47916666666667
95002, 1.3666666666667, 0.6, 0.47916666666667
95003, 1.3666666666667, 0.55, 0.47916666666667
95004, 1.3666666666667, 0.5, 0.47916666666667
95005, 1.3666666666667, 0.45, 0.47916666666667
95006, 1.3666666666667, 0.4, 0.47916666666667
95007, 1.3666666666667, 0.35, 0.47916666666667
95008, 1.3666666666667, 0.3, 0.47916666666667
95009, 1.3666666666667, 0.25, 0.47916666666667
95010, 1.3666666666667, 0.2, 0.47916666666667
95011, 1.4083333333333, 1.3, 0.47916666666667
95012, 1.4083333333333, 1.25, 0.47916666666667
95013, 1.4083333333333, 1.2, 0.47916666666667
95014, 1.4083333333333, 1.15, 0.47916666666667
95015, 1.4083333333333, 1.1, 0.47916666666667
95016, 1.4083333333333, 1.05, 0.47916666666667
95017, 1.4083333333333, 1, 0.47916666666667
95018, 1.4083333333333, 0.95, 0.47916666666667
95019, 1.4083333333333, 0.9, 0.47916666666667
95020, 1.4083333333333, 0.85, 0.47916666666667
95021, 1.4083333333333, 0.8, 0.47916666666667
95022, 1.4083333333333, 0.75, 0.47916666666667
95023, 1.4083333333333, 0.7, 0.47916666666667
95024, 1.4083333333333, 0.65, 0.47916666666667
95025, 1.4083333333333, 0.6, 0.47916666666667
95026, 1.4083333333333, 0.55, 0.47916666666667
95027, 1.4083333333333, 0.5, 0.47916666666667
95028, 1.4083333333333, 0.45, 0.47916666666667
95029, 1.4083333333333, 0.4, 0.47916666666667
95030, 1.4083333333333, 0.35, 0.47916666666667
95031, 1.4083333333333, 0.3, 0.47916666666667
95032, 1.4083333333333, 0.25, 0.47916666666667
95033, 1.4083333333333, 0.2, 0.47916666666667
95034, 1.45, 1.3, 0.47916666666667
95035, 1.45, 1.25, 0.47916666666667
95036, 1.45, 1.2, 0.47916666666667
95037, 1.45, 1.15, 0.47916666666667
95038, 1.45, 1.1, 0.47916666666667
95039, 1.45, 1.05, 0.47916666666667
95040, 1.45, 1, 0.47916666666667
95041, 1.45, 0.95, 0.47916666666667
95042, 1.45, 0.9, 0.47916666666667
95043, 1.45, 0.85, 0.47916666666667
95044, 1.45, 0.8, 0.47916666666667
95045, 1.45, 0.75, 0.47916666666667
95046, 1.45, 0.7, 0.47916666666667
95047, 1.45, 0.65, 0.47916666666667
95048, 1.45, 0.6, 0.47916666666667
95049, 1.45, 0.55, 0.47916666666667
95050, 1.45, 0.5, 0.47916666666667
95051, 1.45, 0.45, 0.47916666666667
95052, 1.45, 0.4, 0.47916666666667
95053, 1.45, 0.35, 0.47916666666667
95054, 1.45, 0.3, 0.47916666666667
95055, 1.45, 0.25, 0.47916666666667
95056, 1.45, 0.2, 0.47916666666667
95057, 1.4916666666667, 1.3, 0.47916666666667
95058, 1.4916666666667, 1.25, 0.47916666666667
95059, 1.4916666666667, 1.2, 0.47916666666667
95060, 1.4916666666667, 1.15, 0.47916666666667
95061, 1.4916666666667, 1.1, 0.47916666666667
95062, 1.4916666666667, 1.05, 0.47916666666667
95063, 1.4916666666667, 1, 0.47916666666667
95064, 1.4916666666667, 0.95, 0.47916666666667
95065, 1.4916666666667, 0.9, 0.47916666666667
95066, 1.4916666666667, 0.85, 0.47916666666667
95067, 1.4916666666667, 0.8, 0.47916666666667
95068, 1.4916666666667, 0.75, 0.47916666666667
95069, 1.4916666666667, 0.7, 0.47916666666667
95070, 1.4916666666667, 0.65, 0.47916666666667
95071, 1.4916666666667, 0.6, 0.47916666666667
95072, 1.4916666666667, 0.55, 0.47916666666667
95073, 1.4916666666667, 0.5, 0.47916666666667
95074, 1.4916666666667, 0.45, 0.47916666666667
95075, 1.4916666666667, 0.4, 0.47916666666667
95076, 1.4916666666667, 0.35, 0.47916666666667
95077, 1.4916666666667, 0.3, 0.47916666666667
95078, 1.4916666666667, 0.25, 0.47916666666667
95079, 1.4916666666667, 0.2, 0.47916666666667
95080, 1.5333333333333, 1.3, 0.47916666666667
95081, 1.5333333333333, 1.25, 0.47916666666667
95082, 1.5333333333333, 1.2, 0.47916666666667
95083, 1.5333333333333, 1.15, 0.47916666666667
95084, 1.5333333333333, 1.1, 0.47916666666667
95085, 1.5333333333333, 1.05, 0.47916666666667
95086, 1.5333333333333, 1, 0.47916666666667
95087, 1.5333333333333, 0.95, 0.47916666666667
95088, 1.5333333333333, 0.9, 0.47916666666667
95089, 1.5333333333333, 0.85, 0.47916666666667
95090, 1.5333333333333, 0.8, 0.47916666666667
95091, 1.5333333333333, 0.75, 0.47916666666667
95092, 1.5333333333333, 0.7, 0.47916666666667
95093, 1.5333333333333, 0.65, 0.47916666666667
95094, 1.5333333333333, 0.6, 0.47916666666667
95095, 1.5333333333333, 0.55, 0.47916666666667
95096, 1.5333333333333, 0.5, 0.47916666666667
95097, 1.5333333333333, 0.45, 0.47916666666667
95098, 1.5333333333333, 0.4, 0.47916666666667
95099, 1.5333333333333, 0.35, 0.47916666666667
95100, 1.5333333333333, 0.3, 0.47916666666667
95101, 1.5333333333333, 0.25, 0.47916666666667
95102, 1.5333333333333, 0.2, 0.47916666666667
95103, 1.575, 1.3, 0.47916666666667
95104, 1.575, 1.25, 0.47916666666667
95105, 1.575, 1.2, 0.47916666666667
95106, 1.575, 1.15, 0.47916666666667
95107, 1.575, 1.1, 0.47916666666667
95108, 1.575, 1.05, 0.47916666666667
95109, 1.575, 1, 0.47916666666667
95110, 1.575, 0.95, 0.47916666666667
95111, 1.575, 0.9, 0.47916666666667
95112, 1.575, 0.85, 0.47916666666667
95113, 1.575, 0.8, 0.47916666666667
95114, 1.575, 0.75, 0.47916666666667
95115, 1.575, 0.7, 0.47916666666667
95116, 1.575, 0.65, 0.47916666666667
95117, 1.575, 0.6, 0.47916666666667
95118, 1.575, 0.55, 0.47916666666667
95119, 1.575, 0.5, 0.47916666666667
95120, 1.575, 0.45, 0.47916666666667
95121, 1.575, 0.4, 0.47916666666667
95122, 1.575, 0.35, 0.47916666666667
95123, 1.575, 0.3, 0.47916666666667
95124, 1.575, 0.25, 0.47916666666667
95125, 1.575, 0.2, 0.47916666666667
95126, 1.6166666666667, 1.3, 0.47916666666667
95127, 1.6166666666667, 1.25, 0.47916666666667
95128, 1.6166666666667, 1.2, 0.47916666666667
95129, 1.6166666666667, 1.15, 0.47916666666667
95130, 1.6166666666667, 1.1, 0.47916666666667
95131, 1.6166666666667, 1.05, 0.47916666666667
95132, 1.6166666666667, 1, 0.47916666666667
95133, 1.6166666666667, 0.95, 0.47916666666667
95134, 1.6166666666667, 0.9, 0.47916666666667
95135, 1.6166666666667, 0.85, 0.47916666666667
95136, 1.6166666666667, 0.8, 0.47916666666667
95137, 1.6166666666667, 0.75, 0.47916666666667
95138, 1.6166666666667, 0.7, 0.47916666666667
95139, 1.6166666666667, 0.65, 0.47916666666667
95140, 1.6166666666667, 0.6, 0.47916666666667
95141, 1.6166666666667, 0.55, 0.47916666666667
95142, 1.6166666666667, 0.5, 0.47916666666667
95143, 1.6166666666667, 0.45, 0.47916666666667
95144, 1.6166666666667, 0.4, 0.47916666666667
95145, 1.6166666666667, 0.35, 0.47916666666667
95146, 1.6166666666667, 0.3, 0.47916666666667
95147, 1.6166666666667, 0.25, 0.47916666666667
95148, 1.6166666666667, 0.2, 0.47916666666667
95149, 1.6583333333333, 1.3, 0.47916666666667
95150, 1.6583333333333, 1.25, 0.47916666666667
95151, 1.6583333333333, 1.2, 0.47916666666667
95152, 1.6583333333333, 1.15, 0.47916666666667
95153, 1.6583333333333, 1.1, 0.47916666666667
95154, 1.6583333333333, 1.05, 0.47916666666667
95155, 1.6583333333333, 1, 0.47916666666667
95156, 1.6583333333333, 0.95, 0.47916666666667
95157, 1.6583333333333, 0.9, 0.47916666666667
95158, 1.6583333333333, 0.85, 0.47916666666667
95159, 1.6583333333333, 0.8, 0.47916666666667
95160, 1.6583333333333, 0.75, 0.47916666666667
95161, 1.6583333333333, 0.7, 0.47916666666667
95162, 1.6583333333333, 0.65, 0.47916666666667
95163, 1.6583333333333, 0.6, 0.47916666666667
95164, 1.6583333333333, 0.55, 0.47916666666667
95165, 1.6583333333333, 0.5, 0.47916666666667
95166, 1.6583333333333, 0.45, 0.47916666666667
95167, 1.6583333333333, 0.4, 0.47916666666667
95168, 1.6583333333333, 0.35, 0.47916666666667
95169, 1.6583333333333, 0.3, 0.47916666666667
95170, 1.6583333333333, 0.25, 0.47916666666667
95171, 1.6583333333333, 0.2, 0.47916666666667
95172, 1.7, 1.3, 0.47916666666667
95173, 1.7, 1.25, 0.47916666666667
95174, 1.7, 1.2, 0.47916666666667
95175, 1.7, 1.15, 0.47916666666667
95176, 1.7, 1.1, 0.47916666666667
95177, 1.7, 1.05, 0.47916666666667
95178, 1.7, 1, 0.47916666666667
95179, 1.7, 0.95, 0.47916666666667
95180, 1.7, 0.9, 0.47916666666667
95181, 1.7, 0.85, 0.47916666666667
95182, 1.7, 0.8, 0.47916666666667
95183, 1.7, 0.75, 0.47916666666667
95184, 1.7, 0.7, 0.47916666666667
95185, 1.7, 0.65, 0.47916666666667
95186, 1.7, 0.6, 0.47916666666667
95187, 1.7, 0.55, 0.47916666666667
95188, 1.7, 0.5, 0.47916666666667
95189, 1.7, 0.45, 0.47916666666667
95190, 1.7, 0.4, 0.47916666666667
95191, 1.7, 0.35, 0.47916666666667
95192, 1.7, 0.3, 0.47916666666667
95193, 1.7, 0.25, 0.47916666666667
95194, 1.7, 0.2, 0.47916666666667
95195, 1.7416666666667, 1.3, 0.47916666666667
95196, 1.7416666666667, 1.25, 0.47916666666667
95197, 1.7416666666667, 1.2, 0.47916666666667
95198, 1.7416666666667, 1.15, 0.47916666666667
95199, 1.7416666666667, 1.1, 0.47916666666667
95200, 1.7416666666667, 1.05, 0.47916666666667
95201, 1.7416666666667, 1, 0.47916666666667
95202, 1.7416666666667, 0.95, 0.47916666666667
95203, 1.7416666666667, 0.9, 0.47916666666667
95204, 1.7416666666667, 0.85, 0.47916666666667
95205, 1.7416666666667, 0.8, 0.47916666666667
95206, 1.7416666666667, 0.75, 0.47916666666667
95207, 1.7416666666667, 0.7, 0.47916666666667
95208, 1.7416666666667, 0.65, 0.47916666666667
95209, 1.7416666666667, 0.6, 0.47916666666667
95210, 1.7416666666667, 0.55, 0.47916666666667
95211, 1.7416666666667, 0.5, 0.47916666666667
95212, 1.7416666666667, 0.45, 0.47916666666667
95213, 1.7416666666667, 0.4, 0.47916666666667
95214, 1.7416666666667, 0.35, 0.47916666666667
95215, 1.7416666666667, 0.3, 0.47916666666667
95216, 1.7416666666667, 0.25, 0.47916666666667
95217, 1.7416666666667, 0.2, 0.47916666666667
95218, 1.7833333333333, 1.3, 0.47916666666667
95219, 1.7833333333333, 1.25, 0.47916666666667
95220, 1.7833333333333, 1.2, 0.47916666666667
95221, 1.7833333333333, 1.15, 0.47916666666667
95222, 1.7833333333333, 1.1, 0.47916666666667
95223, 1.7833333333333, 1.05, 0.47916666666667
95224, 1.7833333333333, 1, 0.47916666666667
95225, 1.7833333333333, 0.95, 0.47916666666667
95226, 1.7833333333333, 0.9, 0.47916666666667
95227, 1.7833333333333, 0.85, 0.47916666666667
95228, 1.7833333333333, 0.8, 0.47916666666667
95229, 1.7833333333333, 0.75, 0.47916666666667
95230, 1.7833333333333, 0.7, 0.47916666666667
95231, 1.7833333333333, 0.65, 0.47916666666667
95232, 1.7833333333333, 0.6, 0.47916666666667
95233, 1.7833333333333, 0.55, 0.47916666666667
95234, 1.7833333333333, 0.5, 0.47916666666667
95235, 1.7833333333333, 0.45, 0.47916666666667
95236, 1.7833333333333, 0.4, 0.47916666666667
95237, 1.7833333333333, 0.35, 0.47916666666667
95238, 1.7833333333333, 0.3, 0.47916666666667
95239, 1.7833333333333, 0.25, 0.47916666666667
95240, 1.7833333333333, 0.2, 0.47916666666667
95241, 1.825, 1.3, 0.47916666666667
95242, 1.825, 1.25, 0.47916666666667
95243, 1.825, 1.2, 0.47916666666667
95244, 1.825, 1.15, 0.47916666666667
95245, 1.825, 1.1, 0.47916666666667
95246, 1.825, 1.05, 0.47916666666667
95247, 1.825, 1, 0.47916666666667
95248, 1.825, 0.95, 0.47916666666667
95249, 1.825, 0.9, 0.47916666666667
95250, 1.825, 0.85, 0.47916666666667
95251, 1.825, 0.8, 0.47916666666667
95252, 1.825, 0.75, 0.47916666666667
95253, 1.825, 0.7, 0.47916666666667
95254, 1.825, 0.65, 0.47916666666667
95255, 1.825, 0.6, 0.47916666666667
95256, 1.825, 0.55, 0.47916666666667
95257, 1.825, 0.5, 0.47916666666667
95258, 1.825, 0.45, 0.47916666666667
95259, 1.825, 0.4, 0.47916666666667
95260, 1.825, 0.35, 0.47916666666667
95261, 1.825, 0.3, 0.47916666666667
95262, 1.825, 0.25, 0.47916666666667
95263, 1.825, 0.2, 0.47916666666667
95264, 1.8666666666667, 1.3, 0.47916666666667
95265, 1.8666666666667, 1.25, 0.47916666666667
95266, 1.8666666666667, 1.2, 0.47916666666667
95267, 1.8666666666667, 1.15, 0.47916666666667
95268, 1.8666666666667, 1.1, 0.47916666666667
95269, 1.8666666666667, 1.05, 0.47916666666667
95270, 1.8666666666667, 1, 0.47916666666667
95271, 1.8666666666667, 0.95, 0.47916666666667
95272, 1.8666666666667, 0.9, 0.47916666666667
95273, 1.8666666666667, 0.85, 0.47916666666667
95274, 1.8666666666667, 0.8, 0.47916666666667
95275, 1.8666666666667, 0.75, 0.47916666666667
95276, 1.8666666666667, 0.7, 0.47916666666667
95277, 1.8666666666667, 0.65, 0.47916666666667
95278, 1.8666666666667, 0.6, 0.47916666666667
95279, 1.8666666666667, 0.55, 0.47916666666667
95280, 1.8666666666667, 0.5, 0.47916666666667
95281, 1.8666666666667, 0.45, 0.47916666666667
95282, 1.8666666666667, 0.4, 0.47916666666667
95283, 1.8666666666667, 0.35, 0.47916666666667
95284, 1.8666666666667, 0.3, 0.47916666666667
95285, 1.8666666666667, 0.25, 0.47916666666667
95286, 1.8666666666667, 0.2, 0.47916666666667
95287, 1.9083333333333, 1.3, 0.47916666666667
95288, 1.9083333333333, 1.25, 0.47916666666667
95289, 1.9083333333333, 1.2, 0.47916666666667
95290, 1.9083333333333, 1.15, 0.47916666666667
95291, 1.9083333333333, 1.1, 0.47916666666667
95292, 1.9083333333333, 1.05, 0.47916666666667
95293, 1.9083333333333, 1, 0.47916666666667
95294, 1.9083333333333, 0.95, 0.47916666666667
95295, 1.9083333333333, 0.9, 0.47916666666667
95296, 1.9083333333333, 0.85, 0.47916666666667
95297, 1.9083333333333, 0.8, 0.47916666666667
95298, 1.9083333333333, 0.75, 0.47916666666667
95299, 1.9083333333333, 0.7, 0.47916666666667
95300, 1.9083333333333, 0.65, 0.47916666666667
95301, 1.9083333333333, 0.6, 0.47916666666667
95302, 1.9083333333333, 0.55, 0.47916666666667
95303, 1.9083333333333, 0.5, 0.47916666666667
95304, 1.9083333333333, 0.45, 0.47916666666667
95305, 1.9083333333333, 0.4, 0.47916666666667
95306, 1.9083333333333, 0.35, 0.47916666666667
95307, 1.9083333333333, 0.3, 0.47916666666667
95308, 1.9083333333333, 0.25, 0.47916666666667
95309, 1.9083333333333, 0.2, 0.47916666666667
95310, 1.95, 1.3, 0.47916666666667
95311, 1.95, 1.25, 0.47916666666667
95312, 1.95, 1.2, 0.47916666666667
95313, 1.95, 1.15, 0.47916666666667
95314, 1.95, 1.1, 0.47916666666667
95315, 1.95, 1.05, 0.47916666666667
95316, 1.95, 1, 0.47916666666667
95317, 1.95, 0.95, 0.47916666666667
95318, 1.95, 0.9, 0.47916666666667
95319, 1.95, 0.85, 0.47916666666667
95320, 1.95, 0.8, 0.47916666666667
95321, 1.95, 0.75, 0.47916666666667
95322, 1.95, 0.7, 0.47916666666667
95323, 1.95, 0.65, 0.47916666666667
95324, 1.95, 0.6, 0.47916666666667
95325, 1.95, 0.55, 0.47916666666667
95326, 1.95, 0.5, 0.47916666666667
95327, 1.95, 0.45, 0.47916666666667
95328, 1.95, 0.4, 0.47916666666667
95329, 1.95, 0.35, 0.47916666666667
95330, 1.95, 0.3, 0.47916666666667
95331, 1.95, 0.25, 0.47916666666667
95332, 1.95, 0.2, 0.47916666666667
95333, 1.9916666666667, 1.3, 0.47916666666667
95334, 1.9916666666667, 1.25, 0.47916666666667
95335, 1.9916666666667, 1.2, 0.47916666666667
95336, 1.9916666666667, 1.15, 0.47916666666667
95337, 1.9916666666667, 1.1, 0.47916666666667
95338, 1.9916666666667, 1.05, 0.47916666666667
95339, 1.9916666666667, 1, 0.47916666666667
95340, 1.9916666666667, 0.95, 0.47916666666667
95341, 1.9916666666667, 0.9, 0.47916666666667
95342, 1.9916666666667, 0.85, 0.47916666666667
95343, 1.9916666666667, 0.8, 0.47916666666667
95344, 1.9916666666667, 0.75, 0.47916666666667
95345, 1.9916666666667, 0.7, 0.47916666666667
95346, 1.9916666666667, 0.65, 0.47916666666667
95347, 1.9916666666667, 0.6, 0.47916666666667
95348, 1.9916666666667, 0.55, 0.47916666666667
95349, 1.9916666666667, 0.5, 0.47916666666667
95350, 1.9916666666667, 0.45, 0.47916666666667
95351, 1.9916666666667, 0.4, 0.47916666666667
95352, 1.9916666666667, 0.35, 0.47916666666667
95353, 1.9916666666667, 0.3, 0.47916666666667
95354, 1.9916666666667, 0.25, 0.47916666666667
95355, 1.9916666666667, 0.2, 0.47916666666667
95356, 2.0333333333333, 1.3, 0.47916666666667
95357, 2.0333333333333, 1.25, 0.47916666666667
95358, 2.0333333333333, 1.2, 0.47916666666667
95359, 2.0333333333333, 1.15, 0.47916666666667
95360, 2.0333333333333, 1.1, 0.47916666666667
95361, 2.0333333333333, 1.05, 0.47916666666667
95362, 2.0333333333333, 1, 0.47916666666667
95363, 2.0333333333333, 0.95, 0.47916666666667
95364, 2.0333333333333, 0.9, 0.47916666666667
95365, 2.0333333333333, 0.85, 0.47916666666667
95366, 2.0333333333333, 0.8, 0.47916666666667
95367, 2.0333333333333, 0.75, 0.47916666666667
95368, 2.0333333333333, 0.7, 0.47916666666667
95369, 2.0333333333333, 0.65, 0.47916666666667
95370, 2.0333333333333, 0.6, 0.47916666666667
95371, 2.0333333333333, 0.55, 0.47916666666667
95372, 2.0333333333333, 0.5, 0.47916666666667
95373, 2.0333333333333, 0.45, 0.47916666666667
95374, 2.0333333333333, 0.4, 0.47916666666667
95375, 2.0333333333333, 0.35, 0.47916666666667
95376, 2.0333333333333, 0.3, 0.47916666666667
95377, 2.0333333333333, 0.25, 0.47916666666667
95378, 2.0333333333333, 0.2, 0.47916666666667
95379, 2.075, 1.3, 0.47916666666667
95380, 2.075, 1.25, 0.47916666666667
95381, 2.075, 1.2, 0.47916666666667
95382, 2.075, 1.15, 0.47916666666667
95383, 2.075, 1.1, 0.47916666666667
95384, 2.075, 1.05, 0.47916666666667
95385, 2.075, 1, 0.47916666666667
95386, 2.075, 0.95, 0.47916666666667
95387, 2.075, 0.9, 0.47916666666667
95388, 2.075, 0.85, 0.47916666666667
95389, 2.075, 0.8, 0.47916666666667
95390, 2.075, 0.75, 0.47916666666667
95391, 2.075, 0.7, 0.47916666666667
95392, 2.075, 0.65, 0.47916666666667
95393, 2.075, 0.6, 0.47916666666667
95394, 2.075, 0.55, 0.47916666666667
95395, 2.075, 0.5, 0.47916666666667
95396, 2.075, 0.45, 0.47916666666667
95397, 2.075, 0.4, 0.47916666666667
95398, 2.075, 0.35, 0.47916666666667
95399, 2.075, 0.3, 0.47916666666667
95400, 2.075, 0.25, 0.47916666666667
95401, 2.075, 0.2, 0.47916666666667
95402, 2.1166666666667, 1.3, 0.47916666666667
95403, 2.1166666666667, 1.25, 0.47916666666667
95404, 2.1166666666667, 1.2, 0.47916666666667
95405, 2.1166666666667, 1.15, 0.47916666666667
95406, 2.1166666666667, 1.1, 0.47916666666667
95407, 2.1166666666667, 1.05, 0.47916666666667
95408, 2.1166666666667, 1, 0.47916666666667
95409, 2.1166666666667, 0.95, 0.47916666666667
95410, 2.1166666666667, 0.9, 0.47916666666667
95411, 2.1166666666667, 0.85, 0.47916666666667
95412, 2.1166666666667, 0.8, 0.47916666666667
95413, 2.1166666666667, 0.75, 0.47916666666667
95414, 2.1166666666667, 0.7, 0.47916666666667
95415, 2.1166666666667, 0.65, 0.47916666666667
95416, 2.1166666666667, 0.6, 0.47916666666667
95417, 2.1166666666667, 0.55, 0.47916666666667
95418, 2.1166666666667, 0.5, 0.47916666666667
95419, 2.1166666666667, 0.45, 0.47916666666667
95420, 2.1166666666667, 0.4, 0.47916666666667
95421, 2.1166666666667, 0.35, 0.47916666666667
95422, 2.1166666666667, 0.3, 0.47916666666667
95423, 2.1166666666667, 0.25, 0.47916666666667
95424, 2.1166666666667, 0.2, 0.47916666666667
95425, 2.1583333333333, 1.3, 0.47916666666667
95426, 2.1583333333333, 1.25, 0.47916666666667
95427, 2.1583333333333, 1.2, 0.47916666666667
95428, 2.1583333333333, 1.15, 0.47916666666667
95429, 2.1583333333333, 1.1, 0.47916666666667
95430, 2.1583333333333, 1.05, 0.47916666666667
95431, 2.1583333333333, 1, 0.47916666666667
95432, 2.1583333333333, 0.95, 0.47916666666667
95433, 2.1583333333333, 0.9, 0.47916666666667
95434, 2.1583333333333, 0.85, 0.47916666666667
95435, 2.1583333333333, 0.8, 0.47916666666667
95436, 2.1583333333333, 0.75, 0.47916666666667
95437, 2.1583333333333, 0.7, 0.47916666666667
95438, 2.1583333333333, 0.65, 0.47916666666667
95439, 2.1583333333333, 0.6, 0.47916666666667
95440, 2.1583333333333, 0.55, 0.47916666666667
95441, 2.1583333333333, 0.5, 0.47916666666667
95442, 2.1583333333333, 0.45, 0.47916666666667
95443, 2.1583333333333, 0.4, 0.47916666666667
95444, 2.1583333333333, 0.35, 0.47916666666667
95445, 2.1583333333333, 0.3, 0.47916666666667
95446, 2.1583333333333, 0.25, 0.47916666666667
95447, 2.1583333333333, 0.2, 0.47916666666667
95448, 1.2416666666667, 0.125, 0.041666666666667
95449, 1.2833333333333, 0.125, 0.041666666666667
95450, 1.325, 0.125, 0.041666666666667
95451, 1.3666666666667, 0.125, 0.041666666666667
95452, 1.4083333333333, 0.125, 0.041666666666667
95453, 1.45, 0.125, 0.041666666666667
95454, 1.4916666666667, 0.125, 0.041666666666667
95455, 1.5333333333333, 0.125, 0.041666666666667
95456, 1.575, 0.125, 0.041666666666667
95457, 1.6166666666667, 0.125, 0.041666666666667
95458, 1.6583333333333, 0.125, 0.041666666666667
95459, 1.7, 0.125, 0.041666666666667
95460, 1.7416666666667, 0.125, 0.041666666666667
95461, 1.7833333333333, 0.125, 0.041666666666667
95462, 1.825, 0.125, 0.041666666666667
95463, 1.8666666666667, 0.125, 0.041666666666667
95464, 1.9083333333333, 0.125, 0.041666666666667
95465, 1.95, 0.125, 0.041666666666667
95466, 1.9916666666667, 0.125, 0.041666666666667
95467, 2.0333333333333, 0.125, 0.041666666666667
95468, 2.075, 0.125, 0.041666666666667
95469, 2.1166666666667, 0.125, 0.041666666666667
95470, 2.1583333333333, 0.125, 0.041666666666667
95471, 1.2416666666667, 0.125, 0.083333333333333
95472, 1.2833333333333, 0.125, 0.083333333333333
95473, 1.325, 0.125, 0.083333333333333
95474, 1.3666666666667, 0.125, 0.083333333333333
95475, 1.4083333333333, 0.125, 0.083333333333333
95476, 1.45, 0.125, 0.083333333333333
95477, 1.4916666666667, 0.125, 0.083333333333333
95478, 1.5333333333333, 0.125, 0.083333333333333
95479, 1.575, 0.125, 0.083333333333333
95480, 1.6166666666667, 0.125, 0.083333333333333
95481, 1.6583333333333, 0.125, 0.083333333333333
95482, 1.7, 0.125, 0.083333333333333
95483, 1.7416666666667, 0.125, 0.083333333333333
95484, 1.7833333333333, 0.125, 0.083333333333333
95485, 1.825, 0.125, 0.083333333333333
95486, 1.8666666666667, 0.125, 0.083333333333333
95487, 1.9083333333333, 0.125, 0.083333333333333
95488, 1.95, 0.125, 0.083333333333333
95489, 1.9916666666667, 0.125, 0.083333333333333
95490, 2.0333333333333, 0.125, 0.083333333333333
95491, 2.075, 0.125, 0.083333333333333
95492, 2.1166666666667, 0.125, 0.083333333333333
95493, 2.1583333333333, 0.125, 0.083333333333333
95494, 1.2416666666667, 0.125, 0.125
95495, 1.2833333333333, 0.125, 0.125
95496, 1.325, 0.125, 0.125
95497, 1.3666666666667, 0.125, 0.125
95498, 1.4083333333333, 0.125, 0.125
95499, 1.45, 0.125, 0.125
95500, 1.4916666666667, 0.125, 0.125
95501, 1.5333333333333, 0.125, 0.125
95502, 1.575, 0.125, 0.125
95503, 1.6166666666667, 0.125, 0.125
95504, 1.6583333333333, 0.125, 0.125
95505, 1.7, 0.125, 0.125
95506, 1.7416666666667, 0.125, 0.125
95507, 1.7833333333333, 0.125, 0.125
95508, 1.825, 0.125, 0.125
95509, 1.8666666666667, 0.125, 0.125
95510, 1.9083333333333, 0.125, 0.125
95511, 1.95, 0.125, 0.125
95512, 1.9916666666667, 0.125, 0.125
95513, 2.0333333333333, 0.125, 0.125
95514, 2.075, 0.125, 0.125
95515, 2.1166666666667, 0.125, 0.125
95516, 2.1583333333333, 0.125, 0.125
95517, 1.2416666666667, 0.125, 0.16666666666667
95518, 1.2833333333333, 0.125, 0.16666666666667
95519, 1.325, 0.125, 0.16666666666667
95520, 1.3666666666667, 0.125, 0.16666666666667
95521, 1.4083333333333, 0.125, 0.16666666666667
95522, 1.45, 0.125, 0.16666666666667
95523, 1.4916666666667, 0.125, 0.16666666666667
95524, 1.5333333333333, 0.125, 0.16666666666667
95525, 1.575, 0.125, 0.16666666666667
95526, 1.6166666666667, 0.125, 0.16666666666667
95527, 1.6583333333333, 0.125, 0.16666666666667
95528, 1.7, 0.125, 0.16666666666667
95529, 1.7416666666667, 0.125, 0.16666666666667
95530, 1.7833333333333, 0.125, 0.16666666666667
95531, 1.825, 0.125, 0.16666666666667
95532, 1.8666666666667, 0.125, 0.16666666666667
95533, 1.9083333333333, 0.125, 0.16666666666667
95534, 1.95, 0.125, 0.16666666666667
95535, 1.9916666666667, 0.125, 0.16666666666667
95536, 2.0333333333333, 0.125, 0.16666666666667
95537, 2.075, 0.125, 0.16666666666667
95538, 2.1166666666667, 0.125, 0.16666666666667
95539, 2.1583333333333, 0.125, 0.16666666666667
95540, 1.2416666666667, 0.125, 0.20833333333333
95541, 1.2833333333333, 0.125, 0.20833333333333
95542, 1.325, 0.125, 0.20833333333333
95543, 1.3666666666667, 0.125, 0.20833333333333
95544, 1.4083333333333, 0.125, 0.20833333333333
95545, 1.45, 0.125, 0.20833333333333
95546, 1.4916666666667, 0.125, 0.20833333333333
95547, 1.5333333333333, 0.125, 0.20833333333333
95548, 1.575, 0.125, 0.20833333333333
95549, 1.6166666666667, 0.125, 0.20833333333333
95550, 1.6583333333333, 0.125, 0.20833333333333
95551, 1.7, 0.125, 0.20833333333333
95552, 1.7416666666667, 0.125, 0.20833333333333
95553, 1.7833333333333, 0.125, 0.20833333333333
95554, 1.825, 0.125, 0.20833333333333
95555, 1.8666666666667, 0.125, 0.20833333333333
95556, 1.9083333333333, 0.125, 0.20833333333333
95557, 1.95, 0.125, 0.20833333333333
95558, 1.9916666666667, 0.125, 0.20833333333333
95559, 2.0333333333333, 0.125, 0.20833333333333
95560, 2.075, 0.125, 0.20833333333333
95561, 2.1166666666667, 0.125, 0.20833333333333
95562, 2.1583333333333, 0.125, 0.20833333333333
95563, 1.2416666666667, 0.125, 0.25
95564, 1.2833333333333, 0.125, 0.25
95565, 1.325, 0.125, 0.25
95566, 1.3666666666667, 0.125, 0.25
95567, 1.4083333333333, 0.125, 0.25
95568, 1.45, 0.125, 0.25
95569, 1.4916666666667, 0.125, 0.25
95570, 1.5333333333333, 0.125, 0.25
95571, 1.575, 0.125, 0.25
95572, 1.6166666666667, 0.125, 0.25
95573, 1.6583333333333, 0.125, 0.25
95574, 1.7, 0.125, 0.25
95575, 1.7416666666667, 0.125, 0.25
95576, 1.7833333333333, 0.125, 0.25
95577, 1.825, 0.125, 0.25
95578, 1.8666666666667, 0.125, 0.25
95579, 1.9083333333333, 0.125, 0.25
95580, 1.95, 0.125, 0.25
95581, 1.9916666666667, 0.125, 0.25
95582, 2.0333333333333, 0.125, 0.25
95583, 2.075, 0.125, 0.25
95584, 2.1166666666667, 0.125, 0.25
95585, 2.1583333333333, 0.125, 0.25
95586, 1.2416666666667, 0.125, 0.29166666666667
95587, 1.2833333333333, 0.125, 0.29166666666667
95588, 1.325, 0.125, 0.29166666666667
95589, 1.3666666666667, 0.125, 0.29166666666667
95590, 1.4083333333333, 0.125, 0.29166666666667
95591, 1.45, 0.125, 0.29166666666667
95592, 1.4916666666667, 0.125, 0.29166666666667
95593, 1.5333333333333, 0.125, 0.29166666666667
95594, 1.575, 0.125, 0.29166666666667
95595, 1.6166666666667, 0.125, 0.29166666666667
95596, 1.6583333333333, 0.125, 0.29166666666667
95597, 1.7, 0.125, 0.29166666666667
95598, 1.7416666666667, 0.125, 0.29166666666667
95599, 1.7833333333333, 0.125, 0.29166666666667
95600, 1.825, 0.125, 0.29166666666667
95601, 1.8666666666667, 0.125, 0.29166666666667
95602, 1.9083333333333, 0.125, 0.29166666666667
95603, 1.95, 0.125, 0.29166666666667
95604, 1.9916666666667, 0.125, 0.29166666666667
95605, 2.0333333333333, 0.125, 0.29166666666667
95606, 2.075, 0.125, 0.29166666666667
95607, 2.1166666666667, 0.125, 0.29166666666667
95608, 2.1583333333333, 0.125, 0.29166666666667
95609, 1.2416666666667, 0.125, 0.33333333333333
95610, 1.2833333333333, 0.125, 0.33333333333333
95611, 1.325, 0.125, 0.33333333333333
95612, 1.3666666666667, 0.125, 0.33333333333333
95613, 1.4083333333333, 0.125, 0.33333333333333
95614, 1.45, 0.125, 0.33333333333333
95615, 1.4916666666667, 0.125, 0.33333333333333
95616, 1.5333333333333, 0.125, 0.33333333333333
95617, 1.575, 0.125, 0.33333333333333
95618, 1.6166666666667, 0.125, 0.33333333333333
95619, 1.6583333333333, 0.125, 0.33333333333333
95620, 1.7, 0.125, 0.33333333333333
95621, 1.7416666666667, 0.125, 0.33333333333333
95622, 1.7833333333333, 0.125, 0.33333333333333
95623, 1.825, 0.125, 0.33333333333333
95624, 1.8666666666667, 0.125, 0.33333333333333
95625, 1.9083333333333, 0.125, 0.33333333333333
95626, 1.95, 0.125, 0.33333333333333
95627, 1.9916666666667, 0.125, 0.33333333333333
95628, 2.0333333333333, 0.125, 0.33333333333333
95629, 2.075, 0.125, 0.33333333333333
95630, 2.1166666666667, 0.125, 0.33333333333333
95631, 2.1583333333333, 0.125, 0.33333333333333
95632, 1.2416666666667, 0.125, 0.375
95633, 1.2833333333333, 0.125, 0.375
95634, 1.325, 0.125, 0.375
95635, 1.3666666666667, 0.125, 0.375
95636, 1.4083333333333, 0.125, 0.375
95637, 1.45, 0.125, 0.375
95638, 1.4916666666667, 0.125, 0.375
95639, 1.5333333333333, 0.125, 0.375
95640, 1.575, 0.125, 0.375
95641, 1.6166666666667, 0.125, 0.375
95642, 1.6583333333333, 0.125, 0.375
95643, 1.7, 0.125, 0.375
95644, 1.7416666666667, 0.125, 0.375
95645, 1.7833333333333, 0.125, 0.375
95646, 1.825, 0.125, 0.375
95647, 1.8666666666667, 0.125, 0.375
95648, 1.9083333333333, 0.125, 0.375
95649, 1.95, 0.125, 0.375
95650, 1.9916666666667, 0.125, 0.375
95651, 2.0333333333333, 0.125, 0.375
95652, 2.075, 0.125, 0.375
95653, 2.1166666666667, 0.125, 0.375
95654, 2.1583333333333, 0.125, 0.375
95655, 1.2416666666667, 0.125, 0.41666666666667
95656, 1.2833333333333, 0.125, 0.41666666666667
95657, 1.325, 0.125, 0.41666666666667
95658, 1.3666666666667, 0.125, 0.41666666666667
95659, 1.4083333333333, 0.125, 0.41666666666667
95660, 1.45, 0.125, 0.41666666666667
95661, 1.4916666666667, 0.125, 0.41666666666667
95662, 1.5333333333333, 0.125, 0.41666666666667
95663, 1.575, 0.125, 0.41666666666667
95664, 1.6166666666667, 0.125, 0.41666666666667
95665, 1.6583333333333, 0.125, 0.41666666666667
95666, 1.7, 0.125, 0.41666666666667
95667, 1.7416666666667, 0.125, 0.41666666666667
95668, 1.7833333333333, 0.125, 0.41666666666667
95669, 1.825, 0.125, 0.41666666666667
95670, 1.8666666666667, 0.125, 0.41666666666667
95671, 1.9083333333333, 0.125, 0.41666666666667
95672, 1.95, 0.125, 0.41666666666667
95673, 1.9916666666667, 0.125, 0.41666666666667
95674, 2.0333333333333, 0.125, 0.41666666666667
95675, 2.075, 0.125, 0.41666666666667
95676, 2.1166666666667, 0.125, 0.41666666666667
95677, 2.1583333333333, 0.125, 0.41666666666667
95678, 1.2416666666667, 0.125, 0.45833333333333
95679, 1.2833333333333, 0.125, 0.45833333333333
95680, 1.325, 0.125, 0.45833333333333
95681, 1.3666666666667, 0.125, 0.45833333333333
95682, 1.4083333333333, 0.125, 0.45833333333333
95683, 1.45, 0.125, 0.45833333333333
95684, 1.4916666666667, 0.125, 0.45833333333333
95685, 1.5333333333333, 0.125, 0.45833333333333
95686, 1.575, 0.125, 0.45833333333333
95687, 1.6166666666667, 0.125, 0.45833333333333
95688, 1.6583333333333, 0.125, 0.45833333333333
95689, 1.7, 0.125, 0.45833333333333
95690, 1.7416666666667, 0.125, 0.45833333333333
95691, 1.7833333333333, 0.125, 0.45833333333333
95692, 1.825, 0.125, 0.45833333333333
95693, 1.8666666666667, 0.125, 0.45833333333333
95694, 1.9083333333333, 0.125, 0.45833333333333
95695, 1.95, 0.125, 0.45833333333333
95696, 1.9916666666667, 0.125, 0.45833333333333
95697, 2.0333333333333, 0.125, 0.45833333333333
95698, 2.075, 0.125, 0.45833333333333
95699, 2.1166666666667, 0.125, 0.45833333333333
95700, 2.1583333333333, 0.125, 0.45833333333333
95701, 1.2416666666667, 0.066666666666667, 0.041666666666667
95702, 1.2416666666667, 0.033333333333333, 0.041666666666667
95703, 1.2833333333333, 0.066666666666667, 0.041666666666667
95704, 1.2833333333333, 0.033333333333333, 0.041666666666667
95705, 1.325, 0.066666666666667, 0.041666666666667
95706, 1.325, 0.033333333333333, 0.041666666666667
95707, 1.3666666666667, 0.066666666666667, 0.041666666666667
95708, 1.3666666666667, 0.033333333333333, 0.041666666666667
95709, 1.4083333333333, 0.066666666666667, 0.041666666666667
95710, 1.4083333333333, 0.033333333333333, 0.041666666666667
95711, 1.45, 0.066666666666667, 0.041666666666667
95712, 1.45, 0.033333333333333, 0.041666666666667
95713, 1.4916666666667, 0.066666666666667, 0.041666666666667
95714, 1.4916666666667, 0.033333333333333, 0.041666666666667
95715, 1.5333333333333, 0.066666666666667, 0.041666666666667
95716, 1.5333333333333, 0.033333333333333, 0.041666666666667
95717, 1.575, 0.066666666666667, 0.041666666666667
95718, 1.575, 0.033333333333333, 0.041666666666667
95719, 1.6166666666667, 0.066666666666667, 0.041666666666667
95720, 1.6166666666667, 0.033333333333333, 0.041666666666667
95721, 1.6583333333333, 0.066666666666667, 0.041666666666667
95722, 1.6583333333333, 0.033333333333333, 0.041666666666667
95723, 1.7, 0.066666666666667, 0.041666666666667
95724, 1.7, 0.033333333333333, 0.041666666666667
95725, 1.7416666666667, 0.066666666666667, 0.041666666666667
95726, 1.7416666666667, 0.033333333333333, 0.041666666666667
95727, 1.7833333333333, 0.066666666666667, 0.041666666666667
95728, 1.7833333333333, 0.033333333333333, 0.041666666666667
95729, 1.825, 0.066666666666667, 0.041666666666667
95730, 1.825, 0.033333333333333, 0.041666666666667
95731, 1.8666666666667, 0.066666666666667, 0.041666666666667
95732, 1.8666666666667, 0.033333333333333, 0.041666666666667
95733, 1.9083333333333, 0.066666666666667, 0.041666666666667
95734, 1.9083333333333, 0.033333333333333, 0.041666666666667
95735, 1.95, 0.066666666666667, 0.041666666666667
95736, 1.95, 0.033333333333333, 0.041666666666667
95737, 1.9916666666667, 0.066666666666667, 0.041666666666667
95738, 1.9916666666667, 0.033333333333333, 0.041666666666667
95739, 2.0333333333333, 0.066666666666667, 0.041666666666667
95740, 2.0333333333333, 0.033333333333333, 0.041666666666667
95741, 2.075, 0.066666666666667, 0.041666666666667
95742, 2.075, 0.033333333333333, 0.041666666666667
95743, 2.1166666666667, 0.066666666666667, 0.041666666666667
95744, 2.1166666666667, 0.033333333333333, 0.041666666666667
95745, 2.1583333333333, 0.066666666666667, 0.041666666666667
95746, 2.1583333333333, 0.033333333333333, 0.041666666666667
95747, 1.2416666666667, 0.066666666666667, 0.083333333333333
95748, 1.2416666666667, 0.033333333333333, 0.083333333333333
95749, 1.2833333333333, 0.066666666666667, 0.083333333333333
95750, 1.2833333333333, 0.033333333333333, 0.083333333333333
95751, 1.325, 0.066666666666667, 0.083333333333333
95752, 1.325, 0.033333333333333, 0.083333333333333
95753, 1.3666666666667, 0.066666666666667, 0.083333333333333
95754, 1.3666666666667, 0.033333333333333, 0.083333333333333
95755, 1.4083333333333, 0.066666666666667, 0.083333333333333
95756, 1.4083333333333, 0.033333333333333, 0.083333333333333
95757, 1.45, 0.066666666666667, 0.083333333333333
95758, 1.45, 0.033333333333333, 0.083333333333333
95759, 1.4916666666667, 0.066666666666667, 0.083333333333333
95760, 1.4916666666667, 0.033333333333333, 0.083333333333333
95761, 1.5333333333333, 0.066666666666667, 0.083333333333333
95762, 1.5333333333333, 0.033333333333333, 0.083333333333333
95763, 1.575, 0.066666666666667, 0.083333333333333
95764, 1.575, 0.033333333333333, 0.083333333333333
95765, 1.6166666666667, 0.066666666666667, 0.083333333333333
95766, 1.6166666666667, 0.033333333333333, 0.083333333333333
95767, 1.6583333333333, 0.066666666666667, 0.083333333333333
95768, 1.6583333333333, 0.033333333333333, 0.083333333333333
95769, 1.7, 0.066666666666667, 0.083333333333333
95770, 1.7, 0.033333333333333, 0.083333333333333
95771, 1.7416666666667, 0.066666666666667, 0.083333333333333
95772, 1.7416666666667, 0.033333333333333, 0.083333333333333
95773, 1.7833333333333, 0.066666666666667, 0.083333333333333
95774, 1.7833333333333, 0.033333333333333, 0.083333333333333
95775, 1.825, 0.066666666666667, 0.083333333333333
95776, 1.825, 0.033333333333333, 0.083333333333333
95777, 1.8666666666667, 0.066666666666667, 0.083333333333333
95778, 1.8666666666667, 0.033333333333333, 0.083333333333333
95779, 1.9083333333333, 0.066666666666667, 0.083333333333333
95780, 1.9083333333333, 0.033333333333333, 0.083333333333333
95781, 1.95, 0.066666666666667, 0.083333333333333
95782, 1.95, 0.033333333333333, 0.083333333333333
95783, 1.9916666666667, 0.066666666666667, 0.083333333333333
95784, 1.9916666666667, 0.033333333333333, 0.083333333333333
95785, 2.0333333333333, 0.066666666666667, 0.083333333333333
95786, 2.0333333333333, 0.033333333333333, 0.083333333333333
95787, 2.075, 0.066666666666667, 0.083333333333333
95788, 2.075, 0.033333333333333, 0.083333333333333
95789, 2.1166666666667, 0.066666666666667, 0.083333333333333
95790, 2.1166666666667, 0.033333333333333, 0.083333333333333
95791, 2.1583333333333, 0.066666666666667, 0.083333333333333
95792, 2.1583333333333, 0.033333333333333, 0.083333333333333
95793, 1.2416666666667, 0.066666666666667, 0.125
95794, 1.2416666666667, 0.033333333333333, 0.125
95795, 1.2833333333333, 0.066666666666667, 0.125
95796, 1.2833333333333, 0.033333333333333, 0.125
95797, 1.325, 0.066666666666667, 0.125
95798, 1.325, 0.033333333333333, 0.125
95799, 1.3666666666667, 0.066666666666667, 0.125
95800, 1.3666666666667, 0.033333333333333, 0.125
95801, 1.4083333333333, 0.066666666666667, 0.125
95802, 1.4083333333333, 0.033333333333333, 0.125
95803, 1.45, 0.066666666666667, 0.125
95804, 1.45, 0.033333333333333, 0.125
95805, 1.4916666666667, 0.066666666666667, 0.125
95806, 1.4916666666667, 0.033333333333333, 0.125
95807, 1.5333333333333, 0.066666666666667, 0.125
95808, 1.5333333333333, 0.033333333333333, 0.125
95809, 1.575, 0.066666666666667, 0.125
95810, 1.575, 0.033333333333333, 0.125
95811, 1.6166666666667, 0.066666666666667, 0.125
95812, 1.6166666666667, 0.033333333333333, 0.125
95813, 1.6583333333333, 0.066666666666667, 0.125
95814, 1.6583333333333, 0.033333333333333, 0.125
95815, 1.7, 0.066666666666667, 0.125
95816, 1.7, 0.033333333333333, 0.125
95817, 1.7416666666667, 0.066666666666667, 0.125
95818, 1.7416666666667, 0.033333333333333, 0.125
95819, 1.7833333333333, 0.066666666666667, 0.125
95820, 1.7833333333333, 0.033333333333333, 0.125
95821, 1.825, 0.066666666666667, 0.125
95822, 1.825, 0.033333333333333, 0.125
95823, 1.8666666666667, 0.066666666666667, 0.125
95824, 1.8666666666667, 0.033333333333333, 0.125
95825, 1.9083333333333, 0.066666666666667, 0.125
95826, 1.9083333333333, 0.033333333333333, 0.125
95827, 1.95, 0.066666666666667, 0.125
95828, 1.95, 0.033333333333333, 0.125
95829, 1.9916666666667, 0.066666666666667, 0.125
95830, 1.9916666666667, 0.033333333333333, 0.125
95831, 2.0333333333333, 0.066666666666667, 0.125
95832, 2.0333333333333, 0.033333333333333, 0.125
95833, 2.075, 0.066666666666667, 0.125
95834, 2.075, 0.033333333333333, 0.125
95835, 2.1166666666667, 0.066666666666667, 0.125
95836, 2.1166666666667, 0.033333333333333, 0.125
95837, 2.1583333333333, 0.066666666666667, 0.125
95838, 2.1583333333333, 0.033333333333333, 0.125
95839, 1.2416666666667, 0.066666666666667, 0.16666666666667
95840, 1.2416666666667, 0.033333333333333, 0.16666666666667
95841, 1.2833333333333, 0.066666666666667, 0.16666666666667
95842, 1.2833333333333, 0.033333333333333, 0.16666666666667
95843, 1.325, 0.066666666666667, 0.16666666666667
95844, 1.325, 0.033333333333333, 0.16666666666667
95845, 1.3666666666667, 0.066666666666667, 0.16666666666667
95846, 1.3666666666667, 0.033333333333333, 0.16666666666667
95847, 1.4083333333333, 0.066666666666667, 0.16666666666667
95848, 1.4083333333333, 0.033333333333333, 0.16666666666667
95849, 1.45, 0.066666666666667, 0.16666666666667
95850, 1.45, 0.033333333333333, 0.16666666666667
95851, 1.4916666666667, 0.066666666666667, 0.16666666666667
95852, 1.4916666666667, 0.033333333333333, 0.16666666666667
95853, 1.5333333333333, 0.066666666666667, 0.16666666666667
95854, 1.5333333333333, 0.033333333333333, 0.16666666666667
95855, 1.575, 0.066666666666667, 0.16666666666667
95856, 1.575, 0.033333333333333, 0.16666666666667
95857, 1.6166666666667, 0.066666666666667, 0.16666666666667
95858, 1.6166666666667, 0.033333333333333, 0.16666666666667
95859, 1.6583333333333, 0.066666666666667, 0.16666666666667
95860, 1.6583333333333, 0.033333333333333, 0.16666666666667
95861, 1.7, 0.066666666666667, 0.16666666666667
95862, 1.7, 0.033333333333333, 0.16666666666667
95863, 1.7416666666667, 0.066666666666667, 0.16666666666667
95864, 1.7416666666667, 0.033333333333333, 0.16666666666667
95865, 1.7833333333333, 0.066666666666667, 0.16666666666667
95866, 1.7833333333333, 0.033333333333333, 0.16666666666667
95867, 1.825, 0.066666666666667, 0.16666666666667
95868, 1.825, 0.033333333333333, 0.16666666666667
95869, 1.8666666666667, 0.066666666666667, 0.16666666666667
95870, 1.8666666666667, 0.033333333333333, 0.16666666666667
95871, 1.9083333333333, 0.066666666666667, 0.16666666666667
95872, 1.9083333333333, 0.033333333333333, 0.16666666666667
95873, 1.95, 0.066666666666667, 0.16666666666667
95874, 1.95, 0.033333333333333, 0.16666666666667
95875, 1.9916666666667, 0.066666666666667, 0.16666666666667
95876, 1.9916666666667, 0.033333333333333, 0.16666666666667
95877, 2.0333333333333, 0.066666666666667, 0.16666666666667
95878, 2.0333333333333, 0.033333333333333, 0.16666666666667
95879, 2.075, 0.066666666666667, 0.16666666666667
95880, 2.075, 0.033333333333333, 0.16666666666667
95881, 2.1166666666667, 0.066666666666667, 0.16666666666667
95882, 2.1166666666667, 0.033333333333333, 0.16666666666667
95883, 2.1583333333333, 0.066666666666667, 0.16666666666667
95884, 2.1583333333333, 0.033333333333333, 0.16666666666667
95885, 1.2416666666667, 0.066666666666667, 0.20833333333333
95886, 1.2416666666667, 0.033333333333333, 0.20833333333333
95887, 1.2833333333333, 0.066666666666667, 0.20833333333333
95888, 1.2833333333333, 0.033333333333333, 0.20833333333333
95889, 1.325, 0.066666666666667, 0.20833333333333
95890, 1.325, 0.033333333333333, 0.20833333333333
95891, 1.3666666666667, 0.066666666666667, 0.20833333333333
95892, 1.3666666666667, 0.033333333333333, 0.20833333333333
95893, 1.4083333333333, 0.066666666666667, 0.20833333333333
95894, 1.4083333333333, 0.033333333333333, 0.20833333333333
95895, 1.45, 0.066666666666667, 0.20833333333333
95896, 1.45, 0.033333333333333, 0.20833333333333
95897, 1.4916666666667, 0.066666666666667, 0.20833333333333
95898, 1.4916666666667, 0.033333333333333, 0.20833333333333
95899, 1.5333333333333, 0.066666666666667, 0.20833333333333
95900, 1.5333333333333, 0.033333333333333, 0.20833333333333
95901, 1.575, 0.066666666666667, 0.20833333333333
95902, 1.575, 0.033333333333333, 0.20833333333333
95903, 1.6166666666667, 0.066666666666667, 0.20833333333333
95904, 1.6166666666667, 0.033333333333333, 0.20833333333333
95905, 1.6583333333333, 0.066666666666667, 0.20833333333333
95906, 1.6583333333333, 0.033333333333333, 0.20833333333333
95907, 1.7, 0.066666666666667, 0.20833333333333
95908, 1.7, 0.033333333333333, 0.20833333333333
95909, 1.7416666666667, 0.066666666666667, 0.20833333333333
95910, 1.7416666666667, 0.033333333333333, 0.20833333333333
95911, 1.7833333333333, 0.066666666666667, 0.20833333333333
95912, 1.7833333333333, 0.033333333333333, 0.20833333333333
95913, 1.825, 0.066666666666667, 0.20833333333333
95914, 1.825, 0.033333333333333, 0.20833333333333
95915, 1.8666666666667, 0.066666666666667, 0.20833333333333
95916, 1.8666666666667, 0.033333333333333, 0.20833333333333
95917, 1.9083333333333, 0.066666666666667, 0.20833333333333
95918, 1.9083333333333, 0.033333333333333, 0.20833333333333
95919, 1.95, 0.066666666666667, 0.20833333333333
95920, 1.95, 0.033333333333333, 0.20833333333333
95921, 1.9916666666667, 0.066666666666667, 0.20833333333333
95922, 1.9916666666667, 0.033333333333333, 0.20833333333333
95923, 2.0333333333333, 0.066666666666667, 0.20833333333333
95924, 2.0333333333333, 0.033333333333333, 0.20833333333333
95925, 2.075, 0.066666666666667, 0.20833333333333
95926, 2.075, 0.033333333333333, 0.20833333333333
95927, 2.1166666666667, 0.066666666666667, 0.20833333333333
95928, 2.1166666666667, 0.033333333333333, 0.20833333333333
95929, 2.1583333333333, 0.066666666666667, 0.20833333333333
95930, 2.1583333333333, 0.033333333333333, 0.20833333333333
95931, 1.2416666666667, 0.066666666666667, 0.25
95932, 1.2416666666667, 0.033333333333333, 0.25
95933, 1.2833333333333, 0.066666666666667, 0.25
95934, 1.2833333333333, 0.033333333333333, 0.25
95935, 1.325, 0.066666666666667, 0.25
95936, 1.325, 0.033333333333333, 0.25
95937, 1.3666666666667, 0.066666666666667, 0.25
95938, 1.3666666666667, 0.033333333333333, 0.25
95939, 1.4083333333333, 0.066666666666667, 0.25
95940, 1.4083333333333, 0.033333333333333, 0.25
95941, 1.45, 0.066666666666667, 0.25
95942, 1.45, 0.033333333333333, 0.25
95943, 1.4916666666667, 0.066666666666667, 0.25
95944, 1.4916666666667, 0.033333333333333, 0.25
95945, 1.5333333333333, 0.066666666666667, 0.25
95946, 1.5333333333333, 0.033333333333333, 0.25
95947, 1.575, 0.066666666666667, 0.25
95948, 1.575, 0.033333333333333, 0.25
95949, 1.6166666666667, 0.066666666666667, 0.25
95950, 1.6166666666667, 0.033333333333333, 0.25
95951, 1.6583333333333, 0.066666666666667, 0.25
95952, 1.6583333333333, 0.033333333333333, 0.25
95953, 1.7, 0.066666666666667, 0.25
95954, 1.7, 0.033333333333333, 0.25
95955, 1.7416666666667, 0.066666666666667, 0.25
95956, 1.7416666666667, 0.033333333333333, 0.25
95957, 1.7833333333333, 0.066666666666667, 0.25
95958, 1.7833333333333, 0.033333333333333, 0.25
95959, 1.825, 0.066666666666667, 0.25
95960, 1.825, 0.033333333333333, 0.25
95961, 1.8666666666667, 0.066666666666667, 0.25
95962, 1.8666666666667, 0.033333333333333, 0.25
95963, 1.9083333333333, 0.066666666666667, 0.25
95964, 1.9083333333333, 0.033333333333333, 0.25
95965, 1.95, 0.066666666666667, 0.25
95966, 1.95, 0.033333333333333, 0.25
95967, 1.9916666666667, 0.066666666666667, 0.25
95968, 1.9916666666667, 0.033333333333333, 0.25
95969, 2.0333333333333, 0.066666666666667, 0.25
95970, 2.0333333333333, 0.033333333333333, 0.25
95971, 2.075, 0.066666666666667, 0.25
95972, 2.075, 0.033333333333333, 0.25
95973, 2.1166666666667, 0.066666666666667, 0.25
95974, 2.1166666666667, 0.033333333333333, 0.25
95975, 2.1583333333333, 0.066666666666667, 0.25
95976, 2.1583333333333, 0.033333333333333, 0.25
95977, 1.2416666666667, 0.066666666666667, 0.29166666666667
95978, 1.2416666666667, 0.033333333333333, 0.29166666666667
95979, 1.2833333333333, 0.066666666666667, 0.29166666666667
95980, 1.2833333333333, 0.033333333333333, 0.29166666666667
95981, 1.325, 0.066666666666667, 0.29166666666667
95982, 1.325, 0.033333333333333, 0.29166666666667
95983, 1.3666666666667, 0.066666666666667, 0.29166666666667
95984, 1.3666666666667, 0.033333333333333, 0.29166666666667
95985, 1.4083333333333, 0.066666666666667, 0.29166666666667
95986, 1.4083333333333, 0.033333333333333, 0.29166666666667
95987, 1.45, 0.066666666666667, 0.29166666666667
95988, 1.45, 0.033333333333333, 0.29166666666667
95989, 1.4916666666667, 0.066666666666667, 0.29166666666667
95990, 1.4916666666667, 0.033333333333333, 0.29166666666667
95991, 1.5333333333333, 0.066666666666667, 0.29166666666667
95992, 1.5333333333333, 0.033333333333333, 0.29166666666667
95993, 1.575, 0.066666666666667, 0.29166666666667
95994, 1.575, 0.033333333333333, 0.29166666666667
95995, 1.6166666666667, 0.066666666666667, 0.29166666666667
95996, 1.6166666666667, 0.033333333333333, 0.29166666666667
95997, 1.6583333333333, 0.066666666666667, 0.29166666666667
95998, 1.6583333333333, 0.033333333333333, 0.29166666666667
95999, 1.7, 0.066666666666667, 0.29166666666667
96000, 1.7, 0.033333333333333, 0.29166666666667
96001, 1.7416666666667, 0.066666666666667, 0.29166666666667
96002, 1.7416666666667, 0.033333333333333, 0.29166666666667
96003, 1.7833333333333, 0.066666666666667, 0.29166666666667
96004, 1.7833333333333, 0.033333333333333, 0.29166666666667
96005, 1.825, 0.066666666666667, 0.29166666666667
96006, 1.825, 0.033333333333333, 0.29166666666667
96007, 1.8666666666667, 0.066666666666667, 0.29166666666667
96008, 1.8666666666667, 0.033333333333333, 0.29166666666667
96009, 1.9083333333333, 0.066666666666667, 0.29166666666667
96010, 1.9083333333333, 0.033333333333333, 0.29166666666667
96011, 1.95, 0.066666666666667, 0.29166666666667
96012, 1.95, 0.033333333333333, 0.29166666666667
96013, 1.9916666666667, 0.066666666666667, 0.29166666666667
96014, 1.9916666666667, 0.033333333333333, 0.29166666666667
96015, 2.0333333333333, 0.066666666666667, 0.29166666666667
96016, 2.0333333333333, 0.033333333333333, 0.29166666666667
96017, 2.075, 0.066666666666667, 0.29166666666667
96018, 2.075, 0.033333333333333, 0.29166666666667
96019, 2.1166666666667, 0.066666666666667, 0.29166666666667
96020, 2.1166666666667, 0.033333333333333, 0.29166666666667
96021, 2.1583333333333, 0.066666666666667, 0.29166666666667
96022, 2.1583333333333, 0.033333333333333, 0.29166666666667
96023, 1.2416666666667, 0.066666666666667, 0.33333333333333
96024, 1.2416666666667, 0.033333333333333, 0.33333333333333
96025, 1.2833333333333, 0.066666666666667, 0.33333333333333
96026, 1.2833333333333, 0.033333333333333, 0.33333333333333
96027, 1.325, 0.066666666666667, 0.33333333333333
96028, 1.325, 0.033333333333333, 0.33333333333333
96029, 1.3666666666667, 0.066666666666667, 0.33333333333333
96030, 1.3666666666667, 0.033333333333333, 0.33333333333333
96031, 1.4083333333333, 0.066666666666667, 0.33333333333333
96032, 1.4083333333333, 0.033333333333333, 0.33333333333333
96033, 1.45, 0.066666666666667, 0.33333333333333
96034, 1.45, 0.033333333333333, 0.33333333333333
96035, 1.4916666666667, 0.066666666666667, 0.33333333333333
96036, 1.4916666666667, 0.033333333333333, 0.33333333333333
96037, 1.5333333333333, 0.066666666666667, 0.33333333333333
96038, 1.5333333333333, 0.033333333333333, 0.33333333333333
96039, 1.575, 0.066666666666667, 0.33333333333333
96040, 1.575, 0.033333333333333, 0.33333333333333
96041, 1.6166666666667, 0.066666666666667, 0.33333333333333
96042, 1.6166666666667, 0.033333333333333, 0.33333333333333
96043, 1.6583333333333, 0.066666666666667, 0.33333333333333
96044, 1.6583333333333, 0.033333333333333, 0.33333333333333
96045, 1.7, 0.066666666666667, 0.33333333333333
96046, 1.7, 0.033333333333333, 0.33333333333333
96047, 1.7416666666667, 0.066666666666667, 0.33333333333333
96048, 1.7416666666667, 0.033333333333333, 0.33333333333333
96049, 1.7833333333333, 0.066666666666667, 0.33333333333333
96050, 1.7833333333333, 0.033333333333333, 0.33333333333333
96051, 1.825, 0.066666666666667, 0.33333333333333
96052, 1.825, 0.033333333333333, 0.33333333333333
96053, 1.8666666666667, 0.066666666666667, 0.33333333333333
96054, 1.8666666666667, 0.033333333333333, 0.33333333333333
96055, 1.9083333333333, 0.066666666666667, 0.33333333333333
96056, 1.9083333333333, 0.033333333333333, 0.33333333333333
96057, 1.95, 0.066666666666667, 0.33333333333333
96058, 1.95, 0.033333333333333, 0.33333333333333
96059, 1.9916666666667, 0.066666666666667, 0.33333333333333
96060, 1.9916666666667, 0.033333333333333, 0.33333333333333
96061, 2.0333333333333, 0.066666666666667, 0.33333333333333
96062, 2.0333333333333, 0.033333333333333, 0.33333333333333
96063, 2.075, 0.066666666666667, 0.33333333333333
96064, 2.075, 0.033333333333333, 0.33333333333333
96065, 2.1166666666667, 0.066666666666667, 0.33333333333333
96066, 2.1166666666667, 0.033333333333333, 0.33333333333333
96067, 2.1583333333333, 0.066666666666667, 0.33333333333333
96068, 2.1583333333333, 0.033333333333333, 0.33333333333333
96069, 1.2416666666667, 0.066666666666667, 0.375
96070, 1.2416666666667, 0.033333333333333, 0.375
96071, 1.2833333333333, 0.066666666666667, 0.375
96072, 1.2833333333333, 0.033333333333333, 0.375
96073, 1.325, 0.066666666666667, 0.375
96074, 1.325, 0.033333333333333, 0.375
96075, 1.3666666666667, 0.066666666666667, 0.375
96076, 1.3666666666667, 0.033333333333333, 0.375
96077, 1.4083333333333, 0.066666666666667, 0.375
96078, 1.4083333333333, 0.033333333333333, 0.375
96079, 1.45, 0.066666666666667, 0.375
96080, 1.45, 0.033333333333333, 0.375
96081, 1.4916666666667, 0.066666666666667, 0.375
96082, 1.4916666666667, 0.033333333333333, 0.375
96083, 1.5333333333333, 0.066666666666667, 0.375
96084, 1.5333333333333, 0.033333333333333, 0.375
96085, 1.575, 0.066666666666667, 0.375
96086, 1.575, 0.033333333333333, 0.375
96087, 1.6166666666667, 0.066666666666667, 0.375
96088, 1.6166666666667, 0.033333333333333, 0.375
96089, 1.6583333333333, 0.066666666666667, 0.375
96090, 1.6583333333333, 0.033333333333333, 0.375
96091, 1.7, 0.066666666666667, 0.375
96092, 1.7, 0.033333333333333, 0.375
96093, 1.7416666666667, 0.066666666666667, 0.375
96094, 1.7416666666667, 0.033333333333333, 0.375
96095, 1.7833333333333, 0.066666666666667, 0.375
96096, 1.7833333333333, 0.033333333333333, 0.375
96097, 1.825, 0.066666666666667, 0.375
96098, 1.825, 0.033333333333333, 0.375
96099, 1.8666666666667, 0.066666666666667, 0.375
96100, 1.8666666666667, 0.033333333333333, 0.375
96101, 1.9083333333333, 0.066666666666667, 0.375
96102, 1.9083333333333, 0.033333333333333, 0.375
96103, 1.95, 0.066666666666667, 0.375
96104, 1.95, 0.033333333333333, 0.375
96105, 1.9916666666667, 0.066666666666667, 0.375
96106, 1.9916666666667, 0.033333333333333, 0.375
96107, 2.0333333333333, 0.066666666666667, 0.375
96108, 2.0333333333333, 0.033333333333333, 0.375
96109, 2.075, 0.066666666666667, 0.375
96110, 2.075, 0.033333333333333, 0.375
96111, 2.1166666666667, 0.066666666666667, 0.375
96112, 2.1166666666667, 0.033333333333333, 0.375
96113, 2.1583333333333, 0.066666666666667, 0.375
96114, 2.1583333333333, 0.033333333333333, 0.375
96115, 1.2416666666667, 0.066666666666667, 0.41666666666667
96116, 1.2416666666667, 0.033333333333333, 0.41666666666667
96117, 1.2833333333333, 0.066666666666667, 0.41666666666667
96118, 1.2833333333333, 0.033333333333333, 0.41666666666667
96119, 1.325, 0.066666666666667, 0.41666666666667
96120, 1.325, 0.033333333333333, 0.41666666666667
96121, 1.3666666666667, 0.066666666666667, 0.41666666666667
96122, 1.3666666666667, 0.033333333333333, 0.41666666666667
96123, 1.4083333333333, 0.066666666666667, 0.41666666666667
96124, 1.4083333333333, 0.033333333333333, 0.41666666666667
96125, 1.45, 0.066666666666667, 0.41666666666667
96126, 1.45, 0.033333333333333, 0.41666666666667
96127, 1.4916666666667, 0.066666666666667, 0.41666666666667
96128, 1.4916666666667, 0.033333333333333, 0.41666666666667
96129, 1.5333333333333, 0.066666666666667, 0.41666666666667
96130, 1.5333333333333, 0.033333333333333, 0.41666666666667
96131, 1.575, 0.066666666666667, 0.41666666666667
96132, 1.575, 0.033333333333333, 0.41666666666667
96133, 1.6166666666667, 0.066666666666667, 0.41666666666667
96134, 1.6166666666667, 0.033333333333333, 0.41666666666667
96135, 1.6583333333333, 0.066666666666667, 0.41666666666667
96136, 1.6583333333333, 0.033333333333333, 0.41666666666667
96137, 1.7, 0.066666666666667, 0.41666666666667
96138, 1.7, 0.033333333333333, 0.41666666666667
96139, 1.7416666666667, 0.066666666666667, 0.41666666666667
96140, 1.7416666666667, 0.033333333333333, 0.41666666666667
96141, 1.7833333333333, 0.066666666666667, 0.41666666666667
96142, 1.7833333333333, 0.033333333333333, 0.41666666666667
96143, 1.825, 0.066666666666667, 0.41666666666667
96144, 1.825, 0.033333333333333, 0.41666666666667
96145, 1.8666666666667, 0.066666666666667, 0.41666666666667
96146, 1.8666666666667, 0.033333333333333, 0.41666666666667
96147, 1.9083333333333, 0.066666666666667, 0.41666666666667
96148, 1.9083333333333, 0.033333333333333, 0.41666666666667
96149, 1.95, 0.066666666666667, 0.41666666666667
96150, 1.95, 0.033333333333333, 0.41666666666667
96151, 1.9916666666667, 0.066666666666667, 0.41666666666667
96152, 1.9916666666667, 0.033333333333333, 0.41666666666667
96153, 2.0333333333333, 0.066666666666667, 0.41666666666667
96154, 2.0333333333333, 0.033333333333333, 0.41666666666667
96155, 2.075, 0.066666666666667, 0.41666666666667
96156, 2.075, 0.033333333333333, 0.41666666666667
96157, 2.1166666666667, 0.066666666666667, 0.41666666666667
96158, 2.1166666666667, 0.033333333333333, 0.41666666666667
96159, 2.1583333333333, 0.066666666666667, 0.41666666666667
96160, 2.1583333333333, 0.033333333333333, 0.41666666666667
96161, 1.2416666666667, 0.066666666666667, 0.45833333333333
96162, 1.2416666666667, 0.033333333333333, 0.45833333333333
96163, 1.2833333333333, 0.066666666666667, 0.45833333333333
96164, 1.2833333333333, 0.033333333333333, 0.45833333333333
96165, 1.325, 0.066666666666667, 0.45833333333333
96166, 1.325, 0.033333333333333, 0.45833333333333
96167, 1.3666666666667, 0.066666666666667, 0.45833333333333
96168, 1.3666666666667, 0.033333333333333, 0.45833333333333
96169, 1.4083333333333, 0.066666666666667, 0.45833333333333
96170, 1.4083333333333, 0.033333333333333, 0.45833333333333
96171, 1.45, 0.066666666666667, 0.45833333333333
96172, 1.45, 0.033333333333333, 0.45833333333333
96173, 1.4916666666667, 0.066666666666667, 0.45833333333333
96174, 1.4916666666667, 0.033333333333333, 0.45833333333333
96175, 1.5333333333333, 0.066666666666667, 0.45833333333333
96176, 1.5333333333333, 0.033333333333333, 0.45833333333333
96177, 1.575, 0.066666666666667, 0.45833333333333
96178, 1.575, 0.033333333333333, 0.45833333333333
96179, 1.6166666666667, 0.066666666666667, 0.45833333333333
96180, 1.6166666666667, 0.033333333333333, 0.45833333333333
96181, 1.6583333333333, 0.066666666666667, 0.45833333333333
96182, 1.6583333333333, 0.033333333333333, 0.45833333333333
96183, 1.7, 0.066666666666667, 0.45833333333333
96184, 1.7, 0.033333333333333, 0.45833333333333
96185, 1.7416666666667, 0.066666666666667, 0.45833333333333
96186, 1.7416666666667, 0.033333333333333, 0.45833333333333
96187, 1.7833333333333, 0.066666666666667, 0.45833333333333
96188, 1.7833333333333, 0.033333333333333, 0.45833333333333
96189, 1.825, 0.066666666666667, 0.45833333333333
96190, 1.825, 0.033333333333333, 0.45833333333333
96191, 1.8666666666667, 0.066666666666667, 0.45833333333333
96192, 1.8666666666667, 0.033333333333333, 0.45833333333333
96193, 1.9083333333333, 0.066666666666667, 0.45833333333333
96194, 1.9083333333333, 0.033333333333333, 0.45833333333333
96195, 1.95, 0.066666666666667, 0.45833333333333
96196, 1.95, 0.033333333333333, 0.45833333333333
96197, 1.9916666666667, 0.066666666666667, 0.45833333333333
96198, 1.9916666666667, 0.033333333333333, 0.45833333333333
96199, 2.0333333333333, 0.066666666666667, 0.45833333333333
96200, 2.0333333333333, 0.033333333333333, 0.45833333333333
96201, 2.075, 0.066666666666667, 0.45833333333333
96202, 2.075, 0.033333333333333, 0.45833333333333
96203, 2.1166666666667, 0.066666666666667, 0.45833333333333
96204, 2.1166666666667, 0.033333333333333, 0.45833333333333
96205, 2.1583333333333, 0.066666666666667, 0.45833333333333
96206, 2.1583333333333, 0.033333333333333, 0.45833333333333
96207, 1.2416666666667, 0.083333333333333, 0.041666666666667
96208, 1.2416666666667, 0.066666666666667, 0.020833333333333
96209, 1.2208333333333, 0.066666666666667, 0.041666666666667
96210, 1.2416666666667, 0.05, 0.041666666666667
96211, 1.2416666666667, 0.033333333333333, 0.020833333333333
96212, 1.2208333333333, 0.033333333333333, 0.041666666666667
96213, 1.2416666666667, 0.016666666666667, 0.041666666666667
96214, 1.2833333333333, 0.083333333333333, 0.041666666666667
96215, 1.2833333333333, 0.066666666666667, 0.020833333333333
96216, 1.2625, 0.066666666666667, 0.041666666666667
96217, 1.2833333333333, 0.05, 0.041666666666667
96218, 1.2833333333333, 0.033333333333333, 0.020833333333333
96219, 1.2625, 0.033333333333333, 0.041666666666667
96220, 1.2833333333333, 0.016666666666667, 0.041666666666667
96221, 1.325, 0.083333333333333, 0.041666666666667
96222, 1.325, 0.066666666666667, 0.020833333333333
96223, 1.3041666666667, 0.066666666666667, 0.041666666666667
96224, 1.325, 0.05, 0.041666666666667
96225, 1.325, 0.033333333333333, 0.020833333333333
96226, 1.3041666666667, 0.033333333333333, 0.041666666666667
96227, 1.325, 0.016666666666667, 0.041666666666667
96228, 1.3666666666667, 0.083333333333333, 0.041666666666667
96229, 1.3666666666667, 0.066666666666667, 0.020833333333333
96230, 1.3458333333333, 0.066666666666667, 0.041666666666667
96231, 1.3666666666667, 0.05, 0.041666666666667
96232, 1.3666666666667, 0.033333333333333, 0.020833333333333
96233, 1.3458333333333, 0.033333333333333, 0.041666666666667
96234, 1.3666666666667, 0.016666666666667, 0.041666666666667
96235, 1.4083333333333, 0.083333333333333, 0.041666666666667
96236, 1.4083333333333, 0.066666666666667, 0.020833333333333
96237, 1.3875, 0.066666666666667, 0.041666666666667
96238, 1.4083333333333, 0.05, 0.041666666666667
96239, 1.4083333333333, 0.033333333333333, 0.020833333333333
96240, 1.3875, 0.033333333333333, 0.041666666666667
96241, 1.4083333333333, 0.016666666666667, 0.041666666666667
96242, 1.45, 0.083333333333333, 0.041666666666667
96243, 1.45, 0.066666666666667, 0.020833333333333
96244, 1.4291666666667, 0.066666666666667, 0.041666666666667
96245, 1.45, 0.05, 0.041666666666667
96246, 1.45, 0.033333333333333, 0.020833333333333
96247, 1.4291666666667, 0.033333333333333, 0.041666666666667
96248, 1.45, 0.016666666666667, 0.041666666666667
96249, 1.4916666666667, 0.083333333333333, 0.041666666666667
96250, 1.4916666666667, 0.066666666666667, 0.020833333333333
96251, 1.4708333333333, 0.066666666666667, 0.041666666666667
96252, 1.4916666666667, 0.05, 0.041666666666667
96253, 1.4916666666667, 0.033333333333333, 0.020833333333333
96254, 1.4708333333333, 0.033333333333333, 0.041666666666667
96255, 1.4916666666667, 0.016666666666667, 0.041666666666667
96256, 1.5333333333333, 0.083333333333333, 0.041666666666667
96257, 1.5333333333333, 0.066666666666667, 0.020833333333333
96258, 1.5125, 0.066666666666667, 0.041666666666667
96259, 1.5333333333333, 0.05, 0.041666666666667
96260, 1.5333333333333, 0.033333333333333, 0.020833333333333
96261, 1.5125, 0.033333333333333, 0.041666666666667
96262, 1.5333333333333, 0.016666666666667, 0.041666666666667
96263, 1.575, 0.083333333333333, 0.041666666666667
96264, 1.575, 0.066666666666667, 0.020833333333333
96265, 1.5541666666667, 0.066666666666667, 0.041666666666667
96266, 1.575, 0.05, 0.041666666666667
96267, 1.575, 0.033333333333333, 0.020833333333333
96268, 1.5541666666667, 0.033333333333333, 0.041666666666667
96269, 1.575, 0.016666666666667, 0.041666666666667
96270, 1.6166666666667, 0.083333333333333, 0.041666666666667
96271, 1.6166666666667, 0.066666666666667, 0.020833333333333
96272, 1.5958333333333, 0.066666666666667, 0.041666666666667
96273, 1.6166666666667, 0.05, 0.041666666666667
96274, 1.6166666666667, 0.033333333333333, 0.020833333333333
96275, 1.5958333333333, 0.033333333333333, 0.041666666666667
96276, 1.6166666666667, 0.016666666666667, 0.041666666666667
96277, 1.6583333333333, 0.083333333333333, 0.041666666666667
96278, 1.6583333333333, 0.066666666666667, 0.020833333333333
96279, 1.6375, 0.066666666666667, 0.041666666666667
96280, 1.6583333333333, 0.05, 0.041666666666667
96281, 1.6583333333333, 0.033333333333333, 0.020833333333333
96282, 1.6375, 0.033333333333333, 0.041666666666667
96283, 1.6583333333333, 0.016666666666667, 0.041666666666667
96284, 1.7, 0.083333333333333, 0.041666666666667
96285, 1.7, 0.066666666666667, 0.020833333333333
96286, 1.6791666666667, 0.066666666666667, 0.041666666666667
96287, 1.7, 0.05, 0.041666666666667
96288, 1.7, 0.033333333333333, 0.020833333333333
96289, 1.6791666666667, 0.033333333333333, 0.041666666666667
96290, 1.7, 0.016666666666667, 0.041666666666667
96291, 1.7416666666667, 0.083333333333333, 0.041666666666667
96292, 1.7416666666667, 0.066666666666667, 0.020833333333333
96293, 1.7208333333333, 0.066666666666667, 0.041666666666667
96294, 1.7416666666667, 0.05, 0.041666666666667
96295, 1.7416666666667, 0.033333333333333, 0.020833333333333
96296, 1.7208333333333, 0.033333333333333, 0.041666666666667
96297, 1.7416666666667, 0.016666666666667, 0.041666666666667
96298, 1.7833333333333, 0.083333333333333, 0.041666666666667
96299, 1.7833333333333, 0.066666666666667, 0.020833333333333
96300, 1.7625, 0.066666666666667, 0.041666666666667
96301, 1.7833333333333, 0.05, 0.041666666666667
96302, 1.7833333333333, 0.033333333333333, 0.020833333333333
96303, 1.7625, 0.033333333333333, 0.041666666666667
96304, 1.7833333333333, 0.016666666666667, 0.041666666666667
96305, 1.825, 0.083333333333333, 0.041666666666667
96306, 1.825, 0.066666666666667, 0.020833333333333
96307, 1.8041666666667, 0.066666666666667, 0.041666666666667
96308, 1.825, 0.05, 0.041666666666667
96309, 1.825, 0.033333333333333, 0.020833333333333
96310, 1.8041666666667, 0.033333333333333, 0.041666666666667
96311, 1.825, 0.016666666666667, 0.041666666666667
96312, 1.8666666666667, 0.083333333333333, 0.041666666666667
96313, 1.8666666666667, 0.066666666666667, 0.020833333333333
96314, 1.8458333333333, 0.066666666666667, 0.041666666666667
96315, 1.8666666666667, 0.05, 0.041666666666667
96316, 1.8666666666667, 0.033333333333333, 0.020833333333333
96317, 1.8458333333333, 0.033333333333333, 0.041666666666667
96318, 1.8666666666667, 0.016666666666667, 0.041666666666667
96319, 1.9083333333333, 0.083333333333333, 0.041666666666667
96320, 1.9083333333333, 0.066666666666667, 0.020833333333333
96321, 1.8875, 0.066666666666667, 0.041666666666667
96322, 1.9083333333333, 0.05, 0.041666666666667
96323, 1.9083333333333, 0.033333333333333, 0.020833333333333
96324, 1.8875, 0.033333333333333, 0.041666666666667
96325, 1.9083333333333, 0.016666666666667, 0.041666666666667
96326, 1.95, 0.083333333333333, 0.041666666666667
96327, 1.95, 0.066666666666667, 0.020833333333333
96328, 1.9291666666667, 0.066666666666667, 0.041666666666667
96329, 1.95, 0.05, 0.041666666666667
96330, 1.95, 0.033333333333333, 0.020833333333333
96331, 1.9291666666667, 0.033333333333333, 0.041666666666667
96332, 1.95, 0.016666666666667, 0.041666666666667
96333, 1.9916666666667, 0.083333333333333, 0.041666666666667
96334, 1.9916666666667, 0.066666666666667, 0.020833333333333
96335, 1.9708333333333, 0.066666666666667, 0.041666666666667
96336, 1.9916666666667, 0.05, 0.041666666666667
96337, 1.9916666666667, 0.033333333333333, 0.020833333333333
96338, 1.9708333333333, 0.033333333333333, 0.041666666666667
96339, 1.9916666666667, 0.016666666666667, 0.041666666666667
96340, 2.0333333333333, 0.083333333333333, 0.041666666666667
96341, 2.0333333333333, 0.066666666666667, 0.020833333333333
96342, 2.0125, 0.066666666666667, 0.041666666666667
96343, 2.0333333333333, 0.05, 0.041666666666667
96344, 2.0333333333333, 0.033333333333333, 0.020833333333333
96345, 2.0125, 0.033333333333333, 0.041666666666667
96346, 2.0333333333333, 0.016666666666667, 0.041666666666667
96347, 2.075, 0.083333333333333, 0.041666666666667
96348, 2.075, 0.066666666666667, 0.020833333333333
96349, 2.0541666666667, 0.066666666666667, 0.041666666666667
96350, 2.075, 0.05, 0.041666666666667
96351, 2.075, 0.033333333333333, 0.020833333333333
96352, 2.0541666666667, 0.033333333333333, 0.041666666666667
96353, 2.075, 0.016666666666667, 0.041666666666667
96354, 2.1166666666667, 0.083333333333333, 0.041666666666667
96355, 2.1166666666667, 0.066666666666667, 0.020833333333333
96356, 2.0958333333333, 0.066666666666667, 0.041666666666667
96357, 2.1166666666667, 0.05, 0.041666666666667
96358, 2.1166666666667, 0.033333333333333, 0.020833333333333
96359, 2.0958333333333, 0.033333333333333, 0.041666666666667
96360, 2.1166666666667, 0.016666666666667, 0.041666666666667
96361, 2.1583333333333, 0.083333333333333, 0.041666666666667
96362, 2.1583333333333, 0.066666666666667, 0.020833333333333
96363, 2.1375, 0.066666666666667, 0.041666666666667
96364, 2.1583333333333, 0.05, 0.041666666666667
96365, 2.1583333333333, 0.033333333333333, 0.020833333333333
96366, 2.1375, 0.033333333333333, 0.041666666666667
96367, 2.1583333333333, 0.016666666666667, 0.041666666666667
96368, 2.1791666666667, 0.066666666666667, 0.041666666666667
96369, 2.1791666666667, 0.033333333333333, 0.041666666666667
96370, 1.2416666666667, 0.083333333333333, 0.083333333333333
96371, 1.2416666666667, 0.066666666666667, 0.0625
96372, 1.2208333333333, 0.066666666666667, 0.083333333333333
96373, 1.2416666666667, 0.05, 0.083333333333333
96374, 1.2416666666667, 0.033333333333333, 0.0625
96375, 1.2208333333333, 0.033333333333333, 0.083333333333333
96376, 1.2416666666667, 0.016666666666667, 0.083333333333333
96377, 1.2833333333333, 0.083333333333333, 0.083333333333333
96378, 1.2833333333333, 0.066666666666667, 0.0625
96379, 1.2625, 0.066666666666667, 0.083333333333333
96380, 1.2833333333333, 0.05, 0.083333333333333
96381, 1.2833333333333, 0.033333333333333, 0.0625
96382, 1.2625, 0.033333333333333, 0.083333333333333
96383, 1.2833333333333, 0.016666666666667, 0.083333333333333
96384, 1.325, 0.083333333333333, 0.083333333333333
96385, 1.325, 0.066666666666667, 0.0625
96386, 1.3041666666667, 0.066666666666667, 0.083333333333333
96387, 1.325, 0.05, 0.083333333333333
96388, 1.325, 0.033333333333333, 0.0625
96389, 1.3041666666667, 0.033333333333333, 0.083333333333333
96390, 1.325, 0.016666666666667, 0.083333333333333
96391, 1.3666666666667, 0.083333333333333, 0.083333333333333
96392, 1.3666666666667, 0.066666666666667, 0.0625
96393, 1.3458333333333, 0.066666666666667, 0.083333333333333
96394, 1.3666666666667, 0.05, 0.083333333333333
96395, 1.3666666666667, 0.033333333333333, 0.0625
96396, 1.3458333333333, 0.033333333333333, 0.083333333333333
96397, 1.3666666666667, 0.016666666666667, 0.083333333333333
96398, 1.4083333333333, 0.083333333333333, 0.083333333333333
96399, 1.4083333333333, 0.066666666666667, 0.0625
96400, 1.3875, 0.066666666666667, 0.083333333333333
96401, 1.4083333333333, 0.05, 0.083333333333333
96402, 1.4083333333333, 0.033333333333333, 0.0625
96403, 1.3875, 0.033333333333333, 0.083333333333333
96404, 1.4083333333333, 0.016666666666667, 0.083333333333333
96405, 1.45, 0.083333333333333, 0.083333333333333
96406, 1.45, 0.066666666666667, 0.0625
96407, 1.4291666666667, 0.066666666666667, 0.083333333333333
96408, 1.45, 0.05, 0.083333333333333
96409, 1.45, 0.033333333333333, 0.0625
96410, 1.4291666666667, 0.033333333333333, 0.083333333333333
96411, 1.45, 0.016666666666667, 0.083333333333333
96412, 1.4916666666667, 0.083333333333333, 0.083333333333333
96413, 1.4916666666667, 0.066666666666667, 0.0625
96414, 1.4708333333333, 0.066666666666667, 0.083333333333333
96415, 1.4916666666667, 0.05, 0.083333333333333
96416, 1.4916666666667, 0.033333333333333, 0.0625
96417, 1.4708333333333, 0.033333333333333, 0.083333333333333
96418, 1.4916666666667, 0.016666666666667, 0.083333333333333
96419, 1.5333333333333, 0.083333333333333, 0.083333333333333
96420, 1.5333333333333, 0.066666666666667, 0.0625
96421, 1.5125, 0.066666666666667, 0.083333333333333
96422, 1.5333333333333, 0.05, 0.083333333333333
96423, 1.5333333333333, 0.033333333333333, 0.0625
96424, 1.5125, 0.033333333333333, 0.083333333333333
96425, 1.5333333333333, 0.016666666666667, 0.083333333333333
96426, 1.575, 0.083333333333333, 0.083333333333333
96427, 1.575, 0.066666666666667, 0.0625
96428, 1.5541666666667, 0.066666666666667, 0.083333333333333
96429, 1.575, 0.05, 0.083333333333333
96430, 1.575, 0.033333333333333, 0.0625
96431, 1.5541666666667, 0.033333333333333, 0.083333333333333
96432, 1.575, 0.016666666666667, 0.083333333333333
96433, 1.6166666666667, 0.083333333333333, 0.083333333333333
96434, 1.6166666666667, 0.066666666666667, 0.0625
96435, 1.5958333333333, 0.066666666666667, 0.083333333333333
96436, 1.6166666666667, 0.05, 0.083333333333333
96437, 1.6166666666667, 0.033333333333333, 0.0625
96438, 1.5958333333333, 0.033333333333333, 0.083333333333333
96439, 1.6166666666667, 0.016666666666667, 0.083333333333333
96440, 1.6583333333333, 0.083333333333333, 0.083333333333333
96441, 1.6583333333333, 0.066666666666667, 0.0625
96442, 1.6375, 0.066666666666667, 0.083333333333333
96443, 1.6583333333333, 0.05, 0.083333333333333
96444, 1.6583333333333, 0.033333333333333, 0.0625
96445, 1.6375, 0.033333333333333, 0.083333333333333
96446, 1.6583333333333, 0.016666666666667, 0.083333333333333
96447, 1.7, 0.083333333333333, 0.083333333333333
96448, 1.7, 0.066666666666667, 0.0625
96449, 1.6791666666667, 0.066666666666667, 0.083333333333333
96450, 1.7, 0.05, 0.083333333333333
96451, 1.7, 0.033333333333333, 0.0625
96452, 1.6791666666667, 0.033333333333333, 0.083333333333333
96453, 1.7, 0.016666666666667, 0.083333333333333
96454, 1.7416666666667, 0.083333333333333, 0.083333333333333
96455, 1.7416666666667, 0.066666666666667, 0.0625
96456, 1.7208333333333, 0.066666666666667, 0.083333333333333
96457, 1.7416666666667, 0.05, 0.083333333333333
96458, 1.7416666666667, 0.033333333333333, 0.0625
96459, 1.7208333333333, 0.033333333333333, 0.083333333333333
96460, 1.7416666666667, 0.016666666666667, 0.083333333333333
96461, 1.7833333333333, 0.083333333333333, 0.083333333333333
96462, 1.7833333333333, 0.066666666666667, 0.0625
96463, 1.7625, 0.066666666666667, 0.083333333333333
96464, 1.7833333333333, 0.05, 0.083333333333333
96465, 1.7833333333333, 0.033333333333333, 0.0625
96466, 1.7625, 0.033333333333333, 0.083333333333333
96467, 1.7833333333333, 0.016666666666667, 0.083333333333333
96468, 1.825, 0.083333333333333, 0.083333333333333
96469, 1.825, 0.066666666666667, 0.0625
96470, 1.8041666666667, 0.066666666666667, 0.083333333333333
96471, 1.825, 0.05, 0.083333333333333
96472, 1.825, 0.033333333333333, 0.0625
96473, 1.8041666666667, 0.033333333333333, 0.083333333333333
96474, 1.825, 0.016666666666667, 0.083333333333333
96475, 1.8666666666667, 0.083333333333333, 0.083333333333333
96476, 1.8666666666667, 0.066666666666667, 0.0625
96477, 1.8458333333333, 0.066666666666667, 0.083333333333333
96478, 1.8666666666667, 0.05, 0.083333333333333
96479, 1.8666666666667, 0.033333333333333, 0.0625
96480, 1.8458333333333, 0.033333333333333, 0.083333333333333
96481, 1.8666666666667, 0.016666666666667, 0.083333333333333
96482, 1.9083333333333, 0.083333333333333, 0.083333333333333
96483, 1.9083333333333, 0.066666666666667, 0.0625
96484, 1.8875, 0.066666666666667, 0.083333333333333
96485, 1.9083333333333, 0.05, 0.083333333333333
96486, 1.9083333333333, 0.033333333333333, 0.0625
96487, 1.8875, 0.033333333333333, 0.083333333333333
96488, 1.9083333333333, 0.016666666666667, 0.083333333333333
96489, 1.95, 0.083333333333333, 0.083333333333333
96490, 1.95, 0.066666666666667, 0.0625
96491, 1.9291666666667, 0.066666666666667, 0.083333333333333
96492, 1.95, 0.05, 0.083333333333333
96493, 1.95, 0.033333333333333, 0.0625
96494, 1.9291666666667, 0.033333333333333, 0.083333333333333
96495, 1.95, 0.016666666666667, 0.083333333333333
96496, 1.9916666666667, 0.083333333333333, 0.083333333333333
96497, 1.9916666666667, 0.066666666666667, 0.0625
96498, 1.9708333333333, 0.066666666666667, 0.083333333333333
96499, 1.9916666666667, 0.05, 0.083333333333333
96500, 1.9916666666667, 0.033333333333333, 0.0625
96501, 1.9708333333333, 0.033333333333333, 0.083333333333333
96502, 1.9916666666667, 0.016666666666667, 0.083333333333333
96503, 2.0333333333333, 0.083333333333333, 0.083333333333333
96504, 2.0333333333333, 0.066666666666667, 0.0625
96505, 2.0125, 0.066666666666667, 0.083333333333333
96506, 2.0333333333333, 0.05, 0.083333333333333
96507, 2.0333333333333, 0.033333333333333, 0.0625
96508, 2.0125, 0.033333333333333, 0.083333333333333
96509, 2.0333333333333, 0.016666666666667, 0.083333333333333
96510, 2.075, 0.083333333333333, 0.083333333333333
96511, 2.075, 0.066666666666667, 0.0625
96512, 2.0541666666667, 0.066666666666667, 0.083333333333333
96513, 2.075, 0.05, 0.083333333333333
96514, 2.075, 0.033333333333333, 0.0625
96515, 2.0541666666667, 0.033333333333333, 0.083333333333333
96516, 2.075, 0.016666666666667, 0.083333333333333
96517, 2.1166666666667, 0.083333333333333, 0.083333333333333
96518, 2.1166666666667, 0.066666666666667, 0.0625
96519, 2.0958333333333, 0.066666666666667, 0.083333333333333
96520, 2.1166666666667, 0.05, 0.083333333333333
96521, 2.1166666666667, 0.033333333333333, 0.0625
96522, 2.0958333333333, 0.033333333333333, 0.083333333333333
96523, 2.1166666666667, 0.016666666666667, 0.083333333333333
96524, 2.1583333333333, 0.083333333333333, 0.083333333333333
96525, 2.1583333333333, 0.066666666666667, 0.0625
96526, 2.1375, 0.066666666666667, 0.083333333333333
96527, 2.1583333333333, 0.05, 0.083333333333333
96528, 2.1583333333333, 0.033333333333333, 0.0625
96529, 2.1375, 0.033333333333333, 0.083333333333333
96530, 2.1583333333333, 0.016666666666667, 0.083333333333333
96531, 2.1791666666667, 0.066666666666667, 0.083333333333333
96532, 2.1791666666667, 0.033333333333333, 0.083333333333333
96533, 1.2416666666667, 0.083333333333333, 0.125
96534, 1.2416666666667, 0.066666666666667, 0.10416666666667
96535, 1.2208333333333, 0.066666666666667, 0.125
96536, 1.2416666666667, 0.05, 0.125
96537, 1.2416666666667, 0.033333333333333, 0.10416666666667
96538, 1.2208333333333, 0.033333333333333, 0.125
96539, 1.2416666666667, 0.016666666666667, 0.125
96540, 1.2833333333333, 0.083333333333333, 0.125
96541, 1.2833333333333, 0.066666666666667, 0.10416666666667
96542, 1.2625, 0.066666666666667, 0.125
96543, 1.2833333333333, 0.05, 0.125
96544, 1.2833333333333, 0.033333333333333, 0.10416666666667
96545, 1.2625, 0.033333333333333, 0.125
96546, 1.2833333333333, 0.016666666666667, 0.125
96547, 1.325, 0.083333333333333, 0.125
96548, 1.325, 0.066666666666667, 0.10416666666667
96549, 1.3041666666667, 0.066666666666667, 0.125
96550, 1.325, 0.05, 0.125
96551, 1.325, 0.033333333333333, 0.10416666666667
96552, 1.3041666666667, 0.033333333333333, 0.125
96553, 1.325, 0.016666666666667, 0.125
96554, 1.3666666666667, 0.083333333333333, 0.125
96555, 1.3666666666667, 0.066666666666667, 0.10416666666667
96556, 1.3458333333333, 0.066666666666667, 0.125
96557, 1.3666666666667, 0.05, 0.125
96558, 1.3666666666667, 0.033333333333333, 0.10416666666667
96559, 1.3458333333333, 0.033333333333333, 0.125
96560, 1.3666666666667, 0.016666666666667, 0.125
96561, 1.4083333333333, 0.083333333333333, 0.125
96562, 1.4083333333333, 0.066666666666667, 0.10416666666667
96563, 1.3875, 0.066666666666667, 0.125
96564, 1.4083333333333, 0.05, 0.125
96565, 1.4083333333333, 0.033333333333333, 0.10416666666667
96566, 1.3875, 0.033333333333333, 0.125
96567, 1.4083333333333, 0.016666666666667, 0.125
96568, 1.45, 0.083333333333333, 0.125
96569, 1.45, 0.066666666666667, 0.10416666666667
96570, 1.4291666666667, 0.066666666666667, 0.125
96571, 1.45, 0.05, 0.125
96572, 1.45, 0.033333333333333, 0.10416666666667
96573, 1.4291666666667, 0.033333333333333, 0.125
96574, 1.45, 0.016666666666667, 0.125
96575, 1.4916666666667, 0.083333333333333, 0.125
96576, 1.4916666666667, 0.066666666666667, 0.10416666666667
96577, 1.4708333333333, 0.066666666666667, 0.125
96578, 1.4916666666667, 0.05, 0.125
96579, 1.4916666666667, 0.033333333333333, 0.10416666666667
96580, 1.4708333333333, 0.033333333333333, 0.125
96581, 1.4916666666667, 0.016666666666667, 0.125
96582, 1.5333333333333, 0.083333333333333, 0.125
96583, 1.5333333333333, 0.066666666666667, 0.10416666666667
96584, 1.5125, 0.066666666666667, 0.125
96585, 1.5333333333333, 0.05, 0.125
96586, 1.5333333333333, 0.033333333333333, 0.10416666666667
96587, 1.5125, 0.033333333333333, 0.125
96588, 1.5333333333333, 0.016666666666667, 0.125
96589, 1.575, 0.083333333333333, 0.125
96590, 1.575, 0.066666666666667, 0.10416666666667
96591, 1.5541666666667, 0.066666666666667, 0.125
96592, 1.575, 0.05, 0.125
96593, 1.575, 0.033333333333333, 0.10416666666667
96594, 1.5541666666667, 0.033333333333333, 0.125
96595, 1.575, 0.016666666666667, 0.125
96596, 1.6166666666667, 0.083333333333333, 0.125
96597, 1.6166666666667, 0.066666666666667, 0.10416666666667
96598, 1.5958333333333, 0.066666666666667, 0.125
96599, 1.6166666666667, 0.05, 0.125
96600, 1.6166666666667, 0.033333333333333, 0.10416666666667
96601, 1.5958333333333, 0.033333333333333, 0.125
96602, 1.6166666666667, 0.016666666666667, 0.125
96603, 1.6583333333333, 0.083333333333333, 0.125
96604, 1.6583333333333, 0.066666666666667, 0.10416666666667
96605, 1.6375, 0.066666666666667, 0.125
96606, 1.6583333333333, 0.05, 0.125
96607, 1.6583333333333, 0.033333333333333, 0.10416666666667
96608, 1.6375, 0.033333333333333, 0.125
96609, 1.6583333333333, 0.016666666666667, 0.125
96610, 1.7, 0.083333333333333, 0.125
96611, 1.7, 0.066666666666667, 0.10416666666667
96612, 1.6791666666667, 0.066666666666667, 0.125
96613, 1.7, 0.05, 0.125
96614, 1.7, 0.033333333333333, 0.10416666666667
96615, 1.6791666666667, 0.033333333333333, 0.125
96616, 1.7, 0.016666666666667, 0.125
96617, 1.7416666666667, 0.083333333333333, 0.125
96618, 1.7416666666667, 0.066666666666667, 0.10416666666667
96619, 1.7208333333333, 0.066666666666667, 0.125
96620, 1.7416666666667, 0.05, 0.125
96621, 1.7416666666667, 0.033333333333333, 0.10416666666667
96622, 1.7208333333333, 0.033333333333333, 0.125
96623, 1.7416666666667, 0.016666666666667, 0.125
96624, 1.7833333333333, 0.083333333333333, 0.125
96625, 1.7833333333333, 0.066666666666667, 0.10416666666667
96626, 1.7625, 0.066666666666667, 0.125
96627, 1.7833333333333, 0.05, 0.125
96628, 1.7833333333333, 0.033333333333333, 0.10416666666667
96629, 1.7625, 0.033333333333333, 0.125
96630, 1.7833333333333, 0.016666666666667, 0.125
96631, 1.825, 0.083333333333333, 0.125
96632, 1.825, 0.066666666666667, 0.10416666666667
96633, 1.8041666666667, 0.066666666666667, 0.125
96634, 1.825, 0.05, 0.125
96635, 1.825, 0.033333333333333, 0.10416666666667
96636, 1.8041666666667, 0.033333333333333, 0.125
96637, 1.825, 0.016666666666667, 0.125
96638, 1.8666666666667, 0.083333333333333, 0.125
96639, 1.8666666666667, 0.066666666666667, 0.10416666666667
96640, 1.8458333333333, 0.066666666666667, 0.125
96641, 1.8666666666667, 0.05, 0.125
96642, 1.8666666666667, 0.033333333333333, 0.10416666666667
96643, 1.8458333333333, 0.033333333333333, 0.125
96644, 1.8666666666667, 0.016666666666667, 0.125
96645, 1.9083333333333, 0.083333333333333, 0.125
96646, 1.9083333333333, 0.066666666666667, 0.10416666666667
96647, 1.8875, 0.066666666666667, 0.125
96648, 1.9083333333333, 0.05, 0.125
96649, 1.9083333333333, 0.033333333333333, 0.10416666666667
96650, 1.8875, 0.033333333333333, 0.125
96651, 1.9083333333333, 0.016666666666667, 0.125
96652, 1.95, 0.083333333333333, 0.125
96653, 1.95, 0.066666666666667, 0.10416666666667
96654, 1.9291666666667, 0.066666666666667, 0.125
96655, 1.95, 0.05, 0.125
96656, 1.95, 0.033333333333333, 0.10416666666667
96657, 1.9291666666667, 0.033333333333333, 0.125
96658, 1.95, 0.016666666666667, 0.125
96659, 1.9916666666667, 0.083333333333333, 0.125
96660, 1.9916666666667, 0.066666666666667, 0.10416666666667
96661, 1.9708333333333, 0.066666666666667, 0.125
96662, 1.9916666666667, 0.05, 0.125
96663, 1.9916666666667, 0.033333333333333, 0.10416666666667
96664, 1.9708333333333, 0.033333333333333, 0.125
96665, 1.9916666666667, 0.016666666666667, 0.125
96666, 2.0333333333333, 0.083333333333333, 0.125
96667, 2.0333333333333, 0.066666666666667, 0.10416666666667
96668, 2.0125, 0.066666666666667, 0.125
96669, 2.0333333333333, 0.05, 0.125
96670, 2.0333333333333, 0.033333333333333, 0.10416666666667
96671, 2.0125, 0.033333333333333, 0.125
96672, 2.0333333333333, 0.016666666666667, 0.125
96673, 2.075, 0.083333333333333, 0.125
96674, 2.075, 0.066666666666667, 0.10416666666667
96675, 2.0541666666667, 0.066666666666667, 0.125
96676, 2.075, 0.05, 0.125
96677, 2.075, 0.033333333333333, 0.10416666666667
96678, 2.0541666666667, 0.033333333333333, 0.125
96679, 2.075, 0.016666666666667, 0.125
96680, 2.1166666666667, 0.083333333333333, 0.125
96681, 2.1166666666667, 0.066666666666667, 0.10416666666667
96682, 2.0958333333333, 0.066666666666667, 0.125
96683, 2.1166666666667, 0.05, 0.125
96684, 2.1166666666667, 0.033333333333333, 0.10416666666667
96685, 2.0958333333333, 0.033333333333333, 0.125
96686, 2.1166666666667, 0.016666666666667, 0.125
96687, 2.1583333333333, 0.083333333333333, 0.125
96688, 2.1583333333333, 0.066666666666667, 0.10416666666667
96689, 2.1375, 0.066666666666667, 0.125
96690, 2.1583333333333, 0.05, 0.125
96691, 2.1583333333333, 0.033333333333333, 0.10416666666667
96692, 2.1375, 0.033333333333333, 0.125
96693, 2.1583333333333, 0.016666666666667, 0.125
96694, 2.1791666666667, 0.066666666666667, 0.125
96695, 2.1791666666667, 0.033333333333333, 0.125
96696, 1.2416666666667, 0.083333333333333, 0.16666666666667
96697, 1.2416666666667, 0.066666666666667, 0.14583333333333
96698, 1.2208333333333, 0.066666666666667, 0.16666666666667
96699, 1.2416666666667, 0.05, 0.16666666666667
96700, 1.2416666666667, 0.033333333333333, 0.14583333333333
96701, 1.2208333333333, 0.033333333333333, 0.16666666666667
96702, 1.2416666666667, 0.016666666666667, 0.16666666666667
96703, 1.2833333333333, 0.083333333333333, 0.16666666666667
96704, 1.2833333333333, 0.066666666666667, 0.14583333333333
96705, 1.2625, 0.066666666666667, 0.16666666666667
96706, 1.2833333333333, 0.05, 0.16666666666667
96707, 1.2833333333333, 0.033333333333333, 0.14583333333333
96708, 1.2625, 0.033333333333333, 0.16666666666667
96709, 1.2833333333333, 0.016666666666667, 0.16666666666667
96710, 1.325, 0.083333333333333, 0.16666666666667
96711, 1.325, 0.066666666666667, 0.14583333333333
96712, 1.3041666666667, 0.066666666666667, 0.16666666666667
96713, 1.325, 0.05, 0.16666666666667
96714, 1.325, 0.033333333333333, 0.14583333333333
96715, 1.3041666666667, 0.033333333333333, 0.16666666666667
96716, 1.325, 0.016666666666667, 0.16666666666667
96717, 1.3666666666667, 0.083333333333333, 0.16666666666667
96718, 1.3666666666667, 0.066666666666667, 0.14583333333333
96719, 1.3458333333333, 0.066666666666667, 0.16666666666667
96720, 1.3666666666667, 0.05, 0.16666666666667
96721, 1.3666666666667, 0.033333333333333, 0.14583333333333
96722, 1.3458333333333, 0.033333333333333, 0.16666666666667
96723, 1.3666666666667, 0.016666666666667, 0.16666666666667
96724, 1.4083333333333, 0.083333333333333, 0.16666666666667
96725, 1.4083333333333, 0.066666666666667, 0.14583333333333
96726, 1.3875, 0.066666666666667, 0.16666666666667
96727, 1.4083333333333, 0.05, 0.16666666666667
96728, 1.4083333333333, 0.033333333333333, 0.14583333333333
96729, 1.3875, 0.033333333333333, 0.16666666666667
96730, 1.4083333333333, 0.016666666666667, 0.16666666666667
96731, 1.45, 0.083333333333333, 0.16666666666667
96732, 1.45, 0.066666666666667, 0.14583333333333
96733, 1.4291666666667, 0.066666666666667, 0.16666666666667
96734, 1.45, 0.05, 0.16666666666667
96735, 1.45, 0.033333333333333, 0.14583333333333
96736, 1.4291666666667, 0.033333333333333, 0.16666666666667
96737, 1.45, 0.016666666666667, 0.16666666666667
96738, 1.4916666666667, 0.083333333333333, 0.16666666666667
96739, 1.4916666666667, 0.066666666666667, 0.14583333333333
96740, 1.4708333333333, 0.066666666666667, 0.16666666666667
96741, 1.4916666666667, 0.05, 0.16666666666667
96742, 1.4916666666667, 0.033333333333333, 0.14583333333333
96743, 1.4708333333333, 0.033333333333333, 0.16666666666667
96744, 1.4916666666667, 0.016666666666667, 0.16666666666667
96745, 1.5333333333333, 0.083333333333333, 0.16666666666667
96746, 1.5333333333333, 0.066666666666667, 0.14583333333333
96747, 1.5125, 0.066666666666667, 0.16666666666667
96748, 1.5333333333333, 0.05, 0.16666666666667
96749, 1.5333333333333, 0.033333333333333, 0.14583333333333
96750, 1.5125, 0.033333333333333, 0.16666666666667
96751, 1.5333333333333, 0.016666666666667, 0.16666666666667
96752, 1.575, 0.083333333333333, 0.16666666666667
96753, 1.575, 0.066666666666667, 0.14583333333333
96754, 1.5541666666667, 0.066666666666667, 0.16666666666667
96755, 1.575, 0.05, 0.16666666666667
96756, 1.575, 0.033333333333333, 0.14583333333333
96757, 1.5541666666667, 0.033333333333333, 0.16666666666667
96758, 1.575, 0.016666666666667, 0.16666666666667
96759, 1.6166666666667, 0.083333333333333, 0.16666666666667
96760, 1.6166666666667, 0.066666666666667, 0.14583333333333
96761, 1.5958333333333, 0.066666666666667, 0.16666666666667
96762, 1.6166666666667, 0.05, 0.16666666666667
96763, 1.6166666666667, 0.033333333333333, 0.14583333333333
96764, 1.5958333333333, 0.033333333333333, 0.16666666666667
96765, 1.6166666666667, 0.016666666666667, 0.16666666666667
96766, 1.6583333333333, 0.083333333333333, 0.16666666666667
96767, 1.6583333333333, 0.066666666666667, 0.14583333333333
96768, 1.6375, 0.066666666666667, 0.16666666666667
96769, 1.6583333333333, 0.05, 0.16666666666667
96770, 1.6583333333333, 0.033333333333333, 0.14583333333333
96771, 1.6375, 0.033333333333333, 0.16666666666667
96772, 1.6583333333333, 0.016666666666667, 0.16666666666667
96773, 1.7, 0.083333333333333, 0.16666666666667
96774, 1.7, 0.066666666666667, 0.14583333333333
96775, 1.6791666666667, 0.066666666666667, 0.16666666666667
96776, 1.7, 0.05, 0.16666666666667
96777, 1.7, 0.033333333333333, 0.14583333333333
96778, 1.6791666666667, 0.033333333333333, 0.16666666666667
96779, 1.7, 0.016666666666667, 0.16666666666667
96780, 1.7416666666667, 0.083333333333333, 0.16666666666667
96781, 1.7416666666667, 0.066666666666667, 0.14583333333333
96782, 1.7208333333333, 0.066666666666667, 0.16666666666667
96783, 1.7416666666667, 0.05, 0.16666666666667
96784, 1.7416666666667, 0.033333333333333, 0.14583333333333
96785, 1.7208333333333, 0.033333333333333, 0.16666666666667
96786, 1.7416666666667, 0.016666666666667, 0.16666666666667
96787, 1.7833333333333, 0.083333333333333, 0.16666666666667
96788, 1.7833333333333, 0.066666666666667, 0.14583333333333
96789, 1.7625, 0.066666666666667, 0.16666666666667
96790, 1.7833333333333, 0.05, 0.16666666666667
96791, 1.7833333333333, 0.033333333333333, 0.14583333333333
96792, 1.7625, 0.033333333333333, 0.16666666666667
96793, 1.7833333333333, 0.016666666666667, 0.16666666666667
96794, 1.825, 0.083333333333333, 0.16666666666667
96795, 1.825, 0.066666666666667, 0.14583333333333
96796, 1.8041666666667, 0.066666666666667, 0.16666666666667
96797, 1.825, 0.05, 0.16666666666667
96798, 1.825, 0.033333333333333, 0.14583333333333
96799, 1.8041666666667, 0.033333333333333, 0.16666666666667
96800, 1.825, 0.016666666666667, 0.16666666666667
96801, 1.8666666666667, 0.083333333333333, 0.16666666666667
96802, 1.8666666666667, 0.066666666666667, 0.14583333333333
96803, 1.8458333333333, 0.066666666666667, 0.16666666666667
96804, 1.8666666666667, 0.05, 0.16666666666667
96805, 1.8666666666667, 0.033333333333333, 0.14583333333333
96806, 1.8458333333333, 0.033333333333333, 0.16666666666667
96807, 1.8666666666667, 0.016666666666667, 0.16666666666667
96808, 1.9083333333333, 0.083333333333333, 0.16666666666667
96809, 1.9083333333333, 0.066666666666667, 0.14583333333333
96810, 1.8875, 0.066666666666667, 0.16666666666667
96811, 1.9083333333333, 0.05, 0.16666666666667
96812, 1.9083333333333, 0.033333333333333, 0.14583333333333
96813, 1.8875, 0.033333333333333, 0.16666666666667
96814, 1.9083333333333, 0.016666666666667, 0.16666666666667
96815, 1.95, 0.083333333333333, 0.16666666666667
96816, 1.95, 0.066666666666667, 0.14583333333333
96817, 1.9291666666667, 0.066666666666667, 0.16666666666667
96818, 1.95, 0.05, 0.16666666666667
96819, 1.95, 0.033333333333333, 0.14583333333333
96820, 1.9291666666667, 0.033333333333333, 0.16666666666667
96821, 1.95, 0.016666666666667, 0.16666666666667
96822, 1.9916666666667, 0.083333333333333, 0.16666666666667
96823, 1.9916666666667, 0.066666666666667, 0.14583333333333
96824, 1.9708333333333, 0.066666666666667, 0.16666666666667
96825, 1.9916666666667, 0.05, 0.16666666666667
96826, 1.9916666666667, 0.033333333333333, 0.14583333333333
96827, 1.9708333333333, 0.033333333333333, 0.16666666666667
96828, 1.9916666666667, 0.016666666666667, 0.16666666666667
96829, 2.0333333333333, 0.083333333333333, 0.16666666666667
96830, 2.0333333333333, 0.066666666666667, 0.14583333333333
96831, 2.0125, 0.066666666666667, 0.16666666666667
96832, 2.0333333333333, 0.05, 0.16666666666667
96833, 2.0333333333333, 0.033333333333333, 0.14583333333333
96834, 2.0125, 0.033333333333333, 0.16666666666667
96835, 2.0333333333333, 0.016666666666667, 0.16666666666667
96836, 2.075, 0.083333333333333, 0.16666666666667
96837, 2.075, 0.066666666666667, 0.14583333333333
96838, 2.0541666666667, 0.066666666666667, 0.16666666666667
96839, 2.075, 0.05, 0.16666666666667
96840, 2.075, 0.033333333333333, 0.14583333333333
96841, 2.0541666666667, 0.033333333333333, 0.16666666666667
96842, 2.075, 0.016666666666667, 0.16666666666667
96843, 2.1166666666667, 0.083333333333333, 0.16666666666667
96844, 2.1166666666667, 0.066666666666667, 0.14583333333333
96845, 2.0958333333333, 0.066666666666667, 0.16666666666667
96846, 2.1166666666667, 0.05, 0.16666666666667
96847, 2.1166666666667, 0.033333333333333, 0.14583333333333
96848, 2.0958333333333, 0.033333333333333, 0.16666666666667
96849, 2.1166666666667, 0.016666666666667, 0.16666666666667
96850, 2.1583333333333, 0.083333333333333, 0.16666666666667
96851, 2.1583333333333, 0.066666666666667, 0.14583333333333
96852, 2.1375, 0.066666666666667, 0.16666666666667
96853, 2.1583333333333, 0.05, 0.16666666666667
96854, 2.1583333333333, 0.033333333333333, 0.14583333333333
96855, 2.1375, 0.033333333333333, 0.16666666666667
96856, 2.1583333333333, 0.016666666666667, 0.16666666666667
96857, 2.1791666666667, 0.066666666666667, 0.16666666666667
96858, 2.1791666666667, 0.033333333333333, 0.16666666666667
96859, 1.2416666666667, 0.083333333333333, 0.20833333333333
96860, 1.2416666666667, 0.066666666666667, 0.1875
96861, 1.2208333333333, 0.066666666666667, 0.20833333333333
96862, 1.2416666666667, 0.05, 0.20833333333333
96863, 1.2416666666667, 0.033333333333333, 0.1875
96864, 1.2208333333333, 0.033333333333333, 0.20833333333333
96865, 1.2416666666667, 0.016666666666667, 0.20833333333333
96866, 1.2833333333333, 0.083333333333333, 0.20833333333333
96867, 1.2833333333333, 0.066666666666667, 0.1875
96868, 1.2625, 0.066666666666667, 0.20833333333333
96869, 1.2833333333333, 0.05, 0.20833333333333
96870, 1.2833333333333, 0.033333333333333, 0.1875
96871, 1.2625, 0.033333333333333, 0.20833333333333
96872, 1.2833333333333, 0.016666666666667, 0.20833333333333
96873, 1.325, 0.083333333333333, 0.20833333333333
96874, 1.325, 0.066666666666667, 0.1875
96875, 1.3041666666667, 0.066666666666667, 0.20833333333333
96876, 1.325, 0.05, 0.20833333333333
96877, 1.325, 0.033333333333333, 0.1875
96878, 1.3041666666667, 0.033333333333333, 0.20833333333333
96879, 1.325, 0.016666666666667, 0.20833333333333
96880, 1.3666666666667, 0.083333333333333, 0.20833333333333
96881, 1.3666666666667, 0.066666666666667, 0.1875
96882, 1.3458333333333, 0.066666666666667, 0.20833333333333
96883, 1.3666666666667, 0.05, 0.20833333333333
96884, 1.3666666666667, 0.033333333333333, 0.1875
96885, 1.3458333333333, 0.033333333333333, 0.20833333333333
96886, 1.3666666666667, 0.016666666666667, 0.20833333333333
96887, 1.4083333333333, 0.083333333333333, 0.20833333333333
96888, 1.4083333333333, 0.066666666666667, 0.1875
96889, 1.3875, 0.066666666666667, 0.20833333333333
96890, 1.4083333333333, 0.05, 0.20833333333333
