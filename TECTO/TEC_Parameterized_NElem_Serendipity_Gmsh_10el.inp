32495, 0.20833333333333, 1.7, 0.14583333333333
32496, 0.1875, 1.7, 0.20833333333333
32497, 0.20833333333333, 1.7, 0.1875
32498, 0.1875, 1.7, 0.25
32499, 0.20833333333333, 1.7, 0.22916666666667
32500, 0.1875, 1.7, 0.29166666666667
32501, 0.20833333333333, 1.7, 0.27083333333333
32502, 0.1875, 1.7, 0.33333333333333
32503, 0.20833333333333, 1.7, 0.3125
32504, 0.1875, 1.7, 0.375
32505, 0.20833333333333, 1.7, 0.35416666666667
32506, 0.1875, 1.7, 0.41666666666667
32507, 0.20833333333333, 1.7, 0.39583333333333
32508, 0.1875, 1.7, 0.45833333333333
32509, 0.20833333333333, 1.7, 0.4375
32510, 0.20833333333333, 1.7, 0.47916666666667
32511, 0.22916666666667, 1.7, 0.041666666666667
32512, 0.25, 1.7, 0.020833333333333
32513, 0.22916666666667, 1.7, 0.083333333333333
32514, 0.25, 1.7, 0.0625
32515, 0.22916666666667, 1.7, 0.125
32516, 0.25, 1.7, 0.10416666666667
32517, 0.22916666666667, 1.7, 0.16666666666667
32518, 0.25, 1.7, 0.14583333333333
32519, 0.22916666666667, 1.7, 0.20833333333333
32520, 0.25, 1.7, 0.1875
32521, 0.22916666666667, 1.7, 0.25
32522, 0.25, 1.7, 0.22916666666667
32523, 0.22916666666667, 1.7, 0.29166666666667
32524, 0.25, 1.7, 0.27083333333333
32525, 0.22916666666667, 1.7, 0.33333333333333
32526, 0.25, 1.7, 0.3125
32527, 0.22916666666667, 1.7, 0.375
32528, 0.25, 1.7, 0.35416666666667
32529, 0.22916666666667, 1.7, 0.41666666666667
32530, 0.25, 1.7, 0.39583333333333
32531, 0.22916666666667, 1.7, 0.45833333333333
32532, 0.25, 1.7, 0.4375
32533, 0.25, 1.7, 0.47916666666667
32534, 0.27083333333333, 1.7, 0.041666666666667
32535, 0.29166666666667, 1.7, 0.020833333333333
32536, 0.27083333333333, 1.7, 0.083333333333333
32537, 0.29166666666667, 1.7, 0.0625
32538, 0.27083333333333, 1.7, 0.125
32539, 0.29166666666667, 1.7, 0.10416666666667
32540, 0.27083333333333, 1.7, 0.16666666666667
32541, 0.29166666666667, 1.7, 0.14583333333333
32542, 0.27083333333333, 1.7, 0.20833333333333
32543, 0.29166666666667, 1.7, 0.1875
32544, 0.27083333333333, 1.7, 0.25
32545, 0.29166666666667, 1.7, 0.22916666666667
32546, 0.27083333333333, 1.7, 0.29166666666667
32547, 0.29166666666667, 1.7, 0.27083333333333
32548, 0.27083333333333, 1.7, 0.33333333333333
32549, 0.29166666666667, 1.7, 0.3125
32550, 0.27083333333333, 1.7, 0.375
32551, 0.29166666666667, 1.7, 0.35416666666667
32552, 0.27083333333333, 1.7, 0.41666666666667
32553, 0.29166666666667, 1.7, 0.39583333333333
32554, 0.27083333333333, 1.7, 0.45833333333333
32555, 0.29166666666667, 1.7, 0.4375
32556, 0.29166666666667, 1.7, 0.47916666666667
32557, 0.3125, 1.7, 0.041666666666667
32558, 0.33333333333333, 1.7, 0.020833333333333
32559, 0.3125, 1.7, 0.083333333333333
32560, 0.33333333333333, 1.7, 0.0625
32561, 0.3125, 1.7, 0.125
32562, 0.33333333333333, 1.7, 0.10416666666667
32563, 0.3125, 1.7, 0.16666666666667
32564, 0.33333333333333, 1.7, 0.14583333333333
32565, 0.3125, 1.7, 0.20833333333333
32566, 0.33333333333333, 1.7, 0.1875
32567, 0.3125, 1.7, 0.25
32568, 0.33333333333333, 1.7, 0.22916666666667
32569, 0.3125, 1.7, 0.29166666666667
32570, 0.33333333333333, 1.7, 0.27083333333333
32571, 0.3125, 1.7, 0.33333333333333
32572, 0.33333333333333, 1.7, 0.3125
32573, 0.3125, 1.7, 0.375
32574, 0.33333333333333, 1.7, 0.35416666666667
32575, 0.3125, 1.7, 0.41666666666667
32576, 0.33333333333333, 1.7, 0.39583333333333
32577, 0.3125, 1.7, 0.45833333333333
32578, 0.33333333333333, 1.7, 0.4375
32579, 0.33333333333333, 1.7, 0.47916666666667
32580, 0.35416666666667, 1.7, 0.041666666666667
32581, 0.375, 1.7, 0.020833333333333
32582, 0.35416666666667, 1.7, 0.083333333333333
32583, 0.375, 1.7, 0.0625
32584, 0.35416666666667, 1.7, 0.125
32585, 0.375, 1.7, 0.10416666666667
32586, 0.35416666666667, 1.7, 0.16666666666667
32587, 0.375, 1.7, 0.14583333333333
32588, 0.35416666666667, 1.7, 0.20833333333333
32589, 0.375, 1.7, 0.1875
32590, 0.35416666666667, 1.7, 0.25
32591, 0.375, 1.7, 0.22916666666667
32592, 0.35416666666667, 1.7, 0.29166666666667
32593, 0.375, 1.7, 0.27083333333333
32594, 0.35416666666667, 1.7, 0.33333333333333
32595, 0.375, 1.7, 0.3125
32596, 0.35416666666667, 1.7, 0.375
32597, 0.375, 1.7, 0.35416666666667
32598, 0.35416666666667, 1.7, 0.41666666666667
32599, 0.375, 1.7, 0.39583333333333
32600, 0.35416666666667, 1.7, 0.45833333333333
32601, 0.375, 1.7, 0.4375
32602, 0.375, 1.7, 0.47916666666667
32603, 0.39583333333333, 1.7, 0.041666666666667
32604, 0.41666666666667, 1.7, 0.020833333333333
32605, 0.39583333333333, 1.7, 0.083333333333333
32606, 0.41666666666667, 1.7, 0.0625
32607, 0.39583333333333, 1.7, 0.125
32608, 0.41666666666667, 1.7, 0.10416666666667
32609, 0.39583333333333, 1.7, 0.16666666666667
32610, 0.41666666666667, 1.7, 0.14583333333333
32611, 0.39583333333333, 1.7, 0.20833333333333
32612, 0.41666666666667, 1.7, 0.1875
32613, 0.39583333333333, 1.7, 0.25
32614, 0.41666666666667, 1.7, 0.22916666666667
32615, 0.39583333333333, 1.7, 0.29166666666667
32616, 0.41666666666667, 1.7, 0.27083333333333
32617, 0.39583333333333, 1.7, 0.33333333333333
32618, 0.41666666666667, 1.7, 0.3125
32619, 0.39583333333333, 1.7, 0.375
32620, 0.41666666666667, 1.7, 0.35416666666667
32621, 0.39583333333333, 1.7, 0.41666666666667
32622, 0.41666666666667, 1.7, 0.39583333333333
32623, 0.39583333333333, 1.7, 0.45833333333333
32624, 0.41666666666667, 1.7, 0.4375
32625, 0.41666666666667, 1.7, 0.47916666666667
32626, 0.4375, 1.7, 0.041666666666667
32627, 0.45833333333333, 1.7, 0.020833333333333
32628, 0.4375, 1.7, 0.083333333333333
32629, 0.45833333333333, 1.7, 0.0625
32630, 0.4375, 1.7, 0.125
32631, 0.45833333333333, 1.7, 0.10416666666667
32632, 0.4375, 1.7, 0.16666666666667
32633, 0.45833333333333, 1.7, 0.14583333333333
32634, 0.4375, 1.7, 0.20833333333333
32635, 0.45833333333333, 1.7, 0.1875
32636, 0.4375, 1.7, 0.25
32637, 0.45833333333333, 1.7, 0.22916666666667
32638, 0.4375, 1.7, 0.29166666666667
32639, 0.45833333333333, 1.7, 0.27083333333333
32640, 0.4375, 1.7, 0.33333333333333
32641, 0.45833333333333, 1.7, 0.3125
32642, 0.4375, 1.7, 0.375
32643, 0.45833333333333, 1.7, 0.35416666666667
32644, 0.4375, 1.7, 0.41666666666667
32645, 0.45833333333333, 1.7, 0.39583333333333
32646, 0.4375, 1.7, 0.45833333333333
32647, 0.45833333333333, 1.7, 0.4375
32648, 0.45833333333333, 1.7, 0.47916666666667
32649, 0.47916666666667, 1.7, 0.041666666666667
32650, 0.5, 1.7, 0.020833333333333
32651, 0.47916666666667, 1.7, 0.083333333333333
32652, 0.5, 1.7, 0.0625
32653, 0.47916666666667, 1.7, 0.125
32654, 0.5, 1.7, 0.10416666666667
32655, 0.47916666666667, 1.7, 0.16666666666667
32656, 0.5, 1.7, 0.14583333333333
32657, 0.47916666666667, 1.7, 0.20833333333333
32658, 0.5, 1.7, 0.1875
32659, 0.47916666666667, 1.7, 0.25
32660, 0.5, 1.7, 0.22916666666667
32661, 0.47916666666667, 1.7, 0.29166666666667
32662, 0.5, 1.7, 0.27083333333333
32663, 0.47916666666667, 1.7, 0.33333333333333
32664, 0.5, 1.7, 0.3125
32665, 0.47916666666667, 1.7, 0.375
32666, 0.5, 1.7, 0.35416666666667
32667, 0.47916666666667, 1.7, 0.41666666666667
32668, 0.5, 1.7, 0.39583333333333
32669, 0.47916666666667, 1.7, 0.45833333333333
32670, 0.5, 1.7, 0.4375
32671, 0.5, 1.7, 0.47916666666667
32672, 0.52083333333333, 1.7, 0.041666666666667
32673, 0.54166666666667, 1.7, 0.020833333333333
32674, 0.52083333333333, 1.7, 0.083333333333333
32675, 0.54166666666667, 1.7, 0.0625
32676, 0.52083333333333, 1.7, 0.125
32677, 0.54166666666667, 1.7, 0.10416666666667
32678, 0.52083333333333, 1.7, 0.16666666666667
32679, 0.54166666666667, 1.7, 0.14583333333333
32680, 0.52083333333333, 1.7, 0.20833333333333
32681, 0.54166666666667, 1.7, 0.1875
32682, 0.52083333333333, 1.7, 0.25
32683, 0.54166666666667, 1.7, 0.22916666666667
32684, 0.52083333333333, 1.7, 0.29166666666667
32685, 0.54166666666667, 1.7, 0.27083333333333
32686, 0.52083333333333, 1.7, 0.33333333333333
32687, 0.54166666666667, 1.7, 0.3125
32688, 0.52083333333333, 1.7, 0.375
32689, 0.54166666666667, 1.7, 0.35416666666667
32690, 0.52083333333333, 1.7, 0.41666666666667
32691, 0.54166666666667, 1.7, 0.39583333333333
32692, 0.52083333333333, 1.7, 0.45833333333333
32693, 0.54166666666667, 1.7, 0.4375
32694, 0.54166666666667, 1.7, 0.47916666666667
32695, 0.5625, 1.7, 0.041666666666667
32696, 0.58333333333333, 1.7, 0.020833333333333
32697, 0.5625, 1.7, 0.083333333333333
32698, 0.58333333333333, 1.7, 0.0625
32699, 0.5625, 1.7, 0.125
32700, 0.58333333333333, 1.7, 0.10416666666667
32701, 0.5625, 1.7, 0.16666666666667
32702, 0.58333333333333, 1.7, 0.14583333333333
32703, 0.5625, 1.7, 0.20833333333333
32704, 0.58333333333333, 1.7, 0.1875
32705, 0.5625, 1.7, 0.25
32706, 0.58333333333333, 1.7, 0.22916666666667
32707, 0.5625, 1.7, 0.29166666666667
32708, 0.58333333333333, 1.7, 0.27083333333333
32709, 0.5625, 1.7, 0.33333333333333
32710, 0.58333333333333, 1.7, 0.3125
32711, 0.5625, 1.7, 0.375
32712, 0.58333333333333, 1.7, 0.35416666666667
32713, 0.5625, 1.7, 0.41666666666667
32714, 0.58333333333333, 1.7, 0.39583333333333
32715, 0.5625, 1.7, 0.45833333333333
32716, 0.58333333333333, 1.7, 0.4375
32717, 0.58333333333333, 1.7, 0.47916666666667
32718, 0.60416666666667, 1.7, 0.041666666666667
32719, 0.625, 1.7, 0.020833333333333
32720, 0.60416666666667, 1.7, 0.083333333333333
32721, 0.625, 1.7, 0.0625
32722, 0.60416666666667, 1.7, 0.125
32723, 0.625, 1.7, 0.10416666666667
32724, 0.60416666666667, 1.7, 0.16666666666667
32725, 0.625, 1.7, 0.14583333333333
32726, 0.60416666666667, 1.7, 0.20833333333333
32727, 0.625, 1.7, 0.1875
32728, 0.60416666666667, 1.7, 0.25
32729, 0.625, 1.7, 0.22916666666667
32730, 0.60416666666667, 1.7, 0.29166666666667
32731, 0.625, 1.7, 0.27083333333333
32732, 0.60416666666667, 1.7, 0.33333333333333
32733, 0.625, 1.7, 0.3125
32734, 0.60416666666667, 1.7, 0.375
32735, 0.625, 1.7, 0.35416666666667
32736, 0.60416666666667, 1.7, 0.41666666666667
32737, 0.625, 1.7, 0.39583333333333
32738, 0.60416666666667, 1.7, 0.45833333333333
32739, 0.625, 1.7, 0.4375
32740, 0.625, 1.7, 0.47916666666667
32741, 0.64583333333333, 1.7, 0.041666666666667
32742, 0.66666666666667, 1.7, 0.020833333333333
32743, 0.64583333333333, 1.7, 0.083333333333333
32744, 0.66666666666667, 1.7, 0.0625
32745, 0.64583333333333, 1.7, 0.125
32746, 0.66666666666667, 1.7, 0.10416666666667
32747, 0.64583333333333, 1.7, 0.16666666666667
32748, 0.66666666666667, 1.7, 0.14583333333333
32749, 0.64583333333333, 1.7, 0.20833333333333
32750, 0.66666666666667, 1.7, 0.1875
32751, 0.64583333333333, 1.7, 0.25
32752, 0.66666666666667, 1.7, 0.22916666666667
32753, 0.64583333333333, 1.7, 0.29166666666667
32754, 0.66666666666667, 1.7, 0.27083333333333
32755, 0.64583333333333, 1.7, 0.33333333333333
32756, 0.66666666666667, 1.7, 0.3125
32757, 0.64583333333333, 1.7, 0.375
32758, 0.66666666666667, 1.7, 0.35416666666667
32759, 0.64583333333333, 1.7, 0.41666666666667
32760, 0.66666666666667, 1.7, 0.39583333333333
32761, 0.64583333333333, 1.7, 0.45833333333333
32762, 0.66666666666667, 1.7, 0.4375
32763, 0.66666666666667, 1.7, 0.47916666666667
32764, 0.6875, 1.7, 0.041666666666667
32765, 0.70833333333333, 1.7, 0.020833333333333
32766, 0.6875, 1.7, 0.083333333333333
32767, 0.70833333333333, 1.7, 0.0625
32768, 0.6875, 1.7, 0.125
32769, 0.70833333333333, 1.7, 0.10416666666667
32770, 0.6875, 1.7, 0.16666666666667
32771, 0.70833333333333, 1.7, 0.14583333333333
32772, 0.6875, 1.7, 0.20833333333333
32773, 0.70833333333333, 1.7, 0.1875
32774, 0.6875, 1.7, 0.25
32775, 0.70833333333333, 1.7, 0.22916666666667
32776, 0.6875, 1.7, 0.29166666666667
32777, 0.70833333333333, 1.7, 0.27083333333333
32778, 0.6875, 1.7, 0.33333333333333
32779, 0.70833333333333, 1.7, 0.3125
32780, 0.6875, 1.7, 0.375
32781, 0.70833333333333, 1.7, 0.35416666666667
32782, 0.6875, 1.7, 0.41666666666667
32783, 0.70833333333333, 1.7, 0.39583333333333
32784, 0.6875, 1.7, 0.45833333333333
32785, 0.70833333333333, 1.7, 0.4375
32786, 0.70833333333333, 1.7, 0.47916666666667
32787, 0.72916666666667, 1.7, 0.041666666666667
32788, 0.75, 1.7, 0.020833333333333
32789, 0.72916666666667, 1.7, 0.083333333333333
32790, 0.75, 1.7, 0.0625
32791, 0.72916666666667, 1.7, 0.125
32792, 0.75, 1.7, 0.10416666666667
32793, 0.72916666666667, 1.7, 0.16666666666667
32794, 0.75, 1.7, 0.14583333333333
32795, 0.72916666666667, 1.7, 0.20833333333333
32796, 0.75, 1.7, 0.1875
32797, 0.72916666666667, 1.7, 0.25
32798, 0.75, 1.7, 0.22916666666667
32799, 0.72916666666667, 1.7, 0.29166666666667
32800, 0.75, 1.7, 0.27083333333333
32801, 0.72916666666667, 1.7, 0.33333333333333
32802, 0.75, 1.7, 0.3125
32803, 0.72916666666667, 1.7, 0.375
32804, 0.75, 1.7, 0.35416666666667
32805, 0.72916666666667, 1.7, 0.41666666666667
32806, 0.75, 1.7, 0.39583333333333
32807, 0.72916666666667, 1.7, 0.45833333333333
32808, 0.75, 1.7, 0.4375
32809, 0.75, 1.7, 0.47916666666667
32810, 0.77083333333333, 1.7, 0.041666666666667
32811, 0.79166666666667, 1.7, 0.020833333333333
32812, 0.77083333333333, 1.7, 0.083333333333333
32813, 0.79166666666667, 1.7, 0.0625
32814, 0.77083333333333, 1.7, 0.125
32815, 0.79166666666667, 1.7, 0.10416666666667
32816, 0.77083333333333, 1.7, 0.16666666666667
32817, 0.79166666666667, 1.7, 0.14583333333333
32818, 0.77083333333333, 1.7, 0.20833333333333
32819, 0.79166666666667, 1.7, 0.1875
32820, 0.77083333333333, 1.7, 0.25
32821, 0.79166666666667, 1.7, 0.22916666666667
32822, 0.77083333333333, 1.7, 0.29166666666667
32823, 0.79166666666667, 1.7, 0.27083333333333
32824, 0.77083333333333, 1.7, 0.33333333333333
32825, 0.79166666666667, 1.7, 0.3125
32826, 0.77083333333333, 1.7, 0.375
32827, 0.79166666666667, 1.7, 0.35416666666667
32828, 0.77083333333333, 1.7, 0.41666666666667
32829, 0.79166666666667, 1.7, 0.39583333333333
32830, 0.77083333333333, 1.7, 0.45833333333333
32831, 0.79166666666667, 1.7, 0.4375
32832, 0.79166666666667, 1.7, 0.47916666666667
32833, 0.8125, 1.7, 0.041666666666667
32834, 0.83333333333333, 1.7, 0.020833333333333
32835, 0.8125, 1.7, 0.083333333333333
32836, 0.83333333333333, 1.7, 0.0625
32837, 0.8125, 1.7, 0.125
32838, 0.83333333333333, 1.7, 0.10416666666667
32839, 0.8125, 1.7, 0.16666666666667
32840, 0.83333333333333, 1.7, 0.14583333333333
32841, 0.8125, 1.7, 0.20833333333333
32842, 0.83333333333333, 1.7, 0.1875
32843, 0.8125, 1.7, 0.25
32844, 0.83333333333333, 1.7, 0.22916666666667
32845, 0.8125, 1.7, 0.29166666666667
32846, 0.83333333333333, 1.7, 0.27083333333333
32847, 0.8125, 1.7, 0.33333333333333
32848, 0.83333333333333, 1.7, 0.3125
32849, 0.8125, 1.7, 0.375
32850, 0.83333333333333, 1.7, 0.35416666666667
32851, 0.8125, 1.7, 0.41666666666667
32852, 0.83333333333333, 1.7, 0.39583333333333
32853, 0.8125, 1.7, 0.45833333333333
32854, 0.83333333333333, 1.7, 0.4375
32855, 0.83333333333333, 1.7, 0.47916666666667
32856, 0.85416666666667, 1.7, 0.041666666666667
32857, 0.875, 1.7, 0.020833333333333
32858, 0.85416666666667, 1.7, 0.083333333333333
32859, 0.875, 1.7, 0.0625
32860, 0.85416666666667, 1.7, 0.125
32861, 0.875, 1.7, 0.10416666666667
32862, 0.85416666666667, 1.7, 0.16666666666667
32863, 0.875, 1.7, 0.14583333333333
32864, 0.85416666666667, 1.7, 0.20833333333333
32865, 0.875, 1.7, 0.1875
32866, 0.85416666666667, 1.7, 0.25
32867, 0.875, 1.7, 0.22916666666667
32868, 0.85416666666667, 1.7, 0.29166666666667
32869, 0.875, 1.7, 0.27083333333333
32870, 0.85416666666667, 1.7, 0.33333333333333
32871, 0.875, 1.7, 0.3125
32872, 0.85416666666667, 1.7, 0.375
32873, 0.875, 1.7, 0.35416666666667
32874, 0.85416666666667, 1.7, 0.41666666666667
32875, 0.875, 1.7, 0.39583333333333
32876, 0.85416666666667, 1.7, 0.45833333333333
32877, 0.875, 1.7, 0.4375
32878, 0.875, 1.7, 0.47916666666667
32879, 0.89583333333333, 1.7, 0.041666666666667
32880, 0.91666666666667, 1.7, 0.020833333333333
32881, 0.89583333333333, 1.7, 0.083333333333333
32882, 0.91666666666667, 1.7, 0.0625
32883, 0.89583333333333, 1.7, 0.125
32884, 0.91666666666667, 1.7, 0.10416666666667
32885, 0.89583333333333, 1.7, 0.16666666666667
32886, 0.91666666666667, 1.7, 0.14583333333333
32887, 0.89583333333333, 1.7, 0.20833333333333
32888, 0.91666666666667, 1.7, 0.1875
32889, 0.89583333333333, 1.7, 0.25
32890, 0.91666666666667, 1.7, 0.22916666666667
32891, 0.89583333333333, 1.7, 0.29166666666667
32892, 0.91666666666667, 1.7, 0.27083333333333
32893, 0.89583333333333, 1.7, 0.33333333333333
32894, 0.91666666666667, 1.7, 0.3125
32895, 0.89583333333333, 1.7, 0.375
32896, 0.91666666666667, 1.7, 0.35416666666667
32897, 0.89583333333333, 1.7, 0.41666666666667
32898, 0.91666666666667, 1.7, 0.39583333333333
32899, 0.89583333333333, 1.7, 0.45833333333333
32900, 0.91666666666667, 1.7, 0.4375
32901, 0.91666666666667, 1.7, 0.47916666666667
32902, 0.9375, 1.7, 0.041666666666667
32903, 0.95833333333333, 1.7, 0.020833333333333
32904, 0.9375, 1.7, 0.083333333333333
32905, 0.95833333333333, 1.7, 0.0625
32906, 0.9375, 1.7, 0.125
32907, 0.95833333333333, 1.7, 0.10416666666667
32908, 0.9375, 1.7, 0.16666666666667
32909, 0.95833333333333, 1.7, 0.14583333333333
32910, 0.9375, 1.7, 0.20833333333333
32911, 0.95833333333333, 1.7, 0.1875
32912, 0.9375, 1.7, 0.25
32913, 0.95833333333333, 1.7, 0.22916666666667
32914, 0.9375, 1.7, 0.29166666666667
32915, 0.95833333333333, 1.7, 0.27083333333333
32916, 0.9375, 1.7, 0.33333333333333
32917, 0.95833333333333, 1.7, 0.3125
32918, 0.9375, 1.7, 0.375
32919, 0.95833333333333, 1.7, 0.35416666666667
32920, 0.9375, 1.7, 0.41666666666667
32921, 0.95833333333333, 1.7, 0.39583333333333
32922, 0.9375, 1.7, 0.45833333333333
32923, 0.95833333333333, 1.7, 0.4375
32924, 0.95833333333333, 1.7, 0.47916666666667
32925, 0.97916666666667, 1.7, 0.041666666666667
32926, 0.97916666666667, 1.7, 0.083333333333333
32927, 0.97916666666667, 1.7, 0.125
32928, 0.97916666666667, 1.7, 0.16666666666667
32929, 0.97916666666667, 1.7, 0.20833333333333
32930, 0.97916666666667, 1.7, 0.25
32931, 0.97916666666667, 1.7, 0.29166666666667
32932, 0.97916666666667, 1.7, 0.33333333333333
32933, 0.97916666666667, 1.7, 0.375
32934, 0.97916666666667, 1.7, 0.41666666666667
32935, 0.97916666666667, 1.7, 0.45833333333333
32936, 1.04, 1.54, 0.5
32937, 1.04, 1.58, 0.5
32938, 1.04, 1.62, 0.5
32939, 1.04, 1.66, 0.5
32940, 1.08, 1.54, 0.5
32941, 1.08, 1.58, 0.5
32942, 1.08, 1.62, 0.5
32943, 1.08, 1.66, 0.5
32944, 1.12, 1.54, 0.5
32945, 1.12, 1.58, 0.5
32946, 1.12, 1.62, 0.5
32947, 1.12, 1.66, 0.5
32948, 1.16, 1.54, 0.5
32949, 1.16, 1.58, 0.5
32950, 1.16, 1.62, 0.5
32951, 1.16, 1.66, 0.5
32952, 1.04, 1.52, 0.5
32953, 1.02, 1.54, 0.5
32954, 1.04, 1.56, 0.5
32955, 1.02, 1.58, 0.5
32956, 1.04, 1.6, 0.5
32957, 1.02, 1.62, 0.5
32958, 1.04, 1.64, 0.5
32959, 1.02, 1.66, 0.5
32960, 1.04, 1.68, 0.5
32961, 1.08, 1.52, 0.5
32962, 1.06, 1.54, 0.5
32963, 1.08, 1.56, 0.5
32964, 1.06, 1.58, 0.5
32965, 1.08, 1.6, 0.5
32966, 1.06, 1.62, 0.5
32967, 1.08, 1.64, 0.5
32968, 1.06, 1.66, 0.5
32969, 1.08, 1.68, 0.5
32970, 1.12, 1.52, 0.5
32971, 1.1, 1.54, 0.5
32972, 1.12, 1.56, 0.5
32973, 1.1, 1.58, 0.5
32974, 1.12, 1.6, 0.5
32975, 1.1, 1.62, 0.5
32976, 1.12, 1.64, 0.5
32977, 1.1, 1.66, 0.5
32978, 1.12, 1.68, 0.5
32979, 1.16, 1.52, 0.5
32980, 1.14, 1.54, 0.5
32981, 1.16, 1.56, 0.5
32982, 1.14, 1.58, 0.5
32983, 1.16, 1.6, 0.5
32984, 1.14, 1.62, 0.5
32985, 1.16, 1.64, 0.5
32986, 1.14, 1.66, 0.5
32987, 1.16, 1.68, 0.5
32988, 1.18, 1.54, 0.5
32989, 1.18, 1.58, 0.5
32990, 1.18, 1.62, 0.5
32991, 1.18, 1.66, 0.5
32992, 1.04, 1.54, 0
32993, 1.04, 1.58, 0
32994, 1.04, 1.62, 0
32995, 1.04, 1.66, 0
32996, 1.08, 1.54, 0
32997, 1.08, 1.58, 0
32998, 1.08, 1.62, 0
32999, 1.08, 1.66, 0
33000, 1.12, 1.54, 0
33001, 1.12, 1.58, 0
33002, 1.12, 1.62, 0
33003, 1.12, 1.66, 0
33004, 1.16, 1.54, 0
33005, 1.16, 1.58, 0
33006, 1.16, 1.62, 0
33007, 1.16, 1.66, 0
33008, 1.02, 1.54, 0
33009, 1.04, 1.52, 0
33010, 1.02, 1.58, 0
33011, 1.04, 1.56, 0
33012, 1.02, 1.62, 0
33013, 1.04, 1.6, 0
33014, 1.02, 1.66, 0
33015, 1.04, 1.64, 0
33016, 1.04, 1.68, 0
33017, 1.06, 1.54, 0
33018, 1.08, 1.52, 0
33019, 1.06, 1.58, 0
33020, 1.08, 1.56, 0
33021, 1.06, 1.62, 0
33022, 1.08, 1.6, 0
33023, 1.06, 1.66, 0
33024, 1.08, 1.64, 0
33025, 1.08, 1.68, 0
33026, 1.1, 1.54, 0
33027, 1.12, 1.52, 0
33028, 1.1, 1.58, 0
33029, 1.12, 1.56, 0
33030, 1.1, 1.62, 0
33031, 1.12, 1.6, 0
33032, 1.1, 1.66, 0
33033, 1.12, 1.64, 0
33034, 1.12, 1.68, 0
33035, 1.14, 1.54, 0
33036, 1.16, 1.52, 0
33037, 1.14, 1.58, 0
33038, 1.16, 1.56, 0
33039, 1.14, 1.62, 0
33040, 1.16, 1.6, 0
33041, 1.14, 1.66, 0
33042, 1.16, 1.64, 0
33043, 1.16, 1.68, 0
33044, 1.18, 1.54, 0
33045, 1.18, 1.58, 0
33046, 1.18, 1.62, 0
33047, 1.18, 1.66, 0
33048, 1.2, 1.54, 0.041666666666667
33049, 1.2, 1.58, 0.041666666666667
33050, 1.2, 1.62, 0.041666666666667
33051, 1.2, 1.66, 0.041666666666667
33052, 1.2, 1.54, 0.083333333333333
33053, 1.2, 1.58, 0.083333333333333
33054, 1.2, 1.62, 0.083333333333333
33055, 1.2, 1.66, 0.083333333333333
33056, 1.2, 1.54, 0.125
33057, 1.2, 1.58, 0.125
33058, 1.2, 1.62, 0.125
33059, 1.2, 1.66, 0.125
33060, 1.2, 1.54, 0.16666666666667
33061, 1.2, 1.58, 0.16666666666667
33062, 1.2, 1.62, 0.16666666666667
33063, 1.2, 1.66, 0.16666666666667
33064, 1.2, 1.54, 0.20833333333333
33065, 1.2, 1.58, 0.20833333333333
33066, 1.2, 1.62, 0.20833333333333
33067, 1.2, 1.66, 0.20833333333333
33068, 1.2, 1.54, 0.25
33069, 1.2, 1.58, 0.25
33070, 1.2, 1.62, 0.25
33071, 1.2, 1.66, 0.25
33072, 1.2, 1.54, 0.29166666666667
33073, 1.2, 1.58, 0.29166666666667
33074, 1.2, 1.62, 0.29166666666667
33075, 1.2, 1.66, 0.29166666666667
33076, 1.2, 1.54, 0.33333333333333
33077, 1.2, 1.58, 0.33333333333333
33078, 1.2, 1.62, 0.33333333333333
33079, 1.2, 1.66, 0.33333333333333
33080, 1.2, 1.54, 0.375
33081, 1.2, 1.58, 0.375
33082, 1.2, 1.62, 0.375
33083, 1.2, 1.66, 0.375
33084, 1.2, 1.54, 0.41666666666667
33085, 1.2, 1.58, 0.41666666666667
33086, 1.2, 1.62, 0.41666666666667
33087, 1.2, 1.66, 0.41666666666667
33088, 1.2, 1.54, 0.45833333333333
33089, 1.2, 1.58, 0.45833333333333
33090, 1.2, 1.62, 0.45833333333333
33091, 1.2, 1.66, 0.45833333333333
33092, 1.2, 1.54, 0.020833333333333
33093, 1.2, 1.52, 0.041666666666667
33094, 1.2, 1.58, 0.020833333333333
33095, 1.2, 1.56, 0.041666666666667
33096, 1.2, 1.62, 0.020833333333333
33097, 1.2, 1.6, 0.041666666666667
33098, 1.2, 1.66, 0.020833333333333
33099, 1.2, 1.64, 0.041666666666667
33100, 1.2, 1.68, 0.041666666666667
33101, 1.2, 1.54, 0.0625
33102, 1.2, 1.52, 0.083333333333333
33103, 1.2, 1.58, 0.0625
33104, 1.2, 1.56, 0.083333333333333
33105, 1.2, 1.62, 0.0625
33106, 1.2, 1.6, 0.083333333333333
33107, 1.2, 1.66, 0.0625
33108, 1.2, 1.64, 0.083333333333333
33109, 1.2, 1.68, 0.083333333333333
33110, 1.2, 1.54, 0.10416666666667
33111, 1.2, 1.52, 0.125
33112, 1.2, 1.58, 0.10416666666667
33113, 1.2, 1.56, 0.125
33114, 1.2, 1.62, 0.10416666666667
33115, 1.2, 1.6, 0.125
33116, 1.2, 1.66, 0.10416666666667
33117, 1.2, 1.64, 0.125
33118, 1.2, 1.68, 0.125
33119, 1.2, 1.54, 0.14583333333333
33120, 1.2, 1.52, 0.16666666666667
33121, 1.2, 1.58, 0.14583333333333
33122, 1.2, 1.56, 0.16666666666667
33123, 1.2, 1.62, 0.14583333333333
33124, 1.2, 1.6, 0.16666666666667
33125, 1.2, 1.66, 0.14583333333333
33126, 1.2, 1.64, 0.16666666666667
33127, 1.2, 1.68, 0.16666666666667
33128, 1.2, 1.54, 0.1875
33129, 1.2, 1.52, 0.20833333333333
33130, 1.2, 1.58, 0.1875
33131, 1.2, 1.56, 0.20833333333333
33132, 1.2, 1.62, 0.1875
33133, 1.2, 1.6, 0.20833333333333
33134, 1.2, 1.66, 0.1875
33135, 1.2, 1.64, 0.20833333333333
33136, 1.2, 1.68, 0.20833333333333
33137, 1.2, 1.54, 0.22916666666667
33138, 1.2, 1.52, 0.25
33139, 1.2, 1.58, 0.22916666666667
33140, 1.2, 1.56, 0.25
33141, 1.2, 1.62, 0.22916666666667
33142, 1.2, 1.6, 0.25
33143, 1.2, 1.66, 0.22916666666667
33144, 1.2, 1.64, 0.25
33145, 1.2, 1.68, 0.25
33146, 1.2, 1.54, 0.27083333333333
33147, 1.2, 1.52, 0.29166666666667
33148, 1.2, 1.58, 0.27083333333333
33149, 1.2, 1.56, 0.29166666666667
33150, 1.2, 1.62, 0.27083333333333
33151, 1.2, 1.6, 0.29166666666667
33152, 1.2, 1.66, 0.27083333333333
33153, 1.2, 1.64, 0.29166666666667
33154, 1.2, 1.68, 0.29166666666667
33155, 1.2, 1.54, 0.3125
33156, 1.2, 1.52, 0.33333333333333
33157, 1.2, 1.58, 0.3125
33158, 1.2, 1.56, 0.33333333333333
33159, 1.2, 1.62, 0.3125
33160, 1.2, 1.6, 0.33333333333333
33161, 1.2, 1.66, 0.3125
33162, 1.2, 1.64, 0.33333333333333
33163, 1.2, 1.68, 0.33333333333333
33164, 1.2, 1.54, 0.35416666666667
33165, 1.2, 1.52, 0.375
33166, 1.2, 1.58, 0.35416666666667
33167, 1.2, 1.56, 0.375
33168, 1.2, 1.62, 0.35416666666667
33169, 1.2, 1.6, 0.375
33170, 1.2, 1.66, 0.35416666666667
33171, 1.2, 1.64, 0.375
33172, 1.2, 1.68, 0.375
33173, 1.2, 1.54, 0.39583333333333
33174, 1.2, 1.52, 0.41666666666667
33175, 1.2, 1.58, 0.39583333333333
33176, 1.2, 1.56, 0.41666666666667
33177, 1.2, 1.62, 0.39583333333333
33178, 1.2, 1.6, 0.41666666666667
33179, 1.2, 1.66, 0.39583333333333
33180, 1.2, 1.64, 0.41666666666667
33181, 1.2, 1.68, 0.41666666666667
33182, 1.2, 1.54, 0.4375
33183, 1.2, 1.52, 0.45833333333333
33184, 1.2, 1.58, 0.4375
33185, 1.2, 1.56, 0.45833333333333
33186, 1.2, 1.62, 0.4375
33187, 1.2, 1.6, 0.45833333333333
33188, 1.2, 1.66, 0.4375
33189, 1.2, 1.64, 0.45833333333333
33190, 1.2, 1.68, 0.45833333333333
33191, 1.2, 1.54, 0.47916666666667
33192, 1.2, 1.58, 0.47916666666667
33193, 1.2, 1.62, 0.47916666666667
33194, 1.2, 1.66, 0.47916666666667
33195, 1.04, 1.7, 0.041666666666667
33196, 1.08, 1.7, 0.041666666666667
33197, 1.12, 1.7, 0.041666666666667
33198, 1.16, 1.7, 0.041666666666667
33199, 1.04, 1.7, 0.083333333333333
33200, 1.08, 1.7, 0.083333333333333
33201, 1.12, 1.7, 0.083333333333333
33202, 1.16, 1.7, 0.083333333333333
33203, 1.04, 1.7, 0.125
33204, 1.08, 1.7, 0.125
33205, 1.12, 1.7, 0.125
33206, 1.16, 1.7, 0.125
33207, 1.04, 1.7, 0.16666666666667
33208, 1.08, 1.7, 0.16666666666667
33209, 1.12, 1.7, 0.16666666666667
33210, 1.16, 1.7, 0.16666666666667
33211, 1.04, 1.7, 0.20833333333333
33212, 1.08, 1.7, 0.20833333333333
33213, 1.12, 1.7, 0.20833333333333
33214, 1.16, 1.7, 0.20833333333333
33215, 1.04, 1.7, 0.25
33216, 1.08, 1.7, 0.25
33217, 1.12, 1.7, 0.25
33218, 1.16, 1.7, 0.25
33219, 1.04, 1.7, 0.29166666666667
33220, 1.08, 1.7, 0.29166666666667
33221, 1.12, 1.7, 0.29166666666667
33222, 1.16, 1.7, 0.29166666666667
33223, 1.04, 1.7, 0.33333333333333
33224, 1.08, 1.7, 0.33333333333333
33225, 1.12, 1.7, 0.33333333333333
33226, 1.16, 1.7, 0.33333333333333
33227, 1.04, 1.7, 0.375
33228, 1.08, 1.7, 0.375
33229, 1.12, 1.7, 0.375
33230, 1.16, 1.7, 0.375
33231, 1.04, 1.7, 0.41666666666667
33232, 1.08, 1.7, 0.41666666666667
33233, 1.12, 1.7, 0.41666666666667
33234, 1.16, 1.7, 0.41666666666667
33235, 1.04, 1.7, 0.45833333333333
33236, 1.08, 1.7, 0.45833333333333
33237, 1.12, 1.7, 0.45833333333333
33238, 1.16, 1.7, 0.45833333333333
33239, 1.02, 1.7, 0.041666666666667
33240, 1.04, 1.7, 0.020833333333333
33241, 1.06, 1.7, 0.041666666666667
33242, 1.08, 1.7, 0.020833333333333
33243, 1.1, 1.7, 0.041666666666667
33244, 1.12, 1.7, 0.020833333333333
33245, 1.14, 1.7, 0.041666666666667
33246, 1.16, 1.7, 0.020833333333333
33247, 1.18, 1.7, 0.041666666666667
33248, 1.02, 1.7, 0.083333333333333
33249, 1.04, 1.7, 0.0625
33250, 1.06, 1.7, 0.083333333333333
33251, 1.08, 1.7, 0.0625
33252, 1.1, 1.7, 0.083333333333333
33253, 1.12, 1.7, 0.0625
33254, 1.14, 1.7, 0.083333333333333
33255, 1.16, 1.7, 0.0625
33256, 1.18, 1.7, 0.083333333333333
33257, 1.02, 1.7, 0.125
33258, 1.04, 1.7, 0.10416666666667
33259, 1.06, 1.7, 0.125
33260, 1.08, 1.7, 0.10416666666667
33261, 1.1, 1.7, 0.125
33262, 1.12, 1.7, 0.10416666666667
33263, 1.14, 1.7, 0.125
33264, 1.16, 1.7, 0.10416666666667
33265, 1.18, 1.7, 0.125
33266, 1.02, 1.7, 0.16666666666667
33267, 1.04, 1.7, 0.14583333333333
33268, 1.06, 1.7, 0.16666666666667
33269, 1.08, 1.7, 0.14583333333333
33270, 1.1, 1.7, 0.16666666666667
33271, 1.12, 1.7, 0.14583333333333
33272, 1.14, 1.7, 0.16666666666667
33273, 1.16, 1.7, 0.14583333333333
33274, 1.18, 1.7, 0.16666666666667
33275, 1.02, 1.7, 0.20833333333333
33276, 1.04, 1.7, 0.1875
33277, 1.06, 1.7, 0.20833333333333
33278, 1.08, 1.7, 0.1875
33279, 1.1, 1.7, 0.20833333333333
33280, 1.12, 1.7, 0.1875
33281, 1.14, 1.7, 0.20833333333333
33282, 1.16, 1.7, 0.1875
33283, 1.18, 1.7, 0.20833333333333
33284, 1.02, 1.7, 0.25
33285, 1.04, 1.7, 0.22916666666667
33286, 1.06, 1.7, 0.25
33287, 1.08, 1.7, 0.22916666666667
33288, 1.1, 1.7, 0.25
33289, 1.12, 1.7, 0.22916666666667
33290, 1.14, 1.7, 0.25
33291, 1.16, 1.7, 0.22916666666667
33292, 1.18, 1.7, 0.25
33293, 1.02, 1.7, 0.29166666666667
33294, 1.04, 1.7, 0.27083333333333
33295, 1.06, 1.7, 0.29166666666667
33296, 1.08, 1.7, 0.27083333333333
33297, 1.1, 1.7, 0.29166666666667
33298, 1.12, 1.7, 0.27083333333333
33299, 1.14, 1.7, 0.29166666666667
33300, 1.16, 1.7, 0.27083333333333
33301, 1.18, 1.7, 0.29166666666667
33302, 1.02, 1.7, 0.33333333333333
33303, 1.04, 1.7, 0.3125
33304, 1.06, 1.7, 0.33333333333333
33305, 1.08, 1.7, 0.3125
33306, 1.1, 1.7, 0.33333333333333
33307, 1.12, 1.7, 0.3125
33308, 1.14, 1.7, 0.33333333333333
33309, 1.16, 1.7, 0.3125
33310, 1.18, 1.7, 0.33333333333333
33311, 1.02, 1.7, 0.375
33312, 1.04, 1.7, 0.35416666666667
33313, 1.06, 1.7, 0.375
33314, 1.08, 1.7, 0.35416666666667
33315, 1.1, 1.7, 0.375
33316, 1.12, 1.7, 0.35416666666667
33317, 1.14, 1.7, 0.375
33318, 1.16, 1.7, 0.35416666666667
33319, 1.18, 1.7, 0.375
33320, 1.02, 1.7, 0.41666666666667
33321, 1.04, 1.7, 0.39583333333333
33322, 1.06, 1.7, 0.41666666666667
33323, 1.08, 1.7, 0.39583333333333
33324, 1.1, 1.7, 0.41666666666667
33325, 1.12, 1.7, 0.39583333333333
33326, 1.14, 1.7, 0.41666666666667
33327, 1.16, 1.7, 0.39583333333333
33328, 1.18, 1.7, 0.41666666666667
33329, 1.02, 1.7, 0.45833333333333
33330, 1.04, 1.7, 0.4375
33331, 1.06, 1.7, 0.45833333333333
33332, 1.08, 1.7, 0.4375
33333, 1.1, 1.7, 0.45833333333333
33334, 1.12, 1.7, 0.4375
33335, 1.14, 1.7, 0.45833333333333
33336, 1.16, 1.7, 0.4375
33337, 1.18, 1.7, 0.45833333333333
33338, 1.04, 1.7, 0.47916666666667
33339, 1.08, 1.7, 0.47916666666667
33340, 1.12, 1.7, 0.47916666666667
33341, 1.16, 1.7, 0.47916666666667
33342, 1.2416666666667, 1.54, 0.5
33343, 1.2416666666667, 1.58, 0.5
33344, 1.2416666666667, 1.62, 0.5
33345, 1.2416666666667, 1.66, 0.5
33346, 1.2833333333333, 1.54, 0.5
33347, 1.2833333333333, 1.58, 0.5
33348, 1.2833333333333, 1.62, 0.5
33349, 1.2833333333333, 1.66, 0.5
33350, 1.325, 1.54, 0.5
33351, 1.325, 1.58, 0.5
33352, 1.325, 1.62, 0.5
33353, 1.325, 1.66, 0.5
33354, 1.3666666666667, 1.54, 0.5
33355, 1.3666666666667, 1.58, 0.5
33356, 1.3666666666667, 1.62, 0.5
33357, 1.3666666666667, 1.66, 0.5
33358, 1.4083333333333, 1.54, 0.5
33359, 1.4083333333333, 1.58, 0.5
33360, 1.4083333333333, 1.62, 0.5
33361, 1.4083333333333, 1.66, 0.5
33362, 1.45, 1.54, 0.5
33363, 1.45, 1.58, 0.5
33364, 1.45, 1.62, 0.5
33365, 1.45, 1.66, 0.5
33366, 1.4916666666667, 1.54, 0.5
33367, 1.4916666666667, 1.58, 0.5
33368, 1.4916666666667, 1.62, 0.5
33369, 1.4916666666667, 1.66, 0.5
33370, 1.5333333333333, 1.54, 0.5
33371, 1.5333333333333, 1.58, 0.5
33372, 1.5333333333333, 1.62, 0.5
33373, 1.5333333333333, 1.66, 0.5
33374, 1.575, 1.54, 0.5
33375, 1.575, 1.58, 0.5
33376, 1.575, 1.62, 0.5
33377, 1.575, 1.66, 0.5
33378, 1.6166666666667, 1.54, 0.5
33379, 1.6166666666667, 1.58, 0.5
33380, 1.6166666666667, 1.62, 0.5
33381, 1.6166666666667, 1.66, 0.5
33382, 1.6583333333333, 1.54, 0.5
33383, 1.6583333333333, 1.58, 0.5
33384, 1.6583333333333, 1.62, 0.5
33385, 1.6583333333333, 1.66, 0.5
33386, 1.7, 1.54, 0.5
33387, 1.7, 1.58, 0.5
33388, 1.7, 1.62, 0.5
33389, 1.7, 1.66, 0.5
33390, 1.7416666666667, 1.54, 0.5
33391, 1.7416666666667, 1.58, 0.5
33392, 1.7416666666667, 1.62, 0.5
33393, 1.7416666666667, 1.66, 0.5
33394, 1.7833333333333, 1.54, 0.5
33395, 1.7833333333333, 1.58, 0.5
33396, 1.7833333333333, 1.62, 0.5
33397, 1.7833333333333, 1.66, 0.5
33398, 1.825, 1.54, 0.5
33399, 1.825, 1.58, 0.5
33400, 1.825, 1.62, 0.5
33401, 1.825, 1.66, 0.5
33402, 1.8666666666667, 1.54, 0.5
33403, 1.8666666666667, 1.58, 0.5
33404, 1.8666666666667, 1.62, 0.5
33405, 1.8666666666667, 1.66, 0.5
33406, 1.9083333333333, 1.54, 0.5
33407, 1.9083333333333, 1.58, 0.5
33408, 1.9083333333333, 1.62, 0.5
33409, 1.9083333333333, 1.66, 0.5
33410, 1.95, 1.54, 0.5
33411, 1.95, 1.58, 0.5
33412, 1.95, 1.62, 0.5
33413, 1.95, 1.66, 0.5
33414, 1.9916666666667, 1.54, 0.5
33415, 1.9916666666667, 1.58, 0.5
33416, 1.9916666666667, 1.62, 0.5
33417, 1.9916666666667, 1.66, 0.5
33418, 2.0333333333333, 1.54, 0.5
33419, 2.0333333333333, 1.58, 0.5
33420, 2.0333333333333, 1.62, 0.5
33421, 2.0333333333333, 1.66, 0.5
33422, 2.075, 1.54, 0.5
33423, 2.075, 1.58, 0.5
33424, 2.075, 1.62, 0.5
33425, 2.075, 1.66, 0.5
33426, 2.1166666666667, 1.54, 0.5
33427, 2.1166666666667, 1.58, 0.5
33428, 2.1166666666667, 1.62, 0.5
33429, 2.1166666666667, 1.66, 0.5
33430, 2.1583333333333, 1.54, 0.5
33431, 2.1583333333333, 1.58, 0.5
33432, 2.1583333333333, 1.62, 0.5
33433, 2.1583333333333, 1.66, 0.5
33434, 1.2416666666667, 1.52, 0.5
33435, 1.2208333333333, 1.54, 0.5
33436, 1.2416666666667, 1.56, 0.5
33437, 1.2208333333333, 1.58, 0.5
33438, 1.2416666666667, 1.6, 0.5
33439, 1.2208333333333, 1.62, 0.5
33440, 1.2416666666667, 1.64, 0.5
33441, 1.2208333333333, 1.66, 0.5
33442, 1.2416666666667, 1.68, 0.5
33443, 1.2833333333333, 1.52, 0.5
33444, 1.2625, 1.54, 0.5
33445, 1.2833333333333, 1.56, 0.5
33446, 1.2625, 1.58, 0.5
33447, 1.2833333333333, 1.6, 0.5
33448, 1.2625, 1.62, 0.5
33449, 1.2833333333333, 1.64, 0.5
33450, 1.2625, 1.66, 0.5
33451, 1.2833333333333, 1.68, 0.5
33452, 1.325, 1.52, 0.5
33453, 1.3041666666667, 1.54, 0.5
33454, 1.325, 1.56, 0.5
33455, 1.3041666666667, 1.58, 0.5
33456, 1.325, 1.6, 0.5
33457, 1.3041666666667, 1.62, 0.5
33458, 1.325, 1.64, 0.5
33459, 1.3041666666667, 1.66, 0.5
33460, 1.325, 1.68, 0.5
33461, 1.3666666666667, 1.52, 0.5
33462, 1.3458333333333, 1.54, 0.5
33463, 1.3666666666667, 1.56, 0.5
33464, 1.3458333333333, 1.58, 0.5
33465, 1.3666666666667, 1.6, 0.5
33466, 1.3458333333333, 1.62, 0.5
33467, 1.3666666666667, 1.64, 0.5
33468, 1.3458333333333, 1.66, 0.5
33469, 1.3666666666667, 1.68, 0.5
33470, 1.4083333333333, 1.52, 0.5
33471, 1.3875, 1.54, 0.5
33472, 1.4083333333333, 1.56, 0.5
33473, 1.3875, 1.58, 0.5
33474, 1.4083333333333, 1.6, 0.5
33475, 1.3875, 1.62, 0.5
33476, 1.4083333333333, 1.64, 0.5
33477, 1.3875, 1.66, 0.5
33478, 1.4083333333333, 1.68, 0.5
33479, 1.45, 1.52, 0.5
33480, 1.4291666666667, 1.54, 0.5
33481, 1.45, 1.56, 0.5
33482, 1.4291666666667, 1.58, 0.5
33483, 1.45, 1.6, 0.5
33484, 1.4291666666667, 1.62, 0.5
33485, 1.45, 1.64, 0.5
33486, 1.4291666666667, 1.66, 0.5
33487, 1.45, 1.68, 0.5
33488, 1.4916666666667, 1.52, 0.5
33489, 1.4708333333333, 1.54, 0.5
33490, 1.4916666666667, 1.56, 0.5
33491, 1.4708333333333, 1.58, 0.5
33492, 1.4916666666667, 1.6, 0.5
33493, 1.4708333333333, 1.62, 0.5
33494, 1.4916666666667, 1.64, 0.5
33495, 1.4708333333333, 1.66, 0.5
33496, 1.4916666666667, 1.68, 0.5
33497, 1.5333333333333, 1.52, 0.5
33498, 1.5125, 1.54, 0.5
33499, 1.5333333333333, 1.56, 0.5
33500, 1.5125, 1.58, 0.5
33501, 1.5333333333333, 1.6, 0.5
33502, 1.5125, 1.62, 0.5
33503, 1.5333333333333, 1.64, 0.5
33504, 1.5125, 1.66, 0.5
33505, 1.5333333333333, 1.68, 0.5
33506, 1.575, 1.52, 0.5
33507, 1.5541666666667, 1.54, 0.5
33508, 1.575, 1.56, 0.5
33509, 1.5541666666667, 1.58, 0.5
33510, 1.575, 1.6, 0.5
33511, 1.5541666666667, 1.62, 0.5
33512, 1.575, 1.64, 0.5
33513, 1.5541666666667, 1.66, 0.5
33514, 1.575, 1.68, 0.5
33515, 1.6166666666667, 1.52, 0.5
33516, 1.5958333333333, 1.54, 0.5
33517, 1.6166666666667, 1.56, 0.5
33518, 1.5958333333333, 1.58, 0.5
33519, 1.6166666666667, 1.6, 0.5
33520, 1.5958333333333, 1.62, 0.5
33521, 1.6166666666667, 1.64, 0.5
33522, 1.5958333333333, 1.66, 0.5
33523, 1.6166666666667, 1.68, 0.5
33524, 1.6583333333333, 1.52, 0.5
33525, 1.6375, 1.54, 0.5
33526, 1.6583333333333, 1.56, 0.5
33527, 1.6375, 1.58, 0.5
33528, 1.6583333333333, 1.6, 0.5
33529, 1.6375, 1.62, 0.5
33530, 1.6583333333333, 1.64, 0.5
33531, 1.6375, 1.66, 0.5
33532, 1.6583333333333, 1.68, 0.5
33533, 1.7, 1.52, 0.5
33534, 1.6791666666667, 1.54, 0.5
33535, 1.7, 1.56, 0.5
33536, 1.6791666666667, 1.58, 0.5
33537, 1.7, 1.6, 0.5
33538, 1.6791666666667, 1.62, 0.5
33539, 1.7, 1.64, 0.5
33540, 1.6791666666667, 1.66, 0.5
33541, 1.7, 1.68, 0.5
33542, 1.7416666666667, 1.52, 0.5
33543, 1.7208333333333, 1.54, 0.5
33544, 1.7416666666667, 1.56, 0.5
33545, 1.7208333333333, 1.58, 0.5
33546, 1.7416666666667, 1.6, 0.5
33547, 1.7208333333333, 1.62, 0.5
33548, 1.7416666666667, 1.64, 0.5
33549, 1.7208333333333, 1.66, 0.5
33550, 1.7416666666667, 1.68, 0.5
33551, 1.7833333333333, 1.52, 0.5
33552, 1.7625, 1.54, 0.5
33553, 1.7833333333333, 1.56, 0.5
33554, 1.7625, 1.58, 0.5
33555, 1.7833333333333, 1.6, 0.5
33556, 1.7625, 1.62, 0.5
33557, 1.7833333333333, 1.64, 0.5
33558, 1.7625, 1.66, 0.5
33559, 1.7833333333333, 1.68, 0.5
33560, 1.825, 1.52, 0.5
33561, 1.8041666666667, 1.54, 0.5
33562, 1.825, 1.56, 0.5
33563, 1.8041666666667, 1.58, 0.5
33564, 1.825, 1.6, 0.5
33565, 1.8041666666667, 1.62, 0.5
33566, 1.825, 1.64, 0.5
33567, 1.8041666666667, 1.66, 0.5
33568, 1.825, 1.68, 0.5
33569, 1.8666666666667, 1.52, 0.5
33570, 1.8458333333333, 1.54, 0.5
33571, 1.8666666666667, 1.56, 0.5
33572, 1.8458333333333, 1.58, 0.5
33573, 1.8666666666667, 1.6, 0.5
33574, 1.8458333333333, 1.62, 0.5
33575, 1.8666666666667, 1.64, 0.5
33576, 1.8458333333333, 1.66, 0.5
33577, 1.8666666666667, 1.68, 0.5
33578, 1.9083333333333, 1.52, 0.5
33579, 1.8875, 1.54, 0.5
33580, 1.9083333333333, 1.56, 0.5
33581, 1.8875, 1.58, 0.5
33582, 1.9083333333333, 1.6, 0.5
33583, 1.8875, 1.62, 0.5
33584, 1.9083333333333, 1.64, 0.5
33585, 1.8875, 1.66, 0.5
33586, 1.9083333333333, 1.68, 0.5
33587, 1.95, 1.52, 0.5
33588, 1.9291666666667, 1.54, 0.5
33589, 1.95, 1.56, 0.5
33590, 1.9291666666667, 1.58, 0.5
33591, 1.95, 1.6, 0.5
33592, 1.9291666666667, 1.62, 0.5
33593, 1.95, 1.64, 0.5
33594, 1.9291666666667, 1.66, 0.5
33595, 1.95, 1.68, 0.5
33596, 1.9916666666667, 1.52, 0.5
33597, 1.9708333333333, 1.54, 0.5
33598, 1.9916666666667, 1.56, 0.5
33599, 1.9708333333333, 1.58, 0.5
33600, 1.9916666666667, 1.6, 0.5
33601, 1.9708333333333, 1.62, 0.5
33602, 1.9916666666667, 1.64, 0.5
33603, 1.9708333333333, 1.66, 0.5
33604, 1.9916666666667, 1.68, 0.5
33605, 2.0333333333333, 1.52, 0.5
33606, 2.0125, 1.54, 0.5
33607, 2.0333333333333, 1.56, 0.5
33608, 2.0125, 1.58, 0.5
33609, 2.0333333333333, 1.6, 0.5
33610, 2.0125, 1.62, 0.5
33611, 2.0333333333333, 1.64, 0.5
33612, 2.0125, 1.66, 0.5
33613, 2.0333333333333, 1.68, 0.5
33614, 2.075, 1.52, 0.5
33615, 2.0541666666667, 1.54, 0.5
33616, 2.075, 1.56, 0.5
33617, 2.0541666666667, 1.58, 0.5
33618, 2.075, 1.6, 0.5
33619, 2.0541666666667, 1.62, 0.5
33620, 2.075, 1.64, 0.5
33621, 2.0541666666667, 1.66, 0.5
33622, 2.075, 1.68, 0.5
33623, 2.1166666666667, 1.52, 0.5
33624, 2.0958333333333, 1.54, 0.5
33625, 2.1166666666667, 1.56, 0.5
33626, 2.0958333333333, 1.58, 0.5
33627, 2.1166666666667, 1.6, 0.5
33628, 2.0958333333333, 1.62, 0.5
33629, 2.1166666666667, 1.64, 0.5
33630, 2.0958333333333, 1.66, 0.5
33631, 2.1166666666667, 1.68, 0.5
33632, 2.1583333333333, 1.52, 0.5
33633, 2.1375, 1.54, 0.5
33634, 2.1583333333333, 1.56, 0.5
33635, 2.1375, 1.58, 0.5
33636, 2.1583333333333, 1.6, 0.5
33637, 2.1375, 1.62, 0.5
33638, 2.1583333333333, 1.64, 0.5
33639, 2.1375, 1.66, 0.5
33640, 2.1583333333333, 1.68, 0.5
33641, 2.1791666666667, 1.54, 0.5
33642, 2.1791666666667, 1.58, 0.5
33643, 2.1791666666667, 1.62, 0.5
33644, 2.1791666666667, 1.66, 0.5
33645, 1.2416666666667, 1.54, 0
33646, 1.2416666666667, 1.58, 0
33647, 1.2416666666667, 1.62, 0
33648, 1.2416666666667, 1.66, 0
33649, 1.2833333333333, 1.54, 0
33650, 1.2833333333333, 1.58, 0
33651, 1.2833333333333, 1.62, 0
33652, 1.2833333333333, 1.66, 0
33653, 1.325, 1.54, 0
33654, 1.325, 1.58, 0
33655, 1.325, 1.62, 0
33656, 1.325, 1.66, 0
33657, 1.3666666666667, 1.54, 0
33658, 1.3666666666667, 1.58, 0
33659, 1.3666666666667, 1.62, 0
33660, 1.3666666666667, 1.66, 0
33661, 1.4083333333333, 1.54, 0
33662, 1.4083333333333, 1.58, 0
33663, 1.4083333333333, 1.62, 0
33664, 1.4083333333333, 1.66, 0
33665, 1.45, 1.54, 0
33666, 1.45, 1.58, 0
33667, 1.45, 1.62, 0
33668, 1.45, 1.66, 0
33669, 1.4916666666667, 1.54, 0
33670, 1.4916666666667, 1.58, 0
33671, 1.4916666666667, 1.62, 0
33672, 1.4916666666667, 1.66, 0
33673, 1.5333333333333, 1.54, 0
33674, 1.5333333333333, 1.58, 0
33675, 1.5333333333333, 1.62, 0
33676, 1.5333333333333, 1.66, 0
33677, 1.575, 1.54, 0
33678, 1.575, 1.58, 0
33679, 1.575, 1.62, 0
33680, 1.575, 1.66, 0
33681, 1.6166666666667, 1.54, 0
33682, 1.6166666666667, 1.58, 0
33683, 1.6166666666667, 1.62, 0
33684, 1.6166666666667, 1.66, 0
33685, 1.6583333333333, 1.54, 0
33686, 1.6583333333333, 1.58, 0
33687, 1.6583333333333, 1.62, 0
33688, 1.6583333333333, 1.66, 0
33689, 1.7, 1.54, 0
33690, 1.7, 1.58, 0
33691, 1.7, 1.62, 0
33692, 1.7, 1.66, 0
33693, 1.7416666666667, 1.54, 0
33694, 1.7416666666667, 1.58, 0
33695, 1.7416666666667, 1.62, 0
33696, 1.7416666666667, 1.66, 0
33697, 1.7833333333333, 1.54, 0
33698, 1.7833333333333, 1.58, 0
33699, 1.7833333333333, 1.62, 0
33700, 1.7833333333333, 1.66, 0
33701, 1.825, 1.54, 0
33702, 1.825, 1.58, 0
33703, 1.825, 1.62, 0
33704, 1.825, 1.66, 0
33705, 1.8666666666667, 1.54, 0
33706, 1.8666666666667, 1.58, 0
33707, 1.8666666666667, 1.62, 0
33708, 1.8666666666667, 1.66, 0
33709, 1.9083333333333, 1.54, 0
33710, 1.9083333333333, 1.58, 0
33711, 1.9083333333333, 1.62, 0
33712, 1.9083333333333, 1.66, 0
33713, 1.95, 1.54, 0
33714, 1.95, 1.58, 0
33715, 1.95, 1.62, 0
33716, 1.95, 1.66, 0
33717, 1.9916666666667, 1.54, 0
33718, 1.9916666666667, 1.58, 0
33719, 1.9916666666667, 1.62, 0
33720, 1.9916666666667, 1.66, 0
33721, 2.0333333333333, 1.54, 0
33722, 2.0333333333333, 1.58, 0
33723, 2.0333333333333, 1.62, 0
33724, 2.0333333333333, 1.66, 0
33725, 2.075, 1.54, 0
33726, 2.075, 1.58, 0
33727, 2.075, 1.62, 0
33728, 2.075, 1.66, 0
33729, 2.1166666666667, 1.54, 0
33730, 2.1166666666667, 1.58, 0
33731, 2.1166666666667, 1.62, 0
33732, 2.1166666666667, 1.66, 0
33733, 2.1583333333333, 1.54, 0
33734, 2.1583333333333, 1.58, 0
33735, 2.1583333333333, 1.62, 0
33736, 2.1583333333333, 1.66, 0
33737, 1.2208333333333, 1.54, 0
33738, 1.2416666666667, 1.52, 0
33739, 1.2208333333333, 1.58, 0
33740, 1.2416666666667, 1.56, 0
33741, 1.2208333333333, 1.62, 0
33742, 1.2416666666667, 1.6, 0
33743, 1.2208333333333, 1.66, 0
33744, 1.2416666666667, 1.64, 0
33745, 1.2416666666667, 1.68, 0
33746, 1.2625, 1.54, 0
33747, 1.2833333333333, 1.52, 0
33748, 1.2625, 1.58, 0
33749, 1.2833333333333, 1.56, 0
33750, 1.2625, 1.62, 0
33751, 1.2833333333333, 1.6, 0
33752, 1.2625, 1.66, 0
33753, 1.2833333333333, 1.64, 0
33754, 1.2833333333333, 1.68, 0
33755, 1.3041666666667, 1.54, 0
33756, 1.325, 1.52, 0
33757, 1.3041666666667, 1.58, 0
33758, 1.325, 1.56, 0
33759, 1.3041666666667, 1.62, 0
33760, 1.325, 1.6, 0
33761, 1.3041666666667, 1.66, 0
33762, 1.325, 1.64, 0
33763, 1.325, 1.68, 0
33764, 1.3458333333333, 1.54, 0
33765, 1.3666666666667, 1.52, 0
33766, 1.3458333333333, 1.58, 0
33767, 1.3666666666667, 1.56, 0
33768, 1.3458333333333, 1.62, 0
33769, 1.3666666666667, 1.6, 0
33770, 1.3458333333333, 1.66, 0
33771, 1.3666666666667, 1.64, 0
33772, 1.3666666666667, 1.68, 0
33773, 1.3875, 1.54, 0
33774, 1.4083333333333, 1.52, 0
33775, 1.3875, 1.58, 0
33776, 1.4083333333333, 1.56, 0
33777, 1.3875, 1.62, 0
33778, 1.4083333333333, 1.6, 0
33779, 1.3875, 1.66, 0
33780, 1.4083333333333, 1.64, 0
33781, 1.4083333333333, 1.68, 0
33782, 1.4291666666667, 1.54, 0
33783, 1.45, 1.52, 0
33784, 1.4291666666667, 1.58, 0
33785, 1.45, 1.56, 0
33786, 1.4291666666667, 1.62, 0
33787, 1.45, 1.6, 0
33788, 1.4291666666667, 1.66, 0
33789, 1.45, 1.64, 0
33790, 1.45, 1.68, 0
33791, 1.4708333333333, 1.54, 0
33792, 1.4916666666667, 1.52, 0
33793, 1.4708333333333, 1.58, 0
33794, 1.4916666666667, 1.56, 0
33795, 1.4708333333333, 1.62, 0
33796, 1.4916666666667, 1.6, 0
33797, 1.4708333333333, 1.66, 0
33798, 1.4916666666667, 1.64, 0
33799, 1.4916666666667, 1.68, 0
33800, 1.5125, 1.54, 0
33801, 1.5333333333333, 1.52, 0
33802, 1.5125, 1.58, 0
33803, 1.5333333333333, 1.56, 0
33804, 1.5125, 1.62, 0
33805, 1.5333333333333, 1.6, 0
33806, 1.5125, 1.66, 0
33807, 1.5333333333333, 1.64, 0
33808, 1.5333333333333, 1.68, 0
33809, 1.5541666666667, 1.54, 0
33810, 1.575, 1.52, 0
33811, 1.5541666666667, 1.58, 0
33812, 1.575, 1.56, 0
33813, 1.5541666666667, 1.62, 0
33814, 1.575, 1.6, 0
33815, 1.5541666666667, 1.66, 0
33816, 1.575, 1.64, 0
33817, 1.575, 1.68, 0
33818, 1.5958333333333, 1.54, 0
33819, 1.6166666666667, 1.52, 0
33820, 1.5958333333333, 1.58, 0
33821, 1.6166666666667, 1.56, 0
33822, 1.5958333333333, 1.62, 0
33823, 1.6166666666667, 1.6, 0
33824, 1.5958333333333, 1.66, 0
33825, 1.6166666666667, 1.64, 0
33826, 1.6166666666667, 1.68, 0
33827, 1.6375, 1.54, 0
33828, 1.6583333333333, 1.52, 0
33829, 1.6375, 1.58, 0
33830, 1.6583333333333, 1.56, 0
33831, 1.6375, 1.62, 0
33832, 1.6583333333333, 1.6, 0
33833, 1.6375, 1.66, 0
33834, 1.6583333333333, 1.64, 0
33835, 1.6583333333333, 1.68, 0
33836, 1.6791666666667, 1.54, 0
33837, 1.7, 1.52, 0
33838, 1.6791666666667, 1.58, 0
33839, 1.7, 1.56, 0
33840, 1.6791666666667, 1.62, 0
33841, 1.7, 1.6, 0
33842, 1.6791666666667, 1.66, 0
33843, 1.7, 1.64, 0
33844, 1.7, 1.68, 0
33845, 1.7208333333333, 1.54, 0
33846, 1.7416666666667, 1.52, 0
33847, 1.7208333333333, 1.58, 0
33848, 1.7416666666667, 1.56, 0
33849, 1.7208333333333, 1.62, 0
33850, 1.7416666666667, 1.6, 0
33851, 1.7208333333333, 1.66, 0
33852, 1.7416666666667, 1.64, 0
33853, 1.7416666666667, 1.68, 0
33854, 1.7625, 1.54, 0
33855, 1.7833333333333, 1.52, 0
33856, 1.7625, 1.58, 0
33857, 1.7833333333333, 1.56, 0
33858, 1.7625, 1.62, 0
33859, 1.7833333333333, 1.6, 0
33860, 1.7625, 1.66, 0
33861, 1.7833333333333, 1.64, 0
33862, 1.7833333333333, 1.68, 0
33863, 1.8041666666667, 1.54, 0
33864, 1.825, 1.52, 0
33865, 1.8041666666667, 1.58, 0
33866, 1.825, 1.56, 0
33867, 1.8041666666667, 1.62, 0
33868, 1.825, 1.6, 0
33869, 1.8041666666667, 1.66, 0
33870, 1.825, 1.64, 0
33871, 1.825, 1.68, 0
33872, 1.8458333333333, 1.54, 0
33873, 1.8666666666667, 1.52, 0
33874, 1.8458333333333, 1.58, 0
33875, 1.8666666666667, 1.56, 0
33876, 1.8458333333333, 1.62, 0
33877, 1.8666666666667, 1.6, 0
33878, 1.8458333333333, 1.66, 0
33879, 1.8666666666667, 1.64, 0
33880, 1.8666666666667, 1.68, 0
33881, 1.8875, 1.54, 0
33882, 1.9083333333333, 1.52, 0
33883, 1.8875, 1.58, 0
33884, 1.9083333333333, 1.56, 0
33885, 1.8875, 1.62, 0
33886, 1.9083333333333, 1.6, 0
33887, 1.8875, 1.66, 0
33888, 1.9083333333333, 1.64, 0
33889, 1.9083333333333, 1.68, 0
33890, 1.9291666666667, 1.54, 0
33891, 1.95, 1.52, 0
33892, 1.9291666666667, 1.58, 0
33893, 1.95, 1.56, 0
33894, 1.9291666666667, 1.62, 0
33895, 1.95, 1.6, 0
33896, 1.9291666666667, 1.66, 0
33897, 1.95, 1.64, 0
33898, 1.95, 1.68, 0
33899, 1.9708333333333, 1.54, 0
33900, 1.9916666666667, 1.52, 0
33901, 1.9708333333333, 1.58, 0
33902, 1.9916666666667, 1.56, 0
33903, 1.9708333333333, 1.62, 0
33904, 1.9916666666667, 1.6, 0
33905, 1.9708333333333, 1.66, 0
33906, 1.9916666666667, 1.64, 0
33907, 1.9916666666667, 1.68, 0
33908, 2.0125, 1.54, 0
33909, 2.0333333333333, 1.52, 0
33910, 2.0125, 1.58, 0
33911, 2.0333333333333, 1.56, 0
33912, 2.0125, 1.62, 0
33913, 2.0333333333333, 1.6, 0
33914, 2.0125, 1.66, 0
33915, 2.0333333333333, 1.64, 0
33916, 2.0333333333333, 1.68, 0
33917, 2.0541666666667, 1.54, 0
33918, 2.075, 1.52, 0
33919, 2.0541666666667, 1.58, 0
33920, 2.075, 1.56, 0
33921, 2.0541666666667, 1.62, 0
33922, 2.075, 1.6, 0
33923, 2.0541666666667, 1.66, 0
33924, 2.075, 1.64, 0
33925, 2.075, 1.68, 0
33926, 2.0958333333333, 1.54, 0
33927, 2.1166666666667, 1.52, 0
33928, 2.0958333333333, 1.58, 0
33929, 2.1166666666667, 1.56, 0
33930, 2.0958333333333, 1.62, 0
33931, 2.1166666666667, 1.6, 0
33932, 2.0958333333333, 1.66, 0
33933, 2.1166666666667, 1.64, 0
33934, 2.1166666666667, 1.68, 0
33935, 2.1375, 1.54, 0
33936, 2.1583333333333, 1.52, 0
33937, 2.1375, 1.58, 0
33938, 2.1583333333333, 1.56, 0
33939, 2.1375, 1.62, 0
33940, 2.1583333333333, 1.6, 0
33941, 2.1375, 1.66, 0
33942, 2.1583333333333, 1.64, 0
33943, 2.1583333333333, 1.68, 0
33944, 2.1791666666667, 1.54, 0
33945, 2.1791666666667, 1.58, 0
33946, 2.1791666666667, 1.62, 0
33947, 2.1791666666667, 1.66, 0
33948, 2.2, 1.54, 0.041666666666667
33949, 2.2, 1.58, 0.041666666666667
33950, 2.2, 1.62, 0.041666666666667
33951, 2.2, 1.66, 0.041666666666667
33952, 2.2, 1.54, 0.083333333333333
33953, 2.2, 1.58, 0.083333333333333
33954, 2.2, 1.62, 0.083333333333333
33955, 2.2, 1.66, 0.083333333333333
33956, 2.2, 1.54, 0.125
33957, 2.2, 1.58, 0.125
33958, 2.2, 1.62, 0.125
33959, 2.2, 1.66, 0.125
33960, 2.2, 1.54, 0.16666666666667
33961, 2.2, 1.58, 0.16666666666667
33962, 2.2, 1.62, 0.16666666666667
33963, 2.2, 1.66, 0.16666666666667
33964, 2.2, 1.54, 0.20833333333333
33965, 2.2, 1.58, 0.20833333333333
33966, 2.2, 1.62, 0.20833333333333
33967, 2.2, 1.66, 0.20833333333333
33968, 2.2, 1.54, 0.25
33969, 2.2, 1.58, 0.25
33970, 2.2, 1.62, 0.25
33971, 2.2, 1.66, 0.25
33972, 2.2, 1.54, 0.29166666666667
33973, 2.2, 1.58, 0.29166666666667
33974, 2.2, 1.62, 0.29166666666667
33975, 2.2, 1.66, 0.29166666666667
33976, 2.2, 1.54, 0.33333333333333
33977, 2.2, 1.58, 0.33333333333333
33978, 2.2, 1.62, 0.33333333333333
33979, 2.2, 1.66, 0.33333333333333
33980, 2.2, 1.54, 0.375
33981, 2.2, 1.58, 0.375
33982, 2.2, 1.62, 0.375
33983, 2.2, 1.66, 0.375
33984, 2.2, 1.54, 0.41666666666667
33985, 2.2, 1.58, 0.41666666666667
33986, 2.2, 1.62, 0.41666666666667
33987, 2.2, 1.66, 0.41666666666667
33988, 2.2, 1.54, 0.45833333333333
33989, 2.2, 1.58, 0.45833333333333
33990, 2.2, 1.62, 0.45833333333333
33991, 2.2, 1.66, 0.45833333333333
33992, 2.2, 1.54, 0.020833333333333
33993, 2.2, 1.52, 0.041666666666667
33994, 2.2, 1.58, 0.020833333333333
33995, 2.2, 1.56, 0.041666666666667
33996, 2.2, 1.62, 0.020833333333333
33997, 2.2, 1.6, 0.041666666666667
33998, 2.2, 1.66, 0.020833333333333
33999, 2.2, 1.64, 0.041666666666667
34000, 2.2, 1.68, 0.041666666666667
34001, 2.2, 1.54, 0.0625
34002, 2.2, 1.52, 0.083333333333333
34003, 2.2, 1.58, 0.0625
34004, 2.2, 1.56, 0.083333333333333
34005, 2.2, 1.62, 0.0625
34006, 2.2, 1.6, 0.083333333333333
34007, 2.2, 1.66, 0.0625
34008, 2.2, 1.64, 0.083333333333333
34009, 2.2, 1.68, 0.083333333333333
34010, 2.2, 1.54, 0.10416666666667
34011, 2.2, 1.52, 0.125
34012, 2.2, 1.58, 0.10416666666667
34013, 2.2, 1.56, 0.125
34014, 2.2, 1.62, 0.10416666666667
34015, 2.2, 1.6, 0.125
34016, 2.2, 1.66, 0.10416666666667
34017, 2.2, 1.64, 0.125
34018, 2.2, 1.68, 0.125
34019, 2.2, 1.54, 0.14583333333333
34020, 2.2, 1.52, 0.16666666666667
34021, 2.2, 1.58, 0.14583333333333
34022, 2.2, 1.56, 0.16666666666667
34023, 2.2, 1.62, 0.14583333333333
34024, 2.2, 1.6, 0.16666666666667
34025, 2.2, 1.66, 0.14583333333333
34026, 2.2, 1.64, 0.16666666666667
34027, 2.2, 1.68, 0.16666666666667
34028, 2.2, 1.54, 0.1875
34029, 2.2, 1.52, 0.20833333333333
34030, 2.2, 1.58, 0.1875
34031, 2.2, 1.56, 0.20833333333333
34032, 2.2, 1.62, 0.1875
34033, 2.2, 1.6, 0.20833333333333
34034, 2.2, 1.66, 0.1875
34035, 2.2, 1.64, 0.20833333333333
34036, 2.2, 1.68, 0.20833333333333
34037, 2.2, 1.54, 0.22916666666667
34038, 2.2, 1.52, 0.25
34039, 2.2, 1.58, 0.22916666666667
34040, 2.2, 1.56, 0.25
34041, 2.2, 1.62, 0.22916666666667
34042, 2.2, 1.6, 0.25
34043, 2.2, 1.66, 0.22916666666667
34044, 2.2, 1.64, 0.25
34045, 2.2, 1.68, 0.25
34046, 2.2, 1.54, 0.27083333333333
34047, 2.2, 1.52, 0.29166666666667
34048, 2.2, 1.58, 0.27083333333333
34049, 2.2, 1.56, 0.29166666666667
34050, 2.2, 1.62, 0.27083333333333
34051, 2.2, 1.6, 0.29166666666667
34052, 2.2, 1.66, 0.27083333333333
34053, 2.2, 1.64, 0.29166666666667
34054, 2.2, 1.68, 0.29166666666667
34055, 2.2, 1.54, 0.3125
34056, 2.2, 1.52, 0.33333333333333
34057, 2.2, 1.58, 0.3125
34058, 2.2, 1.56, 0.33333333333333
34059, 2.2, 1.62, 0.3125
34060, 2.2, 1.6, 0.33333333333333
34061, 2.2, 1.66, 0.3125
34062, 2.2, 1.64, 0.33333333333333
34063, 2.2, 1.68, 0.33333333333333
34064, 2.2, 1.54, 0.35416666666667
34065, 2.2, 1.52, 0.375
34066, 2.2, 1.58, 0.35416666666667
34067, 2.2, 1.56, 0.375
34068, 2.2, 1.62, 0.35416666666667
34069, 2.2, 1.6, 0.375
34070, 2.2, 1.66, 0.35416666666667
34071, 2.2, 1.64, 0.375
34072, 2.2, 1.68, 0.375
34073, 2.2, 1.54, 0.39583333333333
34074, 2.2, 1.52, 0.41666666666667
34075, 2.2, 1.58, 0.39583333333333
34076, 2.2, 1.56, 0.41666666666667
34077, 2.2, 1.62, 0.39583333333333
34078, 2.2, 1.6, 0.41666666666667
34079, 2.2, 1.66, 0.39583333333333
34080, 2.2, 1.64, 0.41666666666667
34081, 2.2, 1.68, 0.41666666666667
34082, 2.2, 1.54, 0.4375
34083, 2.2, 1.52, 0.45833333333333
34084, 2.2, 1.58, 0.4375
34085, 2.2, 1.56, 0.45833333333333
34086, 2.2, 1.62, 0.4375
34087, 2.2, 1.6, 0.45833333333333
34088, 2.2, 1.66, 0.4375
34089, 2.2, 1.64, 0.45833333333333
34090, 2.2, 1.68, 0.45833333333333
34091, 2.2, 1.54, 0.47916666666667
34092, 2.2, 1.58, 0.47916666666667
34093, 2.2, 1.62, 0.47916666666667
34094, 2.2, 1.66, 0.47916666666667
34095, 1.2416666666667, 1.7, 0.041666666666667
34096, 1.2833333333333, 1.7, 0.041666666666667
34097, 1.325, 1.7, 0.041666666666667
34098, 1.3666666666667, 1.7, 0.041666666666667
34099, 1.4083333333333, 1.7, 0.041666666666667
34100, 1.45, 1.7, 0.041666666666667
34101, 1.4916666666667, 1.7, 0.041666666666667
34102, 1.5333333333333, 1.7, 0.041666666666667
34103, 1.575, 1.7, 0.041666666666667
34104, 1.6166666666667, 1.7, 0.041666666666667
34105, 1.6583333333333, 1.7, 0.041666666666667
34106, 1.7, 1.7, 0.041666666666667
34107, 1.7416666666667, 1.7, 0.041666666666667
34108, 1.7833333333333, 1.7, 0.041666666666667
34109, 1.825, 1.7, 0.041666666666667
34110, 1.8666666666667, 1.7, 0.041666666666667
34111, 1.9083333333333, 1.7, 0.041666666666667
34112, 1.95, 1.7, 0.041666666666667
34113, 1.9916666666667, 1.7, 0.041666666666667
34114, 2.0333333333333, 1.7, 0.041666666666667
34115, 2.075, 1.7, 0.041666666666667
34116, 2.1166666666667, 1.7, 0.041666666666667
34117, 2.1583333333333, 1.7, 0.041666666666667
34118, 1.2416666666667, 1.7, 0.083333333333333
34119, 1.2833333333333, 1.7, 0.083333333333333
34120, 1.325, 1.7, 0.083333333333333
34121, 1.3666666666667, 1.7, 0.083333333333333
34122, 1.4083333333333, 1.7, 0.083333333333333
34123, 1.45, 1.7, 0.083333333333333
34124, 1.4916666666667, 1.7, 0.083333333333333
34125, 1.5333333333333, 1.7, 0.083333333333333
34126, 1.575, 1.7, 0.083333333333333
34127, 1.6166666666667, 1.7, 0.083333333333333
34128, 1.6583333333333, 1.7, 0.083333333333333
34129, 1.7, 1.7, 0.083333333333333
34130, 1.7416666666667, 1.7, 0.083333333333333
34131, 1.7833333333333, 1.7, 0.083333333333333
34132, 1.825, 1.7, 0.083333333333333
34133, 1.8666666666667, 1.7, 0.083333333333333
34134, 1.9083333333333, 1.7, 0.083333333333333
34135, 1.95, 1.7, 0.083333333333333
34136, 1.9916666666667, 1.7, 0.083333333333333
34137, 2.0333333333333, 1.7, 0.083333333333333
34138, 2.075, 1.7, 0.083333333333333
34139, 2.1166666666667, 1.7, 0.083333333333333
34140, 2.1583333333333, 1.7, 0.083333333333333
34141, 1.2416666666667, 1.7, 0.125
34142, 1.2833333333333, 1.7, 0.125
34143, 1.325, 1.7, 0.125
34144, 1.3666666666667, 1.7, 0.125
34145, 1.4083333333333, 1.7, 0.125
34146, 1.45, 1.7, 0.125
34147, 1.4916666666667, 1.7, 0.125
34148, 1.5333333333333, 1.7, 0.125
34149, 1.575, 1.7, 0.125
34150, 1.6166666666667, 1.7, 0.125
34151, 1.6583333333333, 1.7, 0.125
34152, 1.7, 1.7, 0.125
34153, 1.7416666666667, 1.7, 0.125
34154, 1.7833333333333, 1.7, 0.125
34155, 1.825, 1.7, 0.125
34156, 1.8666666666667, 1.7, 0.125
34157, 1.9083333333333, 1.7, 0.125
34158, 1.95, 1.7, 0.125
34159, 1.9916666666667, 1.7, 0.125
34160, 2.0333333333333, 1.7, 0.125
34161, 2.075, 1.7, 0.125
34162, 2.1166666666667, 1.7, 0.125
34163, 2.1583333333333, 1.7, 0.125
34164, 1.2416666666667, 1.7, 0.16666666666667
34165, 1.2833333333333, 1.7, 0.16666666666667
34166, 1.325, 1.7, 0.16666666666667
34167, 1.3666666666667, 1.7, 0.16666666666667
34168, 1.4083333333333, 1.7, 0.16666666666667
34169, 1.45, 1.7, 0.16666666666667
34170, 1.4916666666667, 1.7, 0.16666666666667
34171, 1.5333333333333, 1.7, 0.16666666666667
34172, 1.575, 1.7, 0.16666666666667
34173, 1.6166666666667, 1.7, 0.16666666666667
34174, 1.6583333333333, 1.7, 0.16666666666667
34175, 1.7, 1.7, 0.16666666666667
34176, 1.7416666666667, 1.7, 0.16666666666667
34177, 1.7833333333333, 1.7, 0.16666666666667
34178, 1.825, 1.7, 0.16666666666667
34179, 1.8666666666667, 1.7, 0.16666666666667
34180, 1.9083333333333, 1.7, 0.16666666666667
34181, 1.95, 1.7, 0.16666666666667
34182, 1.9916666666667, 1.7, 0.16666666666667
34183, 2.0333333333333, 1.7, 0.16666666666667
34184, 2.075, 1.7, 0.16666666666667
34185, 2.1166666666667, 1.7, 0.16666666666667
34186, 2.1583333333333, 1.7, 0.16666666666667
34187, 1.2416666666667, 1.7, 0.20833333333333
34188, 1.2833333333333, 1.7, 0.20833333333333
34189, 1.325, 1.7, 0.20833333333333
34190, 1.3666666666667, 1.7, 0.20833333333333
34191, 1.4083333333333, 1.7, 0.20833333333333
34192, 1.45, 1.7, 0.20833333333333
34193, 1.4916666666667, 1.7, 0.20833333333333
34194, 1.5333333333333, 1.7, 0.20833333333333
34195, 1.575, 1.7, 0.20833333333333
34196, 1.6166666666667, 1.7, 0.20833333333333
34197, 1.6583333333333, 1.7, 0.20833333333333
34198, 1.7, 1.7, 0.20833333333333
34199, 1.7416666666667, 1.7, 0.20833333333333
34200, 1.7833333333333, 1.7, 0.20833333333333
34201, 1.825, 1.7, 0.20833333333333
34202, 1.8666666666667, 1.7, 0.20833333333333
34203, 1.9083333333333, 1.7, 0.20833333333333
34204, 1.95, 1.7, 0.20833333333333
34205, 1.9916666666667, 1.7, 0.20833333333333
34206, 2.0333333333333, 1.7, 0.20833333333333
34207, 2.075, 1.7, 0.20833333333333
34208, 2.1166666666667, 1.7, 0.20833333333333
34209, 2.1583333333333, 1.7, 0.20833333333333
34210, 1.2416666666667, 1.7, 0.25
34211, 1.2833333333333, 1.7, 0.25
34212, 1.325, 1.7, 0.25
34213, 1.3666666666667, 1.7, 0.25
34214, 1.4083333333333, 1.7, 0.25
34215, 1.45, 1.7, 0.25
34216, 1.4916666666667, 1.7, 0.25
34217, 1.5333333333333, 1.7, 0.25
34218, 1.575, 1.7, 0.25
34219, 1.6166666666667, 1.7, 0.25
34220, 1.6583333333333, 1.7, 0.25
34221, 1.7, 1.7, 0.25
34222, 1.7416666666667, 1.7, 0.25
34223, 1.7833333333333, 1.7, 0.25
34224, 1.825, 1.7, 0.25
34225, 1.8666666666667, 1.7, 0.25
34226, 1.9083333333333, 1.7, 0.25
34227, 1.95, 1.7, 0.25
34228, 1.9916666666667, 1.7, 0.25
34229, 2.0333333333333, 1.7, 0.25
34230, 2.075, 1.7, 0.25
34231, 2.1166666666667, 1.7, 0.25
34232, 2.1583333333333, 1.7, 0.25
34233, 1.2416666666667, 1.7, 0.29166666666667
34234, 1.2833333333333, 1.7, 0.29166666666667
34235, 1.325, 1.7, 0.29166666666667
34236, 1.3666666666667, 1.7, 0.29166666666667
34237, 1.4083333333333, 1.7, 0.29166666666667
34238, 1.45, 1.7, 0.29166666666667
34239, 1.4916666666667, 1.7, 0.29166666666667
34240, 1.5333333333333, 1.7, 0.29166666666667
34241, 1.575, 1.7, 0.29166666666667
34242, 1.6166666666667, 1.7, 0.29166666666667
34243, 1.6583333333333, 1.7, 0.29166666666667
34244, 1.7, 1.7, 0.29166666666667
34245, 1.7416666666667, 1.7, 0.29166666666667
34246, 1.7833333333333, 1.7, 0.29166666666667
34247, 1.825, 1.7, 0.29166666666667
34248, 1.8666666666667, 1.7, 0.29166666666667
34249, 1.9083333333333, 1.7, 0.29166666666667
34250, 1.95, 1.7, 0.29166666666667
34251, 1.9916666666667, 1.7, 0.29166666666667
34252, 2.0333333333333, 1.7, 0.29166666666667
34253, 2.075, 1.7, 0.29166666666667
34254, 2.1166666666667, 1.7, 0.29166666666667
34255, 2.1583333333333, 1.7, 0.29166666666667
34256, 1.2416666666667, 1.7, 0.33333333333333
34257, 1.2833333333333, 1.7, 0.33333333333333
34258, 1.325, 1.7, 0.33333333333333
34259, 1.3666666666667, 1.7, 0.33333333333333
34260, 1.4083333333333, 1.7, 0.33333333333333
34261, 1.45, 1.7, 0.33333333333333
34262, 1.4916666666667, 1.7, 0.33333333333333
34263, 1.5333333333333, 1.7, 0.33333333333333
34264, 1.575, 1.7, 0.33333333333333
34265, 1.6166666666667, 1.7, 0.33333333333333
34266, 1.6583333333333, 1.7, 0.33333333333333
34267, 1.7, 1.7, 0.33333333333333
34268, 1.7416666666667, 1.7, 0.33333333333333
34269, 1.7833333333333, 1.7, 0.33333333333333
34270, 1.825, 1.7, 0.33333333333333
34271, 1.8666666666667, 1.7, 0.33333333333333
34272, 1.9083333333333, 1.7, 0.33333333333333
34273, 1.95, 1.7, 0.33333333333333
34274, 1.9916666666667, 1.7, 0.33333333333333
34275, 2.0333333333333, 1.7, 0.33333333333333
34276, 2.075, 1.7, 0.33333333333333
34277, 2.1166666666667, 1.7, 0.33333333333333
34278, 2.1583333333333, 1.7, 0.33333333333333
34279, 1.2416666666667, 1.7, 0.375
34280, 1.2833333333333, 1.7, 0.375
34281, 1.325, 1.7, 0.375
34282, 1.3666666666667, 1.7, 0.375
34283, 1.4083333333333, 1.7, 0.375
34284, 1.45, 1.7, 0.375
34285, 1.4916666666667, 1.7, 0.375
34286, 1.5333333333333, 1.7, 0.375
34287, 1.575, 1.7, 0.375
34288, 1.6166666666667, 1.7, 0.375
34289, 1.6583333333333, 1.7, 0.375
34290, 1.7, 1.7, 0.375
34291, 1.7416666666667, 1.7, 0.375
34292, 1.7833333333333, 1.7, 0.375
34293, 1.825, 1.7, 0.375
34294, 1.8666666666667, 1.7, 0.375
34295, 1.9083333333333, 1.7, 0.375
34296, 1.95, 1.7, 0.375
34297, 1.9916666666667, 1.7, 0.375
34298, 2.0333333333333, 1.7, 0.375
34299, 2.075, 1.7, 0.375
34300, 2.1166666666667, 1.7, 0.375
34301, 2.1583333333333, 1.7, 0.375
34302, 1.2416666666667, 1.7, 0.41666666666667
34303, 1.2833333333333, 1.7, 0.41666666666667
34304, 1.325, 1.7, 0.41666666666667
34305, 1.3666666666667, 1.7, 0.41666666666667
34306, 1.4083333333333, 1.7, 0.41666666666667
34307, 1.45, 1.7, 0.41666666666667
34308, 1.4916666666667, 1.7, 0.41666666666667
34309, 1.5333333333333, 1.7, 0.41666666666667
34310, 1.575, 1.7, 0.41666666666667
34311, 1.6166666666667, 1.7, 0.41666666666667
34312, 1.6583333333333, 1.7, 0.41666666666667
34313, 1.7, 1.7, 0.41666666666667
34314, 1.7416666666667, 1.7, 0.41666666666667
34315, 1.7833333333333, 1.7, 0.41666666666667
34316, 1.825, 1.7, 0.41666666666667
34317, 1.8666666666667, 1.7, 0.41666666666667
34318, 1.9083333333333, 1.7, 0.41666666666667
34319, 1.95, 1.7, 0.41666666666667
34320, 1.9916666666667, 1.7, 0.41666666666667
34321, 2.0333333333333, 1.7, 0.41666666666667
34322, 2.075, 1.7, 0.41666666666667
34323, 2.1166666666667, 1.7, 0.41666666666667
34324, 2.1583333333333, 1.7, 0.41666666666667
34325, 1.2416666666667, 1.7, 0.45833333333333
34326, 1.2833333333333, 1.7, 0.45833333333333
34327, 1.325, 1.7, 0.45833333333333
34328, 1.3666666666667, 1.7, 0.45833333333333
34329, 1.4083333333333, 1.7, 0.45833333333333
34330, 1.45, 1.7, 0.45833333333333
34331, 1.4916666666667, 1.7, 0.45833333333333
34332, 1.5333333333333, 1.7, 0.45833333333333
34333, 1.575, 1.7, 0.45833333333333
34334, 1.6166666666667, 1.7, 0.45833333333333
34335, 1.6583333333333, 1.7, 0.45833333333333
34336, 1.7, 1.7, 0.45833333333333
34337, 1.7416666666667, 1.7, 0.45833333333333
34338, 1.7833333333333, 1.7, 0.45833333333333
34339, 1.825, 1.7, 0.45833333333333
34340, 1.8666666666667, 1.7, 0.45833333333333
34341, 1.9083333333333, 1.7, 0.45833333333333
34342, 1.95, 1.7, 0.45833333333333
34343, 1.9916666666667, 1.7, 0.45833333333333
34344, 2.0333333333333, 1.7, 0.45833333333333
34345, 2.075, 1.7, 0.45833333333333
34346, 2.1166666666667, 1.7, 0.45833333333333
34347, 2.1583333333333, 1.7, 0.45833333333333
34348, 1.2208333333333, 1.7, 0.041666666666667
34349, 1.2416666666667, 1.7, 0.020833333333333
34350, 1.2625, 1.7, 0.041666666666667
34351, 1.2833333333333, 1.7, 0.020833333333333
34352, 1.3041666666667, 1.7, 0.041666666666667
34353, 1.325, 1.7, 0.020833333333333
34354, 1.3458333333333, 1.7, 0.041666666666667
34355, 1.3666666666667, 1.7, 0.020833333333333
34356, 1.3875, 1.7, 0.041666666666667
34357, 1.4083333333333, 1.7, 0.020833333333333
34358, 1.4291666666667, 1.7, 0.041666666666667
34359, 1.45, 1.7, 0.020833333333333
34360, 1.4708333333333, 1.7, 0.041666666666667
34361, 1.4916666666667, 1.7, 0.020833333333333
34362, 1.5125, 1.7, 0.041666666666667
34363, 1.5333333333333, 1.7, 0.020833333333333
34364, 1.5541666666667, 1.7, 0.041666666666667
34365, 1.575, 1.7, 0.020833333333333
34366, 1.5958333333333, 1.7, 0.041666666666667
34367, 1.6166666666667, 1.7, 0.020833333333333
34368, 1.6375, 1.7, 0.041666666666667
34369, 1.6583333333333, 1.7, 0.020833333333333
34370, 1.6791666666667, 1.7, 0.041666666666667
34371, 1.7, 1.7, 0.020833333333333
34372, 1.7208333333333, 1.7, 0.041666666666667
34373, 1.7416666666667, 1.7, 0.020833333333333
34374, 1.7625, 1.7, 0.041666666666667
34375, 1.7833333333333, 1.7, 0.020833333333333
34376, 1.8041666666667, 1.7, 0.041666666666667
34377, 1.825, 1.7, 0.020833333333333
34378, 1.8458333333333, 1.7, 0.041666666666667
34379, 1.8666666666667, 1.7, 0.020833333333333
34380, 1.8875, 1.7, 0.041666666666667
34381, 1.9083333333333, 1.7, 0.020833333333333
34382, 1.9291666666667, 1.7, 0.041666666666667
34383, 1.95, 1.7, 0.020833333333333
34384, 1.9708333333333, 1.7, 0.041666666666667
34385, 1.9916666666667, 1.7, 0.020833333333333
34386, 2.0125, 1.7, 0.041666666666667
34387, 2.0333333333333, 1.7, 0.020833333333333
34388, 2.0541666666667, 1.7, 0.041666666666667
34389, 2.075, 1.7, 0.020833333333333
34390, 2.0958333333333, 1.7, 0.041666666666667
34391, 2.1166666666667, 1.7, 0.020833333333333
34392, 2.1375, 1.7, 0.041666666666667
34393, 2.1583333333333, 1.7, 0.020833333333333
34394, 2.1791666666667, 1.7, 0.041666666666667
34395, 1.2208333333333, 1.7, 0.083333333333333
34396, 1.2416666666667, 1.7, 0.0625
34397, 1.2625, 1.7, 0.083333333333333
34398, 1.2833333333333, 1.7, 0.0625
34399, 1.3041666666667, 1.7, 0.083333333333333
34400, 1.325, 1.7, 0.0625
34401, 1.3458333333333, 1.7, 0.083333333333333
34402, 1.3666666666667, 1.7, 0.0625
34403, 1.3875, 1.7, 0.083333333333333
34404, 1.4083333333333, 1.7, 0.0625
34405, 1.4291666666667, 1.7, 0.083333333333333
34406, 1.45, 1.7, 0.0625
34407, 1.4708333333333, 1.7, 0.083333333333333
34408, 1.4916666666667, 1.7, 0.0625
34409, 1.5125, 1.7, 0.083333333333333
34410, 1.5333333333333, 1.7, 0.0625
34411, 1.5541666666667, 1.7, 0.083333333333333
34412, 1.575, 1.7, 0.0625
34413, 1.5958333333333, 1.7, 0.083333333333333
34414, 1.6166666666667, 1.7, 0.0625
34415, 1.6375, 1.7, 0.083333333333333
34416, 1.6583333333333, 1.7, 0.0625
34417, 1.6791666666667, 1.7, 0.083333333333333
34418, 1.7, 1.7, 0.0625
34419, 1.7208333333333, 1.7, 0.083333333333333
34420, 1.7416666666667, 1.7, 0.0625
34421, 1.7625, 1.7, 0.083333333333333
34422, 1.7833333333333, 1.7, 0.0625
34423, 1.8041666666667, 1.7, 0.083333333333333
34424, 1.825, 1.7, 0.0625
34425, 1.8458333333333, 1.7, 0.083333333333333
34426, 1.8666666666667, 1.7, 0.0625
34427, 1.8875, 1.7, 0.083333333333333
34428, 1.9083333333333, 1.7, 0.0625
34429, 1.9291666666667, 1.7, 0.083333333333333
34430, 1.95, 1.7, 0.0625
34431, 1.9708333333333, 1.7, 0.083333333333333
34432, 1.9916666666667, 1.7, 0.0625
34433, 2.0125, 1.7, 0.083333333333333
34434, 2.0333333333333, 1.7, 0.0625
34435, 2.0541666666667, 1.7, 0.083333333333333
34436, 2.075, 1.7, 0.0625
34437, 2.0958333333333, 1.7, 0.083333333333333
34438, 2.1166666666667, 1.7, 0.0625
34439, 2.1375, 1.7, 0.083333333333333
34440, 2.1583333333333, 1.7, 0.0625
34441, 2.1791666666667, 1.7, 0.083333333333333
34442, 1.2208333333333, 1.7, 0.125
34443, 1.2416666666667, 1.7, 0.10416666666667
34444, 1.2625, 1.7, 0.125
34445, 1.2833333333333, 1.7, 0.10416666666667
34446, 1.3041666666667, 1.7, 0.125
34447, 1.325, 1.7, 0.10416666666667
34448, 1.3458333333333, 1.7, 0.125
34449, 1.3666666666667, 1.7, 0.10416666666667
34450, 1.3875, 1.7, 0.125
34451, 1.4083333333333, 1.7, 0.10416666666667
34452, 1.4291666666667, 1.7, 0.125
34453, 1.45, 1.7, 0.10416666666667
34454, 1.4708333333333, 1.7, 0.125
34455, 1.4916666666667, 1.7, 0.10416666666667
34456, 1.5125, 1.7, 0.125
34457, 1.5333333333333, 1.7, 0.10416666666667
34458, 1.5541666666667, 1.7, 0.125
34459, 1.575, 1.7, 0.10416666666667
34460, 1.5958333333333, 1.7, 0.125
34461, 1.6166666666667, 1.7, 0.10416666666667
34462, 1.6375, 1.7, 0.125
34463, 1.6583333333333, 1.7, 0.10416666666667
34464, 1.6791666666667, 1.7, 0.125
34465, 1.7, 1.7, 0.10416666666667
34466, 1.7208333333333, 1.7, 0.125
34467, 1.7416666666667, 1.7, 0.10416666666667
34468, 1.7625, 1.7, 0.125
34469, 1.7833333333333, 1.7, 0.10416666666667
34470, 1.8041666666667, 1.7, 0.125
34471, 1.825, 1.7, 0.10416666666667
34472, 1.8458333333333, 1.7, 0.125
34473, 1.8666666666667, 1.7, 0.10416666666667
34474, 1.8875, 1.7, 0.125
34475, 1.9083333333333, 1.7, 0.10416666666667
34476, 1.9291666666667, 1.7, 0.125
34477, 1.95, 1.7, 0.10416666666667
34478, 1.9708333333333, 1.7, 0.125
34479, 1.9916666666667, 1.7, 0.10416666666667
34480, 2.0125, 1.7, 0.125
34481, 2.0333333333333, 1.7, 0.10416666666667
34482, 2.0541666666667, 1.7, 0.125
34483, 2.075, 1.7, 0.10416666666667
34484, 2.0958333333333, 1.7, 0.125
34485, 2.1166666666667, 1.7, 0.10416666666667
34486, 2.1375, 1.7, 0.125
34487, 2.1583333333333, 1.7, 0.10416666666667
34488, 2.1791666666667, 1.7, 0.125
34489, 1.2208333333333, 1.7, 0.16666666666667
34490, 1.2416666666667, 1.7, 0.14583333333333
34491, 1.2625, 1.7, 0.16666666666667
34492, 1.2833333333333, 1.7, 0.14583333333333
34493, 1.3041666666667, 1.7, 0.16666666666667
34494, 1.325, 1.7, 0.14583333333333
34495, 1.3458333333333, 1.7, 0.16666666666667
34496, 1.3666666666667, 1.7, 0.14583333333333
34497, 1.3875, 1.7, 0.16666666666667
34498, 1.4083333333333, 1.7, 0.14583333333333
34499, 1.4291666666667, 1.7, 0.16666666666667
34500, 1.45, 1.7, 0.14583333333333
34501, 1.4708333333333, 1.7, 0.16666666666667
34502, 1.4916666666667, 1.7, 0.14583333333333
34503, 1.5125, 1.7, 0.16666666666667
34504, 1.5333333333333, 1.7, 0.14583333333333
34505, 1.5541666666667, 1.7, 0.16666666666667
34506, 1.575, 1.7, 0.14583333333333
34507, 1.5958333333333, 1.7, 0.16666666666667
34508, 1.6166666666667, 1.7, 0.14583333333333
34509, 1.6375, 1.7, 0.16666666666667
34510, 1.6583333333333, 1.7, 0.14583333333333
34511, 1.6791666666667, 1.7, 0.16666666666667
34512, 1.7, 1.7, 0.14583333333333
34513, 1.7208333333333, 1.7, 0.16666666666667
34514, 1.7416666666667, 1.7, 0.14583333333333
34515, 1.7625, 1.7, 0.16666666666667
34516, 1.7833333333333, 1.7, 0.14583333333333
34517, 1.8041666666667, 1.7, 0.16666666666667
34518, 1.825, 1.7, 0.14583333333333
34519, 1.8458333333333, 1.7, 0.16666666666667
34520, 1.8666666666667, 1.7, 0.14583333333333
34521, 1.8875, 1.7, 0.16666666666667
34522, 1.9083333333333, 1.7, 0.14583333333333
34523, 1.9291666666667, 1.7, 0.16666666666667
34524, 1.95, 1.7, 0.14583333333333
34525, 1.9708333333333, 1.7, 0.16666666666667
34526, 1.9916666666667, 1.7, 0.14583333333333
34527, 2.0125, 1.7, 0.16666666666667
34528, 2.0333333333333, 1.7, 0.14583333333333
34529, 2.0541666666667, 1.7, 0.16666666666667
34530, 2.075, 1.7, 0.14583333333333
34531, 2.0958333333333, 1.7, 0.16666666666667
34532, 2.1166666666667, 1.7, 0.14583333333333
34533, 2.1375, 1.7, 0.16666666666667
34534, 2.1583333333333, 1.7, 0.14583333333333
34535, 2.1791666666667, 1.7, 0.16666666666667
34536, 1.2208333333333, 1.7, 0.20833333333333
34537, 1.2416666666667, 1.7, 0.1875
34538, 1.2625, 1.7, 0.20833333333333
34539, 1.2833333333333, 1.7, 0.1875
34540, 1.3041666666667, 1.7, 0.20833333333333
34541, 1.325, 1.7, 0.1875
34542, 1.3458333333333, 1.7, 0.20833333333333
34543, 1.3666666666667, 1.7, 0.1875
34544, 1.3875, 1.7, 0.20833333333333
34545, 1.4083333333333, 1.7, 0.1875
34546, 1.4291666666667, 1.7, 0.20833333333333
34547, 1.45, 1.7, 0.1875
34548, 1.4708333333333, 1.7, 0.20833333333333
34549, 1.4916666666667, 1.7, 0.1875
34550, 1.5125, 1.7, 0.20833333333333
34551, 1.5333333333333, 1.7, 0.1875
34552, 1.5541666666667, 1.7, 0.20833333333333
34553, 1.575, 1.7, 0.1875
34554, 1.5958333333333, 1.7, 0.20833333333333
34555, 1.6166666666667, 1.7, 0.1875
34556, 1.6375, 1.7, 0.20833333333333
34557, 1.6583333333333, 1.7, 0.1875
34558, 1.6791666666667, 1.7, 0.20833333333333
34559, 1.7, 1.7, 0.1875
34560, 1.7208333333333, 1.7, 0.20833333333333
34561, 1.7416666666667, 1.7, 0.1875
34562, 1.7625, 1.7, 0.20833333333333
34563, 1.7833333333333, 1.7, 0.1875
34564, 1.8041666666667, 1.7, 0.20833333333333
34565, 1.825, 1.7, 0.1875
34566, 1.8458333333333, 1.7, 0.20833333333333
34567, 1.8666666666667, 1.7, 0.1875
34568, 1.8875, 1.7, 0.20833333333333
34569, 1.9083333333333, 1.7, 0.1875
34570, 1.9291666666667, 1.7, 0.20833333333333
34571, 1.95, 1.7, 0.1875
34572, 1.9708333333333, 1.7, 0.20833333333333
34573, 1.9916666666667, 1.7, 0.1875
34574, 2.0125, 1.7, 0.20833333333333
34575, 2.0333333333333, 1.7, 0.1875
34576, 2.0541666666667, 1.7, 0.20833333333333
34577, 2.075, 1.7, 0.1875
34578, 2.0958333333333, 1.7, 0.20833333333333
34579, 2.1166666666667, 1.7, 0.1875
34580, 2.1375, 1.7, 0.20833333333333
34581, 2.1583333333333, 1.7, 0.1875
34582, 2.1791666666667, 1.7, 0.20833333333333
34583, 1.2208333333333, 1.7, 0.25
34584, 1.2416666666667, 1.7, 0.22916666666667
34585, 1.2625, 1.7, 0.25
34586, 1.2833333333333, 1.7, 0.22916666666667
34587, 1.3041666666667, 1.7, 0.25
34588, 1.325, 1.7, 0.22916666666667
34589, 1.3458333333333, 1.7, 0.25
34590, 1.3666666666667, 1.7, 0.22916666666667
34591, 1.3875, 1.7, 0.25
34592, 1.4083333333333, 1.7, 0.22916666666667
34593, 1.4291666666667, 1.7, 0.25
34594, 1.45, 1.7, 0.22916666666667
34595, 1.4708333333333, 1.7, 0.25
34596, 1.4916666666667, 1.7, 0.22916666666667
34597, 1.5125, 1.7, 0.25
34598, 1.5333333333333, 1.7, 0.22916666666667
34599, 1.5541666666667, 1.7, 0.25
34600, 1.575, 1.7, 0.22916666666667
34601, 1.5958333333333, 1.7, 0.25
34602, 1.6166666666667, 1.7, 0.22916666666667
34603, 1.6375, 1.7, 0.25
34604, 1.6583333333333, 1.7, 0.22916666666667
34605, 1.6791666666667, 1.7, 0.25
34606, 1.7, 1.7, 0.22916666666667
34607, 1.7208333333333, 1.7, 0.25
34608, 1.7416666666667, 1.7, 0.22916666666667
34609, 1.7625, 1.7, 0.25
34610, 1.7833333333333, 1.7, 0.22916666666667
34611, 1.8041666666667, 1.7, 0.25
34612, 1.825, 1.7, 0.22916666666667
34613, 1.8458333333333, 1.7, 0.25
34614, 1.8666666666667, 1.7, 0.22916666666667
34615, 1.8875, 1.7, 0.25
34616, 1.9083333333333, 1.7, 0.22916666666667
34617, 1.9291666666667, 1.7, 0.25
34618, 1.95, 1.7, 0.22916666666667
34619, 1.9708333333333, 1.7, 0.25
34620, 1.9916666666667, 1.7, 0.22916666666667
34621, 2.0125, 1.7, 0.25
34622, 2.0333333333333, 1.7, 0.22916666666667
34623, 2.0541666666667, 1.7, 0.25
34624, 2.075, 1.7, 0.22916666666667
34625, 2.0958333333333, 1.7, 0.25
34626, 2.1166666666667, 1.7, 0.22916666666667
34627, 2.1375, 1.7, 0.25
34628, 2.1583333333333, 1.7, 0.22916666666667
34629, 2.1791666666667, 1.7, 0.25
34630, 1.2208333333333, 1.7, 0.29166666666667
34631, 1.2416666666667, 1.7, 0.27083333333333
34632, 1.2625, 1.7, 0.29166666666667
34633, 1.2833333333333, 1.7, 0.27083333333333
34634, 1.3041666666667, 1.7, 0.29166666666667
34635, 1.325, 1.7, 0.27083333333333
34636, 1.3458333333333, 1.7, 0.29166666666667
34637, 1.3666666666667, 1.7, 0.27083333333333
34638, 1.3875, 1.7, 0.29166666666667
34639, 1.4083333333333, 1.7, 0.27083333333333
34640, 1.4291666666667, 1.7, 0.29166666666667
34641, 1.45, 1.7, 0.27083333333333
34642, 1.4708333333333, 1.7, 0.29166666666667
34643, 1.4916666666667, 1.7, 0.27083333333333
34644, 1.5125, 1.7, 0.29166666666667
34645, 1.5333333333333, 1.7, 0.27083333333333
34646, 1.5541666666667, 1.7, 0.29166666666667
34647, 1.575, 1.7, 0.27083333333333
34648, 1.5958333333333, 1.7, 0.29166666666667
34649, 1.6166666666667, 1.7, 0.27083333333333
34650, 1.6375, 1.7, 0.29166666666667
34651, 1.6583333333333, 1.7, 0.27083333333333
34652, 1.6791666666667, 1.7, 0.29166666666667
34653, 1.7, 1.7, 0.27083333333333
34654, 1.7208333333333, 1.7, 0.29166666666667
34655, 1.7416666666667, 1.7, 0.27083333333333
34656, 1.7625, 1.7, 0.29166666666667
34657, 1.7833333333333, 1.7, 0.27083333333333
34658, 1.8041666666667, 1.7, 0.29166666666667
34659, 1.825, 1.7, 0.27083333333333
34660, 1.8458333333333, 1.7, 0.29166666666667
34661, 1.8666666666667, 1.7, 0.27083333333333
34662, 1.8875, 1.7, 0.29166666666667
34663, 1.9083333333333, 1.7, 0.27083333333333
34664, 1.9291666666667, 1.7, 0.29166666666667
34665, 1.95, 1.7, 0.27083333333333
34666, 1.9708333333333, 1.7, 0.29166666666667
34667, 1.9916666666667, 1.7, 0.27083333333333
34668, 2.0125, 1.7, 0.29166666666667
34669, 2.0333333333333, 1.7, 0.27083333333333
34670, 2.0541666666667, 1.7, 0.29166666666667
34671, 2.075, 1.7, 0.27083333333333
34672, 2.0958333333333, 1.7, 0.29166666666667
34673, 2.1166666666667, 1.7, 0.27083333333333
34674, 2.1375, 1.7, 0.29166666666667
34675, 2.1583333333333, 1.7, 0.27083333333333
34676, 2.1791666666667, 1.7, 0.29166666666667
34677, 1.2208333333333, 1.7, 0.33333333333333
34678, 1.2416666666667, 1.7, 0.3125
34679, 1.2625, 1.7, 0.33333333333333
34680, 1.2833333333333, 1.7, 0.3125
34681, 1.3041666666667, 1.7, 0.33333333333333
34682, 1.325, 1.7, 0.3125
34683, 1.3458333333333, 1.7, 0.33333333333333
34684, 1.3666666666667, 1.7, 0.3125
34685, 1.3875, 1.7, 0.33333333333333
34686, 1.4083333333333, 1.7, 0.3125
34687, 1.4291666666667, 1.7, 0.33333333333333
34688, 1.45, 1.7, 0.3125
34689, 1.4708333333333, 1.7, 0.33333333333333
34690, 1.4916666666667, 1.7, 0.3125
34691, 1.5125, 1.7, 0.33333333333333
34692, 1.5333333333333, 1.7, 0.3125
34693, 1.5541666666667, 1.7, 0.33333333333333
34694, 1.575, 1.7, 0.3125
34695, 1.5958333333333, 1.7, 0.33333333333333
34696, 1.6166666666667, 1.7, 0.3125
34697, 1.6375, 1.7, 0.33333333333333
34698, 1.6583333333333, 1.7, 0.3125
34699, 1.6791666666667, 1.7, 0.33333333333333
34700, 1.7, 1.7, 0.3125
34701, 1.7208333333333, 1.7, 0.33333333333333
34702, 1.7416666666667, 1.7, 0.3125
34703, 1.7625, 1.7, 0.33333333333333
34704, 1.7833333333333, 1.7, 0.3125
34705, 1.8041666666667, 1.7, 0.33333333333333
34706, 1.825, 1.7, 0.3125
34707, 1.8458333333333, 1.7, 0.33333333333333
34708, 1.8666666666667, 1.7, 0.3125
34709, 1.8875, 1.7, 0.33333333333333
34710, 1.9083333333333, 1.7, 0.3125
34711, 1.9291666666667, 1.7, 0.33333333333333
34712, 1.95, 1.7, 0.3125
34713, 1.9708333333333, 1.7, 0.33333333333333
34714, 1.9916666666667, 1.7, 0.3125
34715, 2.0125, 1.7, 0.33333333333333
34716, 2.0333333333333, 1.7, 0.3125
34717, 2.0541666666667, 1.7, 0.33333333333333
34718, 2.075, 1.7, 0.3125
34719, 2.0958333333333, 1.7, 0.33333333333333
34720, 2.1166666666667, 1.7, 0.3125
34721, 2.1375, 1.7, 0.33333333333333
34722, 2.1583333333333, 1.7, 0.3125
34723, 2.1791666666667, 1.7, 0.33333333333333
34724, 1.2208333333333, 1.7, 0.375
34725, 1.2416666666667, 1.7, 0.35416666666667
34726, 1.2625, 1.7, 0.375
34727, 1.2833333333333, 1.7, 0.35416666666667
34728, 1.3041666666667, 1.7, 0.375
34729, 1.325, 1.7, 0.35416666666667
34730, 1.3458333333333, 1.7, 0.375
34731, 1.3666666666667, 1.7, 0.35416666666667
34732, 1.3875, 1.7, 0.375
34733, 1.4083333333333, 1.7, 0.35416666666667
34734, 1.4291666666667, 1.7, 0.375
34735, 1.45, 1.7, 0.35416666666667
34736, 1.4708333333333, 1.7, 0.375
34737, 1.4916666666667, 1.7, 0.35416666666667
34738, 1.5125, 1.7, 0.375
34739, 1.5333333333333, 1.7, 0.35416666666667
34740, 1.5541666666667, 1.7, 0.375
34741, 1.575, 1.7, 0.35416666666667
34742, 1.5958333333333, 1.7, 0.375
34743, 1.6166666666667, 1.7, 0.35416666666667
34744, 1.6375, 1.7, 0.375
34745, 1.6583333333333, 1.7, 0.35416666666667
34746, 1.6791666666667, 1.7, 0.375
34747, 1.7, 1.7, 0.35416666666667
34748, 1.7208333333333, 1.7, 0.375
34749, 1.7416666666667, 1.7, 0.35416666666667
34750, 1.7625, 1.7, 0.375
34751, 1.7833333333333, 1.7, 0.35416666666667
34752, 1.8041666666667, 1.7, 0.375
34753, 1.825, 1.7, 0.35416666666667
34754, 1.8458333333333, 1.7, 0.375
34755, 1.8666666666667, 1.7, 0.35416666666667
34756, 1.8875, 1.7, 0.375
34757, 1.9083333333333, 1.7, 0.35416666666667
34758, 1.9291666666667, 1.7, 0.375
34759, 1.95, 1.7, 0.35416666666667
34760, 1.9708333333333, 1.7, 0.375
34761, 1.9916666666667, 1.7, 0.35416666666667
34762, 2.0125, 1.7, 0.375
34763, 2.0333333333333, 1.7, 0.35416666666667
34764, 2.0541666666667, 1.7, 0.375
34765, 2.075, 1.7, 0.35416666666667
34766, 2.0958333333333, 1.7, 0.375
34767, 2.1166666666667, 1.7, 0.35416666666667
34768, 2.1375, 1.7, 0.375
34769, 2.1583333333333, 1.7, 0.35416666666667
34770, 2.1791666666667, 1.7, 0.375
34771, 1.2208333333333, 1.7, 0.41666666666667
34772, 1.2416666666667, 1.7, 0.39583333333333
34773, 1.2625, 1.7, 0.41666666666667
34774, 1.2833333333333, 1.7, 0.39583333333333
34775, 1.3041666666667, 1.7, 0.41666666666667
34776, 1.325, 1.7, 0.39583333333333
34777, 1.3458333333333, 1.7, 0.41666666666667
34778, 1.3666666666667, 1.7, 0.39583333333333
34779, 1.3875, 1.7, 0.41666666666667
34780, 1.4083333333333, 1.7, 0.39583333333333
34781, 1.4291666666667, 1.7, 0.41666666666667
34782, 1.45, 1.7, 0.39583333333333
34783, 1.4708333333333, 1.7, 0.41666666666667
34784, 1.4916666666667, 1.7, 0.39583333333333
34785, 1.5125, 1.7, 0.41666666666667
34786, 1.5333333333333, 1.7, 0.39583333333333
34787, 1.5541666666667, 1.7, 0.41666666666667
34788, 1.575, 1.7, 0.39583333333333
34789, 1.5958333333333, 1.7, 0.41666666666667
34790, 1.6166666666667, 1.7, 0.39583333333333
34791, 1.6375, 1.7, 0.41666666666667
34792, 1.6583333333333, 1.7, 0.39583333333333
34793, 1.6791666666667, 1.7, 0.41666666666667
34794, 1.7, 1.7, 0.39583333333333
34795, 1.7208333333333, 1.7, 0.41666666666667
34796, 1.7416666666667, 1.7, 0.39583333333333
34797, 1.7625, 1.7, 0.41666666666667
34798, 1.7833333333333, 1.7, 0.39583333333333
34799, 1.8041666666667, 1.7, 0.41666666666667
34800, 1.825, 1.7, 0.39583333333333
34801, 1.8458333333333, 1.7, 0.41666666666667
34802, 1.8666666666667, 1.7, 0.39583333333333
34803, 1.8875, 1.7, 0.41666666666667
34804, 1.9083333333333, 1.7, 0.39583333333333
34805, 1.9291666666667, 1.7, 0.41666666666667
34806, 1.95, 1.7, 0.39583333333333
34807, 1.9708333333333, 1.7, 0.41666666666667
34808, 1.9916666666667, 1.7, 0.39583333333333
34809, 2.0125, 1.7, 0.41666666666667
34810, 2.0333333333333, 1.7, 0.39583333333333
34811, 2.0541666666667, 1.7, 0.41666666666667
34812, 2.075, 1.7, 0.39583333333333
34813, 2.0958333333333, 1.7, 0.41666666666667
34814, 2.1166666666667, 1.7, 0.39583333333333
34815, 2.1375, 1.7, 0.41666666666667
34816, 2.1583333333333, 1.7, 0.39583333333333
34817, 2.1791666666667, 1.7, 0.41666666666667
34818, 1.2208333333333, 1.7, 0.45833333333333
34819, 1.2416666666667, 1.7, 0.4375
34820, 1.2625, 1.7, 0.45833333333333
34821, 1.2833333333333, 1.7, 0.4375
34822, 1.3041666666667, 1.7, 0.45833333333333
34823, 1.325, 1.7, 0.4375
34824, 1.3458333333333, 1.7, 0.45833333333333
34825, 1.3666666666667, 1.7, 0.4375
34826, 1.3875, 1.7, 0.45833333333333
34827, 1.4083333333333, 1.7, 0.4375
34828, 1.4291666666667, 1.7, 0.45833333333333
34829, 1.45, 1.7, 0.4375
34830, 1.4708333333333, 1.7, 0.45833333333333
34831, 1.4916666666667, 1.7, 0.4375
34832, 1.5125, 1.7, 0.45833333333333
34833, 1.5333333333333, 1.7, 0.4375
34834, 1.5541666666667, 1.7, 0.45833333333333
34835, 1.575, 1.7, 0.4375
34836, 1.5958333333333, 1.7, 0.45833333333333
34837, 1.6166666666667, 1.7, 0.4375
34838, 1.6375, 1.7, 0.45833333333333
34839, 1.6583333333333, 1.7, 0.4375
34840, 1.6791666666667, 1.7, 0.45833333333333
34841, 1.7, 1.7, 0.4375
34842, 1.7208333333333, 1.7, 0.45833333333333
34843, 1.7416666666667, 1.7, 0.4375
34844, 1.7625, 1.7, 0.45833333333333
34845, 1.7833333333333, 1.7, 0.4375
34846, 1.8041666666667, 1.7, 0.45833333333333
34847, 1.825, 1.7, 0.4375
34848, 1.8458333333333, 1.7, 0.45833333333333
34849, 1.8666666666667, 1.7, 0.4375
34850, 1.8875, 1.7, 0.45833333333333
34851, 1.9083333333333, 1.7, 0.4375
34852, 1.9291666666667, 1.7, 0.45833333333333
34853, 1.95, 1.7, 0.4375
34854, 1.9708333333333, 1.7, 0.45833333333333
34855, 1.9916666666667, 1.7, 0.4375
34856, 2.0125, 1.7, 0.45833333333333
34857, 2.0333333333333, 1.7, 0.4375
34858, 2.0541666666667, 1.7, 0.45833333333333
34859, 2.075, 1.7, 0.4375
34860, 2.0958333333333, 1.7, 0.45833333333333
34861, 2.1166666666667, 1.7, 0.4375
34862, 2.1375, 1.7, 0.45833333333333
34863, 2.1583333333333, 1.7, 0.4375
34864, 2.1791666666667, 1.7, 0.45833333333333
34865, 1.2416666666667, 1.7, 0.47916666666667
34866, 1.2833333333333, 1.7, 0.47916666666667
34867, 1.325, 1.7, 0.47916666666667
34868, 1.3666666666667, 1.7, 0.47916666666667
34869, 1.4083333333333, 1.7, 0.47916666666667
34870, 1.45, 1.7, 0.47916666666667
34871, 1.4916666666667, 1.7, 0.47916666666667
34872, 1.5333333333333, 1.7, 0.47916666666667
34873, 1.575, 1.7, 0.47916666666667
34874, 1.6166666666667, 1.7, 0.47916666666667
34875, 1.6583333333333, 1.7, 0.47916666666667
34876, 1.7, 1.7, 0.47916666666667
34877, 1.7416666666667, 1.7, 0.47916666666667
34878, 1.7833333333333, 1.7, 0.47916666666667
34879, 1.825, 1.7, 0.47916666666667
34880, 1.8666666666667, 1.7, 0.47916666666667
34881, 1.9083333333333, 1.7, 0.47916666666667
34882, 1.95, 1.7, 0.47916666666667
34883, 1.9916666666667, 1.7, 0.47916666666667
34884, 2.0333333333333, 1.7, 0.47916666666667
34885, 2.075, 1.7, 0.47916666666667
34886, 2.1166666666667, 1.7, 0.47916666666667
34887, 2.1583333333333, 1.7, 0.47916666666667
34888, 0.041666666666667, -0.04, 0
34889, 0.041666666666667, -0.08, 0
34890, 0.041666666666667, -0.12, 0
34891, 0.041666666666667, -0.16, 0
34892, 0.083333333333333, -0.04, 0
34893, 0.083333333333333, -0.08, 0
34894, 0.083333333333333, -0.12, 0
34895, 0.083333333333333, -0.16, 0
34896, 0.125, -0.04, 0
34897, 0.125, -0.08, 0
34898, 0.125, -0.12, 0
34899, 0.125, -0.16, 0
34900, 0.16666666666667, -0.04, 0
34901, 0.16666666666667, -0.08, 0
34902, 0.16666666666667, -0.12, 0
34903, 0.16666666666667, -0.16, 0
34904, 0.20833333333333, -0.04, 0
34905, 0.20833333333333, -0.08, 0
34906, 0.20833333333333, -0.12, 0
34907, 0.20833333333333, -0.16, 0
34908, 0.25, -0.04, 0
34909, 0.25, -0.08, 0
34910, 0.25, -0.12, 0
34911, 0.25, -0.16, 0
34912, 0.29166666666667, -0.04, 0
34913, 0.29166666666667, -0.08, 0
34914, 0.29166666666667, -0.12, 0
34915, 0.29166666666667, -0.16, 0
34916, 0.33333333333333, -0.04, 0
34917, 0.33333333333333, -0.08, 0
34918, 0.33333333333333, -0.12, 0
34919, 0.33333333333333, -0.16, 0
34920, 0.375, -0.04, 0
34921, 0.375, -0.08, 0
34922, 0.375, -0.12, 0
34923, 0.375, -0.16, 0
34924, 0.41666666666667, -0.04, 0
34925, 0.41666666666667, -0.08, 0
34926, 0.41666666666667, -0.12, 0
34927, 0.41666666666667, -0.16, 0
34928, 0.45833333333333, -0.04, 0
34929, 0.45833333333333, -0.08, 0
34930, 0.45833333333333, -0.12, 0
34931, 0.45833333333333, -0.16, 0
34932, 0.5, -0.04, 0
34933, 0.5, -0.08, 0
34934, 0.5, -0.12, 0
34935, 0.5, -0.16, 0
34936, 0.54166666666667, -0.04, 0
34937, 0.54166666666667, -0.08, 0
34938, 0.54166666666667, -0.12, 0
34939, 0.54166666666667, -0.16, 0
34940, 0.58333333333333, -0.04, 0
34941, 0.58333333333333, -0.08, 0
34942, 0.58333333333333, -0.12, 0
34943, 0.58333333333333, -0.16, 0
34944, 0.625, -0.04, 0
34945, 0.625, -0.08, 0
34946, 0.625, -0.12, 0
34947, 0.625, -0.16, 0
34948, 0.66666666666667, -0.04, 0
34949, 0.66666666666667, -0.08, 0
34950, 0.66666666666667, -0.12, 0
34951, 0.66666666666667, -0.16, 0
34952, 0.70833333333333, -0.04, 0
34953, 0.70833333333333, -0.08, 0
34954, 0.70833333333333, -0.12, 0
34955, 0.70833333333333, -0.16, 0
34956, 0.75, -0.04, 0
34957, 0.75, -0.08, 0
34958, 0.75, -0.12, 0
34959, 0.75, -0.16, 0
34960, 0.79166666666667, -0.04, 0
34961, 0.79166666666667, -0.08, 0
34962, 0.79166666666667, -0.12, 0
34963, 0.79166666666667, -0.16, 0
34964, 0.83333333333333, -0.04, 0
34965, 0.83333333333333, -0.08, 0
34966, 0.83333333333333, -0.12, 0
34967, 0.83333333333333, -0.16, 0
34968, 0.875, -0.04, 0
34969, 0.875, -0.08, 0
34970, 0.875, -0.12, 0
34971, 0.875, -0.16, 0
34972, 0.91666666666667, -0.04, 0
34973, 0.91666666666667, -0.08, 0
34974, 0.91666666666667, -0.12, 0
34975, 0.91666666666667, -0.16, 0
34976, 0.95833333333333, -0.04, 0
34977, 0.95833333333333, -0.08, 0
34978, 0.95833333333333, -0.12, 0
34979, 0.95833333333333, -0.16, 0
34980, 0.041666666666667, -0.02, 0
34981, 0.020833333333333, -0.04, 0
34982, 0.041666666666667, -0.06, 0
34983, 0.020833333333333, -0.08, 0
34984, 0.041666666666667, -0.1, 0
34985, 0.020833333333333, -0.12, 0
34986, 0.041666666666667, -0.14, 0
34987, 0.020833333333333, -0.16, 0
34988, 0.041666666666667, -0.18, 0
34989, 0.083333333333333, -0.02, 0
34990, 0.0625, -0.04, 0
34991, 0.083333333333333, -0.06, 0
34992, 0.0625, -0.08, 0
34993, 0.083333333333333, -0.1, 0
34994, 0.0625, -0.12, 0
34995, 0.083333333333333, -0.14, 0
34996, 0.0625, -0.16, 0
34997, 0.083333333333333, -0.18, 0
34998, 0.125, -0.02, 0
34999, 0.10416666666667, -0.04, 0
35000, 0.125, -0.06, 0
35001, 0.10416666666667, -0.08, 0
35002, 0.125, -0.1, 0
35003, 0.10416666666667, -0.12, 0
35004, 0.125, -0.14, 0
35005, 0.10416666666667, -0.16, 0
35006, 0.125, -0.18, 0
35007, 0.16666666666667, -0.02, 0
35008, 0.14583333333333, -0.04, 0
35009, 0.16666666666667, -0.06, 0
35010, 0.14583333333333, -0.08, 0
35011, 0.16666666666667, -0.1, 0
35012, 0.14583333333333, -0.12, 0
35013, 0.16666666666667, -0.14, 0
35014, 0.14583333333333, -0.16, 0
35015, 0.16666666666667, -0.18, 0
35016, 0.20833333333333, -0.02, 0
35017, 0.1875, -0.04, 0
35018, 0.20833333333333, -0.06, 0
35019, 0.1875, -0.08, 0
35020, 0.20833333333333, -0.1, 0
35021, 0.1875, -0.12, 0
35022, 0.20833333333333, -0.14, 0
35023, 0.1875, -0.16, 0
35024, 0.20833333333333, -0.18, 0
35025, 0.25, -0.02, 0
35026, 0.22916666666667, -0.04, 0
35027, 0.25, -0.06, 0
35028, 0.22916666666667, -0.08, 0
35029, 0.25, -0.1, 0
35030, 0.22916666666667, -0.12, 0
35031, 0.25, -0.14, 0
35032, 0.22916666666667, -0.16, 0
35033, 0.25, -0.18, 0
35034, 0.29166666666667, -0.02, 0
35035, 0.27083333333333, -0.04, 0
35036, 0.29166666666667, -0.06, 0
35037, 0.27083333333333, -0.08, 0
35038, 0.29166666666667, -0.1, 0
35039, 0.27083333333333, -0.12, 0
35040, 0.29166666666667, -0.14, 0
35041, 0.27083333333333, -0.16, 0
35042, 0.29166666666667, -0.18, 0
35043, 0.33333333333333, -0.02, 0
35044, 0.3125, -0.04, 0
35045, 0.33333333333333, -0.06, 0
35046, 0.3125, -0.08, 0
35047, 0.33333333333333, -0.1, 0
35048, 0.3125, -0.12, 0
35049, 0.33333333333333, -0.14, 0
35050, 0.3125, -0.16, 0
35051, 0.33333333333333, -0.18, 0
35052, 0.375, -0.02, 0
35053, 0.35416666666667, -0.04, 0
35054, 0.375, -0.06, 0
35055, 0.35416666666667, -0.08, 0
35056, 0.375, -0.1, 0
35057, 0.35416666666667, -0.12, 0
35058, 0.375, -0.14, 0
35059, 0.35416666666667, -0.16, 0
35060, 0.375, -0.18, 0
35061, 0.41666666666667, -0.02, 0
35062, 0.39583333333333, -0.04, 0
35063, 0.41666666666667, -0.06, 0
35064, 0.39583333333333, -0.08, 0
35065, 0.41666666666667, -0.1, 0
35066, 0.39583333333333, -0.12, 0
35067, 0.41666666666667, -0.14, 0
35068, 0.39583333333333, -0.16, 0
35069, 0.41666666666667, -0.18, 0
35070, 0.45833333333333, -0.02, 0
35071, 0.4375, -0.04, 0
35072, 0.45833333333333, -0.06, 0
35073, 0.4375, -0.08, 0
35074, 0.45833333333333, -0.1, 0
35075, 0.4375, -0.12, 0
35076, 0.45833333333333, -0.14, 0
35077, 0.4375, -0.16, 0
35078, 0.45833333333333, -0.18, 0
35079, 0.5, -0.02, 0
35080, 0.47916666666667, -0.04, 0
35081, 0.5, -0.06, 0
35082, 0.47916666666667, -0.08, 0
35083, 0.5, -0.1, 0
35084, 0.47916666666667, -0.12, 0
35085, 0.5, -0.14, 0
35086, 0.47916666666667, -0.16, 0
35087, 0.5, -0.18, 0
35088, 0.54166666666667, -0.02, 0
35089, 0.52083333333333, -0.04, 0
35090, 0.54166666666667, -0.06, 0
35091, 0.52083333333333, -0.08, 0
35092, 0.54166666666667, -0.1, 0
35093, 0.52083333333333, -0.12, 0
35094, 0.54166666666667, -0.14, 0
35095, 0.52083333333333, -0.16, 0
35096, 0.54166666666667, -0.18, 0
35097, 0.58333333333333, -0.02, 0
35098, 0.5625, -0.04, 0
35099, 0.58333333333333, -0.06, 0
35100, 0.5625, -0.08, 0
35101, 0.58333333333333, -0.1, 0
35102, 0.5625, -0.12, 0
35103, 0.58333333333333, -0.14, 0
35104, 0.5625, -0.16, 0
35105, 0.58333333333333, -0.18, 0
35106, 0.625, -0.02, 0
35107, 0.60416666666667, -0.04, 0
35108, 0.625, -0.06, 0
35109, 0.60416666666667, -0.08, 0
35110, 0.625, -0.1, 0
35111, 0.60416666666667, -0.12, 0
35112, 0.625, -0.14, 0
35113, 0.60416666666667, -0.16, 0
35114, 0.625, -0.18, 0
35115, 0.66666666666667, -0.02, 0
35116, 0.64583333333333, -0.04, 0
35117, 0.66666666666667, -0.06, 0
35118, 0.64583333333333, -0.08, 0
35119, 0.66666666666667, -0.1, 0
35120, 0.64583333333333, -0.12, 0
35121, 0.66666666666667, -0.14, 0
35122, 0.64583333333333, -0.16, 0
35123, 0.66666666666667, -0.18, 0
35124, 0.70833333333333, -0.02, 0
35125, 0.6875, -0.04, 0
35126, 0.70833333333333, -0.06, 0
35127, 0.6875, -0.08, 0
35128, 0.70833333333333, -0.1, 0
35129, 0.6875, -0.12, 0
35130, 0.70833333333333, -0.14, 0
35131, 0.6875, -0.16, 0
35132, 0.70833333333333, -0.18, 0
35133, 0.75, -0.02, 0
35134, 0.72916666666667, -0.04, 0
35135, 0.75, -0.06, 0
35136, 0.72916666666667, -0.08, 0
35137, 0.75, -0.1, 0
35138, 0.72916666666667, -0.12, 0
35139, 0.75, -0.14, 0
35140, 0.72916666666667, -0.16, 0
35141, 0.75, -0.18, 0
35142, 0.79166666666667, -0.02, 0
35143, 0.77083333333333, -0.04, 0
35144, 0.79166666666667, -0.06, 0
35145, 0.77083333333333, -0.08, 0
35146, 0.79166666666667, -0.1, 0
35147, 0.77083333333333, -0.12, 0
35148, 0.79166666666667, -0.14, 0
35149, 0.77083333333333, -0.16, 0
35150, 0.79166666666667, -0.18, 0
35151, 0.83333333333333, -0.02, 0
35152, 0.8125, -0.04, 0
35153, 0.83333333333333, -0.06, 0
35154, 0.8125, -0.08, 0
35155, 0.83333333333333, -0.1, 0
35156, 0.8125, -0.12, 0
35157, 0.83333333333333, -0.14, 0
35158, 0.8125, -0.16, 0
35159, 0.83333333333333, -0.18, 0
35160, 0.875, -0.02, 0
35161, 0.85416666666667, -0.04, 0
35162, 0.875, -0.06, 0
35163, 0.85416666666667, -0.08, 0
35164, 0.875, -0.1, 0
35165, 0.85416666666667, -0.12, 0
35166, 0.875, -0.14, 0
35167, 0.85416666666667, -0.16, 0
35168, 0.875, -0.18, 0
35169, 0.91666666666667, -0.02, 0
35170, 0.89583333333333, -0.04, 0
35171, 0.91666666666667, -0.06, 0
35172, 0.89583333333333, -0.08, 0
35173, 0.91666666666667, -0.1, 0
35174, 0.89583333333333, -0.12, 0
35175, 0.91666666666667, -0.14, 0
35176, 0.89583333333333, -0.16, 0
35177, 0.91666666666667, -0.18, 0
35178, 0.95833333333333, -0.02, 0
35179, 0.9375, -0.04, 0
35180, 0.95833333333333, -0.06, 0
35181, 0.9375, -0.08, 0
35182, 0.95833333333333, -0.1, 0
35183, 0.9375, -0.12, 0
35184, 0.95833333333333, -0.14, 0
35185, 0.9375, -0.16, 0
35186, 0.95833333333333, -0.18, 0
35187, 0.97916666666667, -0.04, 0
35188, 0.97916666666667, -0.08, 0
35189, 0.97916666666667, -0.12, 0
35190, 0.97916666666667, -0.16, 0
35191, 1, -0.04, 0.041666666666667
35192, 1, -0.08, 0.041666666666667
35193, 1, -0.12, 0.041666666666667
35194, 1, -0.16, 0.041666666666667
35195, 1, -0.04, 0.083333333333333
35196, 1, -0.08, 0.083333333333333
35197, 1, -0.12, 0.083333333333333
35198, 1, -0.16, 0.083333333333333
35199, 1, -0.04, 0.125
35200, 1, -0.08, 0.125
35201, 1, -0.12, 0.125
35202, 1, -0.16, 0.125
35203, 1, -0.04, 0.16666666666667
35204, 1, -0.08, 0.16666666666667
35205, 1, -0.12, 0.16666666666667
35206, 1, -0.16, 0.16666666666667
35207, 1, -0.04, 0.20833333333333
35208, 1, -0.08, 0.20833333333333
35209, 1, -0.12, 0.20833333333333
35210, 1, -0.16, 0.20833333333333
35211, 1, -0.04, 0.25
35212, 1, -0.08, 0.25
35213, 1, -0.12, 0.25
35214, 1, -0.16, 0.25
35215, 1, -0.04, 0.29166666666667
35216, 1, -0.08, 0.29166666666667
35217, 1, -0.12, 0.29166666666667
35218, 1, -0.16, 0.29166666666667
35219, 1, -0.04, 0.33333333333333
35220, 1, -0.08, 0.33333333333333
35221, 1, -0.12, 0.33333333333333
35222, 1, -0.16, 0.33333333333333
35223, 1, -0.04, 0.375
35224, 1, -0.08, 0.375
35225, 1, -0.12, 0.375
35226, 1, -0.16, 0.375
35227, 1, -0.04, 0.41666666666667
35228, 1, -0.08, 0.41666666666667
35229, 1, -0.12, 0.41666666666667
35230, 1, -0.16, 0.41666666666667
35231, 1, -0.04, 0.45833333333333
35232, 1, -0.08, 0.45833333333333
35233, 1, -0.12, 0.45833333333333
35234, 1, -0.16, 0.45833333333333
35235, 1, -0.02, 0.041666666666667
35236, 1, -0.04, 0.020833333333333
35237, 1, -0.06, 0.041666666666667
35238, 1, -0.08, 0.020833333333333
35239, 1, -0.1, 0.041666666666667
35240, 1, -0.12, 0.020833333333333
35241, 1, -0.14, 0.041666666666667
35242, 1, -0.16, 0.020833333333333
35243, 1, -0.18, 0.041666666666667
35244, 1, -0.02, 0.083333333333333
35245, 1, -0.04, 0.0625
35246, 1, -0.06, 0.083333333333333
35247, 1, -0.08, 0.0625
35248, 1, -0.1, 0.083333333333333
35249, 1, -0.12, 0.0625
35250, 1, -0.14, 0.083333333333333
35251, 1, -0.16, 0.0625
35252, 1, -0.18, 0.083333333333333
35253, 1, -0.02, 0.125
35254, 1, -0.04, 0.10416666666667
35255, 1, -0.06, 0.125
35256, 1, -0.08, 0.10416666666667
35257, 1, -0.1, 0.125
35258, 1, -0.12, 0.10416666666667
35259, 1, -0.14, 0.125
35260, 1, -0.16, 0.10416666666667
35261, 1, -0.18, 0.125
35262, 1, -0.02, 0.16666666666667
35263, 1, -0.04, 0.14583333333333
35264, 1, -0.06, 0.16666666666667
35265, 1, -0.08, 0.14583333333333
35266, 1, -0.1, 0.16666666666667
35267, 1, -0.12, 0.14583333333333
35268, 1, -0.14, 0.16666666666667
35269, 1, -0.16, 0.14583333333333
35270, 1, -0.18, 0.16666666666667
35271, 1, -0.02, 0.20833333333333
35272, 1, -0.04, 0.1875
35273, 1, -0.06, 0.20833333333333
35274, 1, -0.08, 0.1875
35275, 1, -0.1, 0.20833333333333
35276, 1, -0.12, 0.1875
35277, 1, -0.14, 0.20833333333333
35278, 1, -0.16, 0.1875
35279, 1, -0.18, 0.20833333333333
35280, 1, -0.02, 0.25
35281, 1, -0.04, 0.22916666666667
35282, 1, -0.06, 0.25
35283, 1, -0.08, 0.22916666666667
35284, 1, -0.1, 0.25
35285, 1, -0.12, 0.22916666666667
35286, 1, -0.14, 0.25
35287, 1, -0.16, 0.22916666666667
35288, 1, -0.18, 0.25
35289, 1, -0.02, 0.29166666666667
35290, 1, -0.04, 0.27083333333333
35291, 1, -0.06, 0.29166666666667
35292, 1, -0.08, 0.27083333333333
35293, 1, -0.1, 0.29166666666667
35294, 1, -0.12, 0.27083333333333
35295, 1, -0.14, 0.29166666666667
35296, 1, -0.16, 0.27083333333333
35297, 1, -0.18, 0.29166666666667
35298, 1, -0.02, 0.33333333333333
35299, 1, -0.04, 0.3125
35300, 1, -0.06, 0.33333333333333
35301, 1, -0.08, 0.3125
35302, 1, -0.1, 0.33333333333333
35303, 1, -0.12, 0.3125
35304, 1, -0.14, 0.33333333333333
35305, 1, -0.16, 0.3125
35306, 1, -0.18, 0.33333333333333
35307, 1, -0.02, 0.375
35308, 1, -0.04, 0.35416666666667
35309, 1, -0.06, 0.375
35310, 1, -0.08, 0.35416666666667
35311, 1, -0.1, 0.375
35312, 1, -0.12, 0.35416666666667
35313, 1, -0.14, 0.375
35314, 1, -0.16, 0.35416666666667
35315, 1, -0.18, 0.375
35316, 1, -0.02, 0.41666666666667
35317, 1, -0.04, 0.39583333333333
35318, 1, -0.06, 0.41666666666667
35319, 1, -0.08, 0.39583333333333
35320, 1, -0.1, 0.41666666666667
35321, 1, -0.12, 0.39583333333333
35322, 1, -0.14, 0.41666666666667
35323, 1, -0.16, 0.39583333333333
35324, 1, -0.18, 0.41666666666667
35325, 1, -0.02, 0.45833333333333
35326, 1, -0.04, 0.4375
35327, 1, -0.06, 0.45833333333333
35328, 1, -0.08, 0.4375
35329, 1, -0.1, 0.45833333333333
35330, 1, -0.12, 0.4375
35331, 1, -0.14, 0.45833333333333
35332, 1, -0.16, 0.4375
35333, 1, -0.18, 0.45833333333333
35334, 1, -0.04, 0.47916666666667
35335, 1, -0.08, 0.47916666666667
35336, 1, -0.12, 0.47916666666667
35337, 1, -0.16, 0.47916666666667
35338, 0.041666666666667, -0.04, 0.5
35339, 0.041666666666667, -0.08, 0.5
35340, 0.041666666666667, -0.12, 0.5
35341, 0.041666666666667, -0.16, 0.5
35342, 0.083333333333333, -0.04, 0.5
35343, 0.083333333333333, -0.08, 0.5
35344, 0.083333333333333, -0.12, 0.5
35345, 0.083333333333333, -0.16, 0.5
35346, 0.125, -0.04, 0.5
35347, 0.125, -0.08, 0.5
35348, 0.125, -0.12, 0.5
35349, 0.125, -0.16, 0.5
35350, 0.16666666666667, -0.04, 0.5
35351, 0.16666666666667, -0.08, 0.5
35352, 0.16666666666667, -0.12, 0.5
35353, 0.16666666666667, -0.16, 0.5
35354, 0.20833333333333, -0.04, 0.5
35355, 0.20833333333333, -0.08, 0.5
35356, 0.20833333333333, -0.12, 0.5
35357, 0.20833333333333, -0.16, 0.5
35358, 0.25, -0.04, 0.5
35359, 0.25, -0.08, 0.5
35360, 0.25, -0.12, 0.5
35361, 0.25, -0.16, 0.5
35362, 0.29166666666667, -0.04, 0.5
35363, 0.29166666666667, -0.08, 0.5
35364, 0.29166666666667, -0.12, 0.5
35365, 0.29166666666667, -0.16, 0.5
35366, 0.33333333333333, -0.04, 0.5
35367, 0.33333333333333, -0.08, 0.5
35368, 0.33333333333333, -0.12, 0.5
35369, 0.33333333333333, -0.16, 0.5
35370, 0.375, -0.04, 0.5
35371, 0.375, -0.08, 0.5
35372, 0.375, -0.12, 0.5
35373, 0.375, -0.16, 0.5
35374, 0.41666666666667, -0.04, 0.5
35375, 0.41666666666667, -0.08, 0.5
35376, 0.41666666666667, -0.12, 0.5
35377, 0.41666666666667, -0.16, 0.5
35378, 0.45833333333333, -0.04, 0.5
35379, 0.45833333333333, -0.08, 0.5
35380, 0.45833333333333, -0.12, 0.5
35381, 0.45833333333333, -0.16, 0.5
35382, 0.5, -0.04, 0.5
35383, 0.5, -0.08, 0.5
35384, 0.5, -0.12, 0.5
35385, 0.5, -0.16, 0.5
35386, 0.54166666666667, -0.04, 0.5
35387, 0.54166666666667, -0.08, 0.5
35388, 0.54166666666667, -0.12, 0.5
35389, 0.54166666666667, -0.16, 0.5
35390, 0.58333333333333, -0.04, 0.5
35391, 0.58333333333333, -0.08, 0.5
35392, 0.58333333333333, -0.12, 0.5
35393, 0.58333333333333, -0.16, 0.5
35394, 0.625, -0.04, 0.5
35395, 0.625, -0.08, 0.5
35396, 0.625, -0.12, 0.5
35397, 0.625, -0.16, 0.5
35398, 0.66666666666667, -0.04, 0.5
35399, 0.66666666666667, -0.08, 0.5
35400, 0.66666666666667, -0.12, 0.5
35401, 0.66666666666667, -0.16, 0.5
35402, 0.70833333333333, -0.04, 0.5
35403, 0.70833333333333, -0.08, 0.5
35404, 0.70833333333333, -0.12, 0.5
35405, 0.70833333333333, -0.16, 0.5
35406, 0.75, -0.04, 0.5
