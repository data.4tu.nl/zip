24255, 65982, 65984, 66006, 66004, 65983, 65985, 66007, 66005, 67050, 67128, 67129, 67121, 67053, 67131, 67132, 
67124, 67044, 67051, 67130, 67123
24256, 65983, 65985, 66007, 66005, 14015, 14016, 14027, 14026, 67053, 67131, 67132, 67124, 14387, 14409, 14410, 
14407, 67047, 67054, 67133, 67126
24257, 12739, 12740, 12751, 12750, 65984, 65986, 66008, 66006, 13112, 13134, 13135, 13132, 67057, 67135, 67136, 
67128, 67048, 67055, 67134, 67127
24258, 65984, 65986, 66008, 66006, 65985, 65987, 66009, 66007, 67057, 67135, 67136, 67128, 67060, 67138, 67139, 
67131, 67051, 67058, 67137, 67130
24259, 65985, 65987, 66009, 66007, 14016, 14017, 14028, 14027, 67060, 67138, 67139, 67131, 14389, 14411, 14412, 
14409, 67054, 67061, 67140, 67133
24260, 12740, 952, 953, 12751, 65986, 13684, 13686, 66008, 13113, 976, 13136, 13134, 67062, 13763, 67141, 
67135, 67055, 13757, 13762, 67134
24261, 65986, 13684, 13686, 66008, 65987, 13685, 13687, 66009, 67062, 13763, 67141, 67135, 67063, 13765, 67142, 
67138, 67058, 13759, 13764, 67137
24262, 65987, 13685, 13687, 66009, 14017, 1112, 1113, 14028, 67063, 13765, 67142, 67138, 14390, 1136, 14413, 
14411, 67061, 13761, 13766, 67140
24263, 881, 12741, 12752, 882, 13444, 65988, 66010, 13446, 13115, 13137, 13138, 905, 67066, 67144, 67145, 
13525, 13521, 67064, 67143, 13526
24264, 13444, 65988, 66010, 13446, 13445, 65989, 66011, 13447, 67066, 67144, 67145, 13525, 67069, 67147, 67148, 
13527, 13523, 67067, 67146, 13528
24265, 13445, 65989, 66011, 13447, 1033, 14018, 14029, 1034, 67069, 67147, 67148, 13527, 14392, 14414, 14415, 
1057, 13524, 67070, 67149, 13529
24266, 12741, 12742, 12753, 12752, 65988, 65990, 66012, 66010, 13117, 13139, 13140, 13137, 67073, 67151, 67152, 
67144, 67064, 67071, 67150, 67143
24267, 65988, 65990, 66012, 66010, 65989, 65991, 66013, 66011, 67073, 67151, 67152, 67144, 67076, 67154, 67155, 
67147, 67067, 67074, 67153, 67146
24268, 65989, 65991, 66013, 66011, 14018, 14019, 14030, 14029, 67076, 67154, 67155, 67147, 14394, 14416, 14417, 
14414, 67070, 67077, 67156, 67149
24269, 12742, 12743, 12754, 12753, 65990, 65992, 66014, 66012, 13119, 13141, 13142, 13139, 67080, 67158, 67159, 
67151, 67071, 67078, 67157, 67150
24270, 65990, 65992, 66014, 66012, 65991, 65993, 66015, 66013, 67080, 67158, 67159, 67151, 67083, 67161, 67162, 
67154, 67074, 67081, 67160, 67153
24271, 65991, 65993, 66015, 66013, 14019, 14020, 14031, 14030, 67083, 67161, 67162, 67154, 14396, 14418, 14419, 
14416, 67077, 67084, 67163, 67156
24272, 12743, 12744, 12755, 12754, 65992, 65994, 66016, 66014, 13121, 13143, 13144, 13141, 67087, 67165, 67166, 
67158, 67078, 67085, 67164, 67157
24273, 65992, 65994, 66016, 66014, 65993, 65995, 66017, 66015, 67087, 67165, 67166, 67158, 67090, 67168, 67169, 
67161, 67081, 67088, 67167, 67160
24274, 65993, 65995, 66017, 66015, 14020, 14021, 14032, 14031, 67090, 67168, 67169, 67161, 14398, 14420, 14421, 
14418, 67084, 67091, 67170, 67163
24275, 12744, 12745, 12756, 12755, 65994, 65996, 66018, 66016, 13123, 13145, 13146, 13143, 67094, 67172, 67173, 
67165, 67085, 67092, 67171, 67164
24276, 65994, 65996, 66018, 66016, 65995, 65997, 66019, 66017, 67094, 67172, 67173, 67165, 67097, 67175, 67176, 
67168, 67088, 67095, 67174, 67167
24277, 65995, 65997, 66019, 66017, 14021, 14022, 14033, 14032, 67097, 67175, 67176, 67168, 14400, 14422, 14423, 
14420, 67091, 67098, 67177, 67170
24278, 12745, 12746, 12757, 12756, 65996, 65998, 66020, 66018, 13125, 13147, 13148, 13145, 67101, 67179, 67180, 
67172, 67092, 67099, 67178, 67171
24279, 65996, 65998, 66020, 66018, 65997, 65999, 66021, 66019, 67101, 67179, 67180, 67172, 67104, 67182, 67183, 
67175, 67095, 67102, 67181, 67174
24280, 65997, 65999, 66021, 66019, 14022, 14023, 14034, 14033, 67104, 67182, 67183, 67175, 14402, 14424, 14425, 
14422, 67098, 67105, 67184, 67177
24281, 12746, 12747, 12758, 12757, 65998, 66000, 66022, 66020, 13127, 13149, 13150, 13147, 67108, 67186, 67187, 
67179, 67099, 67106, 67185, 67178
24282, 65998, 66000, 66022, 66020, 65999, 66001, 66023, 66021, 67108, 67186, 67187, 67179, 67111, 67189, 67190, 
67182, 67102, 67109, 67188, 67181
24283, 65999, 66001, 66023, 66021, 14023, 14024, 14035, 14034, 67111, 67189, 67190, 67182, 14404, 14426, 14427, 
14424, 67105, 67112, 67191, 67184
24284, 12747, 12748, 12759, 12758, 66000, 66002, 66024, 66022, 13129, 13151, 13152, 13149, 67115, 67193, 67194, 
67186, 67106, 67113, 67192, 67185
24285, 66000, 66002, 66024, 66022, 66001, 66003, 66025, 66023, 67115, 67193, 67194, 67186, 67118, 67196, 67197, 
67189, 67109, 67116, 67195, 67188
24286, 66001, 66003, 66025, 66023, 14024, 14025, 14036, 14035, 67118, 67196, 67197, 67189, 14406, 14428, 14429, 
14426, 67112, 67119, 67198, 67191
24287, 12748, 12749, 12760, 12759, 66002, 66004, 66026, 66024, 13131, 13153, 13154, 13151, 67122, 67200, 67201, 
67193, 67113, 67120, 67199, 67192
24288, 66002, 66004, 66026, 66024, 66003, 66005, 66027, 66025, 67122, 67200, 67201, 67193, 67125, 67203, 67204, 
67196, 67116, 67123, 67202, 67195
24289, 66003, 66005, 66027, 66025, 14025, 14026, 14037, 14036, 67125, 67203, 67204, 67196, 14408, 14430, 14431, 
14428, 67119, 67126, 67205, 67198
24290, 12749, 12750, 12761, 12760, 66004, 66006, 66028, 66026, 13133, 13155, 13156, 13153, 67129, 67207, 67208, 
67200, 67120, 67127, 67206, 67199
24291, 66004, 66006, 66028, 66026, 66005, 66007, 66029, 66027, 67129, 67207, 67208, 67200, 67132, 67210, 67211, 
67203, 67123, 67130, 67209, 67202
24292, 66005, 66007, 66029, 66027, 14026, 14027, 14038, 14037, 67132, 67210, 67211, 67203, 14410, 14432, 14433, 
14430, 67126, 67133, 67212, 67205
24293, 12750, 12751, 12762, 12761, 66006, 66008, 66030, 66028, 13135, 13157, 13158, 13155, 67136, 67214, 67215, 
67207, 67127, 67134, 67213, 67206
24294, 66006, 66008, 66030, 66028, 66007, 66009, 66031, 66029, 67136, 67214, 67215, 67207, 67139, 67217, 67218, 
67210, 67130, 67137, 67216, 67209
24295, 66007, 66009, 66031, 66029, 14027, 14028, 14039, 14038, 67139, 67217, 67218, 67210, 14412, 14434, 14435, 
14432, 67133, 67140, 67219, 67212
24296, 12751, 953, 954, 12762, 66008, 13686, 13688, 66030, 13136, 977, 13159, 13157, 67141, 13768, 67220, 
67214, 67134, 13762, 13767, 67213
24297, 66008, 13686, 13688, 66030, 66009, 13687, 13689, 66031, 67141, 13768, 67220, 67214, 67142, 13770, 67221, 
67217, 67137, 13764, 13769, 67216
24298, 66009, 13687, 13689, 66031, 14028, 1113, 1114, 14039, 67142, 13770, 67221, 67217, 14413, 1137, 14436, 
14434, 67140, 13766, 13771, 67219
24299, 882, 12752, 12763, 883, 13446, 66010, 66032, 13448, 13138, 13160, 13161, 906, 67145, 67223, 67224, 
13530, 13526, 67143, 67222, 13531
24300, 13446, 66010, 66032, 13448, 13447, 66011, 66033, 13449, 67145, 67223, 67224, 13530, 67148, 67226, 67227, 
13532, 13528, 67146, 67225, 13533
24301, 13447, 66011, 66033, 13449, 1034, 14029, 14040, 1035, 67148, 67226, 67227, 13532, 14415, 14437, 14438, 
1058, 13529, 67149, 67228, 13534
24302, 12752, 12753, 12764, 12763, 66010, 66012, 66034, 66032, 13140, 13162, 13163, 13160, 67152, 67230, 67231, 
67223, 67143, 67150, 67229, 67222
24303, 66010, 66012, 66034, 66032, 66011, 66013, 66035, 66033, 67152, 67230, 67231, 67223, 67155, 67233, 67234, 
67226, 67146, 67153, 67232, 67225
24304, 66011, 66013, 66035, 66033, 14029, 14030, 14041, 14040, 67155, 67233, 67234, 67226, 14417, 14439, 14440, 
14437, 67149, 67156, 67235, 67228
24305, 12753, 12754, 12765, 12764, 66012, 66014, 66036, 66034, 13142, 13164, 13165, 13162, 67159, 67237, 67238, 
67230, 67150, 67157, 67236, 67229
24306, 66012, 66014, 66036, 66034, 66013, 66015, 66037, 66035, 67159, 67237, 67238, 67230, 67162, 67240, 67241, 
67233, 67153, 67160, 67239, 67232
24307, 66013, 66015, 66037, 66035, 14030, 14031, 14042, 14041, 67162, 67240, 67241, 67233, 14419, 14441, 14442, 
14439, 67156, 67163, 67242, 67235
24308, 12754, 12755, 12766, 12765, 66014, 66016, 66038, 66036, 13144, 13166, 13167, 13164, 67166, 67244, 67245, 
67237, 67157, 67164, 67243, 67236
24309, 66014, 66016, 66038, 66036, 66015, 66017, 66039, 66037, 67166, 67244, 67245, 67237, 67169, 67247, 67248, 
67240, 67160, 67167, 67246, 67239
24310, 66015, 66017, 66039, 66037, 14031, 14032, 14043, 14042, 67169, 67247, 67248, 67240, 14421, 14443, 14444, 
14441, 67163, 67170, 67249, 67242
24311, 12755, 12756, 12767, 12766, 66016, 66018, 66040, 66038, 13146, 13168, 13169, 13166, 67173, 67251, 67252, 
67244, 67164, 67171, 67250, 67243
24312, 66016, 66018, 66040, 66038, 66017, 66019, 66041, 66039, 67173, 67251, 67252, 67244, 67176, 67254, 67255, 
67247, 67167, 67174, 67253, 67246
24313, 66017, 66019, 66041, 66039, 14032, 14033, 14044, 14043, 67176, 67254, 67255, 67247, 14423, 14445, 14446, 
14443, 67170, 67177, 67256, 67249
24314, 12756, 12757, 12768, 12767, 66018, 66020, 66042, 66040, 13148, 13170, 13171, 13168, 67180, 67258, 67259, 
67251, 67171, 67178, 67257, 67250
24315, 66018, 66020, 66042, 66040, 66019, 66021, 66043, 66041, 67180, 67258, 67259, 67251, 67183, 67261, 67262, 
67254, 67174, 67181, 67260, 67253
24316, 66019, 66021, 66043, 66041, 14033, 14034, 14045, 14044, 67183, 67261, 67262, 67254, 14425, 14447, 14448, 
14445, 67177, 67184, 67263, 67256
24317, 12757, 12758, 12769, 12768, 66020, 66022, 66044, 66042, 13150, 13172, 13173, 13170, 67187, 67265, 67266, 
67258, 67178, 67185, 67264, 67257
24318, 66020, 66022, 66044, 66042, 66021, 66023, 66045, 66043, 67187, 67265, 67266, 67258, 67190, 67268, 67269, 
67261, 67181, 67188, 67267, 67260
24319, 66021, 66023, 66045, 66043, 14034, 14035, 14046, 14045, 67190, 67268, 67269, 67261, 14427, 14449, 14450, 
14447, 67184, 67191, 67270, 67263
24320, 12758, 12759, 12770, 12769, 66022, 66024, 66046, 66044, 13152, 13174, 13175, 13172, 67194, 67272, 67273, 
67265, 67185, 67192, 67271, 67264
24321, 66022, 66024, 66046, 66044, 66023, 66025, 66047, 66045, 67194, 67272, 67273, 67265, 67197, 67275, 67276, 
67268, 67188, 67195, 67274, 67267
24322, 66023, 66025, 66047, 66045, 14035, 14036, 14047, 14046, 67197, 67275, 67276, 67268, 14429, 14451, 14452, 
14449, 67191, 67198, 67277, 67270
24323, 12759, 12760, 12771, 12770, 66024, 66026, 66048, 66046, 13154, 13176, 13177, 13174, 67201, 67279, 67280, 
67272, 67192, 67199, 67278, 67271
24324, 66024, 66026, 66048, 66046, 66025, 66027, 66049, 66047, 67201, 67279, 67280, 67272, 67204, 67282, 67283, 
67275, 67195, 67202, 67281, 67274
24325, 66025, 66027, 66049, 66047, 14036, 14037, 14048, 14047, 67204, 67282, 67283, 67275, 14431, 14453, 14454, 
14451, 67198, 67205, 67284, 67277
24326, 12760, 12761, 12772, 12771, 66026, 66028, 66050, 66048, 13156, 13178, 13179, 13176, 67208, 67286, 67287, 
67279, 67199, 67206, 67285, 67278
24327, 66026, 66028, 66050, 66048, 66027, 66029, 66051, 66049, 67208, 67286, 67287, 67279, 67211, 67289, 67290, 
67282, 67202, 67209, 67288, 67281
24328, 66027, 66029, 66051, 66049, 14037, 14038, 14049, 14048, 67211, 67289, 67290, 67282, 14433, 14455, 14456, 
14453, 67205, 67212, 67291, 67284
24329, 12761, 12762, 12773, 12772, 66028, 66030, 66052, 66050, 13158, 13180, 13181, 13178, 67215, 67293, 67294, 
67286, 67206, 67213, 67292, 67285
24330, 66028, 66030, 66052, 66050, 66029, 66031, 66053, 66051, 67215, 67293, 67294, 67286, 67218, 67296, 67297, 
67289, 67209, 67216, 67295, 67288
24331, 66029, 66031, 66053, 66051, 14038, 14039, 14050, 14049, 67218, 67296, 67297, 67289, 14435, 14457, 14458, 
14455, 67212, 67219, 67298, 67291
24332, 12762, 954, 955, 12773, 66030, 13688, 13690, 66052, 13159, 978, 13182, 13180, 67220, 13773, 67299, 
67293, 67213, 13767, 13772, 67292
24333, 66030, 13688, 13690, 66052, 66031, 13689, 13691, 66053, 67220, 13773, 67299, 67293, 67221, 13775, 67300, 
67296, 67216, 13769, 13774, 67295
24334, 66031, 13689, 13691, 66053, 14039, 1114, 1115, 14050, 67221, 13775, 67300, 67296, 14436, 1138, 14459, 
14457, 67219, 13771, 13776, 67298
24335, 883, 12763, 12774, 884, 13448, 66032, 66054, 13450, 13161, 13183, 13184, 907, 67224, 67302, 67303, 
13535, 13531, 67222, 67301, 13536
24336, 13448, 66032, 66054, 13450, 13449, 66033, 66055, 13451, 67224, 67302, 67303, 13535, 67227, 67305, 67306, 
13537, 13533, 67225, 67304, 13538
24337, 13449, 66033, 66055, 13451, 1035, 14040, 14051, 1036, 67227, 67305, 67306, 13537, 14438, 14460, 14461, 
1059, 13534, 67228, 67307, 13539
24338, 12763, 12764, 12775, 12774, 66032, 66034, 66056, 66054, 13163, 13185, 13186, 13183, 67231, 67309, 67310, 
67302, 67222, 67229, 67308, 67301
24339, 66032, 66034, 66056, 66054, 66033, 66035, 66057, 66055, 67231, 67309, 67310, 67302, 67234, 67312, 67313, 
67305, 67225, 67232, 67311, 67304
24340, 66033, 66035, 66057, 66055, 14040, 14041, 14052, 14051, 67234, 67312, 67313, 67305, 14440, 14462, 14463, 
14460, 67228, 67235, 67314, 67307
24341, 12764, 12765, 12776, 12775, 66034, 66036, 66058, 66056, 13165, 13187, 13188, 13185, 67238, 67316, 67317, 
67309, 67229, 67236, 67315, 67308
24342, 66034, 66036, 66058, 66056, 66035, 66037, 66059, 66057, 67238, 67316, 67317, 67309, 67241, 67319, 67320, 
67312, 67232, 67239, 67318, 67311
24343, 66035, 66037, 66059, 66057, 14041, 14042, 14053, 14052, 67241, 67319, 67320, 67312, 14442, 14464, 14465, 
14462, 67235, 67242, 67321, 67314
24344, 12765, 12766, 12777, 12776, 66036, 66038, 66060, 66058, 13167, 13189, 13190, 13187, 67245, 67323, 67324, 
67316, 67236, 67243, 67322, 67315
24345, 66036, 66038, 66060, 66058, 66037, 66039, 66061, 66059, 67245, 67323, 67324, 67316, 67248, 67326, 67327, 
67319, 67239, 67246, 67325, 67318
24346, 66037, 66039, 66061, 66059, 14042, 14043, 14054, 14053, 67248, 67326, 67327, 67319, 14444, 14466, 14467, 
14464, 67242, 67249, 67328, 67321
24347, 12766, 12767, 12778, 12777, 66038, 66040, 66062, 66060, 13169, 13191, 13192, 13189, 67252, 67330, 67331, 
67323, 67243, 67250, 67329, 67322
24348, 66038, 66040, 66062, 66060, 66039, 66041, 66063, 66061, 67252, 67330, 67331, 67323, 67255, 67333, 67334, 
67326, 67246, 67253, 67332, 67325
24349, 66039, 66041, 66063, 66061, 14043, 14044, 14055, 14054, 67255, 67333, 67334, 67326, 14446, 14468, 14469, 
14466, 67249, 67256, 67335, 67328
24350, 12767, 12768, 12779, 12778, 66040, 66042, 66064, 66062, 13171, 13193, 13194, 13191, 67259, 67337, 67338, 
67330, 67250, 67257, 67336, 67329
24351, 66040, 66042, 66064, 66062, 66041, 66043, 66065, 66063, 67259, 67337, 67338, 67330, 67262, 67340, 67341, 
67333, 67253, 67260, 67339, 67332
24352, 66041, 66043, 66065, 66063, 14044, 14045, 14056, 14055, 67262, 67340, 67341, 67333, 14448, 14470, 14471, 
14468, 67256, 67263, 67342, 67335
24353, 12768, 12769, 12780, 12779, 66042, 66044, 66066, 66064, 13173, 13195, 13196, 13193, 67266, 67344, 67345, 
67337, 67257, 67264, 67343, 67336
24354, 66042, 66044, 66066, 66064, 66043, 66045, 66067, 66065, 67266, 67344, 67345, 67337, 67269, 67347, 67348, 
67340, 67260, 67267, 67346, 67339
24355, 66043, 66045, 66067, 66065, 14045, 14046, 14057, 14056, 67269, 67347, 67348, 67340, 14450, 14472, 14473, 
14470, 67263, 67270, 67349, 67342
24356, 12769, 12770, 12781, 12780, 66044, 66046, 66068, 66066, 13175, 13197, 13198, 13195, 67273, 67351, 67352, 
67344, 67264, 67271, 67350, 67343
24357, 66044, 66046, 66068, 66066, 66045, 66047, 66069, 66067, 67273, 67351, 67352, 67344, 67276, 67354, 67355, 
67347, 67267, 67274, 67353, 67346
24358, 66045, 66047, 66069, 66067, 14046, 14047, 14058, 14057, 67276, 67354, 67355, 67347, 14452, 14474, 14475, 
14472, 67270, 67277, 67356, 67349
24359, 12770, 12771, 12782, 12781, 66046, 66048, 66070, 66068, 13177, 13199, 13200, 13197, 67280, 67358, 67359, 
67351, 67271, 67278, 67357, 67350
24360, 66046, 66048, 66070, 66068, 66047, 66049, 66071, 66069, 67280, 67358, 67359, 67351, 67283, 67361, 67362, 
67354, 67274, 67281, 67360, 67353
24361, 66047, 66049, 66071, 66069, 14047, 14048, 14059, 14058, 67283, 67361, 67362, 67354, 14454, 14476, 14477, 
14474, 67277, 67284, 67363, 67356
24362, 12771, 12772, 12783, 12782, 66048, 66050, 66072, 66070, 13179, 13201, 13202, 13199, 67287, 67365, 67366, 
67358, 67278, 67285, 67364, 67357
24363, 66048, 66050, 66072, 66070, 66049, 66051, 66073, 66071, 67287, 67365, 67366, 67358, 67290, 67368, 67369, 
67361, 67281, 67288, 67367, 67360
24364, 66049, 66051, 66073, 66071, 14048, 14049, 14060, 14059, 67290, 67368, 67369, 67361, 14456, 14478, 14479, 
14476, 67284, 67291, 67370, 67363
24365, 12772, 12773, 12784, 12783, 66050, 66052, 66074, 66072, 13181, 13203, 13204, 13201, 67294, 67372, 67373, 
67365, 67285, 67292, 67371, 67364
24366, 66050, 66052, 66074, 66072, 66051, 66053, 66075, 66073, 67294, 67372, 67373, 67365, 67297, 67375, 67376, 
67368, 67288, 67295, 67374, 67367
24367, 66051, 66053, 66075, 66073, 14049, 14050, 14061, 14060, 67297, 67375, 67376, 67368, 14458, 14480, 14481, 
14478, 67291, 67298, 67377, 67370
24368, 12773, 955, 956, 12784, 66052, 13690, 13692, 66074, 13182, 979, 13205, 13203, 67299, 13778, 67378, 
67372, 67292, 13772, 13777, 67371
24369, 66052, 13690, 13692, 66074, 66053, 13691, 13693, 66075, 67299, 13778, 67378, 67372, 67300, 13780, 67379, 
67375, 67295, 13774, 13779, 67374
24370, 66053, 13691, 13693, 66075, 14050, 1115, 1116, 14061, 67300, 13780, 67379, 67375, 14459, 1139, 14482, 
14480, 67298, 13776, 13781, 67377
24371, 884, 12774, 12785, 885, 13450, 66054, 66076, 13452, 13184, 13206, 13207, 908, 67303, 67381, 67382, 
13540, 13536, 67301, 67380, 13541
24372, 13450, 66054, 66076, 13452, 13451, 66055, 66077, 13453, 67303, 67381, 67382, 13540, 67306, 67384, 67385, 
13542, 13538, 67304, 67383, 13543
24373, 13451, 66055, 66077, 13453, 1036, 14051, 14062, 1037, 67306, 67384, 67385, 13542, 14461, 14483, 14484, 
1060, 13539, 67307, 67386, 13544
24374, 12774, 12775, 12786, 12785, 66054, 66056, 66078, 66076, 13186, 13208, 13209, 13206, 67310, 67388, 67389, 
67381, 67301, 67308, 67387, 67380
24375, 66054, 66056, 66078, 66076, 66055, 66057, 66079, 66077, 67310, 67388, 67389, 67381, 67313, 67391, 67392, 
67384, 67304, 67311, 67390, 67383
24376, 66055, 66057, 66079, 66077, 14051, 14052, 14063, 14062, 67313, 67391, 67392, 67384, 14463, 14485, 14486, 
14483, 67307, 67314, 67393, 67386
24377, 12775, 12776, 12787, 12786, 66056, 66058, 66080, 66078, 13188, 13210, 13211, 13208, 67317, 67395, 67396, 
67388, 67308, 67315, 67394, 67387
24378, 66056, 66058, 66080, 66078, 66057, 66059, 66081, 66079, 67317, 67395, 67396, 67388, 67320, 67398, 67399, 
67391, 67311, 67318, 67397, 67390
24379, 66057, 66059, 66081, 66079, 14052, 14053, 14064, 14063, 67320, 67398, 67399, 67391, 14465, 14487, 14488, 
14485, 67314, 67321, 67400, 67393
24380, 12776, 12777, 12788, 12787, 66058, 66060, 66082, 66080, 13190, 13212, 13213, 13210, 67324, 67402, 67403, 
67395, 67315, 67322, 67401, 67394
24381, 66058, 66060, 66082, 66080, 66059, 66061, 66083, 66081, 67324, 67402, 67403, 67395, 67327, 67405, 67406, 
67398, 67318, 67325, 67404, 67397
24382, 66059, 66061, 66083, 66081, 14053, 14054, 14065, 14064, 67327, 67405, 67406, 67398, 14467, 14489, 14490, 
14487, 67321, 67328, 67407, 67400
24383, 12777, 12778, 12789, 12788, 66060, 66062, 66084, 66082, 13192, 13214, 13215, 13212, 67331, 67409, 67410, 
67402, 67322, 67329, 67408, 67401
24384, 66060, 66062, 66084, 66082, 66061, 66063, 66085, 66083, 67331, 67409, 67410, 67402, 67334, 67412, 67413, 
67405, 67325, 67332, 67411, 67404
24385, 66061, 66063, 66085, 66083, 14054, 14055, 14066, 14065, 67334, 67412, 67413, 67405, 14469, 14491, 14492, 
14489, 67328, 67335, 67414, 67407
24386, 12778, 12779, 12790, 12789, 66062, 66064, 66086, 66084, 13194, 13216, 13217, 13214, 67338, 67416, 67417, 
67409, 67329, 67336, 67415, 67408
24387, 66062, 66064, 66086, 66084, 66063, 66065, 66087, 66085, 67338, 67416, 67417, 67409, 67341, 67419, 67420, 
67412, 67332, 67339, 67418, 67411
24388, 66063, 66065, 66087, 66085, 14055, 14056, 14067, 14066, 67341, 67419, 67420, 67412, 14471, 14493, 14494, 
14491, 67335, 67342, 67421, 67414
24389, 12779, 12780, 12791, 12790, 66064, 66066, 66088, 66086, 13196, 13218, 13219, 13216, 67345, 67423, 67424, 
67416, 67336, 67343, 67422, 67415
24390, 66064, 66066, 66088, 66086, 66065, 66067, 66089, 66087, 67345, 67423, 67424, 67416, 67348, 67426, 67427, 
67419, 67339, 67346, 67425, 67418
24391, 66065, 66067, 66089, 66087, 14056, 14057, 14068, 14067, 67348, 67426, 67427, 67419, 14473, 14495, 14496, 
14493, 67342, 67349, 67428, 67421
24392, 12780, 12781, 12792, 12791, 66066, 66068, 66090, 66088, 13198, 13220, 13221, 13218, 67352, 67430, 67431, 
67423, 67343, 67350, 67429, 67422
24393, 66066, 66068, 66090, 66088, 66067, 66069, 66091, 66089, 67352, 67430, 67431, 67423, 67355, 67433, 67434, 
67426, 67346, 67353, 67432, 67425
24394, 66067, 66069, 66091, 66089, 14057, 14058, 14069, 14068, 67355, 67433, 67434, 67426, 14475, 14497, 14498, 
14495, 67349, 67356, 67435, 67428
24395, 12781, 12782, 12793, 12792, 66068, 66070, 66092, 66090, 13200, 13222, 13223, 13220, 67359, 67437, 67438, 
67430, 67350, 67357, 67436, 67429
24396, 66068, 66070, 66092, 66090, 66069, 66071, 66093, 66091, 67359, 67437, 67438, 67430, 67362, 67440, 67441, 
67433, 67353, 67360, 67439, 67432
24397, 66069, 66071, 66093, 66091, 14058, 14059, 14070, 14069, 67362, 67440, 67441, 67433, 14477, 14499, 14500, 
14497, 67356, 67363, 67442, 67435
24398, 12782, 12783, 12794, 12793, 66070, 66072, 66094, 66092, 13202, 13224, 13225, 13222, 67366, 67444, 67445, 
67437, 67357, 67364, 67443, 67436
24399, 66070, 66072, 66094, 66092, 66071, 66073, 66095, 66093, 67366, 67444, 67445, 67437, 67369, 67447, 67448, 
67440, 67360, 67367, 67446, 67439
24400, 66071, 66073, 66095, 66093, 14059, 14060, 14071, 14070, 67369, 67447, 67448, 67440, 14479, 14501, 14502, 
14499, 67363, 67370, 67449, 67442
24401, 12783, 12784, 12795, 12794, 66072, 66074, 66096, 66094, 13204, 13226, 13227, 13224, 67373, 67451, 67452, 
67444, 67364, 67371, 67450, 67443
24402, 66072, 66074, 66096, 66094, 66073, 66075, 66097, 66095, 67373, 67451, 67452, 67444, 67376, 67454, 67455, 
67447, 67367, 67374, 67453, 67446
24403, 66073, 66075, 66097, 66095, 14060, 14061, 14072, 14071, 67376, 67454, 67455, 67447, 14481, 14503, 14504, 
14501, 67370, 67377, 67456, 67449
24404, 12784, 956, 957, 12795, 66074, 13692, 13694, 66096, 13205, 980, 13228, 13226, 67378, 13783, 67457, 
67451, 67371, 13777, 13782, 67450
24405, 66074, 13692, 13694, 66096, 66075, 13693, 13695, 66097, 67378, 13783, 67457, 67451, 67379, 13785, 67458, 
67454, 67374, 13779, 13784, 67453
24406, 66075, 13693, 13695, 66097, 14061, 1116, 1117, 14072, 67379, 13785, 67458, 67454, 14482, 1140, 14505, 
14503, 67377, 13781, 13786, 67456
24407, 885, 12785, 12796, 886, 13452, 66076, 66098, 13454, 13207, 13229, 13230, 909, 67382, 67460, 67461, 
13545, 13541, 67380, 67459, 13546
24408, 13452, 66076, 66098, 13454, 13453, 66077, 66099, 13455, 67382, 67460, 67461, 13545, 67385, 67463, 67464, 
13547, 13543, 67383, 67462, 13548
24409, 13453, 66077, 66099, 13455, 1037, 14062, 14073, 1038, 67385, 67463, 67464, 13547, 14484, 14506, 14507, 
1061, 13544, 67386, 67465, 13549
24410, 12785, 12786, 12797, 12796, 66076, 66078, 66100, 66098, 13209, 13231, 13232, 13229, 67389, 67467, 67468, 
67460, 67380, 67387, 67466, 67459
24411, 66076, 66078, 66100, 66098, 66077, 66079, 66101, 66099, 67389, 67467, 67468, 67460, 67392, 67470, 67471, 
67463, 67383, 67390, 67469, 67462
24412, 66077, 66079, 66101, 66099, 14062, 14063, 14074, 14073, 67392, 67470, 67471, 67463, 14486, 14508, 14509, 
14506, 67386, 67393, 67472, 67465
24413, 12786, 12787, 12798, 12797, 66078, 66080, 66102, 66100, 13211, 13233, 13234, 13231, 67396, 67474, 67475, 
67467, 67387, 67394, 67473, 67466
24414, 66078, 66080, 66102, 66100, 66079, 66081, 66103, 66101, 67396, 67474, 67475, 67467, 67399, 67477, 67478, 
67470, 67390, 67397, 67476, 67469
24415, 66079, 66081, 66103, 66101, 14063, 14064, 14075, 14074, 67399, 67477, 67478, 67470, 14488, 14510, 14511, 
14508, 67393, 67400, 67479, 67472
24416, 12787, 12788, 12799, 12798, 66080, 66082, 66104, 66102, 13213, 13235, 13236, 13233, 67403, 67481, 67482, 
67474, 67394, 67401, 67480, 67473
24417, 66080, 66082, 66104, 66102, 66081, 66083, 66105, 66103, 67403, 67481, 67482, 67474, 67406, 67484, 67485, 
67477, 67397, 67404, 67483, 67476
24418, 66081, 66083, 66105, 66103, 14064, 14065, 14076, 14075, 67406, 67484, 67485, 67477, 14490, 14512, 14513, 
14510, 67400, 67407, 67486, 67479
24419, 12788, 12789, 12800, 12799, 66082, 66084, 66106, 66104, 13215, 13237, 13238, 13235, 67410, 67488, 67489, 
67481, 67401, 67408, 67487, 67480
24420, 66082, 66084, 66106, 66104, 66083, 66085, 66107, 66105, 67410, 67488, 67489, 67481, 67413, 67491, 67492, 
67484, 67404, 67411, 67490, 67483
24421, 66083, 66085, 66107, 66105, 14065, 14066, 14077, 14076, 67413, 67491, 67492, 67484, 14492, 14514, 14515, 
14512, 67407, 67414, 67493, 67486
24422, 12789, 12790, 12801, 12800, 66084, 66086, 66108, 66106, 13217, 13239, 13240, 13237, 67417, 67495, 67496, 
67488, 67408, 67415, 67494, 67487
24423, 66084, 66086, 66108, 66106, 66085, 66087, 66109, 66107, 67417, 67495, 67496, 67488, 67420, 67498, 67499, 
67491, 67411, 67418, 67497, 67490
24424, 66085, 66087, 66109, 66107, 14066, 14067, 14078, 14077, 67420, 67498, 67499, 67491, 14494, 14516, 14517, 
14514, 67414, 67421, 67500, 67493
24425, 12790, 12791, 12802, 12801, 66086, 66088, 66110, 66108, 13219, 13241, 13242, 13239, 67424, 67502, 67503, 
67495, 67415, 67422, 67501, 67494
24426, 66086, 66088, 66110, 66108, 66087, 66089, 66111, 66109, 67424, 67502, 67503, 67495, 67427, 67505, 67506, 
67498, 67418, 67425, 67504, 67497
24427, 66087, 66089, 66111, 66109, 14067, 14068, 14079, 14078, 67427, 67505, 67506, 67498, 14496, 14518, 14519, 
14516, 67421, 67428, 67507, 67500
24428, 12791, 12792, 12803, 12802, 66088, 66090, 66112, 66110, 13221, 13243, 13244, 13241, 67431, 67509, 67510, 
67502, 67422, 67429, 67508, 67501
24429, 66088, 66090, 66112, 66110, 66089, 66091, 66113, 66111, 67431, 67509, 67510, 67502, 67434, 67512, 67513, 
67505, 67425, 67432, 67511, 67504
24430, 66089, 66091, 66113, 66111, 14068, 14069, 14080, 14079, 67434, 67512, 67513, 67505, 14498, 14520, 14521, 
14518, 67428, 67435, 67514, 67507
24431, 12792, 12793, 12804, 12803, 66090, 66092, 66114, 66112, 13223, 13245, 13246, 13243, 67438, 67516, 67517, 
67509, 67429, 67436, 67515, 67508
24432, 66090, 66092, 66114, 66112, 66091, 66093, 66115, 66113, 67438, 67516, 67517, 67509, 67441, 67519, 67520, 
67512, 67432, 67439, 67518, 67511
24433, 66091, 66093, 66115, 66113, 14069, 14070, 14081, 14080, 67441, 67519, 67520, 67512, 14500, 14522, 14523, 
14520, 67435, 67442, 67521, 67514
24434, 12793, 12794, 12805, 12804, 66092, 66094, 66116, 66114, 13225, 13247, 13248, 13245, 67445, 67523, 67524, 
67516, 67436, 67443, 67522, 67515
24435, 66092, 66094, 66116, 66114, 66093, 66095, 66117, 66115, 67445, 67523, 67524, 67516, 67448, 67526, 67527, 
67519, 67439, 67446, 67525, 67518
24436, 66093, 66095, 66117, 66115, 14070, 14071, 14082, 14081, 67448, 67526, 67527, 67519, 14502, 14524, 14525, 
14522, 67442, 67449, 67528, 67521
24437, 12794, 12795, 12806, 12805, 66094, 66096, 66118, 66116, 13227, 13249, 13250, 13247, 67452, 67530, 67531, 
67523, 67443, 67450, 67529, 67522
24438, 66094, 66096, 66118, 66116, 66095, 66097, 66119, 66117, 67452, 67530, 67531, 67523, 67455, 67533, 67534, 
67526, 67446, 67453, 67532, 67525
24439, 66095, 66097, 66119, 66117, 14071, 14072, 14083, 14082, 67455, 67533, 67534, 67526, 14504, 14526, 14527, 
14524, 67449, 67456, 67535, 67528
24440, 12795, 957, 958, 12806, 66096, 13694, 13696, 66118, 13228, 981, 13251, 13249, 67457, 13788, 67536, 
67530, 67450, 13782, 13787, 67529
24441, 66096, 13694, 13696, 66118, 66097, 13695, 13697, 66119, 67457, 13788, 67536, 67530, 67458, 13790, 67537, 
67533, 67453, 13784, 13789, 67532
24442, 66097, 13695, 13697, 66119, 14072, 1117, 1118, 14083, 67458, 13790, 67537, 67533, 14505, 1141, 14528, 
14526, 67456, 13786, 13791, 67535
24443, 886, 12796, 12807, 887, 13454, 66098, 66120, 13456, 13230, 13252, 13253, 910, 67461, 67539, 67540, 
13550, 13546, 67459, 67538, 13551
24444, 13454, 66098, 66120, 13456, 13455, 66099, 66121, 13457, 67461, 67539, 67540, 13550, 67464, 67542, 67543, 
13552, 13548, 67462, 67541, 13553
24445, 13455, 66099, 66121, 13457, 1038, 14073, 14084, 1039, 67464, 67542, 67543, 13552, 14507, 14529, 14530, 
1062, 13549, 67465, 67544, 13554
24446, 12796, 12797, 12808, 12807, 66098, 66100, 66122, 66120, 13232, 13254, 13255, 13252, 67468, 67546, 67547, 
67539, 67459, 67466, 67545, 67538
24447, 66098, 66100, 66122, 66120, 66099, 66101, 66123, 66121, 67468, 67546, 67547, 67539, 67471, 67549, 67550, 
67542, 67462, 67469, 67548, 67541
24448, 66099, 66101, 66123, 66121, 14073, 14074, 14085, 14084, 67471, 67549, 67550, 67542, 14509, 14531, 14532, 
14529, 67465, 67472, 67551, 67544
24449, 12797, 12798, 12809, 12808, 66100, 66102, 66124, 66122, 13234, 13256, 13257, 13254, 67475, 67553, 67554, 
67546, 67466, 67473, 67552, 67545
24450, 66100, 66102, 66124, 66122, 66101, 66103, 66125, 66123, 67475, 67553, 67554, 67546, 67478, 67556, 67557, 
67549, 67469, 67476, 67555, 67548
24451, 66101, 66103, 66125, 66123, 14074, 14075, 14086, 14085, 67478, 67556, 67557, 67549, 14511, 14533, 14534, 
14531, 67472, 67479, 67558, 67551
24452, 12798, 12799, 12810, 12809, 66102, 66104, 66126, 66124, 13236, 13258, 13259, 13256, 67482, 67560, 67561, 
67553, 67473, 67480, 67559, 67552
24453, 66102, 66104, 66126, 66124, 66103, 66105, 66127, 66125, 67482, 67560, 67561, 67553, 67485, 67563, 67564, 
67556, 67476, 67483, 67562, 67555
24454, 66103, 66105, 66127, 66125, 14075, 14076, 14087, 14086, 67485, 67563, 67564, 67556, 14513, 14535, 14536, 
14533, 67479, 67486, 67565, 67558
24455, 12799, 12800, 12811, 12810, 66104, 66106, 66128, 66126, 13238, 13260, 13261, 13258, 67489, 67567, 67568, 
67560, 67480, 67487, 67566, 67559
24456, 66104, 66106, 66128, 66126, 66105, 66107, 66129, 66127, 67489, 67567, 67568, 67560, 67492, 67570, 67571, 
67563, 67483, 67490, 67569, 67562
24457, 66105, 66107, 66129, 66127, 14076, 14077, 14088, 14087, 67492, 67570, 67571, 67563, 14515, 14537, 14538, 
14535, 67486, 67493, 67572, 67565
24458, 12800, 12801, 12812, 12811, 66106, 66108, 66130, 66128, 13240, 13262, 13263, 13260, 67496, 67574, 67575, 
67567, 67487, 67494, 67573, 67566
24459, 66106, 66108, 66130, 66128, 66107, 66109, 66131, 66129, 67496, 67574, 67575, 67567, 67499, 67577, 67578, 
67570, 67490, 67497, 67576, 67569
24460, 66107, 66109, 66131, 66129, 14077, 14078, 14089, 14088, 67499, 67577, 67578, 67570, 14517, 14539, 14540, 
14537, 67493, 67500, 67579, 67572
24461, 12801, 12802, 12813, 12812, 66108, 66110, 66132, 66130, 13242, 13264, 13265, 13262, 67503, 67581, 67582, 
67574, 67494, 67501, 67580, 67573
24462, 66108, 66110, 66132, 66130, 66109, 66111, 66133, 66131, 67503, 67581, 67582, 67574, 67506, 67584, 67585, 
67577, 67497, 67504, 67583, 67576
24463, 66109, 66111, 66133, 66131, 14078, 14079, 14090, 14089, 67506, 67584, 67585, 67577, 14519, 14541, 14542, 
14539, 67500, 67507, 67586, 67579
24464, 12802, 12803, 12814, 12813, 66110, 66112, 66134, 66132, 13244, 13266, 13267, 13264, 67510, 67588, 67589, 
67581, 67501, 67508, 67587, 67580
24465, 66110, 66112, 66134, 66132, 66111, 66113, 66135, 66133, 67510, 67588, 67589, 67581, 67513, 67591, 67592, 
67584, 67504, 67511, 67590, 67583
24466, 66111, 66113, 66135, 66133, 14079, 14080, 14091, 14090, 67513, 67591, 67592, 67584, 14521, 14543, 14544, 
14541, 67507, 67514, 67593, 67586
24467, 12803, 12804, 12815, 12814, 66112, 66114, 66136, 66134, 13246, 13268, 13269, 13266, 67517, 67595, 67596, 
67588, 67508, 67515, 67594, 67587
24468, 66112, 66114, 66136, 66134, 66113, 66115, 66137, 66135, 67517, 67595, 67596, 67588, 67520, 67598, 67599, 
67591, 67511, 67518, 67597, 67590
24469, 66113, 66115, 66137, 66135, 14080, 14081, 14092, 14091, 67520, 67598, 67599, 67591, 14523, 14545, 14546, 
14543, 67514, 67521, 67600, 67593
24470, 12804, 12805, 12816, 12815, 66114, 66116, 66138, 66136, 13248, 13270, 13271, 13268, 67524, 67602, 67603, 
67595, 67515, 67522, 67601, 67594
24471, 66114, 66116, 66138, 66136, 66115, 66117, 66139, 66137, 67524, 67602, 67603, 67595, 67527, 67605, 67606, 
67598, 67518, 67525, 67604, 67597
24472, 66115, 66117, 66139, 66137, 14081, 14082, 14093, 14092, 67527, 67605, 67606, 67598, 14525, 14547, 14548, 
14545, 67521, 67528, 67607, 67600
24473, 12805, 12806, 12817, 12816, 66116, 66118, 66140, 66138, 13250, 13272, 13273, 13270, 67531, 67609, 67610, 
67602, 67522, 67529, 67608, 67601
24474, 66116, 66118, 66140, 66138, 66117, 66119, 66141, 66139, 67531, 67609, 67610, 67602, 67534, 67612, 67613, 
67605, 67525, 67532, 67611, 67604
24475, 66117, 66119, 66141, 66139, 14082, 14083, 14094, 14093, 67534, 67612, 67613, 67605, 14527, 14549, 14550, 
14547, 67528, 67535, 67614, 67607
24476, 12806, 958, 959, 12817, 66118, 13696, 13698, 66140, 13251, 982, 13274, 13272, 67536, 13793, 67615, 
67609, 67529, 13787, 13792, 67608
24477, 66118, 13696, 13698, 66140, 66119, 13697, 13699, 66141, 67536, 13793, 67615, 67609, 67537, 13795, 67616, 
67612, 67532, 13789, 13794, 67611
24478, 66119, 13697, 13699, 66141, 14083, 1118, 1119, 14094, 67537, 13795, 67616, 67612, 14528, 1142, 14551, 
14549, 67535, 13791, 13796, 67614
24479, 887, 12807, 12818, 888, 13456, 66120, 66142, 13458, 13253, 13275, 13276, 911, 67540, 67618, 67619, 
13555, 13551, 67538, 67617, 13556
24480, 13456, 66120, 66142, 13458, 13457, 66121, 66143, 13459, 67540, 67618, 67619, 13555, 67543, 67621, 67622, 
13557, 13553, 67541, 67620, 13558
24481, 13457, 66121, 66143, 13459, 1039, 14084, 14095, 1040, 67543, 67621, 67622, 13557, 14530, 14552, 14553, 
1063, 13554, 67544, 67623, 13559
24482, 12807, 12808, 12819, 12818, 66120, 66122, 66144, 66142, 13255, 13277, 13278, 13275, 67547, 67625, 67626, 
67618, 67538, 67545, 67624, 67617
24483, 66120, 66122, 66144, 66142, 66121, 66123, 66145, 66143, 67547, 67625, 67626, 67618, 67550, 67628, 67629, 
67621, 67541, 67548, 67627, 67620
24484, 66121, 66123, 66145, 66143, 14084, 14085, 14096, 14095, 67550, 67628, 67629, 67621, 14532, 14554, 14555, 
14552, 67544, 67551, 67630, 67623
24485, 12808, 12809, 12820, 12819, 66122, 66124, 66146, 66144, 13257, 13279, 13280, 13277, 67554, 67632, 67633, 
67625, 67545, 67552, 67631, 67624
24486, 66122, 66124, 66146, 66144, 66123, 66125, 66147, 66145, 67554, 67632, 67633, 67625, 67557, 67635, 67636, 
67628, 67548, 67555, 67634, 67627
24487, 66123, 66125, 66147, 66145, 14085, 14086, 14097, 14096, 67557, 67635, 67636, 67628, 14534, 14556, 14557, 
14554, 67551, 67558, 67637, 67630
24488, 12809, 12810, 12821, 12820, 66124, 66126, 66148, 66146, 13259, 13281, 13282, 13279, 67561, 67639, 67640, 
67632, 67552, 67559, 67638, 67631
24489, 66124, 66126, 66148, 66146, 66125, 66127, 66149, 66147, 67561, 67639, 67640, 67632, 67564, 67642, 67643, 
67635, 67555, 67562, 67641, 67634
24490, 66125, 66127, 66149, 66147, 14086, 14087, 14098, 14097, 67564, 67642, 67643, 67635, 14536, 14558, 14559, 
14556, 67558, 67565, 67644, 67637
24491, 12810, 12811, 12822, 12821, 66126, 66128, 66150, 66148, 13261, 13283, 13284, 13281, 67568, 67646, 67647, 
67639, 67559, 67566, 67645, 67638
24492, 66126, 66128, 66150, 66148, 66127, 66129, 66151, 66149, 67568, 67646, 67647, 67639, 67571, 67649, 67650, 
67642, 67562, 67569, 67648, 67641
24493, 66127, 66129, 66151, 66149, 14087, 14088, 14099, 14098, 67571, 67649, 67650, 67642, 14538, 14560, 14561, 
14558, 67565, 67572, 67651, 67644
24494, 12811, 12812, 12823, 12822, 66128, 66130, 66152, 66150, 13263, 13285, 13286, 13283, 67575, 67653, 67654, 
67646, 67566, 67573, 67652, 67645
24495, 66128, 66130, 66152, 66150, 66129, 66131, 66153, 66151, 67575, 67653, 67654, 67646, 67578, 67656, 67657, 
67649, 67569, 67576, 67655, 67648
24496, 66129, 66131, 66153, 66151, 14088, 14089, 14100, 14099, 67578, 67656, 67657, 67649, 14540, 14562, 14563, 
14560, 67572, 67579, 67658, 67651
24497, 12812, 12813, 12824, 12823, 66130, 66132, 66154, 66152, 13265, 13287, 13288, 13285, 67582, 67660, 67661, 
67653, 67573, 67580, 67659, 67652
24498, 66130, 66132, 66154, 66152, 66131, 66133, 66155, 66153, 67582, 67660, 67661, 67653, 67585, 67663, 67664, 
67656, 67576, 67583, 67662, 67655
24499, 66131, 66133, 66155, 66153, 14089, 14090, 14101, 14100, 67585, 67663, 67664, 67656, 14542, 14564, 14565, 
14562, 67579, 67586, 67665, 67658
24500, 12813, 12814, 12825, 12824, 66132, 66134, 66156, 66154, 13267, 13289, 13290, 13287, 67589, 67667, 67668, 
67660, 67580, 67587, 67666, 67659
24501, 66132, 66134, 66156, 66154, 66133, 66135, 66157, 66155, 67589, 67667, 67668, 67660, 67592, 67670, 67671, 
67663, 67583, 67590, 67669, 67662
24502, 66133, 66135, 66157, 66155, 14090, 14091, 14102, 14101, 67592, 67670, 67671, 67663, 14544, 14566, 14567, 
14564, 67586, 67593, 67672, 67665
24503, 12814, 12815, 12826, 12825, 66134, 66136, 66158, 66156, 13269, 13291, 13292, 13289, 67596, 67674, 67675, 
67667, 67587, 67594, 67673, 67666
24504, 66134, 66136, 66158, 66156, 66135, 66137, 66159, 66157, 67596, 67674, 67675, 67667, 67599, 67677, 67678, 
67670, 67590, 67597, 67676, 67669
24505, 66135, 66137, 66159, 66157, 14091, 14092, 14103, 14102, 67599, 67677, 67678, 67670, 14546, 14568, 14569, 
14566, 67593, 67600, 67679, 67672
24506, 12815, 12816, 12827, 12826, 66136, 66138, 66160, 66158, 13271, 13293, 13294, 13291, 67603, 67681, 67682, 
67674, 67594, 67601, 67680, 67673
24507, 66136, 66138, 66160, 66158, 66137, 66139, 66161, 66159, 67603, 67681, 67682, 67674, 67606, 67684, 67685, 
67677, 67597, 67604, 67683, 67676
24508, 66137, 66139, 66161, 66159, 14092, 14093, 14104, 14103, 67606, 67684, 67685, 67677, 14548, 14570, 14571, 
14568, 67600, 67607, 67686, 67679
24509, 12816, 12817, 12828, 12827, 66138, 66140, 66162, 66160, 13273, 13295, 13296, 13293, 67610, 67688, 67689, 
67681, 67601, 67608, 67687, 67680
24510, 66138, 66140, 66162, 66160, 66139, 66141, 66163, 66161, 67610, 67688, 67689, 67681, 67613, 67691, 67692, 
67684, 67604, 67611, 67690, 67683
24511, 66139, 66141, 66163, 66161, 14093, 14094, 14105, 14104, 67613, 67691, 67692, 67684, 14550, 14572, 14573, 
14570, 67607, 67614, 67693, 67686
24512, 12817, 959, 960, 12828, 66140, 13698, 13700, 66162, 13274, 983, 13297, 13295, 67615, 13798, 67694, 
67688, 67608, 13792, 13797, 67687
24513, 66140, 13698, 13700, 66162, 66141, 13699, 13701, 66163, 67615, 13798, 67694, 67688, 67616, 13800, 67695, 
67691, 67611, 13794, 13799, 67690
24514, 66141, 13699, 13701, 66163, 14094, 1119, 1120, 14105, 67616, 13800, 67695, 67691, 14551, 1143, 14574, 
14572, 67614, 13796, 13801, 67693
24515, 888, 12818, 12829, 889, 13458, 66142, 66164, 13460, 13276, 13298, 13299, 912, 67619, 67697, 67698, 
13560, 13556, 67617, 67696, 13561
24516, 13458, 66142, 66164, 13460, 13459, 66143, 66165, 13461, 67619, 67697, 67698, 13560, 67622, 67700, 67701, 
13562, 13558, 67620, 67699, 13563
24517, 13459, 66143, 66165, 13461, 1040, 14095, 14106, 1041, 67622, 67700, 67701, 13562, 14553, 14575, 14576, 
1064, 13559, 67623, 67702, 13564
24518, 12818, 12819, 12830, 12829, 66142, 66144, 66166, 66164, 13278, 13300, 13301, 13298, 67626, 67704, 67705, 
67697, 67617, 67624, 67703, 67696
24519, 66142, 66144, 66166, 66164, 66143, 66145, 66167, 66165, 67626, 67704, 67705, 67697, 67629, 67707, 67708, 
67700, 67620, 67627, 67706, 67699
24520, 66143, 66145, 66167, 66165, 14095, 14096, 14107, 14106, 67629, 67707, 67708, 67700, 14555, 14577, 14578, 
14575, 67623, 67630, 67709, 67702
24521, 12819, 12820, 12831, 12830, 66144, 66146, 66168, 66166, 13280, 13302, 13303, 13300, 67633, 67711, 67712, 
67704, 67624, 67631, 67710, 67703
24522, 66144, 66146, 66168, 66166, 66145, 66147, 66169, 66167, 67633, 67711, 67712, 67704, 67636, 67714, 67715, 
67707, 67627, 67634, 67713, 67706
24523, 66145, 66147, 66169, 66167, 14096, 14097, 14108, 14107, 67636, 67714, 67715, 67707, 14557, 14579, 14580, 
14577, 67630, 67637, 67716, 67709
24524, 12820, 12821, 12832, 12831, 66146, 66148, 66170, 66168, 13282, 13304, 13305, 13302, 67640, 67718, 67719, 
67711, 67631, 67638, 67717, 67710
24525, 66146, 66148, 66170, 66168, 66147, 66149, 66171, 66169, 67640, 67718, 67719, 67711, 67643, 67721, 67722, 
67714, 67634, 67641, 67720, 67713
24526, 66147, 66149, 66171, 66169, 14097, 14098, 14109, 14108, 67643, 67721, 67722, 67714, 14559, 14581, 14582, 
14579, 67637, 67644, 67723, 67716
24527, 12821, 12822, 12833, 12832, 66148, 66150, 66172, 66170, 13284, 13306, 13307, 13304, 67647, 67725, 67726, 
67718, 67638, 67645, 67724, 67717
24528, 66148, 66150, 66172, 66170, 66149, 66151, 66173, 66171, 67647, 67725, 67726, 67718, 67650, 67728, 67729, 
67721, 67641, 67648, 67727, 67720
24529, 66149, 66151, 66173, 66171, 14098, 14099, 14110, 14109, 67650, 67728, 67729, 67721, 14561, 14583, 14584, 
14581, 67644, 67651, 67730, 67723
24530, 12822, 12823, 12834, 12833, 66150, 66152, 66174, 66172, 13286, 13308, 13309, 13306, 67654, 67732, 67733, 
67725, 67645, 67652, 67731, 67724
24531, 66150, 66152, 66174, 66172, 66151, 66153, 66175, 66173, 67654, 67732, 67733, 67725, 67657, 67735, 67736, 
67728, 67648, 67655, 67734, 67727
24532, 66151, 66153, 66175, 66173, 14099, 14100, 14111, 14110, 67657, 67735, 67736, 67728, 14563, 14585, 14586, 
14583, 67651, 67658, 67737, 67730
24533, 12823, 12824, 12835, 12834, 66152, 66154, 66176, 66174, 13288, 13310, 13311, 13308, 67661, 67739, 67740, 
67732, 67652, 67659, 67738, 67731
24534, 66152, 66154, 66176, 66174, 66153, 66155, 66177, 66175, 67661, 67739, 67740, 67732, 67664, 67742, 67743, 
67735, 67655, 67662, 67741, 67734
24535, 66153, 66155, 66177, 66175, 14100, 14101, 14112, 14111, 67664, 67742, 67743, 67735, 14565, 14587, 14588, 
14585, 67658, 67665, 67744, 67737
24536, 12824, 12825, 12836, 12835, 66154, 66156, 66178, 66176, 13290, 13312, 13313, 13310, 67668, 67746, 67747, 
67739, 67659, 67666, 67745, 67738
24537, 66154, 66156, 66178, 66176, 66155, 66157, 66179, 66177, 67668, 67746, 67747, 67739, 67671, 67749, 67750, 
67742, 67662, 67669, 67748, 67741
24538, 66155, 66157, 66179, 66177, 14101, 14102, 14113, 14112, 67671, 67749, 67750, 67742, 14567, 14589, 14590, 
14587, 67665, 67672, 67751, 67744
24539, 12825, 12826, 12837, 12836, 66156, 66158, 66180, 66178, 13292, 13314, 13315, 13312, 67675, 67753, 67754, 
67746, 67666, 67673, 67752, 67745
24540, 66156, 66158, 66180, 66178, 66157, 66159, 66181, 66179, 67675, 67753, 67754, 67746, 67678, 67756, 67757, 
67749, 67669, 67676, 67755, 67748
24541, 66157, 66159, 66181, 66179, 14102, 14103, 14114, 14113, 67678, 67756, 67757, 67749, 14569, 14591, 14592, 
14589, 67672, 67679, 67758, 67751
24542, 12826, 12827, 12838, 12837, 66158, 66160, 66182, 66180, 13294, 13316, 13317, 13314, 67682, 67760, 67761, 
67753, 67673, 67680, 67759, 67752
24543, 66158, 66160, 66182, 66180, 66159, 66161, 66183, 66181, 67682, 67760, 67761, 67753, 67685, 67763, 67764, 
67756, 67676, 67683, 67762, 67755
24544, 66159, 66161, 66183, 66181, 14103, 14104, 14115, 14114, 67685, 67763, 67764, 67756, 14571, 14593, 14594, 
14591, 67679, 67686, 67765, 67758
24545, 12827, 12828, 12839, 12838, 66160, 66162, 66184, 66182, 13296, 13318, 13319, 13316, 67689, 67767, 67768, 
67760, 67680, 67687, 67766, 67759
24546, 66160, 66162, 66184, 66182, 66161, 66163, 66185, 66183, 67689, 67767, 67768, 67760, 67692, 67770, 67771, 
67763, 67683, 67690, 67769, 67762
24547, 66161, 66163, 66185, 66183, 14104, 14105, 14116, 14115, 67692, 67770, 67771, 67763, 14573, 14595, 14596, 
14593, 67686, 67693, 67772, 67765
24548, 12828, 960, 961, 12839, 66162, 13700, 13702, 66184, 13297, 984, 13320, 13318, 67694, 13803, 67773, 
67767, 67687, 13797, 13802, 67766
24549, 66162, 13700, 13702, 66184, 66163, 13701, 13703, 66185, 67694, 13803, 67773, 67767, 67695, 13805, 67774, 
67770, 67690, 13799, 13804, 67769
24550, 66163, 13701, 13703, 66185, 14105, 1120, 1121, 14116, 67695, 13805, 67774, 67770, 14574, 1144, 14597, 
14595, 67693, 13801, 13806, 67772
24551, 889, 12829, 12840, 890, 13460, 66164, 66186, 13462, 13299, 13321, 13322, 913, 67698, 67776, 67777, 
13565, 13561, 67696, 67775, 13566
24552, 13460, 66164, 66186, 13462, 13461, 66165, 66187, 13463, 67698, 67776, 67777, 13565, 67701, 67779, 67780, 
13567, 13563, 67699, 67778, 13568
24553, 13461, 66165, 66187, 13463, 1041, 14106, 14117, 1042, 67701, 67779, 67780, 13567, 14576, 14598, 14599, 
1065, 13564, 67702, 67781, 13569
24554, 12829, 12830, 12841, 12840, 66164, 66166, 66188, 66186, 13301, 13323, 13324, 13321, 67705, 67783, 67784, 
67776, 67696, 67703, 67782, 67775
24555, 66164, 66166, 66188, 66186, 66165, 66167, 66189, 66187, 67705, 67783, 67784, 67776, 67708, 67786, 67787, 
67779, 67699, 67706, 67785, 67778
24556, 66165, 66167, 66189, 66187, 14106, 14107, 14118, 14117, 67708, 67786, 67787, 67779, 14578, 14600, 14601, 
14598, 67702, 67709, 67788, 67781
24557, 12830, 12831, 12842, 12841, 66166, 66168, 66190, 66188, 13303, 13325, 13326, 13323, 67712, 67790, 67791, 
67783, 67703, 67710, 67789, 67782
24558, 66166, 66168, 66190, 66188, 66167, 66169, 66191, 66189, 67712, 67790, 67791, 67783, 67715, 67793, 67794, 
67786, 67706, 67713, 67792, 67785
24559, 66167, 66169, 66191, 66189, 14107, 14108, 14119, 14118, 67715, 67793, 67794, 67786, 14580, 14602, 14603, 
14600, 67709, 67716, 67795, 67788
24560, 12831, 12832, 12843, 12842, 66168, 66170, 66192, 66190, 13305, 13327, 13328, 13325, 67719, 67797, 67798, 
67790, 67710, 67717, 67796, 67789
24561, 66168, 66170, 66192, 66190, 66169, 66171, 66193, 66191, 67719, 67797, 67798, 67790, 67722, 67800, 67801, 
67793, 67713, 67720, 67799, 67792
24562, 66169, 66171, 66193, 66191, 14108, 14109, 14120, 14119, 67722, 67800, 67801, 67793, 14582, 14604, 14605, 
14602, 67716, 67723, 67802, 67795
24563, 12832, 12833, 12844, 12843, 66170, 66172, 66194, 66192, 13307, 13329, 13330, 13327, 67726, 67804, 67805, 
67797, 67717, 67724, 67803, 67796
24564, 66170, 66172, 66194, 66192, 66171, 66173, 66195, 66193, 67726, 67804, 67805, 67797, 67729, 67807, 67808, 
67800, 67720, 67727, 67806, 67799
24565, 66171, 66173, 66195, 66193, 14109, 14110, 14121, 14120, 67729, 67807, 67808, 67800, 14584, 14606, 14607, 
14604, 67723, 67730, 67809, 67802
24566, 12833, 12834, 12845, 12844, 66172, 66174, 66196, 66194, 13309, 13331, 13332, 13329, 67733, 67811, 67812, 
67804, 67724, 67731, 67810, 67803
24567, 66172, 66174, 66196, 66194, 66173, 66175, 66197, 66195, 67733, 67811, 67812, 67804, 67736, 67814, 67815, 
67807, 67727, 67734, 67813, 67806
24568, 66173, 66175, 66197, 66195, 14110, 14111, 14122, 14121, 67736, 67814, 67815, 67807, 14586, 14608, 14609, 
14606, 67730, 67737, 67816, 67809
24569, 12834, 12835, 12846, 12845, 66174, 66176, 66198, 66196, 13311, 13333, 13334, 13331, 67740, 67818, 67819, 
67811, 67731, 67738, 67817, 67810
24570, 66174, 66176, 66198, 66196, 66175, 66177, 66199, 66197, 67740, 67818, 67819, 67811, 67743, 67821, 67822, 
67814, 67734, 67741, 67820, 67813
24571, 66175, 66177, 66199, 66197, 14111, 14112, 14123, 14122, 67743, 67821, 67822, 67814, 14588, 14610, 14611, 
14608, 67737, 67744, 67823, 67816
24572, 12835, 12836, 12847, 12846, 66176, 66178, 66200, 66198, 13313, 13335, 13336, 13333, 67747, 67825, 67826, 
67818, 67738, 67745, 67824, 67817
24573, 66176, 66178, 66200, 66198, 66177, 66179, 66201, 66199, 67747, 67825, 67826, 67818, 67750, 67828, 67829, 
67821, 67741, 67748, 67827, 67820
24574, 66177, 66179, 66201, 66199, 14112, 14113, 14124, 14123, 67750, 67828, 67829, 67821, 14590, 14612, 14613, 
14610, 67744, 67751, 67830, 67823
24575, 12836, 12837, 12848, 12847, 66178, 66180, 66202, 66200, 13315, 13337, 13338, 13335, 67754, 67832, 67833, 
67825, 67745, 67752, 67831, 67824
24576, 66178, 66180, 66202, 66200, 66179, 66181, 66203, 66201, 67754, 67832, 67833, 67825, 67757, 67835, 67836, 
67828, 67748, 67755, 67834, 67827
24577, 66179, 66181, 66203, 66201, 14113, 14114, 14125, 14124, 67757, 67835, 67836, 67828, 14592, 14614, 14615, 
14612, 67751, 67758, 67837, 67830
24578, 12837, 12838, 12849, 12848, 66180, 66182, 66204, 66202, 13317, 13339, 13340, 13337, 67761, 67839, 67840, 
67832, 67752, 67759, 67838, 67831
24579, 66180, 66182, 66204, 66202, 66181, 66183, 66205, 66203, 67761, 67839, 67840, 67832, 67764, 67842, 67843, 
67835, 67755, 67762, 67841, 67834
24580, 66181, 66183, 66205, 66203, 14114, 14115, 14126, 14125, 67764, 67842, 67843, 67835, 14594, 14616, 14617, 
14614, 67758, 67765, 67844, 67837
24581, 12838, 12839, 12850, 12849, 66182, 66184, 66206, 66204, 13319, 13341, 13342, 13339, 67768, 67846, 67847, 
67839, 67759, 67766, 67845, 67838
24582, 66182, 66184, 66206, 66204, 66183, 66185, 66207, 66205, 67768, 67846, 67847, 67839, 67771, 67849, 67850, 
67842, 67762, 67769, 67848, 67841
24583, 66183, 66185, 66207, 66205, 14115, 14116, 14127, 14126, 67771, 67849, 67850, 67842, 14596, 14618, 14619, 
14616, 67765, 67772, 67851, 67844
24584, 12839, 961, 962, 12850, 66184, 13702, 13704, 66206, 13320, 985, 13343, 13341, 67773, 13808, 67852, 
67846, 67766, 13802, 13807, 67845
24585, 66184, 13702, 13704, 66206, 66185, 13703, 13705, 66207, 67773, 13808, 67852, 67846, 67774, 13810, 67853, 
67849, 67769, 13804, 13809, 67848
24586, 66185, 13703, 13705, 66207, 14116, 1121, 1122, 14127, 67774, 13810, 67853, 67849, 14597, 1145, 14620, 
14618, 67772, 13806, 13811, 67851
24587, 890, 12840, 12851, 891, 13462, 66186, 66208, 13464, 13322, 13344, 13345, 914, 67777, 67855, 67856, 
13570, 13566, 67775, 67854, 13571
24588, 13462, 66186, 66208, 13464, 13463, 66187, 66209, 13465, 67777, 67855, 67856, 13570, 67780, 67858, 67859, 
13572, 13568, 67778, 67857, 13573
24589, 13463, 66187, 66209, 13465, 1042, 14117, 14128, 1043, 67780, 67858, 67859, 13572, 14599, 14621, 14622, 
1066, 13569, 67781, 67860, 13574
24590, 12840, 12841, 12852, 12851, 66186, 66188, 66210, 66208, 13324, 13346, 13347, 13344, 67784, 67862, 67863, 
67855, 67775, 67782, 67861, 67854
24591, 66186, 66188, 66210, 66208, 66187, 66189, 66211, 66209, 67784, 67862, 67863, 67855, 67787, 67865, 67866, 
67858, 67778, 67785, 67864, 67857
24592, 66187, 66189, 66211, 66209, 14117, 14118, 14129, 14128, 67787, 67865, 67866, 67858, 14601, 14623, 14624, 
14621, 67781, 67788, 67867, 67860
24593, 12841, 12842, 12853, 12852, 66188, 66190, 66212, 66210, 13326, 13348, 13349, 13346, 67791, 67869, 67870, 
67862, 67782, 67789, 67868, 67861
24594, 66188, 66190, 66212, 66210, 66189, 66191, 66213, 66211, 67791, 67869, 67870, 67862, 67794, 67872, 67873, 
67865, 67785, 67792, 67871, 67864
24595, 66189, 66191, 66213, 66211, 14118, 14119, 14130, 14129, 67794, 67872, 67873, 67865, 14603, 14625, 14626, 
14623, 67788, 67795, 67874, 67867
24596, 12842, 12843, 12854, 12853, 66190, 66192, 66214, 66212, 13328, 13350, 13351, 13348, 67798, 67876, 67877, 
67869, 67789, 67796, 67875, 67868
24597, 66190, 66192, 66214, 66212, 66191, 66193, 66215, 66213, 67798, 67876, 67877, 67869, 67801, 67879, 67880, 
67872, 67792, 67799, 67878, 67871
24598, 66191, 66193, 66215, 66213, 14119, 14120, 14131, 14130, 67801, 67879, 67880, 67872, 14605, 14627, 14628, 
14625, 67795, 67802, 67881, 67874
24599, 12843, 12844, 12855, 12854, 66192, 66194, 66216, 66214, 13330, 13352, 13353, 13350, 67805, 67883, 67884, 
67876, 67796, 67803, 67882, 67875
24600, 66192, 66194, 66216, 66214, 66193, 66195, 66217, 66215, 67805, 67883, 67884, 67876, 67808, 67886, 67887, 
67879, 67799, 67806, 67885, 67878
24601, 66193, 66195, 66217, 66215, 14120, 14121, 14132, 14131, 67808, 67886, 67887, 67879, 14607, 14629, 14630, 
14627, 67802, 67809, 67888, 67881
24602, 12844, 12845, 12856, 12855, 66194, 66196, 66218, 66216, 13332, 13354, 13355, 13352, 67812, 67890, 67891, 
67883, 67803, 67810, 67889, 67882
24603, 66194, 66196, 66218, 66216, 66195, 66197, 66219, 66217, 67812, 67890, 67891, 67883, 67815, 67893, 67894, 
67886, 67806, 67813, 67892, 67885
24604, 66195, 66197, 66219, 66217, 14121, 14122, 14133, 14132, 67815, 67893, 67894, 67886, 14609, 14631, 14632, 
14629, 67809, 67816, 67895, 67888
24605, 12845, 12846, 12857, 12856, 66196, 66198, 66220, 66218, 13334, 13356, 13357, 13354, 67819, 67897, 67898, 
67890, 67810, 67817, 67896, 67889
24606, 66196, 66198, 66220, 66218, 66197, 66199, 66221, 66219, 67819, 67897, 67898, 67890, 67822, 67900, 67901, 
67893, 67813, 67820, 67899, 67892
24607, 66197, 66199, 66221, 66219, 14122, 14123, 14134, 14133, 67822, 67900, 67901, 67893, 14611, 14633, 14634, 
14631, 67816, 67823, 67902, 67895
24608, 12846, 12847, 12858, 12857, 66198, 66200, 66222, 66220, 13336, 13358, 13359, 13356, 67826, 67904, 67905, 
67897, 67817, 67824, 67903, 67896
24609, 66198, 66200, 66222, 66220, 66199, 66201, 66223, 66221, 67826, 67904, 67905, 67897, 67829, 67907, 67908, 
67900, 67820, 67827, 67906, 67899
24610, 66199, 66201, 66223, 66221, 14123, 14124, 14135, 14134, 67829, 67907, 67908, 67900, 14613, 14635, 14636, 
14633, 67823, 67830, 67909, 67902
24611, 12847, 12848, 12859, 12858, 66200, 66202, 66224, 66222, 13338, 13360, 13361, 13358, 67833, 67911, 67912, 
67904, 67824, 67831, 67910, 67903
24612, 66200, 66202, 66224, 66222, 66201, 66203, 66225, 66223, 67833, 67911, 67912, 67904, 67836, 67914, 67915, 
67907, 67827, 67834, 67913, 67906
24613, 66201, 66203, 66225, 66223, 14124, 14125, 14136, 14135, 67836, 67914, 67915, 67907, 14615, 14637, 14638, 
14635, 67830, 67837, 67916, 67909
24614, 12848, 12849, 12860, 12859, 66202, 66204, 66226, 66224, 13340, 13362, 13363, 13360, 67840, 67918, 67919, 
67911, 67831, 67838, 67917, 67910
24615, 66202, 66204, 66226, 66224, 66203, 66205, 66227, 66225, 67840, 67918, 67919, 67911, 67843, 67921, 67922, 
67914, 67834, 67841, 67920, 67913
24616, 66203, 66205, 66227, 66225, 14125, 14126, 14137, 14136, 67843, 67921, 67922, 67914, 14617, 14639, 14640, 
14637, 67837, 67844, 67923, 67916
24617, 12849, 12850, 12861, 12860, 66204, 66206, 66228, 66226, 13342, 13364, 13365, 13362, 67847, 67925, 67926, 
67918, 67838, 67845, 67924, 67917
24618, 66204, 66206, 66228, 66226, 66205, 66207, 66229, 66227, 67847, 67925, 67926, 67918, 67850, 67928, 67929, 
67921, 67841, 67848, 67927, 67920
24619, 66205, 66207, 66229, 66227, 14126, 14127, 14138, 14137, 67850, 67928, 67929, 67921, 14619, 14641, 14642, 
14639, 67844, 67851, 67930, 67923
24620, 12850, 962, 963, 12861, 66206, 13704, 13706, 66228, 13343, 986, 13366, 13364, 67852, 13813, 67931, 
67925, 67845, 13807, 13812, 67924
24621, 66206, 13704, 13706, 66228, 66207, 13705, 13707, 66229, 67852, 13813, 67931, 67925, 67853, 13815, 67932, 
67928, 67848, 13809, 13814, 67927
24622, 66207, 13705, 13707, 66229, 14127, 1122, 1123, 14138, 67853, 13815, 67932, 67928, 14620, 1146, 14643, 
14641, 67851, 13811, 13816, 67930
24623, 891, 12851, 12862, 892, 13464, 66208, 66230, 13466, 13345, 13367, 13368, 915, 67856, 67934, 67935, 
13575, 13571, 67854, 67933, 13576
24624, 13464, 66208, 66230, 13466, 13465, 66209, 66231, 13467, 67856, 67934, 67935, 13575, 67859, 67937, 67938, 
13577, 13573, 67857, 67936, 13578
24625, 13465, 66209, 66231, 13467, 1043, 14128, 14139, 1044, 67859, 67937, 67938, 13577, 14622, 14644, 14645, 
1067, 13574, 67860, 67939, 13579
24626, 12851, 12852, 12863, 12862, 66208, 66210, 66232, 66230, 13347, 13369, 13370, 13367, 67863, 67941, 67942, 
67934, 67854, 67861, 67940, 67933
24627, 66208, 66210, 66232, 66230, 66209, 66211, 66233, 66231, 67863, 67941, 67942, 67934, 67866, 67944, 67945, 
67937, 67857, 67864, 67943, 67936
24628, 66209, 66211, 66233, 66231, 14128, 14129, 14140, 14139, 67866, 67944, 67945, 67937, 14624, 14646, 14647, 
14644, 67860, 67867, 67946, 67939
24629, 12852, 12853, 12864, 12863, 66210, 66212, 66234, 66232, 13349, 13371, 13372, 13369, 67870, 67948, 67949, 
67941, 67861, 67868, 67947, 67940
24630, 66210, 66212, 66234, 66232, 66211, 66213, 66235, 66233, 67870, 67948, 67949, 67941, 67873, 67951, 67952, 
67944, 67864, 67871, 67950, 67943
24631, 66211, 66213, 66235, 66233, 14129, 14130, 14141, 14140, 67873, 67951, 67952, 67944, 14626, 14648, 14649, 
14646, 67867, 67874, 67953, 67946
24632, 12853, 12854, 12865, 12864, 66212, 66214, 66236, 66234, 13351, 13373, 13374, 13371, 67877, 67955, 67956, 
67948, 67868, 67875, 67954, 67947
24633, 66212, 66214, 66236, 66234, 66213, 66215, 66237, 66235, 67877, 67955, 67956, 67948, 67880, 67958, 67959, 
67951, 67871, 67878, 67957, 67950
24634, 66213, 66215, 66237, 66235, 14130, 14131, 14142, 14141, 67880, 67958, 67959, 67951, 14628, 14650, 14651, 
14648, 67874, 67881, 67960, 67953
24635, 12854, 12855, 12866, 12865, 66214, 66216, 66238, 66236, 13353, 13375, 13376, 13373, 67884, 67962, 67963, 
67955, 67875, 67882, 67961, 67954
24636, 66214, 66216, 66238, 66236, 66215, 66217, 66239, 66237, 67884, 67962, 67963, 67955, 67887, 67965, 67966, 
67958, 67878, 67885, 67964, 67957
24637, 66215, 66217, 66239, 66237, 14131, 14132, 14143, 14142, 67887, 67965, 67966, 67958, 14630, 14652, 14653, 
14650, 67881, 67888, 67967, 67960
24638, 12855, 12856, 12867, 12866, 66216, 66218, 66240, 66238, 13355, 13377, 13378, 13375, 67891, 67969, 67970, 
67962, 67882, 67889, 67968, 67961
24639, 66216, 66218, 66240, 66238, 66217, 66219, 66241, 66239, 67891, 67969, 67970, 67962, 67894, 67972, 67973, 
67965, 67885, 67892, 67971, 67964
24640, 66217, 66219, 66241, 66239, 14132, 14133, 14144, 14143, 67894, 67972, 67973, 67965, 14632, 14654, 14655, 
14652, 67888, 67895, 67974, 67967
24641, 12856, 12857, 12868, 12867, 66218, 66220, 66242, 66240, 13357, 13379, 13380, 13377, 67898, 67976, 67977, 
67969, 67889, 67896, 67975, 67968
24642, 66218, 66220, 66242, 66240, 66219, 66221, 66243, 66241, 67898, 67976, 67977, 67969, 67901, 67979, 67980, 
67972, 67892, 67899, 67978, 67971
24643, 66219, 66221, 66243, 66241, 14133, 14134, 14145, 14144, 67901, 67979, 67980, 67972, 14634, 14656, 14657, 
14654, 67895, 67902, 67981, 67974
24644, 12857, 12858, 12869, 12868, 66220, 66222, 66244, 66242, 13359, 13381, 13382, 13379, 67905, 67983, 67984, 
67976, 67896, 67903, 67982, 67975
24645, 66220, 66222, 66244, 66242, 66221, 66223, 66245, 66243, 67905, 67983, 67984, 67976, 67908, 67986, 67987, 
67979, 67899, 67906, 67985, 67978
24646, 66221, 66223, 66245, 66243, 14134, 14135, 14146, 14145, 67908, 67986, 67987, 67979, 14636, 14658, 14659, 
14656, 67902, 67909, 67988, 67981
24647, 12858, 12859, 12870, 12869, 66222, 66224, 66246, 66244, 13361, 13383, 13384, 13381, 67912, 67990, 67991, 
67983, 67903, 67910, 67989, 67982
24648, 66222, 66224, 66246, 66244, 66223, 66225, 66247, 66245, 67912, 67990, 67991, 67983, 67915, 67993, 67994, 
67986, 67906, 67913, 67992, 67985
24649, 66223, 66225, 66247, 66245, 14135, 14136, 14147, 14146, 67915, 67993, 67994, 67986, 14638, 14660, 14661, 
14658, 67909, 67916, 67995, 67988
24650, 12859, 12860, 12871, 12870, 66224, 66226, 66248, 66246, 13363, 13385, 13386, 13383, 67919, 67997, 67998, 
67990, 67910, 67917, 67996, 67989
24651, 66224, 66226, 66248, 66246, 66225, 66227, 66249, 66247, 67919, 67997, 67998, 67990, 67922, 68000, 68001, 
67993, 67913, 67920, 67999, 67992
24652, 66225, 66227, 66249, 66247, 14136, 14137, 14148, 14147, 67922, 68000, 68001, 67993, 14640, 14662, 14663, 
14660, 67916, 67923, 68002, 67995
24653, 12860, 12861, 12872, 12871, 66226, 66228, 66250, 66248, 13365, 13387, 13388, 13385, 67926, 68004, 68005, 
67997, 67917, 67924, 68003, 67996
24654, 66226, 66228, 66250, 66248, 66227, 66229, 66251, 66249, 67926, 68004, 68005, 67997, 67929, 68007, 68008, 
68000, 67920, 67927, 68006, 67999
24655, 66227, 66229, 66251, 66249, 14137, 14138, 14149, 14148, 67929, 68007, 68008, 68000, 14642, 14664, 14665, 
14662, 67923, 67930, 68009, 68002
24656, 12861, 963, 964, 12872, 66228, 13706, 13708, 66250, 13366, 987, 13389, 13387, 67931, 13818, 68010, 
68004, 67924, 13812, 13817, 68003
24657, 66228, 13706, 13708, 66250, 66229, 13707, 13709, 66251, 67931, 13818, 68010, 68004, 67932, 13820, 68011, 
68007, 67927, 13814, 13819, 68006
24658, 66229, 13707, 13709, 66251, 14138, 1123, 1124, 14149, 67932, 13820, 68011, 68007, 14643, 1147, 14666, 
14664, 67930, 13816, 13821, 68009
24659, 892, 12862, 12873, 893, 13466, 66230, 66252, 13468, 13368, 13390, 13391, 916, 67935, 68013, 68014, 
13580, 13576, 67933, 68012, 13581
24660, 13466, 66230, 66252, 13468, 13467, 66231, 66253, 13469, 67935, 68013, 68014, 13580, 67938, 68016, 68017, 
13582, 13578, 67936, 68015, 13583
24661, 13467, 66231, 66253, 13469, 1044, 14139, 14150, 1045, 67938, 68016, 68017, 13582, 14645, 14667, 14668, 
1068, 13579, 67939, 68018, 13584
24662, 12862, 12863, 12874, 12873, 66230, 66232, 66254, 66252, 13370, 13392, 13393, 13390, 67942, 68020, 68021, 
68013, 67933, 67940, 68019, 68012
24663, 66230, 66232, 66254, 66252, 66231, 66233, 66255, 66253, 67942, 68020, 68021, 68013, 67945, 68023, 68024, 
68016, 67936, 67943, 68022, 68015
24664, 66231, 66233, 66255, 66253, 14139, 14140, 14151, 14150, 67945, 68023, 68024, 68016, 14647, 14669, 14670, 
14667, 67939, 67946, 68025, 68018
24665, 12863, 12864, 12875, 12874, 66232, 66234, 66256, 66254, 13372, 13394, 13395, 13392, 67949, 68027, 68028, 
68020, 67940, 67947, 68026, 68019
24666, 66232, 66234, 66256, 66254, 66233, 66235, 66257, 66255, 67949, 68027, 68028, 68020, 67952, 68030, 68031, 
68023, 67943, 67950, 68029, 68022
24667, 66233, 66235, 66257, 66255, 14140, 14141, 14152, 14151, 67952, 68030, 68031, 68023, 14649, 14671, 14672, 
14669, 67946, 67953, 68032, 68025
24668, 12864, 12865, 12876, 12875, 66234, 66236, 66258, 66256, 13374, 13396, 13397, 13394, 67956, 68034, 68035, 
68027, 67947, 67954, 68033, 68026
24669, 66234, 66236, 66258, 66256, 66235, 66237, 66259, 66257, 67956, 68034, 68035, 68027, 67959, 68037, 68038, 
68030, 67950, 67957, 68036, 68029
24670, 66235, 66237, 66259, 66257, 14141, 14142, 14153, 14152, 67959, 68037, 68038, 68030, 14651, 14673, 14674, 
14671, 67953, 67960, 68039, 68032
24671, 12865, 12866, 12877, 12876, 66236, 66238, 66260, 66258, 13376, 13398, 13399, 13396, 67963, 68041, 68042, 
68034, 67954, 67961, 68040, 68033
24672, 66236, 66238, 66260, 66258, 66237, 66239, 66261, 66259, 67963, 68041, 68042, 68034, 67966, 68044, 68045, 
68037, 67957, 67964, 68043, 68036
24673, 66237, 66239, 66261, 66259, 14142, 14143, 14154, 14153, 67966, 68044, 68045, 68037, 14653, 14675, 14676, 
14673, 67960, 67967, 68046, 68039
24674, 12866, 12867, 12878, 12877, 66238, 66240, 66262, 66260, 13378, 13400, 13401, 13398, 67970, 68048, 68049, 
68041, 67961, 67968, 68047, 68040
24675, 66238, 66240, 66262, 66260, 66239, 66241, 66263, 66261, 67970, 68048, 68049, 68041, 67973, 68051, 68052, 
68044, 67964, 67971, 68050, 68043
24676, 66239, 66241, 66263, 66261, 14143, 14144, 14155, 14154, 67973, 68051, 68052, 68044, 14655, 14677, 14678, 
14675, 67967, 67974, 68053, 68046
24677, 12867, 12868, 12879, 12878, 66240, 66242, 66264, 66262, 13380, 13402, 13403, 13400, 67977, 68055, 68056, 
68048, 67968, 67975, 68054, 68047
24678, 66240, 66242, 66264, 66262, 66241, 66243, 66265, 66263, 67977, 68055, 68056, 68048, 67980, 68058, 68059, 
68051, 67971, 67978, 68057, 68050
24679, 66241, 66243, 66265, 66263, 14144, 14145, 14156, 14155, 67980, 68058, 68059, 68051, 14657, 14679, 14680, 
14677, 67974, 67981, 68060, 68053
24680, 12868, 12869, 12880, 12879, 66242, 66244, 66266, 66264, 13382, 13404, 13405, 13402, 67984, 68062, 68063, 
68055, 67975, 67982, 68061, 68054
24681, 66242, 66244, 66266, 66264, 66243, 66245, 66267, 66265, 67984, 68062, 68063, 68055, 67987, 68065, 68066, 
68058, 67978, 67985, 68064, 68057
24682, 66243, 66245, 66267, 66265, 14145, 14146, 14157, 14156, 67987, 68065, 68066, 68058, 14659, 14681, 14682, 
14679, 67981, 67988, 68067, 68060
24683, 12869, 12870, 12881, 12880, 66244, 66246, 66268, 66266, 13384, 13406, 13407, 13404, 67991, 68069, 68070, 
68062, 67982, 67989, 68068, 68061
24684, 66244, 66246, 66268, 66266, 66245, 66247, 66269, 66267, 67991, 68069, 68070, 68062, 67994, 68072, 68073, 
68065, 67985, 67992, 68071, 68064
24685, 66245, 66247, 66269, 66267, 14146, 14147, 14158, 14157, 67994, 68072, 68073, 68065, 14661, 14683, 14684, 
14681, 67988, 67995, 68074, 68067
24686, 12870, 12871, 12882, 12881, 66246, 66248, 66270, 66268, 13386, 13408, 13409, 13406, 67998, 68076, 68077, 
68069, 67989, 67996, 68075, 68068
24687, 66246, 66248, 66270, 66268, 66247, 66249, 66271, 66269, 67998, 68076, 68077, 68069, 68001, 68079, 68080, 
68072, 67992, 67999, 68078, 68071
24688, 66247, 66249, 66271, 66269, 14147, 14148, 14159, 14158, 68001, 68079, 68080, 68072, 14663, 14685, 14686, 
14683, 67995, 68002, 68081, 68074
24689, 12871, 12872, 12883, 12882, 66248, 66250, 66272, 66270, 13388, 13410, 13411, 13408, 68005, 68083, 68084, 
68076, 67996, 68003, 68082, 68075
24690, 66248, 66250, 66272, 66270, 66249, 66251, 66273, 66271, 68005, 68083, 68084, 68076, 68008, 68086, 68087, 
68079, 67999, 68006, 68085, 68078
24691, 66249, 66251, 66273, 66271, 14148, 14149, 14160, 14159, 68008, 68086, 68087, 68079, 14665, 14687, 14688, 
14685, 68002, 68009, 68088, 68081
24692, 12872, 964, 965, 12883, 66250, 13708, 13710, 66272, 13389, 988, 13412, 13410, 68010, 13823, 68089, 
68083, 68003, 13817, 13822, 68082
24693, 66250, 13708, 13710, 66272, 66251, 13709, 13711, 66273, 68010, 13823, 68089, 68083, 68011, 13825, 68090, 
68086, 68006, 13819, 13824, 68085
24694, 66251, 13709, 13711, 66273, 14149, 1124, 1125, 14160, 68011, 13825, 68090, 68086, 14666, 1148, 14689, 
14687, 68009, 13821, 13826, 68088
24695, 893, 12873, 919, 17, 13468, 66252, 13587, 1013, 13391, 13413, 930, 917, 68014, 68091, 13609, 
13585, 13581, 68012, 13610, 1015
24696, 13468, 66252, 13587, 1013, 13469, 66253, 13588, 1014, 68014, 68091, 13609, 13585, 68017, 68092, 13611, 
13586, 13583, 68015, 13612, 1016
24697, 13469, 66253, 13588, 1014, 1045, 14150, 1075, 21, 68017, 68092, 13611, 13586, 14668, 14690, 1086, 
1069, 13584, 68018, 13613, 1017
24698, 12873, 12874, 920, 919, 66252, 66254, 13589, 13587, 13393, 13414, 931, 13413, 68021, 68093, 13614, 
68091, 68012, 68019, 13615, 13610
24699, 66252, 66254, 13589, 13587, 66253, 66255, 13590, 13588, 68021, 68093, 13614, 68091, 68024, 68094, 13616, 
68092, 68015, 68022, 13617, 13612
24700, 66253, 66255, 13590, 13588, 14150, 14151, 1076, 1075, 68024, 68094, 13616, 68092, 14670, 14691, 1087, 
14690, 68018, 68025, 13618, 13613
24701, 12874, 12875, 921, 920, 66254, 66256, 13591, 13589, 13395, 13415, 932, 13414, 68028, 68095, 13619, 
68093, 68019, 68026, 13620, 13615
24702, 66254, 66256, 13591, 13589, 66255, 66257, 13592, 13590, 68028, 68095, 13619, 68093, 68031, 68096, 13621, 
68094, 68022, 68029, 13622, 13617
24703, 66255, 66257, 13592, 13590, 14151, 14152, 1077, 1076, 68031, 68096, 13621, 68094, 14672, 14692, 1088, 
14691, 68025, 68032, 13623, 13618
24704, 12875, 12876, 922, 921, 66256, 66258, 13593, 13591, 13397, 13416, 933, 13415, 68035, 68097, 13624, 
68095, 68026, 68033, 13625, 13620
24705, 66256, 66258, 13593, 13591, 66257, 66259, 13594, 13592, 68035, 68097, 13624, 68095, 68038, 68098, 13626, 
68096, 68029, 68036, 13627, 13622
24706, 66257, 66259, 13594, 13592, 14152, 14153, 1078, 1077, 68038, 68098, 13626, 68096, 14674, 14693, 1089, 
14692, 68032, 68039, 13628, 13623
24707, 12876, 12877, 923, 922, 66258, 66260, 13595, 13593, 13399, 13417, 934, 13416, 68042, 68099, 13629, 
68097, 68033, 68040, 13630, 13625
24708, 66258, 66260, 13595, 13593, 66259, 66261, 13596, 13594, 68042, 68099, 13629, 68097, 68045, 68100, 13631, 
68098, 68036, 68043, 13632, 13627
24709, 66259, 66261, 13596, 13594, 14153, 14154, 1079, 1078, 68045, 68100, 13631, 68098, 14676, 14694, 1090, 
14693, 68039, 68046, 13633, 13628
24710, 12877, 12878, 924, 923, 66260, 66262, 13597, 13595, 13401, 13418, 935, 13417, 68049, 68101, 13634, 
68099, 68040, 68047, 13635, 13630
24711, 66260, 66262, 13597, 13595, 66261, 66263, 13598, 13596, 68049, 68101, 13634, 68099, 68052, 68102, 13636, 
68100, 68043, 68050, 13637, 13632
24712, 66261, 66263, 13598, 13596, 14154, 14155, 1080, 1079, 68052, 68102, 13636, 68100, 14678, 14695, 1091, 
14694, 68046, 68053, 13638, 13633
24713, 12878, 12879, 925, 924, 66262, 66264, 13599, 13597, 13403, 13419, 936, 13418, 68056, 68103, 13639, 
68101, 68047, 68054, 13640, 13635
24714, 66262, 66264, 13599, 13597, 66263, 66265, 13600, 13598, 68056, 68103, 13639, 68101, 68059, 68104, 13641, 
68102, 68050, 68057, 13642, 13637
24715, 66263, 66265, 13600, 13598, 14155, 14156, 1081, 1080, 68059, 68104, 13641, 68102, 14680, 14696, 1092, 
14695, 68053, 68060, 13643, 13638
24716, 12879, 12880, 926, 925, 66264, 66266, 13601, 13599, 13405, 13420, 937, 13419, 68063, 68105, 13644, 
68103, 68054, 68061, 13645, 13640
24717, 66264, 66266, 13601, 13599, 66265, 66267, 13602, 13600, 68063, 68105, 13644, 68103, 68066, 68106, 13646, 
68104, 68057, 68064, 13647, 13642
24718, 66265, 66267, 13602, 13600, 14156, 14157, 1082, 1081, 68066, 68106, 13646, 68104, 14682, 14697, 1093, 
14696, 68060, 68067, 13648, 13643
24719, 12880, 12881, 927, 926, 66266, 66268, 13603, 13601, 13407, 13421, 938, 13420, 68070, 68107, 13649, 
68105, 68061, 68068, 13650, 13645
24720, 66266, 66268, 13603, 13601, 66267, 66269, 13604, 13602, 68070, 68107, 13649, 68105, 68073, 68108, 13651, 
68106, 68064, 68071, 13652, 13647
24721, 66267, 66269, 13604, 13602, 14157, 14158, 1083, 1082, 68073, 68108, 13651, 68106, 14684, 14698, 1094, 
14697, 68067, 68074, 13653, 13648
24722, 12881, 12882, 928, 927, 66268, 66270, 13605, 13603, 13409, 13422, 939, 13421, 68077, 68109, 13654, 
68107, 68068, 68075, 13655, 13650
24723, 66268, 66270, 13605, 13603, 66269, 66271, 13606, 13604, 68077, 68109, 13654, 68107, 68080, 68110, 13656, 
68108, 68071, 68078, 13657, 13652
24724, 66269, 66271, 13606, 13604, 14158, 14159, 1084, 1083, 68080, 68110, 13656, 68108, 14686, 14699, 1095, 
14698, 68074, 68081, 13658, 13653
24725, 12882, 12883, 929, 928, 66270, 66272, 13607, 13605, 13411, 13423, 940, 13422, 68084, 68111, 13659, 
68109, 68075, 68082, 13660, 13655
24726, 66270, 66272, 13607, 13605, 66271, 66273, 13608, 13606, 68084, 68111, 13659, 68109, 68087, 68112, 13661, 
68110, 68078, 68085, 13662, 13657
24727, 66271, 66273, 13608, 13606, 14159, 14160, 1085, 1084, 68087, 68112, 13661, 68110, 14688, 14700, 1096, 
14699, 68081, 68088, 13663, 13658
24728, 12883, 965, 19, 929, 66272, 13710, 1070, 13607, 13412, 989, 941, 13423, 68089, 13827, 13664, 
68111, 68082, 13822, 1072, 13660
24729, 66272, 13710, 1070, 13607, 66273, 13711, 1071, 13608, 68089, 13827, 13664, 68111, 68090, 13828, 13665, 
68112, 68085, 13824, 1073, 13662
24730, 66273, 13711, 1071, 13608, 14160, 1125, 23, 1085, 68090, 13828, 13665, 68112, 14689, 1149, 1097, 
14700, 68088, 13826, 1074, 13663
*ELEMENT, type=C3D20, ELSET=Volume6
24731, 17, 1013, 13587, 919, 1196, 14731, 68113, 14761, 1015, 13609, 13610, 930, 14740, 68202, 68203, 
14805, 1200, 14739, 68201, 14806
24732, 1196, 14731, 68113, 14761, 1197, 14732, 68114, 14762, 14740, 68202, 68203, 14805, 14742, 68205, 68206, 
14807, 1201, 14741, 68204, 14808
24733, 1197, 14732, 68114, 14762, 1198, 14733, 68115, 14763, 14742, 68205, 68206, 14807, 14744, 68208, 68209, 
14809, 1202, 14743, 68207, 14810
24734, 1198, 14733, 68115, 14763, 1199, 14734, 68116, 14764, 14744, 68208, 68209, 14809, 14746, 68211, 68212, 
14811, 1203, 14745, 68210, 14812
24735, 1199, 14734, 68116, 14764, 27, 1214, 15055, 1219, 14746, 68211, 68212, 14811, 1216, 15077, 15078, 
1230, 1204, 14747, 68213, 14813
24736, 1013, 1014, 13588, 13587, 14731, 14735, 68117, 68113, 1016, 13611, 13612, 13609, 14749, 68215, 68216, 
68202, 14739, 14748, 68214, 68201
24737, 14731, 14735, 68117, 68113, 14732, 14736, 68118, 68114, 14749, 68215, 68216, 68202, 14751, 68218, 68219, 
68205, 14741, 14750, 68217, 68204
24738, 14732, 14736, 68118, 68114, 14733, 14737, 68119, 68115, 14751, 68218, 68219, 68205, 14753, 68221, 68222, 
68208, 14743, 14752, 68220, 68207
24739, 14733, 14737, 68119, 68115, 14734, 14738, 68120, 68116, 14753, 68221, 68222, 68208, 14755, 68224, 68225, 
68211, 14745, 14754, 68223, 68210
24740, 14734, 14738, 68120, 68116, 1214, 1215, 15056, 15055, 14755, 68224, 68225, 68211, 1217, 15079, 15080, 
15077, 14747, 14756, 68226, 68213
24741, 1014, 21, 1075, 13588, 14735, 1205, 14908, 68117, 1017, 1086, 13613, 13611, 14757, 14953, 68227, 
68215, 14748, 1209, 14952, 68214
24742, 14735, 1205, 14908, 68117, 14736, 1206, 14909, 68118, 14757, 14953, 68227, 68215, 14758, 14955, 68228, 
68218, 14750, 1210, 14954, 68217
24743, 14736, 1206, 14909, 68118, 14737, 1207, 14910, 68119, 14758, 14955, 68228, 68218, 14759, 14957, 68229, 
68221, 14752, 1211, 14956, 68220
24744, 14737, 1207, 14910, 68119, 14738, 1208, 14911, 68120, 14759, 14957, 68229, 68221, 14760, 14959, 68230, 
68224, 14754, 1212, 14958, 68223
24745, 14738, 1208, 14911, 68120, 1215, 28, 1242, 15056, 14760, 14959, 68230, 68224, 1218, 1253, 15081, 
15079, 14756, 1213, 14960, 68226
24746, 919, 13587, 13589, 920, 14761, 68113, 68121, 14765, 13610, 13614, 13615, 931, 68203, 68232, 68233, 
14814, 14806, 68201, 68231, 14815
24747, 14761, 68113, 68121, 14765, 14762, 68114, 68122, 14766, 68203, 68232, 68233, 14814, 68206, 68235, 68236, 
14816, 14808, 68204, 68234, 14817
24748, 14762, 68114, 68122, 14766, 14763, 68115, 68123, 14767, 68206, 68235, 68236, 14816, 68209, 68238, 68239, 
14818, 14810, 68207, 68237, 14819
24749, 14763, 68115, 68123, 14767, 14764, 68116, 68124, 14768, 68209, 68238, 68239, 14818, 68212, 68241, 68242, 
14820, 14812, 68210, 68240, 14821
24750, 14764, 68116, 68124, 14768, 1219, 15055, 15057, 1220, 68212, 68241, 68242, 14820, 15078, 15082, 15083, 
1231, 14813, 68213, 68243, 14822
24751, 13587, 13588, 13590, 13589, 68113, 68117, 68125, 68121, 13612, 13616, 13617, 13614, 68216, 68245, 68246, 
68232, 68201, 68214, 68244, 68231
24752, 68113, 68117, 68125, 68121, 68114, 68118, 68126, 68122, 68216, 68245, 68246, 68232, 68219, 68248, 68249, 
68235, 68204, 68217, 68247, 68234
24753, 68114, 68118, 68126, 68122, 68115, 68119, 68127, 68123, 68219, 68248, 68249, 68235, 68222, 68251, 68252, 
68238, 68207, 68220, 68250, 68237
24754, 68115, 68119, 68127, 68123, 68116, 68120, 68128, 68124, 68222, 68251, 68252, 68238, 68225, 68254, 68255, 
68241, 68210, 68223, 68253, 68240
24755, 68116, 68120, 68128, 68124, 15055, 15056, 15058, 15057, 68225, 68254, 68255, 68241, 15080, 15084, 15085, 
15082, 68213, 68226, 68256, 68243
24756, 13588, 1075, 1076, 13590, 68117, 14908, 14912, 68125, 13613, 1087, 13618, 13616, 68227, 14962, 68257, 
68245, 68214, 14952, 14961, 68244
24757, 68117, 14908, 14912, 68125, 68118, 14909, 14913, 68126, 68227, 14962, 68257, 68245, 68228, 14964, 68258, 
68248, 68217, 14954, 14963, 68247
24758, 68118, 14909, 14913, 68126, 68119, 14910, 14914, 68127, 68228, 14964, 68258, 68248, 68229, 14966, 68259, 
68251, 68220, 14956, 14965, 68250
24759, 68119, 14910, 14914, 68127, 68120, 14911, 14915, 68128, 68229, 14966, 68259, 68251, 68230, 14968, 68260, 
68254, 68223, 14958, 14967, 68253
24760, 68120, 14911, 14915, 68128, 15056, 1242, 1243, 15058, 68230, 14968, 68260, 68254, 15081, 1254, 15086, 
15084, 68226, 14960, 14969, 68256
24761, 920, 13589, 13591, 921, 14765, 68121, 68129, 14769, 13615, 13619, 13620, 932, 68233, 68262, 68263, 
14823, 14815, 68231, 68261, 14824
24762, 14765, 68121, 68129, 14769, 14766, 68122, 68130, 14770, 68233, 68262, 68263, 14823, 68236, 68265, 68266, 
14825, 14817, 68234, 68264, 14826
24763, 14766, 68122, 68130, 14770, 14767, 68123, 68131, 14771, 68236, 68265, 68266, 14825, 68239, 68268, 68269, 
14827, 14819, 68237, 68267, 14828
24764, 14767, 68123, 68131, 14771, 14768, 68124, 68132, 14772, 68239, 68268, 68269, 14827, 68242, 68271, 68272, 
14829, 14821, 68240, 68270, 14830
24765, 14768, 68124, 68132, 14772, 1220, 15057, 15059, 1221, 68242, 68271, 68272, 14829, 15083, 15087, 15088, 
1232, 14822, 68243, 68273, 14831
24766, 13589, 13590, 13592, 13591, 68121, 68125, 68133, 68129, 13617, 13621, 13622, 13619, 68246, 68275, 68276, 
68262, 68231, 68244, 68274, 68261
24767, 68121, 68125, 68133, 68129, 68122, 68126, 68134, 68130, 68246, 68275, 68276, 68262, 68249, 68278, 68279, 
68265, 68234, 68247, 68277, 68264
24768, 68122, 68126, 68134, 68130, 68123, 68127, 68135, 68131, 68249, 68278, 68279, 68265, 68252, 68281, 68282, 
68268, 68237, 68250, 68280, 68267
24769, 68123, 68127, 68135, 68131, 68124, 68128, 68136, 68132, 68252, 68281, 68282, 68268, 68255, 68284, 68285, 
68271, 68240, 68253, 68283, 68270
24770, 68124, 68128, 68136, 68132, 15057, 15058, 15060, 15059, 68255, 68284, 68285, 68271, 15085, 15089, 15090, 
15087, 68243, 68256, 68286, 68273
24771, 13590, 1076, 1077, 13592, 68125, 14912, 14916, 68133, 13618, 1088, 13623, 13621, 68257, 14971, 68287, 
68275, 68244, 14961, 14970, 68274
24772, 68125, 14912, 14916, 68133, 68126, 14913, 14917, 68134, 68257, 14971, 68287, 68275, 68258, 14973, 68288, 
68278, 68247, 14963, 14972, 68277
24773, 68126, 14913, 14917, 68134, 68127, 14914, 14918, 68135, 68258, 14973, 68288, 68278, 68259, 14975, 68289, 
68281, 68250, 14965, 14974, 68280
24774, 68127, 14914, 14918, 68135, 68128, 14915, 14919, 68136, 68259, 14975, 68289, 68281, 68260, 14977, 68290, 
68284, 68253, 14967, 14976, 68283
24775, 68128, 14915, 14919, 68136, 15058, 1243, 1244, 15060, 68260, 14977, 68290, 68284, 15086, 1255, 15091, 
15089, 68256, 14969, 14978, 68286
24776, 921, 13591, 13593, 922, 14769, 68129, 68137, 14773, 13620, 13624, 13625, 933, 68263, 68292, 68293, 
14832, 14824, 68261, 68291, 14833
24777, 14769, 68129, 68137, 14773, 14770, 68130, 68138, 14774, 68263, 68292, 68293, 14832, 68266, 68295, 68296, 
14834, 14826, 68264, 68294, 14835
24778, 14770, 68130, 68138, 14774, 14771, 68131, 68139, 14775, 68266, 68295, 68296, 14834, 68269, 68298, 68299, 
14836, 14828, 68267, 68297, 14837
24779, 14771, 68131, 68139, 14775, 14772, 68132, 68140, 14776, 68269, 68298, 68299, 14836, 68272, 68301, 68302, 
14838, 14830, 68270, 68300, 14839
24780, 14772, 68132, 68140, 14776, 1221, 15059, 15061, 1222, 68272, 68301, 68302, 14838, 15088, 15092, 15093, 
1233, 14831, 68273, 68303, 14840
24781, 13591, 13592, 13594, 13593, 68129, 68133, 68141, 68137, 13622, 13626, 13627, 13624, 68276, 68305, 68306, 
68292, 68261, 68274, 68304, 68291
24782, 68129, 68133, 68141, 68137, 68130, 68134, 68142, 68138, 68276, 68305, 68306, 68292, 68279, 68308, 68309, 
68295, 68264, 68277, 68307, 68294
24783, 68130, 68134, 68142, 68138, 68131, 68135, 68143, 68139, 68279, 68308, 68309, 68295, 68282, 68311, 68312, 
68298, 68267, 68280, 68310, 68297
24784, 68131, 68135, 68143, 68139, 68132, 68136, 68144, 68140, 68282, 68311, 68312, 68298, 68285, 68314, 68315, 
68301, 68270, 68283, 68313, 68300
24785, 68132, 68136, 68144, 68140, 15059, 15060, 15062, 15061, 68285, 68314, 68315, 68301, 15090, 15094, 15095, 
15092, 68273, 68286, 68316, 68303
24786, 13592, 1077, 1078, 13594, 68133, 14916, 14920, 68141, 13623, 1089, 13628, 13626, 68287, 14980, 68317, 
68305, 68274, 14970, 14979, 68304
24787, 68133, 14916, 14920, 68141, 68134, 14917, 14921, 68142, 68287, 14980, 68317, 68305, 68288, 14982, 68318, 
68308, 68277, 14972, 14981, 68307
24788, 68134, 14917, 14921, 68142, 68135, 14918, 14922, 68143, 68288, 14982, 68318, 68308, 68289, 14984, 68319, 
68311, 68280, 14974, 14983, 68310
24789, 68135, 14918, 14922, 68143, 68136, 14919, 14923, 68144, 68289, 14984, 68319, 68311, 68290, 14986, 68320, 
68314, 68283, 14976, 14985, 68313
24790, 68136, 14919, 14923, 68144, 15060, 1244, 1245, 15062, 68290, 14986, 68320, 68314, 15091, 1256, 15096, 
15094, 68286, 14978, 14987, 68316
24791, 922, 13593, 13595, 923, 14773, 68137, 68145, 14777, 13625, 13629, 13630, 934, 68293, 68322, 68323, 
14841, 14833, 68291, 68321, 14842
24792, 14773, 68137, 68145, 14777, 14774, 68138, 68146, 14778, 68293, 68322, 68323, 14841, 68296, 68325, 68326, 
14843, 14835, 68294, 68324, 14844
24793, 14774, 68138, 68146, 14778, 14775, 68139, 68147, 14779, 68296, 68325, 68326, 14843, 68299, 68328, 68329, 
14845, 14837, 68297, 68327, 14846
24794, 14775, 68139, 68147, 14779, 14776, 68140, 68148, 14780, 68299, 68328, 68329, 14845, 68302, 68331, 68332, 
14847, 14839, 68300, 68330, 14848
24795, 14776, 68140, 68148, 14780, 1222, 15061, 15063, 1223, 68302, 68331, 68332, 14847, 15093, 15097, 15098, 
1234, 14840, 68303, 68333, 14849
24796, 13593, 13594, 13596, 13595, 68137, 68141, 68149, 68145, 13627, 13631, 13632, 13629, 68306, 68335, 68336, 
68322, 68291, 68304, 68334, 68321
24797, 68137, 68141, 68149, 68145, 68138, 68142, 68150, 68146, 68306, 68335, 68336, 68322, 68309, 68338, 68339, 
68325, 68294, 68307, 68337, 68324
24798, 68138, 68142, 68150, 68146, 68139, 68143, 68151, 68147, 68309, 68338, 68339, 68325, 68312, 68341, 68342, 
68328, 68297, 68310, 68340, 68327
24799, 68139, 68143, 68151, 68147, 68140, 68144, 68152, 68148, 68312, 68341, 68342, 68328, 68315, 68344, 68345, 
68331, 68300, 68313, 68343, 68330
24800, 68140, 68144, 68152, 68148, 15061, 15062, 15064, 15063, 68315, 68344, 68345, 68331, 15095, 15099, 15100, 
15097, 68303, 68316, 68346, 68333
24801, 13594, 1078, 1079, 13596, 68141, 14920, 14924, 68149, 13628, 1090, 13633, 13631, 68317, 14989, 68347, 
68335, 68304, 14979, 14988, 68334
24802, 68141, 14920, 14924, 68149, 68142, 14921, 14925, 68150, 68317, 14989, 68347, 68335, 68318, 14991, 68348, 
68338, 68307, 14981, 14990, 68337
24803, 68142, 14921, 14925, 68150, 68143, 14922, 14926, 68151, 68318, 14991, 68348, 68338, 68319, 14993, 68349, 
68341, 68310, 14983, 14992, 68340
24804, 68143, 14922, 14926, 68151, 68144, 14923, 14927, 68152, 68319, 14993, 68349, 68341, 68320, 14995, 68350, 
68344, 68313, 14985, 14994, 68343
24805, 68144, 14923, 14927, 68152, 15062, 1245, 1246, 15064, 68320, 14995, 68350, 68344, 15096, 1257, 15101, 
15099, 68316, 14987, 14996, 68346
24806, 923, 13595, 13597, 924, 14777, 68145, 68153, 14781, 13630, 13634, 13635, 935, 68323, 68352, 68353, 
14850, 14842, 68321, 68351, 14851
24807, 14777, 68145, 68153, 14781, 14778, 68146, 68154, 14782, 68323, 68352, 68353, 14850, 68326, 68355, 68356, 
14852, 14844, 68324, 68354, 14853
24808, 14778, 68146, 68154, 14782, 14779, 68147, 68155, 14783, 68326, 68355, 68356, 14852, 68329, 68358, 68359, 
14854, 14846, 68327, 68357, 14855
24809, 14779, 68147, 68155, 14783, 14780, 68148, 68156, 14784, 68329, 68358, 68359, 14854, 68332, 68361, 68362, 
14856, 14848, 68330, 68360, 14857
24810, 14780, 68148, 68156, 14784, 1223, 15063, 15065, 1224, 68332, 68361, 68362, 14856, 15098, 15102, 15103, 
1235, 14849, 68333, 68363, 14858
24811, 13595, 13596, 13598, 13597, 68145, 68149, 68157, 68153, 13632, 13636, 13637, 13634, 68336, 68365, 68366, 
68352, 68321, 68334, 68364, 68351
24812, 68145, 68149, 68157, 68153, 68146, 68150, 68158, 68154, 68336, 68365, 68366, 68352, 68339, 68368, 68369, 
68355, 68324, 68337, 68367, 68354
24813, 68146, 68150, 68158, 68154, 68147, 68151, 68159, 68155, 68339, 68368, 68369, 68355, 68342, 68371, 68372, 
68358, 68327, 68340, 68370, 68357
24814, 68147, 68151, 68159, 68155, 68148, 68152, 68160, 68156, 68342, 68371, 68372, 68358, 68345, 68374, 68375, 
68361, 68330, 68343, 68373, 68360
24815, 68148, 68152, 68160, 68156, 15063, 15064, 15066, 15065, 68345, 68374, 68375, 68361, 15100, 15104, 15105, 
15102, 68333, 68346, 68376, 68363
24816, 13596, 1079, 1080, 13598, 68149, 14924, 14928, 68157, 13633, 1091, 13638, 13636, 68347, 14998, 68377, 
68365, 68334, 14988, 14997, 68364
24817, 68149, 14924, 14928, 68157, 68150, 14925, 14929, 68158, 68347, 14998, 68377, 68365, 68348, 15000, 68378, 
68368, 68337, 14990, 14999, 68367
24818, 68150, 14925, 14929, 68158, 68151, 14926, 14930, 68159, 68348, 15000, 68378, 68368, 68349, 15002, 68379, 
68371, 68340, 14992, 15001, 68370
24819, 68151, 14926, 14930, 68159, 68152, 14927, 14931, 68160, 68349, 15002, 68379, 68371, 68350, 15004, 68380, 
68374, 68343, 14994, 15003, 68373
24820, 68152, 14927, 14931, 68160, 15064, 1246, 1247, 15066, 68350, 15004, 68380, 68374, 15101, 1258, 15106, 
15104, 68346, 14996, 15005, 68376
24821, 924, 13597, 13599, 925, 14781, 68153, 68161, 14785, 13635, 13639, 13640, 936, 68353, 68382, 68383, 
14859, 14851, 68351, 68381, 14860
24822, 14781, 68153, 68161, 14785, 14782, 68154, 68162, 14786, 68353, 68382, 68383, 14859, 68356, 68385, 68386, 
14861, 14853, 68354, 68384, 14862
24823, 14782, 68154, 68162, 14786, 14783, 68155, 68163, 14787, 68356, 68385, 68386, 14861, 68359, 68388, 68389, 
14863, 14855, 68357, 68387, 14864
24824, 14783, 68155, 68163, 14787, 14784, 68156, 68164, 14788, 68359, 68388, 68389, 14863, 68362, 68391, 68392, 
14865, 14857, 68360, 68390, 14866
24825, 14784, 68156, 68164, 14788, 1224, 15065, 15067, 1225, 68362, 68391, 68392, 14865, 15103, 15107, 15108, 
1236, 14858, 68363, 68393, 14867
24826, 13597, 13598, 13600, 13599, 68153, 68157, 68165, 68161, 13637, 13641, 13642, 13639, 68366, 68395, 68396, 
68382, 68351, 68364, 68394, 68381
24827, 68153, 68157, 68165, 68161, 68154, 68158, 68166, 68162, 68366, 68395, 68396, 68382, 68369, 68398, 68399, 
68385, 68354, 68367, 68397, 68384
24828, 68154, 68158, 68166, 68162, 68155, 68159, 68167, 68163, 68369, 68398, 68399, 68385, 68372, 68401, 68402, 
68388, 68357, 68370, 68400, 68387
24829, 68155, 68159, 68167, 68163, 68156, 68160, 68168, 68164, 68372, 68401, 68402, 68388, 68375, 68404, 68405, 
68391, 68360, 68373, 68403, 68390
24830, 68156, 68160, 68168, 68164, 15065, 15066, 15068, 15067, 68375, 68404, 68405, 68391, 15105, 15109, 15110, 
15107, 68363, 68376, 68406, 68393
24831, 13598, 1080, 1081, 13600, 68157, 14928, 14932, 68165, 13638, 1092, 13643, 13641, 68377, 15007, 68407, 
68395, 68364, 14997, 15006, 68394
24832, 68157, 14928, 14932, 68165, 68158, 14929, 14933, 68166, 68377, 15007, 68407, 68395, 68378, 15009, 68408, 
68398, 68367, 14999, 15008, 68397
24833, 68158, 14929, 14933, 68166, 68159, 14930, 14934, 68167, 68378, 15009, 68408, 68398, 68379, 15011, 68409, 
68401, 68370, 15001, 15010, 68400
24834, 68159, 14930, 14934, 68167, 68160, 14931, 14935, 68168, 68379, 15011, 68409, 68401, 68380, 15013, 68410, 
68404, 68373, 15003, 15012, 68403
24835, 68160, 14931, 14935, 68168, 15066, 1247, 1248, 15068, 68380, 15013, 68410, 68404, 15106, 1259, 15111, 
15109, 68376, 15005, 15014, 68406
24836, 925, 13599, 13601, 926, 14785, 68161, 68169, 14789, 13640, 13644, 13645, 937, 68383, 68412, 68413, 
14868, 14860, 68381, 68411, 14869
24837, 14785, 68161, 68169, 14789, 14786, 68162, 68170, 14790, 68383, 68412, 68413, 14868, 68386, 68415, 68416, 
14870, 14862, 68384, 68414, 14871
24838, 14786, 68162, 68170, 14790, 14787, 68163, 68171, 14791, 68386, 68415, 68416, 14870, 68389, 68418, 68419, 
14872, 14864, 68387, 68417, 14873
24839, 14787, 68163, 68171, 14791, 14788, 68164, 68172, 14792, 68389, 68418, 68419, 14872, 68392, 68421, 68422, 
14874, 14866, 68390, 68420, 14875
24840, 14788, 68164, 68172, 14792, 1225, 15067, 15069, 1226, 68392, 68421, 68422, 14874, 15108, 15112, 15113, 
1237, 14867, 68393, 68423, 14876
24841, 13599, 13600, 13602, 13601, 68161, 68165, 68173, 68169, 13642, 13646, 13647, 13644, 68396, 68425, 68426, 
68412, 68381, 68394, 68424, 68411
24842, 68161, 68165, 68173, 68169, 68162, 68166, 68174, 68170, 68396, 68425, 68426, 68412, 68399, 68428, 68429, 
68415, 68384, 68397, 68427, 68414
24843, 68162, 68166, 68174, 68170, 68163, 68167, 68175, 68171, 68399, 68428, 68429, 68415, 68402, 68431, 68432, 
68418, 68387, 68400, 68430, 68417
24844, 68163, 68167, 68175, 68171, 68164, 68168, 68176, 68172, 68402, 68431, 68432, 68418, 68405, 68434, 68435, 
68421, 68390, 68403, 68433, 68420
24845, 68164, 68168, 68176, 68172, 15067, 15068, 15070, 15069, 68405, 68434, 68435, 68421, 15110, 15114, 15115, 
15112, 68393, 68406, 68436, 68423
24846, 13600, 1081, 1082, 13602, 68165, 14932, 14936, 68173, 13643, 1093, 13648, 13646, 68407, 15016, 68437, 
68425, 68394, 15006, 15015, 68424
24847, 68165, 14932, 14936, 68173, 68166, 14933, 14937, 68174, 68407, 15016, 68437, 68425, 68408, 15018, 68438, 
68428, 68397, 15008, 15017, 68427
24848, 68166, 14933, 14937, 68174, 68167, 14934, 14938, 68175, 68408, 15018, 68438, 68428, 68409, 15020, 68439, 
68431, 68400, 15010, 15019, 68430
24849, 68167, 14934, 14938, 68175, 68168, 14935, 14939, 68176, 68409, 15020, 68439, 68431, 68410, 15022, 68440, 
68434, 68403, 15012, 15021, 68433
24850, 68168, 14935, 14939, 68176, 15068, 1248, 1249, 15070, 68410, 15022, 68440, 68434, 15111, 1260, 15116, 
15114, 68406, 15014, 15023, 68436
24851, 926, 13601, 13603, 927, 14789, 68169, 68177, 14793, 13645, 13649, 13650, 938, 68413, 68442, 68443, 
14877, 14869, 68411, 68441, 14878
24852, 14789, 68169, 68177, 14793, 14790, 68170, 68178, 14794, 68413, 68442, 68443, 14877, 68416, 68445, 68446, 
14879, 14871, 68414, 68444, 14880
24853, 14790, 68170, 68178, 14794, 14791, 68171, 68179, 14795, 68416, 68445, 68446, 14879, 68419, 68448, 68449, 
14881, 14873, 68417, 68447, 14882
24854, 14791, 68171, 68179, 14795, 14792, 68172, 68180, 14796, 68419, 68448, 68449, 14881, 68422, 68451, 68452, 
14883, 14875, 68420, 68450, 14884
24855, 14792, 68172, 68180, 14796, 1226, 15069, 15071, 1227, 68422, 68451, 68452, 14883, 15113, 15117, 15118, 
1238, 14876, 68423, 68453, 14885
24856, 13601, 13602, 13604, 13603, 68169, 68173, 68181, 68177, 13647, 13651, 13652, 13649, 68426, 68455, 68456, 
68442, 68411, 68424, 68454, 68441
24857, 68169, 68173, 68181, 68177, 68170, 68174, 68182, 68178, 68426, 68455, 68456, 68442, 68429, 68458, 68459, 
68445, 68414, 68427, 68457, 68444
24858, 68170, 68174, 68182, 68178, 68171, 68175, 68183, 68179, 68429, 68458, 68459, 68445, 68432, 68461, 68462, 
68448, 68417, 68430, 68460, 68447
24859, 68171, 68175, 68183, 68179, 68172, 68176, 68184, 68180, 68432, 68461, 68462, 68448, 68435, 68464, 68465, 
68451, 68420, 68433, 68463, 68450
24860, 68172, 68176, 68184, 68180, 15069, 15070, 15072, 15071, 68435, 68464, 68465, 68451, 15115, 15119, 15120, 
15117, 68423, 68436, 68466, 68453
24861, 13602, 1082, 1083, 13604, 68173, 14936, 14940, 68181, 13648, 1094, 13653, 13651, 68437, 15025, 68467, 
68455, 68424, 15015, 15024, 68454
24862, 68173, 14936, 14940, 68181, 68174, 14937, 14941, 68182, 68437, 15025, 68467, 68455, 68438, 15027, 68468, 
68458, 68427, 15017, 15026, 68457
24863, 68174, 14937, 14941, 68182, 68175, 14938, 14942, 68183, 68438, 15027, 68468, 68458, 68439, 15029, 68469, 
68461, 68430, 15019, 15028, 68460
24864, 68175, 14938, 14942, 68183, 68176, 14939, 14943, 68184, 68439, 15029, 68469, 68461, 68440, 15031, 68470, 
68464, 68433, 15021, 15030, 68463
24865, 68176, 14939, 14943, 68184, 15070, 1249, 1250, 15072, 68440, 15031, 68470, 68464, 15116, 1261, 15121, 
15119, 68436, 15023, 15032, 68466
24866, 927, 13603, 13605, 928, 14793, 68177, 68185, 14797, 13650, 13654, 13655, 939, 68443, 68472, 68473, 
14886, 14878, 68441, 68471, 14887
24867, 14793, 68177, 68185, 14797, 14794, 68178, 68186, 14798, 68443, 68472, 68473, 14886, 68446, 68475, 68476, 
14888, 14880, 68444, 68474, 14889
24868, 14794, 68178, 68186, 14798, 14795, 68179, 68187, 14799, 68446, 68475, 68476, 14888, 68449, 68478, 68479, 
14890, 14882, 68447, 68477, 14891
24869, 14795, 68179, 68187, 14799, 14796, 68180, 68188, 14800, 68449, 68478, 68479, 14890, 68452, 68481, 68482, 
14892, 14884, 68450, 68480, 14893
24870, 14796, 68180, 68188, 14800, 1227, 15071, 15073, 1228, 68452, 68481, 68482, 14892, 15118, 15122, 15123, 
1239, 14885, 68453, 68483, 14894
24871, 13603, 13604, 13606, 13605, 68177, 68181, 68189, 68185, 13652, 13656, 13657, 13654, 68456, 68485, 68486, 
68472, 68441, 68454, 68484, 68471
24872, 68177, 68181, 68189, 68185, 68178, 68182, 68190, 68186, 68456, 68485, 68486, 68472, 68459, 68488, 68489, 
68475, 68444, 68457, 68487, 68474
24873, 68178, 68182, 68190, 68186, 68179, 68183, 68191, 68187, 68459, 68488, 68489, 68475, 68462, 68491, 68492, 
68478, 68447, 68460, 68490, 68477
24874, 68179, 68183, 68191, 68187, 68180, 68184, 68192, 68188, 68462, 68491, 68492, 68478, 68465, 68494, 68495, 
68481, 68450, 68463, 68493, 68480
24875, 68180, 68184, 68192, 68188, 15071, 15072, 15074, 15073, 68465, 68494, 68495, 68481, 15120, 15124, 15125, 
15122, 68453, 68466, 68496, 68483
24876, 13604, 1083, 1084, 13606, 68181, 14940, 14944, 68189, 13653, 1095, 13658, 13656, 68467, 15034, 68497, 
68485, 68454, 15024, 15033, 68484
24877, 68181, 14940, 14944, 68189, 68182, 14941, 14945, 68190, 68467, 15034, 68497, 68485, 68468, 15036, 68498, 
68488, 68457, 15026, 15035, 68487
24878, 68182, 14941, 14945, 68190, 68183, 14942, 14946, 68191, 68468, 15036, 68498, 68488, 68469, 15038, 68499, 
68491, 68460, 15028, 15037, 68490
24879, 68183, 14942, 14946, 68191, 68184, 14943, 14947, 68192, 68469, 15038, 68499, 68491, 68470, 15040, 68500, 
68494, 68463, 15030, 15039, 68493
24880, 68184, 14943, 14947, 68192, 15072, 1250, 1251, 15074, 68470, 15040, 68500, 68494, 15121, 1262, 15126, 
15124, 68466, 15032, 15041, 68496
24881, 928, 13605, 13607, 929, 14797, 68185, 68193, 14801, 13655, 13659, 13660, 940, 68473, 68502, 68503, 
14895, 14887, 68471, 68501, 14896
24882, 14797, 68185, 68193, 14801, 14798, 68186, 68194, 14802, 68473, 68502, 68503, 14895, 68476, 68505, 68506, 
14897, 14889, 68474, 68504, 14898
24883, 14798, 68186, 68194, 14802, 14799, 68187, 68195, 14803, 68476, 68505, 68506, 14897, 68479, 68508, 68509, 
14899, 14891, 68477, 68507, 14900
24884, 14799, 68187, 68195, 14803, 14800, 68188, 68196, 14804, 68479, 68508, 68509, 14899, 68482, 68511, 68512, 
14901, 14893, 68480, 68510, 14902
24885, 14800, 68188, 68196, 14804, 1228, 15073, 15075, 1229, 68482, 68511, 68512, 14901, 15123, 15127, 15128, 
1240, 14894, 68483, 68513, 14903
24886, 13605, 13606, 13608, 13607, 68185, 68189, 68197, 68193, 13657, 13661, 13662, 13659, 68486, 68515, 68516, 
68502, 68471, 68484, 68514, 68501
24887, 68185, 68189, 68197, 68193, 68186, 68190, 68198, 68194, 68486, 68515, 68516, 68502, 68489, 68518, 68519, 
68505, 68474, 68487, 68517, 68504
24888, 68186, 68190, 68198, 68194, 68187, 68191, 68199, 68195, 68489, 68518, 68519, 68505, 68492, 68521, 68522, 
68508, 68477, 68490, 68520, 68507
24889, 68187, 68191, 68199, 68195, 68188, 68192, 68200, 68196, 68492, 68521, 68522, 68508, 68495, 68524, 68525, 
68511, 68480, 68493, 68523, 68510
24890, 68188, 68192, 68200, 68196, 15073, 15074, 15076, 15075, 68495, 68524, 68525, 68511, 15125, 15129, 15130, 
15127, 68483, 68496, 68526, 68513
24891, 13606, 1084, 1085, 13608, 68189, 14944, 14948, 68197, 13658, 1096, 13663, 13661, 68497, 15043, 68527, 
68515, 68484, 15033, 15042, 68514
24892, 68189, 14944, 14948, 68197, 68190, 14945, 14949, 68198, 68497, 15043, 68527, 68515, 68498, 15045, 68528, 
68518, 68487, 15035, 15044, 68517
24893, 68190, 14945, 14949, 68198, 68191, 14946, 14950, 68199, 68498, 15045, 68528, 68518, 68499, 15047, 68529, 
68521, 68490, 15037, 15046, 68520
24894, 68191, 14946, 14950, 68199, 68192, 14947, 14951, 68200, 68499, 15047, 68529, 68521, 68500, 15049, 68530, 
68524, 68493, 15039, 15048, 68523
24895, 68192, 14947, 14951, 68200, 15074, 1251, 1252, 15076, 68500, 15049, 68530, 68524, 15126, 1263, 15131, 
15129, 68496, 15041, 15050, 68526
24896, 929, 13607, 1070, 19, 14801, 68193, 14701, 1173, 13660, 13664, 1072, 941, 68503, 68531, 14709, 
14904, 14896, 68501, 14710, 1177
24897, 14801, 68193, 14701, 1173, 14802, 68194, 14702, 1174, 68503, 68531, 14709, 14904, 68506, 68532, 14711, 
14905, 14898, 68504, 14712, 1178
24898, 14802, 68194, 14702, 1174, 14803, 68195, 14703, 1175, 68506, 68532, 14711, 14905, 68509, 68533, 14713, 
14906, 14900, 68507, 14714, 1179
24899, 14803, 68195, 14703, 1175, 14804, 68196, 14704, 1176, 68509, 68533, 14713, 14906, 68512, 68534, 14715, 
14907, 14902, 68510, 14716, 1180
24900, 14804, 68196, 14704, 1176, 1229, 15075, 1191, 25, 68512, 68534, 14715, 14907, 15128, 15132, 1193, 
1241, 14903, 68513, 14717, 1181
24901, 13607, 13608, 1071, 1070, 68193, 68197, 14705, 14701, 13662, 13665, 1073, 13664, 68516, 68535, 14718, 
68531, 68501, 68514, 14719, 14710
24902, 68193, 68197, 14705, 14701, 68194, 68198, 14706, 14702, 68516, 68535, 14718, 68531, 68519, 68536, 14720, 
68532, 68504, 68517, 14721, 14712
24903, 68194, 68198, 14706, 14702, 68195, 68199, 14707, 14703, 68519, 68536, 14720, 68532, 68522, 68537, 14722, 
68533, 68507, 68520, 14723, 14714
24904, 68195, 68199, 14707, 14703, 68196, 68200, 14708, 14704, 68522, 68537, 14722, 68533, 68525, 68538, 14724, 
68534, 68510, 68523, 14725, 14716
24905, 68196, 68200, 14708, 14704, 15075, 15076, 1192, 1191, 68525, 68538, 14724, 68534, 15130, 15133, 1194, 
15132, 68513, 68526, 14726, 14717
24906, 13608, 1085, 23, 1071, 68197, 14948, 1182, 14705, 13663, 1097, 1074, 13665, 68527, 15051, 14727, 
68535, 68514, 15042, 1186, 14719
24907, 68197, 14948, 1182, 14705, 68198, 14949, 1183, 14706, 68527, 15051, 14727, 68535, 68528, 15052, 14728, 
68536, 68517, 15044, 1187, 14721
24908, 68198, 14949, 1183, 14706, 68199, 14950, 1184, 14707, 68528, 15052, 14728, 68536, 68529, 15053, 14729, 
68537, 68520, 15046, 1188, 14723
24909, 68199, 14950, 1184, 14707, 68200, 14951, 1185, 14708, 68529, 15053, 14729, 68537, 68530, 15054, 14730, 
68538, 68523, 15048, 1189, 14725
24910, 68200, 14951, 1185, 14708, 15076, 1252, 26, 1192, 68530, 15054, 14730, 68538, 15131, 1264, 1195, 
15133, 68526, 15050, 1190, 14726
*ELEMENT, type=C3D20, ELSET=Volume7
24911, 27, 1214, 15055, 1219, 1364, 15297, 68539, 15460, 1216, 15077, 15078, 1230, 15344, 69046, 69047, 
15713, 1387, 15343, 69045, 15714
24912, 1364, 15297, 68539, 15460, 1365, 15298, 68540, 15461, 15344, 69046, 69047, 15713, 15346, 69049, 69050, 
15715, 1388, 15345, 69048, 15716
24913, 1365, 15298, 68540, 15461, 1366, 15299, 68541, 15462, 15346, 69049, 69050, 15715, 15348, 69052, 69053, 
15717, 1389, 15347, 69051, 15718
24914, 1366, 15299, 68541, 15462, 1367, 15300, 68542, 15463, 15348, 69052, 69053, 15717, 15350, 69055, 69056, 
15719, 1390, 15349, 69054, 15720
24915, 1367, 15300, 68542, 15463, 1368, 15301, 68543, 15464, 15350, 69055, 69056, 15719, 15352, 69058, 69059, 
15721, 1391, 15351, 69057, 15722
24916, 1368, 15301, 68543, 15464, 1369, 15302, 68544, 15465, 15352, 69058, 69059, 15721, 15354, 69061, 69062, 
15723, 1392, 15353, 69060, 15724
24917, 1369, 15302, 68544, 15465, 1370, 15303, 68545, 15466, 15354, 69061, 69062, 15723, 15356, 69064, 69065, 
15725, 1393, 15355, 69063, 15726
24918, 1370, 15303, 68545, 15466, 1371, 15304, 68546, 15467, 15356, 69064, 69065, 15725, 15358, 69067, 69068, 
15727, 1394, 15357, 69066, 15728
24919, 1371, 15304, 68546, 15467, 1372, 15305, 68547, 15468, 15358, 69067, 69068, 15727, 15360, 69070, 69071, 
15729, 1395, 15359, 69069, 15730
24920, 1372, 15305, 68547, 15468, 1373, 15306, 68548, 15469, 15360, 69070, 69071, 15729, 15362, 69073, 69074, 
15731, 1396, 15361, 69072, 15732
24921, 1373, 15306, 68548, 15469, 1374, 15307, 68549, 15470, 15362, 69073, 69074, 15731, 15364, 69076, 69077, 
15733, 1397, 15363, 69075, 15734
24922, 1374, 15307, 68549, 15470, 1375, 15308, 68550, 15471, 15364, 69076, 69077, 15733, 15366, 69079, 69080, 
15735, 1398, 15365, 69078, 15736
24923, 1375, 15308, 68550, 15471, 1376, 15309, 68551, 15472, 15366, 69079, 69080, 15735, 15368, 69082, 69083, 
15737, 1399, 15367, 69081, 15738
24924, 1376, 15309, 68551, 15472, 1377, 15310, 68552, 15473, 15368, 69082, 69083, 15737, 15370, 69085, 69086, 
15739, 1400, 15369, 69084, 15740
24925, 1377, 15310, 68552, 15473, 1378, 15311, 68553, 15474, 15370, 69085, 69086, 15739, 15372, 69088, 69089, 
15741, 1401, 15371, 69087, 15742
24926, 1378, 15311, 68553, 15474, 1379, 15312, 68554, 15475, 15372, 69088, 69089, 15741, 15374, 69091, 69092, 
15743, 1402, 15373, 69090, 15744
24927, 1379, 15312, 68554, 15475, 1380, 15313, 68555, 15476, 15374, 69091, 69092, 15743, 15376, 69094, 69095, 
15745, 1403, 15375, 69093, 15746
24928, 1380, 15313, 68555, 15476, 1381, 15314, 68556, 15477, 15376, 69094, 69095, 15745, 15378, 69097, 69098, 
15747, 1404, 15377, 69096, 15748
24929, 1381, 15314, 68556, 15477, 1382, 15315, 68557, 15478, 15378, 69097, 69098, 15747, 15380, 69100, 69101, 
15749, 1405, 15379, 69099, 15750
24930, 1382, 15315, 68557, 15478, 1383, 15316, 68558, 15479, 15380, 69100, 69101, 15749, 15382, 69103, 69104, 
15751, 1406, 15381, 69102, 15752
24931, 1383, 15316, 68558, 15479, 1384, 15317, 68559, 15480, 15382, 69103, 69104, 15751, 15384, 69106, 69107, 
15753, 1407, 15383, 69105, 15754
24932, 1384, 15317, 68559, 15480, 1385, 15318, 68560, 15481, 15384, 69106, 69107, 15753, 15386, 69109, 69110, 
15755, 1408, 15385, 69108, 15756
24933, 1385, 15318, 68560, 15481, 1386, 15319, 68561, 15482, 15386, 69109, 69110, 15755, 15388, 69112, 69113, 
15757, 1409, 15387, 69111, 15758
24934, 1386, 15319, 68561, 15482, 31, 1458, 17046, 1463, 15388, 69112, 69113, 15757, 1460, 17068, 17069, 
1474, 1410, 15389, 69114, 15759
24935, 1214, 1215, 15056, 15055, 15297, 15320, 68562, 68539, 1217, 15079, 15080, 15077, 15391, 69116, 69117, 
69046, 15343, 15390, 69115, 69045
24936, 15297, 15320, 68562, 68539, 15298, 15321, 68563, 68540, 15391, 69116, 69117, 69046, 15393, 69119, 69120, 
69049, 15345, 15392, 69118, 69048
24937, 15298, 15321, 68563, 68540, 15299, 15322, 68564, 68541, 15393, 69119, 69120, 69049, 15395, 69122, 69123, 
69052, 15347, 15394, 69121, 69051
24938, 15299, 15322, 68564, 68541, 15300, 15323, 68565, 68542, 15395, 69122, 69123, 69052, 15397, 69125, 69126, 
69055, 15349, 15396, 69124, 69054
