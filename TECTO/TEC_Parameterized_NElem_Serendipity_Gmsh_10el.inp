42130, 2268, 2328, 2329, 2269, 37524, 38472, 38476, 37528, 25790, 2340, 25791, 2280, 118278, 38556, 118282, 
37608, 37598, 38546, 38555, 37607
42131, 37524, 38472, 38476, 37528, 37525, 38473, 38477, 37529, 118278, 38556, 118282, 37608, 118279, 38558, 118283, 
37610, 37600, 38548, 38557, 37609
42132, 37525, 38473, 38477, 37529, 37526, 38474, 38478, 37530, 118279, 38558, 118283, 37610, 118280, 38560, 118284, 
37612, 37602, 38550, 38559, 37611
42133, 37526, 38474, 38478, 37530, 37527, 38475, 38479, 37531, 118280, 38560, 118284, 37612, 118281, 38562, 118285, 
37614, 37604, 38552, 38561, 37613
42134, 37527, 38475, 38479, 37531, 3927, 3970, 3971, 3928, 118281, 38562, 118285, 37614, 38601, 3982, 38602, 
3939, 37606, 38554, 38563, 37615
42135, 2269, 2329, 2330, 2270, 37528, 38476, 38480, 37532, 25791, 2341, 25792, 2281, 118282, 38565, 118286, 
37617, 37607, 38555, 38564, 37616
42136, 37528, 38476, 38480, 37532, 37529, 38477, 38481, 37533, 118282, 38565, 118286, 37617, 118283, 38567, 118287, 
37619, 37609, 38557, 38566, 37618
42137, 37529, 38477, 38481, 37533, 37530, 38478, 38482, 37534, 118283, 38567, 118287, 37619, 118284, 38569, 118288, 
37621, 37611, 38559, 38568, 37620
42138, 37530, 38478, 38482, 37534, 37531, 38479, 38483, 37535, 118284, 38569, 118288, 37621, 118285, 38571, 118289, 
37623, 37613, 38561, 38570, 37622
42139, 37531, 38479, 38483, 37535, 3928, 3971, 3972, 3929, 118285, 38571, 118289, 37623, 38602, 3983, 38603, 
3940, 37615, 38563, 38572, 37624
42140, 2270, 2330, 2331, 2271, 37532, 38480, 38484, 37536, 25792, 2342, 25793, 2282, 118286, 38574, 118290, 
37626, 37616, 38564, 38573, 37625
42141, 37532, 38480, 38484, 37536, 37533, 38481, 38485, 37537, 118286, 38574, 118290, 37626, 118287, 38576, 118291, 
37628, 37618, 38566, 38575, 37627
42142, 37533, 38481, 38485, 37537, 37534, 38482, 38486, 37538, 118287, 38576, 118291, 37628, 118288, 38578, 118292, 
37630, 37620, 38568, 38577, 37629
42143, 37534, 38482, 38486, 37538, 37535, 38483, 38487, 37539, 118288, 38578, 118292, 37630, 118289, 38580, 118293, 
37632, 37622, 38570, 38579, 37631
42144, 37535, 38483, 38487, 37539, 3929, 3972, 3973, 3930, 118289, 38580, 118293, 37632, 38603, 3984, 38604, 
3941, 37624, 38572, 38581, 37633
42145, 2271, 2331, 2332, 2272, 37536, 38484, 38488, 37540, 25793, 2343, 25794, 2283, 118290, 38583, 118294, 
37635, 37625, 38573, 38582, 37634
42146, 37536, 38484, 38488, 37540, 37537, 38485, 38489, 37541, 118290, 38583, 118294, 37635, 118291, 38585, 118295, 
37637, 37627, 38575, 38584, 37636
42147, 37537, 38485, 38489, 37541, 37538, 38486, 38490, 37542, 118291, 38585, 118295, 37637, 118292, 38587, 118296, 
37639, 37629, 38577, 38586, 37638
42148, 37538, 38486, 38490, 37542, 37539, 38487, 38491, 37543, 118292, 38587, 118296, 37639, 118293, 38589, 118297, 
37641, 37631, 38579, 38588, 37640
42149, 37539, 38487, 38491, 37543, 3930, 3973, 3974, 3931, 118293, 38589, 118297, 37641, 38604, 3985, 38605, 
3942, 37633, 38581, 38590, 37642
42150, 2272, 2332, 50, 46, 37540, 38488, 3944, 3777, 25794, 2344, 2286, 2284, 118294, 38591, 38440, 
37643, 37634, 38582, 3948, 3781
42151, 37540, 38488, 3944, 3777, 37541, 38489, 3945, 3778, 118294, 38591, 38440, 37643, 118295, 38592, 38441, 
37644, 37636, 38584, 3949, 3782
42152, 37541, 38489, 3945, 3778, 37542, 38490, 3946, 3779, 118295, 38592, 38441, 37644, 118296, 38593, 38442, 
37645, 37638, 38586, 3950, 3783
42153, 37542, 38490, 3946, 3779, 37543, 38491, 3947, 3780, 118296, 38593, 38442, 37645, 118297, 38594, 38443, 
37646, 37640, 38588, 3951, 3784
42154, 37543, 38491, 3947, 3780, 3931, 3974, 95, 92, 118297, 38594, 38443, 37646, 38605, 3986, 3953, 
3943, 37642, 38590, 3952, 3785
*ELSET,ELSET=VoltageL_2D
1286, 1287, 1288, 
*ELSET,ELSET=VoltageR_2D
1239, 1240, 1241, 
*ELSET,ELSET=TopCeramic_2D
1769, 1770, 1771, 1772, 1773, 1774, 1775, 1776, 1777, 1778, 
1779, 1780, 1781, 1782, 1783, 1784, 1785, 1786, 1787, 1788, 
1789, 1790, 1791, 1792, 1810, 1811, 1812, 1813, 1814, 1842, 
1843, 1844, 1845, 1846, 1847, 1848, 1849, 1850, 1851, 1852, 
1853, 1854, 1855, 1856, 1857, 1858, 1859, 1860, 1861, 1862, 
1863, 1864, 1865, 
*ELSET,ELSET=BottomCeramic_2D
1963, 1964, 1965, 1966, 1967, 1968, 1969, 1970, 1971, 1972, 
1973, 1974, 1975, 1976, 1977, 1978, 1979, 1980, 1981, 1982, 
1983, 1984, 1985, 1986, 2004, 2033, 2034, 2035, 2036, 2037, 
2038, 2039, 2040, 2041, 2042, 2043, 2044, 2045, 2046, 2047, 
2048, 2049, 2050, 2051, 2052, 2053, 2054, 2055, 2056, 2120, 
*ELSET,ELSET=Qin
5883, 5884, 5885, 5886, 5887, 5888, 5889, 5890, 5891, 5892, 
5893, 5894, 5895, 5896, 5897, 5898, 5899, 5900, 5901, 5902, 
5903, 5904, 5905, 5906, 5907, 5908, 5909, 5910, 5911, 5912, 
5913, 5914, 5915, 5916, 5917, 5918, 5919, 5920, 5921, 5922, 
5923, 5924, 5925, 5926, 5927, 5928, 5929, 5930, 5931, 5932, 
5933, 5934, 5935, 5936, 5937, 5938, 5939, 5940, 5941, 5942, 
5943, 5944, 5945, 5946, 5947, 5948, 5949, 5950, 5951, 5952, 
5953, 5954, 5955, 5956, 5957, 5958, 5959, 5960, 5961, 5962, 
5963, 5964, 5965, 5966, 5967, 5968, 5969, 5970, 5971, 5972, 
5973, 5974, 5975, 5976, 5977, 5978, 5979, 5980, 5981, 5982, 
5983, 5984, 5985, 5986, 5987, 5988, 5989, 5990, 5991, 5992, 
5993, 5994, 5995, 5996, 5997, 5998, 5999, 6000, 6001, 6002, 
6003, 6004, 6005, 6006, 6007, 6008, 6009, 6010, 6011, 6012, 
6013, 6014, 6015, 6016, 6017, 6018, 6019, 6020, 6021, 6022, 
6023, 6024, 6025, 6026, 6027, 6028, 6029, 6030, 6031, 6032, 
6033, 6034, 6035, 6036, 6037, 6038, 6039, 6040, 6041, 6042, 
6043, 6044, 6045, 6046, 6047, 6048, 6049, 6050, 6051, 6052, 
6053, 6054, 6055, 6056, 6057, 6058, 6059, 6060, 6061, 6062, 
6063, 6064, 6065, 6066, 6067, 6068, 6069, 6070, 6071, 6072, 
6073, 6074, 6075, 6076, 6077, 6078, 6079, 6080, 6081, 6082, 
6083, 6084, 6085, 6086, 6087, 6088, 6089, 6090, 6091, 6092, 
6093, 6094, 6095, 6096, 6097, 6098, 6099, 6100, 6101, 6102, 
6103, 6104, 6105, 6106, 6107, 6108, 6109, 6110, 6111, 6112, 
6113, 6114, 6115, 6116, 6117, 6118, 6119, 6120, 6121, 6122, 
6123, 6124, 6125, 6126, 6127, 6128, 6129, 6130, 6131, 6132, 
6133, 6134, 6135, 6136, 6137, 6138, 6139, 6140, 6141, 6142, 
6143, 6144, 6145, 6146, 6147, 6148, 6149, 6150, 6151, 6152, 
6153, 6154, 6155, 6156, 6157, 6158, 6159, 6160, 6161, 6162, 
6163, 6164, 6165, 6166, 6167, 6168, 6169, 6170, 6261, 6262, 
6263, 6264, 6265, 6266, 6267, 6268, 6269, 6270, 6271, 6272, 
6273, 6274, 6275, 6276, 6277, 6278, 6279, 6280, 6281, 6282, 
6283, 6284, 6285, 6286, 6287, 6288, 6289, 6290, 6291, 6292, 
6293, 6294, 6295, 6296, 6297, 6298, 6299, 6300, 6301, 6302, 
6303, 6304, 6305, 6306, 6307, 6308, 6309, 6310, 6311, 6312, 
6313, 6314, 6315, 6316, 6317, 6318, 6319, 6320, 6789, 6790, 
6791, 6792, 6793, 6794, 6795, 6796, 6797, 6798, 6799, 6800, 
6801, 6802, 6803, 6804, 6805, 6806, 6807, 6808, 6809, 6810, 
6811, 6812, 6813, 6814, 6815, 6816, 6817, 6818, 6819, 6820, 
6821, 6822, 6823, 6824, 6825, 6826, 6827, 6828, 6829, 6830, 
6831, 6832, 6833, 6834, 6835, 6836, 6837, 6838, 6839, 6840, 
6841, 6842, 6843, 6844, 6845, 6846, 6847, 6848, 6849, 6850, 
6851, 6852, 6853, 6854, 6855, 6856, 6857, 6858, 6859, 6860, 
6861, 6862, 6863, 6864, 6865, 6866, 6867, 6868, 6869, 6870, 
6871, 6872, 6873, 6874, 6875, 6876, 6877, 6878, 6879, 6880, 
6881, 6882, 6883, 6884, 6885, 6886, 6887, 6888, 6889, 6890, 
6891, 6892, 6893, 6894, 6895, 6896, 6897, 6898, 6899, 6900, 
6901, 6902, 6903, 6904, 6905, 6906, 6907, 6908, 6909, 6910, 
6911, 6912, 6913, 6914, 6915, 6916, 6917, 6918, 6919, 6920, 
6921, 6922, 6923, 6924, 6925, 6926, 6927, 6928, 6929, 6930, 
6931, 6932, 6933, 6934, 6935, 6936, 6937, 6938, 6939, 6940, 
6941, 6942, 6943, 6944, 6945, 6946, 6947, 6948, 6949, 6950, 
6951, 6952, 6953, 6954, 6955, 6956, 6957, 6958, 6959, 6960, 
6961, 6962, 6963, 6964, 6965, 6966, 6967, 6968, 6969, 6970, 
6971, 6972, 6973, 6974, 6975, 6976, 6977, 6978, 6979, 6980, 
6981, 6982, 6983, 6984, 6985, 6986, 6987, 6988, 6989, 6990, 
6991, 6992, 6993, 6994, 6995, 6996, 6997, 6998, 6999, 7000, 
7001, 7002, 7003, 7004, 7005, 7006, 7007, 7008, 7009, 7010, 
7011, 7012, 7013, 7014, 7015, 7016, 7017, 7018, 7019, 7020, 
7021, 7022, 7023, 7024, 7025, 7026, 7027, 7028, 7029, 7030, 
7031, 7032, 7033, 7034, 7035, 7036, 7037, 7038, 7039, 7040, 
7041, 7042, 7043, 7044, 7045, 7046, 7047, 7048, 7049, 7050, 
7051, 7052, 7053, 7054, 7055, 7056, 7057, 7058, 7059, 7060, 
7061, 7062, 7063, 7064, 7065, 7066, 7067, 7068, 7069, 7070, 
7071, 7072, 7073, 7074, 7075, 7076, 
*ELSET,ELSET=HeatSink
2211, 2212, 2213, 2214, 2215, 2216, 2217, 2218, 2219, 2220, 
2221, 2222, 2223, 2224, 2225, 2226, 2227, 2228, 2229, 2230, 
2231, 2232, 2233, 2234, 2235, 2236, 2237, 2238, 2239, 2240, 
2241, 2242, 2243, 2244, 2245, 2246, 2247, 2248, 2249, 2250, 
2251, 2252, 2253, 2254, 2255, 2256, 2257, 2258, 2259, 2260, 
2261, 2262, 2263, 2264, 2265, 2266, 2267, 2268, 2269, 2270, 
2271, 2272, 2273, 2274, 2275, 2276, 2277, 2278, 2279, 2280, 
2281, 2282, 2283, 2284, 2285, 2286, 2287, 2288, 2289, 2290, 
2291, 2292, 2293, 2294, 2295, 2296, 2297, 2298, 2299, 2300, 
2301, 2302, 2303, 2304, 2305, 2306, 2307, 2308, 2309, 2310, 
2311, 2312, 2313, 2314, 2315, 2316, 2317, 2318, 2319, 2320, 
2321, 2322, 2323, 2324, 2325, 2326, 2327, 2328, 2329, 2330, 
2331, 2332, 2333, 2334, 2335, 2336, 2337, 2338, 2339, 2340, 
2341, 2342, 2343, 2344, 2345, 2346, 2347, 2348, 2349, 2350, 
2351, 2352, 2353, 2354, 2355, 2356, 2357, 2358, 2359, 2360, 
2361, 2362, 2363, 2364, 2365, 2366, 2367, 2368, 2369, 2370, 
2371, 2372, 2373, 2374, 2375, 2376, 2377, 2378, 2379, 2380, 
2381, 2382, 2383, 2384, 2385, 2386, 2387, 2388, 2389, 2390, 
2391, 2392, 2393, 2394, 2395, 2396, 2397, 2398, 2399, 2400, 
2401, 2402, 2403, 2404, 2405, 2406, 2407, 2408, 2409, 2410, 
2411, 2412, 2413, 2414, 2415, 2416, 2417, 2418, 2419, 2420, 
2421, 2422, 2423, 2424, 2425, 2426, 2427, 2428, 2429, 2430, 
2431, 2432, 2433, 2434, 2435, 2436, 2437, 2438, 2439, 2440, 
2441, 2442, 2443, 2444, 2445, 2446, 2447, 2448, 2449, 2450, 
2451, 2452, 2453, 2454, 2455, 2456, 2457, 2458, 2459, 2460, 
2461, 2462, 2463, 2464, 2465, 2466, 2467, 2468, 2469, 2470, 
2471, 2472, 2473, 2474, 2475, 2476, 2477, 2478, 2479, 2480, 
2481, 2482, 2483, 2484, 2485, 2486, 2487, 2488, 2489, 2490, 
2491, 2492, 2493, 2494, 2495, 2496, 2497, 2498, 10065, 10066, 
10067, 10068, 10069, 10070, 10071, 10072, 10073, 10074, 10075, 10076, 
10077, 10078, 10079, 10080, 10081, 10082, 10083, 10084, 10085, 10086, 
10087, 10088, 10089, 10090, 10091, 10092, 10093, 10094, 10095, 10096, 
10097, 10098, 10099, 10100, 10101, 10102, 10103, 10104, 10105, 10106, 
10107, 10108, 10109, 10110, 10111, 10112, 10113, 10114, 10115, 10116, 
10117, 10118, 10119, 10120, 10121, 10122, 10123, 10124, 10125, 10126, 
10127, 10128, 10129, 10130, 10131, 10132, 10133, 10134, 10135, 10136, 
10137, 10138, 10139, 10140, 10141, 10142, 10143, 10144, 10145, 10146, 
10147, 10148, 10149, 10150, 10151, 10152, 10153, 10154, 10155, 10156, 
10157, 10158, 10159, 10160, 10161, 10162, 10163, 10164, 10165, 10166, 
10167, 10168, 10169, 10170, 10171, 10172, 10173, 10174, 10175, 10176, 
10177, 10178, 10179, 10180, 10181, 10182, 10183, 10184, 10185, 10186, 
10187, 10188, 10189, 10190, 10191, 10192, 10193, 10194, 10195, 10196, 
10197, 10198, 10199, 10200, 10201, 10202, 10203, 10204, 10205, 10206, 
10207, 10208, 10209, 10210, 10211, 10212, 10213, 10214, 10215, 10216, 
10217, 10218, 10219, 10220, 10221, 10222, 10223, 10224, 10225, 10226, 
10227, 10228, 10229, 10230, 10231, 10232, 10233, 10234, 10235, 10236, 
10237, 10238, 10239, 10240, 10241, 10242, 10243, 10244, 10245, 10246, 
10247, 10248, 10249, 10250, 10251, 10252, 10253, 10254, 10255, 10256, 
10257, 10258, 10259, 10260, 10261, 10262, 10263, 10264, 10265, 10266, 
10267, 10268, 10269, 10270, 10271, 10272, 10273, 10274, 10275, 10276, 
10277, 10278, 10279, 10280, 10281, 10282, 10283, 10284, 10285, 10286, 
10287, 10288, 10289, 10290, 10291, 10292, 10293, 10294, 10295, 10296, 
10297, 10298, 10299, 10300, 10301, 10302, 10303, 10304, 10305, 10306, 
10307, 10308, 10309, 10310, 10311, 10312, 10313, 10314, 10315, 10316, 
10317, 10318, 10319, 10320, 10321, 10322, 10323, 10324, 10325, 10326, 
10327, 10328, 10329, 10330, 10331, 10332, 10333, 10334, 10335, 10336, 
10337, 10338, 10339, 10340, 10341, 10342, 10343, 10344, 10345, 10346, 
10347, 10348, 10349, 10350, 10351, 10352, 
*ELSET,ELSET=ElectrodeMaxX
10383, 10384, 10385, 10386, 10387, 10388, 10389, 10390, 10391, 10392, 
10393, 10394, 10395, 10396, 10397, 10398, 10399, 10400, 10401, 10402, 
10403, 10404, 10405, 10406, 10407, 10408, 10409, 10410, 10411, 10412, 
10413, 10414, 10415, 10416, 10417, 10418, 
*ELSET,ELSET=ElectrodeMinX
10449, 10450, 10451, 10452, 10453, 10454, 10455, 10456, 10457, 10458, 
10459, 10460, 10461, 10462, 10463, 10464, 10465, 10466, 10467, 10468, 
10469, 10470, 10471, 10472, 10473, 10474, 10475, 10476, 10477, 10478, 
10479, 10480, 10481, 10482, 10483, 10484, 
*ELSET,ELSET=Force
5847, 5848, 5849, 5850, 5851, 5852, 5853, 5854, 5855, 5856, 
5857, 5858, 5859, 5860, 5861, 5862, 5863, 5864, 5865, 5866, 
5867, 5868, 5869, 5870, 5871, 5872, 5873, 5874, 5875, 5876, 
5877, 5878, 5879, 5880, 5881, 5882, 
*ELSET,ELSET=Ceramic_Top
13009, 13010, 13011, 13012, 13013, 13014, 13015, 13016, 13017, 13018, 
13019, 13020, 13021, 13022, 13023, 13024, 13025, 13026, 13027, 13028, 
13029, 13030, 13031, 13032, 13033, 13034, 13035, 13036, 13037, 13038, 
13039, 13040, 13041, 13042, 13043, 13044, 13045, 13046, 13047, 13048, 
13049, 13050, 13051, 13052, 13053, 13054, 13055, 13056, 13057, 13058, 
13059, 13060, 13061, 13062, 13063, 13064, 13065, 13066, 13067, 13068, 
13069, 13070, 13071, 13072, 13073, 13074, 13075, 13076, 13077, 13078, 
13079, 13080, 13081, 13082, 13083, 13084, 13085, 13086, 13087, 13088, 
13089, 13090, 13091, 13092, 13093, 13094, 13095, 13096, 13097, 13098, 
13099, 13100, 13101, 13102, 13103, 13104, 13105, 13106, 13107, 13108, 
13109, 13110, 13111, 13112, 13113, 13114, 13115, 13116, 13117, 13118, 
13119, 13120, 13121, 13122, 13123, 13124, 13125, 13126, 13127, 13128, 
13129, 13130, 13131, 13132, 13133, 13134, 13135, 13136, 13137, 13138, 
13139, 13140, 13141, 13142, 13143, 13144, 13145, 13146, 13147, 13148, 
13149, 13150, 13151, 13152, 13153, 13154, 13155, 13156, 13157, 13158, 
13159, 13160, 13161, 13162, 13163, 13164, 13165, 13166, 13167, 13168, 
13169, 13170, 13171, 13172, 13173, 13174, 13175, 13176, 13177, 13178, 
13179, 13180, 13181, 13182, 13183, 13184, 13185, 13186, 13187, 13188, 
13189, 13190, 13191, 13192, 13193, 13194, 13195, 13196, 13197, 13198, 
13199, 13200, 13201, 13202, 13203, 13204, 13205, 13206, 13207, 13208, 
13209, 13210, 13211, 13212, 13213, 13214, 13215, 13216, 13217, 13218, 
13219, 13220, 13221, 13222, 13223, 13224, 13225, 13226, 13227, 13228, 
13229, 13230, 13231, 13232, 13233, 13234, 13235, 13236, 13237, 13238, 
13239, 13240, 13241, 13242, 13243, 13244, 13245, 13246, 13247, 13248, 
13249, 13250, 13251, 13252, 13253, 13254, 13255, 13256, 13257, 13258, 
13259, 13260, 13261, 13262, 13263, 13264, 13265, 13266, 13267, 13268, 
13269, 13270, 13271, 13272, 13273, 13274, 13275, 13276, 13277, 13278, 
13279, 13280, 13281, 13282, 13283, 13284, 13285, 13286, 13287, 13288, 
13289, 13290, 13291, 13292, 13293, 13294, 13295, 13296, 13407, 13408, 
13409, 13410, 13411, 13412, 13413, 13414, 13415, 13416, 13417, 13418, 
13419, 13420, 13421, 13422, 13423, 13424, 13425, 13426, 13427, 13428, 
13429, 13430, 13431, 13432, 13433, 13434, 13435, 13436, 13437, 13438, 
13439, 13440, 13441, 13442, 13443, 13444, 13445, 13446, 13447, 13448, 
13449, 13450, 13451, 13452, 13453, 13454, 13455, 13456, 13457, 13458, 
13459, 13460, 13461, 13462, 13463, 13464, 13465, 13466, 13767, 13768, 
13769, 13770, 13771, 13772, 13773, 13774, 13775, 13776, 13777, 13778, 
13779, 13780, 13781, 13782, 13783, 13784, 13785, 13786, 13787, 13788, 
13789, 13790, 13791, 13792, 13793, 13794, 13795, 13796, 13797, 13798, 
13799, 13800, 13801, 13802, 13803, 13804, 13805, 13806, 13807, 13808, 
13809, 13810, 13811, 13812, 13813, 13814, 13815, 13816, 13817, 13818, 
13819, 13820, 13821, 13822, 13823, 13824, 13825, 13826, 13827, 13828, 
13829, 13830, 13831, 13832, 13833, 13834, 13835, 13836, 13837, 13838, 
13839, 13840, 13841, 13842, 13843, 13844, 13845, 13846, 13847, 13848, 
13849, 13850, 13851, 13852, 13853, 13854, 13855, 13856, 13857, 13858, 
13859, 13860, 13861, 13862, 13863, 13864, 13865, 13866, 13867, 13868, 
13869, 13870, 13871, 13872, 13873, 13874, 13875, 13876, 13877, 13878, 
13879, 13880, 13881, 13882, 13883, 13884, 13885, 13886, 13887, 13888, 
13889, 13890, 13891, 13892, 13893, 13894, 13895, 13896, 13897, 13898, 
13899, 13900, 13901, 13902, 13903, 13904, 13905, 13906, 13907, 13908, 
13909, 13910, 13911, 13912, 13913, 13914, 13915, 13916, 13917, 13918, 
13919, 13920, 13921, 13922, 13923, 13924, 13925, 13926, 13927, 13928, 
13929, 13930, 13931, 13932, 13933, 13934, 13935, 13936, 13937, 13938, 
13939, 13940, 13941, 13942, 13943, 13944, 13945, 13946, 13947, 13948, 
13949, 13950, 13951, 13952, 13953, 13954, 13955, 13956, 13957, 13958, 
13959, 13960, 13961, 13962, 13963, 13964, 13965, 13966, 13967, 13968, 
13969, 13970, 13971, 13972, 13973, 13974, 13975, 13976, 13977, 13978, 
13979, 13980, 13981, 13982, 13983, 13984, 13985, 13986, 13987, 13988, 
13989, 13990, 13991, 13992, 13993, 13994, 13995, 13996, 13997, 13998, 
13999, 14000, 14001, 14002, 14003, 14004, 14005, 14006, 14007, 14008, 
14009, 14010, 14011, 14012, 14013, 14014, 14015, 14016, 14017, 14018, 
14019, 14020, 14021, 14022, 14023, 14024, 14025, 14026, 14027, 14028, 
14029, 14030, 14031, 14032, 14033, 14034, 14035, 14036, 14037, 14038, 
14039, 14040, 14041, 14042, 14043, 14044, 14045, 14046, 14047, 14048, 
14049, 14050, 14051, 14052, 14053, 14054, 
*ELSET,ELSET=Ceramic_Bottom
13297, 13298, 13299, 13300, 13301, 13302, 13303, 13304, 13305, 13306, 
13307, 13308, 13309, 13310, 13311, 13312, 13313, 13314, 13315, 13316, 
13317, 13318, 13319, 13320, 13321, 14415, 14416, 14417, 14418, 14419, 
14420, 14421, 14422, 14423, 14424, 14425, 14426, 14427, 14428, 14429, 
14430, 14431, 14432, 14433, 14434, 14435, 14436, 14437, 14438, 14439, 
14440, 14441, 14442, 14443, 14444, 14445, 14446, 14447, 14448, 14449, 
14450, 14451, 14452, 14453, 14454, 14455, 14456, 14457, 14458, 14459, 
14460, 14461, 14462, 14463, 14464, 14465, 14466, 14467, 14468, 14469, 
14470, 14471, 14472, 14473, 14474, 14475, 14476, 14477, 14478, 14479, 
14480, 14481, 14482, 14483, 14484, 14485, 14486, 14487, 14488, 14489, 
14490, 14491, 14492, 14493, 14494, 14495, 14496, 14497, 14498, 14499, 
14500, 14501, 14502, 14503, 14504, 14505, 14506, 14507, 14508, 14509, 
14510, 14511, 14512, 14513, 14514, 14515, 14516, 14517, 14518, 14519, 
14520, 14521, 14522, 14523, 14524, 14525, 14526, 14527, 14528, 14529, 
14530, 14531, 14532, 14533, 14534, 14535, 14536, 14537, 14538, 14539, 
14540, 14541, 14542, 14543, 14544, 14545, 14546, 14547, 14548, 14549, 
14550, 14551, 14552, 14553, 14554, 14555, 14556, 14557, 14558, 14559, 
14560, 14561, 14562, 14563, 14564, 14565, 14566, 14567, 14568, 14569, 
14570, 14571, 14572, 14573, 14574, 14575, 14576, 14577, 14578, 14579, 
14580, 14581, 14582, 14583, 14584, 14585, 14586, 14587, 14588, 14589, 
14590, 14591, 14592, 14593, 14594, 14595, 14596, 14597, 14598, 14599, 
14600, 14601, 14602, 14603, 14604, 14605, 14606, 14607, 14608, 14609, 
14610, 14611, 14612, 14613, 14614, 14615, 14616, 14617, 14618, 14619, 
14620, 14621, 14622, 14623, 14624, 14625, 14626, 14627, 14628, 14629, 
14630, 14631, 14632, 14633, 14634, 14635, 14636, 14637, 14638, 14639, 
14640, 14641, 14642, 14643, 14644, 14645, 14646, 14647, 14648, 14649, 
14650, 14651, 14652, 14653, 14654, 14655, 14656, 14657, 14658, 14659, 
14660, 14661, 14662, 14663, 14664, 14665, 14666, 14667, 14668, 14669, 
14670, 14671, 14672, 14673, 14674, 14675, 14676, 14677, 14678, 14679, 
14680, 14681, 14682, 14683, 14684, 14685, 14686, 14687, 14688, 14689, 
14690, 14691, 14692, 14693, 14694, 14695, 14696, 14697, 14698, 14699, 
14700, 14701, 14702, 15145, 15146, 15147, 15148, 15149, 15150, 15151, 
15152, 15153, 15154, 15155, 15156, 15157, 15158, 15159, 15160, 15161, 
15162, 15163, 15164, 15165, 15166, 15167, 15168, 15169, 15170, 15171, 
15172, 15173, 15174, 15175, 15176, 15177, 15178, 15179, 15180, 15181, 
15182, 15183, 15184, 15185, 15186, 15187, 15188, 15189, 15190, 15191, 
15192, 15193, 15194, 15195, 15196, 15197, 15198, 15199, 15200, 15201, 
15202, 15203, 15204, 15205, 15206, 15207, 15208, 15209, 15210, 15211, 
15212, 15213, 15214, 15215, 15216, 15217, 15218, 15219, 15220, 15221, 
15222, 15223, 15224, 15225, 15226, 15227, 15228, 15229, 15230, 15231, 
15232, 15233, 15234, 15235, 15236, 15237, 15238, 15239, 15240, 15241, 
15242, 15243, 15244, 15245, 15246, 15247, 15248, 15249, 15250, 15251, 
15252, 15253, 15254, 15255, 15256, 15257, 15258, 15259, 15260, 15261, 
15262, 15263, 15264, 15265, 15266, 15267, 15268, 15269, 15270, 15271, 
15272, 15273, 15274, 15275, 15276, 15277, 15278, 15279, 15280, 15281, 
15282, 15283, 15284, 15285, 15286, 15287, 15288, 15289, 15290, 15291, 
15292, 15293, 15294, 15295, 15296, 15297, 15298, 15299, 15300, 15301, 
15302, 15303, 15304, 15305, 15306, 15307, 15308, 15309, 15310, 15311, 
15312, 15313, 15314, 15315, 15316, 15317, 15318, 15319, 15320, 15321, 
15322, 15323, 15324, 15325, 15326, 15327, 15328, 15329, 15330, 15331, 
15332, 15333, 15334, 15335, 15336, 15337, 15338, 15339, 15340, 15341, 
15342, 15343, 15344, 15345, 15346, 15347, 15348, 15349, 15350, 15351, 
15352, 15353, 15354, 15355, 15356, 15357, 15358, 15359, 15360, 15361, 
15362, 15363, 15364, 15365, 15366, 15367, 15368, 15369, 15370, 15371, 
15372, 15373, 15374, 15375, 15376, 15377, 15378, 15379, 15380, 15381, 
15382, 15383, 15384, 15385, 15386, 15387, 15388, 15389, 15390, 15391, 
15392, 15393, 15394, 15395, 15396, 15397, 15398, 15399, 15400, 15401, 
15402, 15403, 15404, 15405, 15406, 15407, 15408, 15409, 15410, 15411, 
15412, 15413, 15414, 15415, 15416, 15417, 15418, 15419, 15420, 15421, 
15422, 15423, 15424, 15425, 15426, 15427, 15428, 15429, 15430, 15431, 
15432, 
*ELSET,ELSET=Top_Semiconductors
5019, 5020, 5021, 5022, 5023, 5024, 5025, 5026, 5027, 5028, 
5029, 5030, 5031, 5032, 5033, 5034, 5035, 5036, 5037, 5038, 
5039, 5040, 5041, 5042, 5043, 5044, 5045, 5046, 5047, 5048, 
5049, 5050, 5051, 5052, 5053, 5054, 5055, 5056, 5057, 5058, 
5059, 5060, 5061, 5062, 5063, 5064, 5065, 5066, 5067, 5068, 
5069, 5070, 5071, 5072, 5073, 5074, 5075, 5076, 5077, 5078, 
5079, 5080, 5081, 5082, 5083, 5084, 5085, 5086, 5087, 5088, 
5089, 5090, 5091, 5092, 5093, 5094, 5095, 5096, 5097, 5098, 
5099, 5100, 5101, 5102, 5103, 5104, 5105, 5106, 5107, 5108, 
5109, 5110, 5111, 5112, 5113, 5114, 5115, 5116, 5117, 5118, 
5119, 5120, 5121, 5122, 5123, 5124, 5125, 5126, 5127, 5128, 
5129, 5130, 5131, 5132, 5133, 5134, 5135, 5136, 5137, 5138, 
5139, 5140, 5141, 5142, 5143, 5144, 5145, 5146, 5147, 5148, 
5149, 5150, 5151, 5152, 5153, 5154, 5155, 5156, 5157, 5158, 
5159, 5160, 5161, 5162, 5163, 5164, 5165, 5166, 5167, 5168, 
5169, 5170, 5171, 5172, 5173, 5174, 5175, 5176, 5177, 5178, 
5179, 5180, 5181, 5182, 5183, 5184, 5185, 5186, 5187, 5188, 
5189, 5190, 5191, 5192, 5193, 5194, 5195, 5196, 5197, 5198, 
5199, 5200, 5201, 5202, 5203, 5204, 5205, 5206, 5207, 5208, 
5209, 5210, 5211, 5212, 5213, 5214, 5215, 5216, 5217, 5218, 
5219, 5220, 5221, 5222, 5223, 5224, 5225, 5226, 5227, 5228, 
5229, 5230, 5231, 5232, 5233, 5234, 5235, 5236, 5237, 5238, 
5239, 5240, 5241, 5242, 5243, 5244, 5245, 5246, 5247, 5248, 
5249, 5250, 5251, 5252, 5253, 5254, 5255, 5256, 5257, 5258, 
5259, 5260, 5261, 5262, 5263, 5264, 5265, 5266, 5267, 5268, 
5269, 5270, 5271, 5272, 5273, 5274, 5275, 5276, 5277, 5278, 
5279, 5280, 5281, 5282, 5283, 5284, 5285, 5286, 5287, 5288, 
5289, 5290, 5291, 5292, 5293, 5294, 5295, 5296, 5297, 5298, 
5299, 5300, 5301, 5302, 5303, 5304, 5305, 5306, 7185, 7186, 
7187, 7188, 7189, 7190, 7191, 7192, 7193, 7194, 7195, 7196, 
7197, 7198, 7199, 7200, 7201, 7202, 7203, 7204, 7205, 7206, 
7207, 7208, 7209, 7210, 7211, 7212, 7213, 7214, 7215, 7216, 
7217, 7218, 7219, 7220, 7221, 7222, 7223, 7224, 7225, 7226, 
7227, 7228, 7229, 7230, 7231, 7232, 7233, 7234, 7235, 7236, 
7237, 7238, 7239, 7240, 7241, 7242, 7243, 7244, 7245, 7246, 
7247, 7248, 7249, 7250, 7251, 7252, 7253, 7254, 7255, 7256, 
7257, 7258, 7259, 7260, 7261, 7262, 7263, 7264, 7265, 7266, 
7267, 7268, 7269, 7270, 7271, 7272, 7273, 7274, 7275, 7276, 
7277, 7278, 7279, 7280, 7281, 7282, 7283, 7284, 7285, 7286, 
7287, 7288, 7289, 7290, 7291, 7292, 7293, 7294, 7295, 7296, 
7297, 7298, 7299, 7300, 7301, 7302, 7303, 7304, 7305, 7306, 
7307, 7308, 7309, 7310, 7311, 7312, 7313, 7314, 7315, 7316, 
7317, 7318, 7319, 7320, 7321, 7322, 7323, 7324, 7325, 7326, 
7327, 7328, 7329, 7330, 7331, 7332, 7333, 7334, 7335, 7336, 
7337, 7338, 7339, 7340, 7341, 7342, 7343, 7344, 7345, 7346, 
7347, 7348, 7349, 7350, 7351, 7352, 7353, 7354, 7355, 7356, 
7357, 7358, 7359, 7360, 7361, 7362, 7363, 7364, 7365, 7366, 
7367, 7368, 7369, 7370, 7371, 7372, 7373, 7374, 7375, 7376, 
7377, 7378, 7379, 7380, 7381, 7382, 7383, 7384, 7385, 7386, 
7387, 7388, 7389, 7390, 7391, 7392, 7393, 7394, 7395, 7396, 
7397, 7398, 7399, 7400, 7401, 7402, 7403, 7404, 7405, 7406, 
7407, 7408, 7409, 7410, 7411, 7412, 7413, 7414, 7415, 7416, 
7417, 7418, 7419, 7420, 7421, 7422, 7423, 7424, 7425, 7426, 
7427, 7428, 7429, 7430, 7431, 7432, 7433, 7434, 7435, 7436, 
7437, 7438, 7439, 7440, 7441, 7442, 7443, 7444, 7445, 7446, 
7447, 7448, 7449, 7450, 7451, 7452, 7453, 7454, 7455, 7456, 
7457, 7458, 7459, 7460, 7461, 7462, 7463, 7464, 7465, 7466, 
7467, 7468, 7469, 7470, 7471, 7472, 
*ELSET,ELSET=top
13009, 13010, 13011, 13012, 13013, 13014, 13015, 13016, 13017, 13018, 
13019, 13020, 13021, 13022, 13023, 13024, 13025, 13026, 13027, 13028, 
13029, 13030, 13031, 13032, 13033, 13034, 13035, 13036, 13037, 13038, 
13039, 13040, 13041, 13042, 13043, 13044, 13045, 13046, 13047, 13048, 
13049, 13050, 13051, 13052, 13053, 13054, 13055, 13056, 13057, 13058, 
13059, 13060, 13061, 13062, 13063, 13064, 13065, 13066, 13067, 13068, 
13069, 13070, 13071, 13072, 13073, 13074, 13075, 13076, 13077, 13078, 
13079, 13080, 13081, 13082, 13083, 13084, 13085, 13086, 13087, 13088, 
13089, 13090, 13091, 13092, 13093, 13094, 13095, 13096, 13097, 13098, 
13099, 13100, 13101, 13102, 13103, 13104, 13105, 13106, 13107, 13108, 
13109, 13110, 13111, 13112, 13113, 13114, 13115, 13116, 13117, 13118, 
13119, 13120, 13121, 13122, 13123, 13124, 13125, 13126, 13127, 13128, 
13129, 13130, 13131, 13132, 13133, 13134, 13135, 13136, 13137, 13138, 
13139, 13140, 13141, 13142, 13143, 13144, 13145, 13146, 13147, 13148, 
13149, 13150, 13151, 13152, 13153, 13154, 13155, 13156, 13157, 13158, 
13159, 13160, 13161, 13162, 13163, 13164, 13165, 13166, 13167, 13168, 
13169, 13170, 13171, 13172, 13173, 13174, 13175, 13176, 13177, 13178, 
13179, 13180, 13181, 13182, 13183, 13184, 13185, 13186, 13187, 13188, 
13189, 13190, 13191, 13192, 13193, 13194, 13195, 13196, 13197, 13198, 
13199, 13200, 13201, 13202, 13203, 13204, 13205, 13206, 13207, 13208, 
13209, 13210, 13211, 13212, 13213, 13214, 13215, 13216, 13217, 13218, 
13219, 13220, 13221, 13222, 13223, 13224, 13225, 13226, 13227, 13228, 
13229, 13230, 13231, 13232, 13233, 13234, 13235, 13236, 13237, 13238, 
13239, 13240, 13241, 13242, 13243, 13244, 13245, 13246, 13247, 13248, 
13249, 13250, 13251, 13252, 13253, 13254, 13255, 13256, 13257, 13258, 
13259, 13260, 13261, 13262, 13263, 13264, 13265, 13266, 13267, 13268, 
13269, 13270, 13271, 13272, 13273, 13274, 13275, 13276, 13277, 13278, 
13279, 13280, 13281, 13282, 13283, 13284, 13285, 13286, 13287, 13288, 
13289, 13290, 13291, 13292, 13293, 13294, 13295, 13296, 13407, 13408, 
13409, 13410, 13411, 13412, 13413, 13414, 13415, 13416, 13417, 13418, 
13419, 13420, 13421, 13422, 13423, 13424, 13425, 13426, 13427, 13428, 
13429, 13430, 13431, 13432, 13433, 13434, 13435, 13436, 13437, 13438, 
13439, 13440, 13441, 13442, 13443, 13444, 13445, 13446, 13447, 13448, 
13449, 13450, 13451, 13452, 13453, 13454, 13455, 13456, 13457, 13458, 
13459, 13460, 13461, 13462, 13463, 13464, 13465, 13466, 13767, 13768, 
13769, 13770, 13771, 13772, 13773, 13774, 13775, 13776, 13777, 13778, 
13779, 13780, 13781, 13782, 13783, 13784, 13785, 13786, 13787, 13788, 
13789, 13790, 13791, 13792, 13793, 13794, 13795, 13796, 13797, 13798, 
13799, 13800, 13801, 13802, 13803, 13804, 13805, 13806, 13807, 13808, 
13809, 13810, 13811, 13812, 13813, 13814, 13815, 13816, 13817, 13818, 
13819, 13820, 13821, 13822, 13823, 13824, 13825, 13826, 13827, 13828, 
13829, 13830, 13831, 13832, 13833, 13834, 13835, 13836, 13837, 13838, 
13839, 13840, 13841, 13842, 13843, 13844, 13845, 13846, 13847, 13848, 
13849, 13850, 13851, 13852, 13853, 13854, 13855, 13856, 13857, 13858, 
13859, 13860, 13861, 13862, 13863, 13864, 13865, 13866, 13867, 13868, 
13869, 13870, 13871, 13872, 13873, 13874, 13875, 13876, 13877, 13878, 
13879, 13880, 13881, 13882, 13883, 13884, 13885, 13886, 13887, 13888, 
13889, 13890, 13891, 13892, 13893, 13894, 13895, 13896, 13897, 13898, 
13899, 13900, 13901, 13902, 13903, 13904, 13905, 13906, 13907, 13908, 
13909, 13910, 13911, 13912, 13913, 13914, 13915, 13916, 13917, 13918, 
13919, 13920, 13921, 13922, 13923, 13924, 13925, 13926, 13927, 13928, 
13929, 13930, 13931, 13932, 13933, 13934, 13935, 13936, 13937, 13938, 
13939, 13940, 13941, 13942, 13943, 13944, 13945, 13946, 13947, 13948, 
13949, 13950, 13951, 13952, 13953, 13954, 13955, 13956, 13957, 13958, 
13959, 13960, 13961, 13962, 13963, 13964, 13965, 13966, 13967, 13968, 
13969, 13970, 13971, 13972, 13973, 13974, 13975, 13976, 13977, 13978, 
13979, 13980, 13981, 13982, 13983, 13984, 13985, 13986, 13987, 13988, 
13989, 13990, 13991, 13992, 13993, 13994, 13995, 13996, 13997, 13998, 
13999, 14000, 14001, 14002, 14003, 14004, 14005, 14006, 14007, 14008, 
14009, 14010, 14011, 14012, 14013, 14014, 14015, 14016, 14017, 14018, 
14019, 14020, 14021, 14022, 14023, 14024, 14025, 14026, 14027, 14028, 
14029, 14030, 14031, 14032, 14033, 14034, 14035, 14036, 14037, 14038, 
14039, 14040, 14041, 14042, 14043, 14044, 14045, 14046, 14047, 14048, 
14049, 14050, 14051, 14052, 14053, 14054, 
*ELSET,ELSET=bottom
14415, 14416, 14417, 14418, 14419, 14420, 14421, 14422, 14423, 14424, 
14425, 14426, 14427, 14428, 14429, 14430, 14431, 14432, 14433, 14434, 
14435, 14436, 14437, 14438, 14439, 14440, 14441, 14442, 14443, 14444, 
14445, 14446, 14447, 14448, 14449, 14450, 14451, 14452, 14453, 14454, 
14455, 14456, 14457, 14458, 14459, 14460, 14461, 14462, 14463, 14464, 
14465, 14466, 14467, 14468, 14469, 14470, 14471, 14472, 14473, 14474, 
14475, 14476, 14477, 14478, 14479, 14480, 14481, 14482, 14483, 14484, 
14485, 14486, 14487, 14488, 14489, 14490, 14491, 14492, 14493, 14494, 
14495, 14496, 14497, 14498, 14499, 14500, 14501, 14502, 14503, 14504, 
14505, 14506, 14507, 14508, 14509, 14510, 14511, 14512, 14513, 14514, 
14515, 14516, 14517, 14518, 14519, 14520, 14521, 14522, 14523, 14524, 
14525, 14526, 14527, 14528, 14529, 14530, 14531, 14532, 14533, 14534, 
14535, 14536, 14537, 14538, 14539, 14540, 14541, 14542, 14543, 14544, 
14545, 14546, 14547, 14548, 14549, 14550, 14551, 14552, 14553, 14554, 
14555, 14556, 14557, 14558, 14559, 14560, 14561, 14562, 14563, 14564, 
14565, 14566, 14567, 14568, 14569, 14570, 14571, 14572, 14573, 14574, 
14575, 14576, 14577, 14578, 14579, 14580, 14581, 14582, 14583, 14584, 
14585, 14586, 14587, 14588, 14589, 14590, 14591, 14592, 14593, 14594, 
14595, 14596, 14597, 14598, 14599, 14600, 14601, 14602, 14603, 14604, 
14605, 14606, 14607, 14608, 14609, 14610, 14611, 14612, 14613, 14614, 
14615, 14616, 14617, 14618, 14619, 14620, 14621, 14622, 14623, 14624, 
14625, 14626, 14627, 14628, 14629, 14630, 14631, 14632, 14633, 14634, 
14635, 14636, 14637, 14638, 14639, 14640, 14641, 14642, 14643, 14644, 
14645, 14646, 14647, 14648, 14649, 14650, 14651, 14652, 14653, 14654, 
14655, 14656, 14657, 14658, 14659, 14660, 14661, 14662, 14663, 14664, 
14665, 14666, 14667, 14668, 14669, 14670, 14671, 14672, 14673, 14674, 
14675, 14676, 14677, 14678, 14679, 14680, 14681, 14682, 14683, 14684, 
14685, 14686, 14687, 14688, 14689, 14690, 14691, 14692, 14693, 14694, 
14695, 14696, 14697, 14698, 14699, 14700, 14701, 14702, 14773, 14774, 
14775, 14776, 14777, 14778, 14779, 14780, 14781, 14782, 14783, 14784, 
15145, 15146, 15147, 15148, 15149, 15150, 15151, 15152, 15153, 15154, 
15155, 15156, 15157, 15158, 15159, 15160, 15161, 15162, 15163, 15164, 
15165, 15166, 15167, 15168, 15169, 15170, 15171, 15172, 15173, 15174, 
15175, 15176, 15177, 15178, 15179, 15180, 15181, 15182, 15183, 15184, 
15185, 15186, 15187, 15188, 15189, 15190, 15191, 15192, 15193, 15194, 
15195, 15196, 15197, 15198, 15199, 15200, 15201, 15202, 15203, 15204, 
15205, 15206, 15207, 15208, 15209, 15210, 15211, 15212, 15213, 15214, 
15215, 15216, 15217, 15218, 15219, 15220, 15221, 15222, 15223, 15224, 
15225, 15226, 15227, 15228, 15229, 15230, 15231, 15232, 15233, 15234, 
15235, 15236, 15237, 15238, 15239, 15240, 15241, 15242, 15243, 15244, 
15245, 15246, 15247, 15248, 15249, 15250, 15251, 15252, 15253, 15254, 
15255, 15256, 15257, 15258, 15259, 15260, 15261, 15262, 15263, 15264, 
15265, 15266, 15267, 15268, 15269, 15270, 15271, 15272, 15273, 15274, 
15275, 15276, 15277, 15278, 15279, 15280, 15281, 15282, 15283, 15284, 
15285, 15286, 15287, 15288, 15289, 15290, 15291, 15292, 15293, 15294, 
15295, 15296, 15297, 15298, 15299, 15300, 15301, 15302, 15303, 15304, 
15305, 15306, 15307, 15308, 15309, 15310, 15311, 15312, 15313, 15314, 
15315, 15316, 15317, 15318, 15319, 15320, 15321, 15322, 15323, 15324, 
15325, 15326, 15327, 15328, 15329, 15330, 15331, 15332, 15333, 15334, 
15335, 15336, 15337, 15338, 15339, 15340, 15341, 15342, 15343, 15344, 
15345, 15346, 15347, 15348, 15349, 15350, 15351, 15352, 15353, 15354, 
15355, 15356, 15357, 15358, 15359, 15360, 15361, 15362, 15363, 15364, 
15365, 15366, 15367, 15368, 15369, 15370, 15371, 15372, 15373, 15374, 
15375, 15376, 15377, 15378, 15379, 15380, 15381, 15382, 15383, 15384, 
15385, 15386, 15387, 15388, 15389, 15390, 15391, 15392, 15393, 15394, 
15395, 15396, 15397, 15398, 15399, 15400, 15401, 15402, 15403, 15404, 
15405, 15406, 15407, 15408, 15409, 15410, 15411, 15412, 15413, 15414, 
15415, 15416, 15417, 15418, 15419, 15420, 15421, 15422, 15423, 15424, 
15425, 15426, 15427, 15428, 15429, 15430, 15431, 15432, 15503, 15504, 
15505, 15506, 15507, 15508, 15509, 15510, 15511, 15512, 15513, 15514, 
*ELSET,ELSET=symmetry
2859, 2860, 2861, 2862, 2863, 2864, 2865, 2866, 2867, 2868, 
2869, 2870, 2871, 2872, 2873, 2874, 2875, 2876, 2877, 2878, 
2879, 2880, 2881, 2882, 2883, 2884, 2885, 2886, 2887, 2888, 
2889, 2890, 2891, 2892, 2893, 2894, 2895, 2896, 2897, 2898, 
2899, 2900, 2901, 2902, 2903, 2904, 2905, 2906, 2907, 2908, 
2909, 2910, 2911, 2912, 2913, 2914, 2915, 2916, 2917, 2918, 
2919, 2920, 2921, 2922, 2923, 2924, 2925, 2926, 2927, 2928, 
2929, 2930, 2967, 2968, 2969, 2970, 2971, 2972, 2973, 2974, 
2975, 2976, 2977, 2978, 2979, 2980, 2981, 2982, 2983, 2984, 
2985, 2986, 2987, 2988, 2989, 2990, 4155, 4156, 4157, 4158, 
4159, 4160, 4161, 4162, 4163, 4164, 4165, 4166, 4167, 4168, 
4169, 4170, 4171, 4172, 4173, 4174, 4175, 4176, 4177, 4178, 
4179, 4180, 4181, 4182, 4183, 4184, 4185, 4186, 4187, 4188, 
4189, 4190, 4191, 4192, 4193, 4194, 4195, 4196, 4197, 4198, 
4199, 4200, 4201, 4202, 4203, 4204, 4205, 4206, 4207, 4208, 
4209, 4210, 4211, 4212, 4213, 4214, 4215, 4216, 4217, 4218, 
4219, 4220, 4221, 4222, 4223, 4224, 4225, 4226, 4227, 4228, 
4229, 4230, 4231, 4232, 4233, 4234, 4235, 4236, 4237, 4238, 
4239, 4240, 4241, 4242, 4243, 4244, 4245, 4246, 4247, 4248, 
4249, 4250, 4251, 4252, 4253, 4254, 4255, 4256, 4257, 4258, 
4259, 4260, 4261, 4262, 4263, 4264, 4265, 4266, 4267, 4268, 
4269, 4270, 4271, 4272, 4273, 4274, 4275, 4276, 4277, 4278, 
4279, 4280, 4281, 4282, 4283, 4284, 4285, 4286, 4287, 4288, 
4289, 4290, 4291, 4292, 4293, 4294, 4295, 4296, 4297, 4298, 
4299, 4300, 4301, 4302, 4303, 4304, 4305, 4306, 4307, 4308, 
4309, 4310, 4311, 4312, 4313, 4314, 4315, 4316, 4317, 4318, 
4319, 4320, 4321, 4322, 4323, 4324, 4325, 4326, 4327, 4328, 
4329, 4330, 4331, 4332, 4333, 4334, 4335, 4336, 4337, 4338, 
4339, 4340, 4341, 4342, 4343, 4344, 4345, 4346, 4347, 4348, 
4349, 4350, 4351, 4352, 4353, 4354, 4355, 4356, 4357, 4358, 
4359, 4360, 4361, 4362, 4363, 4364, 4365, 4366, 4367, 4368, 
4369, 4370, 4371, 4372, 4373, 4374, 4375, 4376, 4377, 4378, 
4379, 4380, 4381, 4382, 4383, 4384, 4385, 4386, 4387, 4388, 
4389, 4390, 4391, 4392, 4393, 4394, 4395, 4396, 4397, 4398, 
4399, 4400, 4401, 4402, 4403, 4404, 4405, 4406, 4407, 4408, 
4409, 4410, 4411, 4412, 4413, 4414, 4415, 4416, 4417, 4418, 
4419, 4420, 4421, 4422, 4423, 4424, 4425, 4426, 4427, 4428, 
4429, 4430, 4431, 4432, 4433, 4434, 4435, 4436, 4437, 4438, 
4439, 4440, 4441, 4442, 4443, 4444, 4445, 4446, 4447, 4448, 
4449, 4450, 4451, 4452, 4453, 4454, 4455, 4456, 4457, 4458, 
4459, 4460, 4461, 4462, 4463, 4464, 4465, 4466, 4467, 4468, 
4469, 4470, 4471, 4472, 4473, 4474, 4475, 4476, 4477, 4478, 
4479, 4480, 4481, 4482, 4483, 4484, 4485, 4486, 4487, 4488, 
4489, 4490, 4491, 4492, 4493, 4494, 4495, 4496, 4497, 4498, 
4499, 4500, 4501, 4502, 4503, 4504, 4505, 4506, 4507, 4508, 
4509, 4510, 4511, 4512, 4513, 4514, 4515, 4516, 4517, 4518, 
4519, 4520, 4521, 4522, 4523, 4524, 4525, 4526, 4527, 4528, 
4529, 4530, 4531, 4532, 4533, 4534, 4535, 4536, 4537, 4538, 
4539, 4540, 4541, 4542, 4543, 4544, 4545, 4546, 4547, 4548, 
4549, 4550, 4551, 4552, 4553, 4554, 4555, 4556, 4557, 4558, 
4559, 4560, 4561, 4562, 4563, 4564, 4565, 4566, 4567, 4568, 
4569, 4570, 4571, 4572, 4573, 4574, 4575, 4576, 4577, 4578, 
4579, 4580, 4581, 4582, 4583, 4584, 4585, 4586, 4587, 4588, 
4589, 4590, 4591, 4592, 4593, 4594, 4595, 4596, 4597, 4598, 
4599, 4600, 4601, 4602, 4603, 4604, 4605, 4606, 4607, 4608, 
4609, 4610, 4611, 4612, 4613, 4614, 4615, 4616, 4617, 4618, 
4619, 4620, 4621, 4622, 4623, 4624, 4625, 4626, 4627, 4628, 
4629, 4630, 4631, 4632, 4633, 4634, 4635, 4636, 4637, 4638, 
4639, 4640, 4641, 4642, 4643, 4644, 4645, 4646, 4647, 4648, 
4649, 4650, 4651, 4652, 4653, 4654, 4655, 4656, 4657, 4658, 
4659, 4660, 4661, 4662, 4663, 4664, 4665, 4666, 4667, 4668, 
4669, 4670, 4671, 4672, 4673, 4674, 4675, 4676, 4677, 4678, 
4679, 4680, 4681, 4682, 4683, 4684, 4685, 4686, 4687, 4688, 
4689, 4690, 4691, 4692, 4693, 4694, 4695, 4696, 4697, 4698, 
4699, 4700, 4701, 4702, 4703, 4704, 4705, 4706, 4707, 4708, 
4709, 4710, 4711, 4712, 4713, 4714, 4715, 4716, 4717, 4718, 
4719, 4720, 4721, 4722, 4723, 4724, 4725, 4726, 4727, 4728, 
4729, 4730, 5343, 5344, 5345, 5346, 5347, 5348, 5349, 5350, 
5351, 5352, 5353, 5354, 5355, 5356, 5357, 5358, 5359, 5360, 
5361, 5362, 5363, 5364, 5365, 5366, 5775, 5776, 5777, 5778, 
5779, 5780, 5781, 5782, 5783, 5784, 5785, 5786, 5787, 5788, 
5789, 5790, 5791, 5792, 5793, 5794, 5795, 5796, 5797, 5798, 
5799, 5800, 5801, 5802, 5803, 5804, 5805, 5806, 5807, 5808, 
5809, 5810, 5811, 5812, 5813, 5814, 5815, 5816, 5817, 5818, 
5819, 5820, 5821, 5822, 5823, 5824, 5825, 5826, 5827, 5828, 
5829, 5830, 5831, 5832, 5833, 5834, 5835, 5836, 5837, 5838, 
5839, 5840, 5841, 5842, 5843, 5844, 5845, 5846, 6171, 6172, 
6173, 6174, 6175, 6176, 6177, 6178, 6179, 6180, 6181, 6182, 
6183, 6184, 6185, 6357, 6358, 6359, 6360, 6361, 6362, 6363, 
6364, 6365, 6366, 6367, 6368, 6369, 6370, 6371, 6372, 6373, 
6374, 6375, 6376, 6377, 6378, 6379, 6380, 6381, 6382, 6383, 
6384, 6385, 6386, 6387, 6388, 6389, 6390, 6391, 6392, 6393, 
6394, 6395, 6396, 6397, 6398, 6399, 6400, 6401, 6402, 6403, 
6404, 6405, 6406, 6407, 6408, 6409, 6410, 6411, 6412, 6413, 
6414, 6415, 6416, 6417, 6418, 6419, 6420, 6421, 6422, 6423, 
6424, 6425, 6426, 6427, 6428, 7113, 7114, 7115, 7116, 7117, 
7118, 7119, 7120, 7121, 7122, 7123, 7124, 7125, 7126, 7127, 
7128, 7129, 7130, 7131, 7132, 7133, 7134, 7135, 7136, 7473, 
7474, 7475, 7476, 7477, 7478, 7479, 7480, 7481, 7482, 7483, 
7484, 7485, 7486, 7487, 7488, 7489, 7490, 7491, 7492, 7493, 
7494, 7495, 7496, 7497, 7498, 7499, 7500, 7501, 7502, 7503, 
7504, 7505, 7506, 7507, 7508, 7509, 7510, 7511, 7512, 7513, 
7514, 7515, 7516, 7517, 7518, 7519, 7520, 7521, 7522, 7523, 
7524, 7525, 7526, 7527, 7528, 7529, 7530, 7531, 7532, 7533, 
7534, 7535, 7536, 7537, 7538, 7539, 7540, 7541, 7542, 7543, 
7544, 7545, 7546, 7547, 7548, 7549, 7550, 7551, 7552, 7553, 
7554, 7555, 7556, 7557, 7558, 7559, 7560, 7561, 7562, 7563, 
7564, 7565, 7566, 7567, 7568, 7569, 7570, 7571, 7572, 7573, 
7574, 7575, 7576, 7577, 7578, 7579, 7580, 7581, 7582, 7583, 
7584, 7585, 7586, 7587, 7588, 7589, 7590, 7591, 7592, 7593, 
7594, 7595, 7596, 7597, 7598, 7599, 7600, 7601, 7602, 7603, 
7604, 7605, 7606, 7607, 7608, 7609, 7610, 7611, 7612, 7613, 
7614, 7615, 7616, 7617, 7618, 7619, 7620, 7621, 7622, 7623, 
7624, 7625, 7626, 7627, 7628, 7629, 7630, 7631, 7632, 7633, 
7634, 7635, 7636, 7637, 7638, 7639, 7640, 7641, 7642, 7643, 
7644, 7645, 7646, 7647, 7648, 7649, 7650, 7651, 7652, 7653, 
7654, 7655, 7656, 7657, 7658, 7659, 7660, 7661, 7662, 7663, 
7664, 7665, 7666, 7667, 7668, 7669, 7670, 7671, 7672, 7673, 
7674, 7675, 7676, 7677, 7678, 7679, 7680, 7681, 7682, 7683, 
7684, 7685, 7686, 7687, 7688, 7689, 7690, 7691, 7692, 7693, 
7694, 7695, 7696, 7697, 7698, 7699, 7700, 7701, 7702, 7703, 
7704, 7705, 7706, 7707, 7708, 7709, 7710, 7711, 7712, 7713, 
7714, 7715, 7716, 7717, 7718, 7719, 7720, 7721, 7722, 7723, 
7724, 7725, 7726, 7727, 7728, 7729, 7730, 7731, 7732, 7733, 
7734, 7735, 7736, 7737, 7738, 7739, 7740, 7741, 7742, 7743, 
7744, 7745, 7746, 7747, 7748, 7749, 7750, 7751, 7752, 7753, 
7754, 7755, 7756, 7757, 7758, 7759, 7760, 7761, 7762, 7763, 
7764, 7765, 7766, 7767, 7768, 7769, 7770, 7771, 7772, 7773, 
7774, 7775, 7776, 7777, 7778, 7779, 7780, 7781, 7782, 7783, 
7784, 7785, 7786, 7787, 7788, 7789, 7790, 7791, 7792, 7793, 
7794, 7795, 7796, 7797, 7798, 7799, 7800, 7801, 7802, 7803, 
7804, 7805, 7806, 7807, 7808, 7809, 7810, 7811, 7812, 7813, 
7814, 7815, 7816, 7817, 7818, 7819, 7820, 7821, 7822, 7823, 
7824, 7825, 7826, 7827, 7828, 7829, 7830, 7831, 7832, 7833, 
7834, 7835, 7836, 7837, 7838, 7839, 7840, 7841, 7842, 7843, 
7844, 7845, 7846, 7847, 7848, 7849, 7850, 7851, 7852, 7853, 
7854, 7855, 7856, 7857, 7858, 7859, 7860, 7861, 7862, 7863, 
7864, 7865, 7866, 7867, 7868, 7869, 7870, 7871, 7872, 7873, 
7874, 7875, 7876, 7877, 7878, 7879, 7880, 7881, 7882, 7883, 
7884, 7885, 7886, 7887, 7888, 7889, 7890, 7891, 7892, 7893, 
7894, 7895, 7896, 7897, 7898, 7899, 7900, 7901, 7902, 7903, 
7904, 7905, 7906, 7907, 7908, 7909, 7910, 7911, 7912, 7913, 
7914, 7915, 7916, 7917, 7918, 7919, 7920, 7921, 7922, 7923, 
7924, 7925, 7926, 7927, 7928, 7929, 7930, 7931, 7932, 7933, 
7934, 7935, 7936, 7937, 7938, 7939, 7940, 7941, 7942, 7943, 
7944, 7945, 7946, 7947, 7948, 7949, 7950, 7951, 7952, 7953, 
7954, 7955, 7956, 7957, 7958, 7959, 7960, 7961, 7962, 7963, 
7964, 7965, 7966, 7967, 7968, 7969, 7970, 7971, 7972, 7973, 
7974, 7975, 7976, 7977, 7978, 7979, 7980, 7981, 7982, 7983, 
7984, 7985, 7986, 7987, 7988, 7989, 7990, 7991, 7992, 7993, 
7994, 7995, 7996, 7997, 7998, 7999, 8000, 8001, 8002, 8003, 
8004, 8005, 8006, 8007, 8008, 8009, 8010, 8011, 8012, 8013, 
8014, 8015, 8016, 8017, 8018, 8019, 8020, 8021, 8022, 8023, 
8024, 8025, 8026, 8027, 8028, 8029, 8030, 8031, 8032, 8033, 
8034, 8035, 8036, 8037, 8038, 8039, 8040, 8041, 8042, 8043, 
8044, 8045, 8046, 8047, 8048, 9489, 9490, 9491, 9492, 9493, 
9494, 9495, 9496, 9497, 9498, 9499, 9500, 9501, 9502, 9503, 
9504, 9505, 9506, 9507, 9508, 9509, 9510, 9511, 9512, 9849, 
9850, 9851, 9852, 9853, 9854, 9855, 9856, 9857, 9858, 9859, 
9860, 9861, 9862, 9863, 9864, 9865, 9866, 9867, 9868, 9869, 
9870, 9871, 9872, 9873, 9874, 9875, 9876, 9877, 9878, 9879, 
9880, 9881, 9882, 9883, 9884, 9885, 9886, 9887, 9888, 9889, 
9890, 9891, 9892, 9893, 9894, 9895, 9896, 9897, 9898, 9899, 
9900, 9901, 9902, 9903, 9904, 9905, 9906, 9907, 9908, 9909, 
9910, 9911, 9912, 9913, 9914, 9915, 9916, 9917, 9918, 9919, 
9920, 10353, 10354, 10355, 10431, 10432, 10433, 10485, 10486, 10487, 
10488, 10489, 10490, 10491, 10492, 10493, 10494, 10495, 10496, 10497, 
10498, 10499, 10500, 10501, 10502, 10503, 10504, 10505, 10506, 10507, 
10508, 10845, 10846, 10847, 10848, 10849, 10850, 10851, 10852, 10853, 
10854, 10855, 10856, 10857, 10858, 10859, 10860, 10861, 10862, 10863, 
10864, 10865, 10866, 10867, 10868, 12829, 12830, 12831, 12832, 12833, 
12834, 12835, 12836, 12837, 12838, 12839, 12840, 12841, 12842, 12843, 
12844, 12845, 12846, 12847, 12848, 12849, 12850, 12851, 12852, 12853, 
12854, 12855, 12856, 12857, 12858, 12859, 12860, 12861, 12862, 12863, 
12864, 12865, 12866, 12867, 12868, 12869, 12870, 12871, 12872, 12873, 
12874, 12875, 12876, 12877, 12878, 12879, 12880, 12881, 12882, 12883, 
12884, 12885, 12886, 12887, 12888, 12889, 12890, 12891, 12892, 12893, 
12894, 12895, 12896, 12897, 12898, 12899, 12900, 12901, 12902, 12903, 
12904, 12905, 12906, 12907, 12908, 12909, 12910, 12911, 12912, 12913, 
12914, 12915, 12916, 12917, 12918, 12919, 12920, 12921, 12922, 12923, 
12924, 12925, 12926, 12927, 12928, 12929, 12930, 12931, 12932, 12933, 
12934, 12935, 12936, 12937, 12938, 12939, 12940, 12941, 12942, 12943, 
12944, 12945, 12946, 12947, 12948, 13297, 13298, 13299, 13300, 13301, 
13302, 13303, 13304, 13305, 13306, 13307, 13308, 13309, 13310, 13311, 
13312, 13313, 13314, 13315, 13316, 13317, 13318, 13319, 13320, 13321, 
13467, 13468, 13469, 13470, 13471, 13472, 13473, 13474, 13475, 13476, 
13477, 13478, 13479, 13480, 13481, 13482, 13483, 13484, 13485, 13486, 
13487, 13488, 13489, 13490, 13491, 13492, 13493, 13494, 13495, 13496, 
13497, 13498, 13499, 13500, 13501, 13502, 13503, 13504, 13505, 13506, 
13507, 13508, 13509, 13510, 13511, 13512, 13513, 13514, 13515, 13516, 
13517, 13518, 13519, 13520, 13521, 13522, 13523, 13524, 13525, 13526, 
13527, 13528, 13529, 13530, 13531, 13532, 13533, 13534, 13535, 13536, 
13537, 13538, 13539, 13540, 13541, 13542, 13543, 13544, 13545, 13546, 
13547, 13548, 13549, 13550, 13551, 13552, 13553, 13554, 13555, 13556, 
13557, 13558, 13559, 13560, 13561, 13562, 13563, 13564, 13565, 13566, 
13567, 13568, 13569, 13570, 13571, 13572, 13573, 13574, 13575, 13576, 
13577, 13578, 13579, 13580, 13581, 13582, 13583, 13584, 13585, 13586, 
14235, 14236, 14237, 14238, 14239, 14240, 14241, 14242, 14243, 14244, 
14245, 14246, 14247, 14248, 14249, 14250, 14251, 14252, 14253, 14254, 
14255, 14256, 14257, 14258, 14259, 14260, 14261, 14262, 14263, 14264, 
14265, 14266, 14267, 14268, 14269, 14270, 14271, 14272, 14273, 14274, 
14275, 14276, 14277, 14278, 14279, 14280, 14281, 14282, 14283, 14284, 
14285, 14286, 14287, 14288, 14289, 14290, 14291, 14292, 14293, 14294, 
14295, 14296, 14297, 14298, 14299, 14300, 14301, 14302, 14303, 14304, 
14305, 14306, 14307, 14308, 14309, 14310, 14311, 14312, 14313, 14314, 
14315, 14316, 14317, 14318, 14319, 14320, 14321, 14322, 14323, 14324, 
14325, 14326, 14327, 14328, 14329, 14330, 14331, 14332, 14333, 14334, 
14335, 14336, 14337, 14338, 14339, 14340, 14341, 14342, 14343, 14344, 
14345, 14346, 14347, 14348, 14349, 14350, 14351, 14352, 14353, 14354, 
14703, 14704, 14705, 14706, 14707, 14785, 14786, 14787, 14788, 14789, 
14790, 14791, 14792, 14793, 14794, 14795, 14796, 14797, 14798, 14799, 
14800, 14801, 14802, 14803, 14804, 14805, 14806, 14807, 14808, 14809, 
14810, 14811, 14812, 14813, 14814, 14815, 14816, 14817, 14818, 14819, 
14820, 14821, 14822, 14823, 14824, 14825, 14826, 14827, 14828, 14829, 
14830, 14831, 14832, 14833, 14834, 14835, 14836, 14837, 14838, 14839, 
14840, 14841, 14842, 14843, 14844, 14845, 14846, 14847, 14848, 14849, 
14850, 14851, 14852, 14853, 14854, 14855, 14856, 14857, 14858, 14859, 
14860, 14861, 14862, 14863, 14864, 14865, 14866, 14867, 14868, 14869, 
14870, 14871, 14872, 14873, 14874, 14875, 14876, 14877, 14878, 14879, 
14880, 14881, 14882, 14883, 14884, 14885, 14886, 14887, 14888, 14889, 
14890, 14891, 14892, 14893, 14894, 14895, 14896, 14897, 14898, 14899, 
14900, 14901, 14902, 14903, 14904, 15433, 15434, 15435, 15436, 15437, 
*ELSET,ELSET=Ceramic_Contact
2211, 2212, 2213, 2214, 2215, 2216, 2217, 2218, 2219, 2220, 
2221, 2222, 2223, 2224, 2225, 2226, 2227, 2228, 2229, 2230, 
2231, 2232, 2233, 2234, 2235, 2236, 2237, 2238, 2239, 2240, 
2241, 2242, 2243, 2244, 2245, 2246, 2247, 2248, 2249, 2250, 
2251, 2252, 2253, 2254, 2255, 2256, 2257, 2258, 2259, 2260, 
2261, 2262, 2263, 2264, 2265, 2266, 2267, 2268, 2269, 2270, 
2271, 2272, 2273, 2274, 2275, 2276, 2277, 2278, 2279, 2280, 
2281, 2282, 2283, 2284, 2285, 2286, 2287, 2288, 2289, 2290, 
2291, 2292, 2293, 2294, 2295, 2296, 2297, 2298, 2299, 2300, 
2301, 2302, 2303, 2304, 2305, 2306, 2307, 2308, 2309, 2310, 
2311, 2312, 2313, 2314, 2315, 2316, 2317, 2318, 2319, 2320, 
2321, 2322, 2323, 2324, 2325, 2326, 2327, 2328, 2329, 2330, 
2331, 2332, 2333, 2334, 2335, 2336, 2337, 2338, 2339, 2340, 
2341, 2342, 2343, 2344, 2345, 2346, 2347, 2348, 2349, 2350, 
2351, 2352, 2353, 2354, 2355, 2356, 2357, 2358, 2359, 2360, 
2361, 2362, 2363, 2364, 2365, 2366, 2367, 2368, 2369, 2370, 
2371, 2372, 2373, 2374, 2375, 2376, 2377, 2378, 2379, 2380, 
2381, 2382, 2383, 2384, 2385, 2386, 2387, 2388, 2389, 2390, 
2391, 2392, 2393, 2394, 2395, 2396, 2397, 2398, 2399, 2400, 
2401, 2402, 2403, 2404, 2405, 2406, 2407, 2408, 2409, 2410, 
2411, 2412, 2413, 2414, 2415, 2416, 2417, 2418, 2419, 2420, 
2421, 2422, 2423, 2424, 2425, 2426, 2427, 2428, 2429, 2430, 
2431, 2432, 2433, 2434, 2435, 2436, 2437, 2438, 2439, 2440, 
2441, 2442, 2443, 2444, 2445, 2446, 2447, 2448, 2449, 2450, 
2451, 2452, 2453, 2454, 2455, 2456, 2457, 2458, 2459, 2460, 
2461, 2462, 2463, 2464, 2465, 2466, 2467, 2468, 2469, 2470, 
2471, 2472, 2473, 2474, 2475, 2476, 2477, 2478, 2479, 2480, 
2481, 2482, 2483, 2484, 2485, 2486, 2487, 2488, 2489, 2490, 
2491, 2492, 2493, 2494, 2495, 2496, 2497, 2498, 5883, 5884, 
5885, 5886, 5887, 5888, 5889, 5890, 5891, 5892, 5893, 5894, 
5895, 5896, 5897, 5898, 5899, 5900, 5901, 5902, 5903, 5904, 
5905, 5906, 5907, 5908, 5909, 5910, 5911, 5912, 5913, 5914, 
5915, 5916, 5917, 5918, 5919, 5920, 5921, 5922, 5923, 5924, 
5925, 5926, 5927, 5928, 5929, 5930, 5931, 5932, 5933, 5934, 
5935, 5936, 5937, 5938, 5939, 5940, 5941, 5942, 5943, 5944, 
5945, 5946, 5947, 5948, 5949, 5950, 5951, 5952, 5953, 5954, 
5955, 5956, 5957, 5958, 5959, 5960, 5961, 5962, 5963, 5964, 
5965, 5966, 5967, 5968, 5969, 5970, 5971, 5972, 5973, 5974, 
5975, 5976, 5977, 5978, 5979, 5980, 5981, 5982, 5983, 5984, 
5985, 5986, 5987, 5988, 5989, 5990, 5991, 5992, 5993, 5994, 
5995, 5996, 5997, 5998, 5999, 6000, 6001, 6002, 6003, 6004, 
6005, 6006, 6007, 6008, 6009, 6010, 6011, 6012, 6013, 6014, 
6015, 6016, 6017, 6018, 6019, 6020, 6021, 6022, 6023, 6024, 
6025, 6026, 6027, 6028, 6029, 6030, 6031, 6032, 6033, 6034, 
6035, 6036, 6037, 6038, 6039, 6040, 6041, 6042, 6043, 6044, 
6045, 6046, 6047, 6048, 6049, 6050, 6051, 6052, 6053, 6054, 
6055, 6056, 6057, 6058, 6059, 6060, 6061, 6062, 6063, 6064, 
6065, 6066, 6067, 6068, 6069, 6070, 6071, 6072, 6073, 6074, 
6075, 6076, 6077, 6078, 6079, 6080, 6081, 6082, 6083, 6084, 
6085, 6086, 6087, 6088, 6089, 6090, 6091, 6092, 6093, 6094, 
6095, 6096, 6097, 6098, 6099, 6100, 6101, 6102, 6103, 6104, 
6105, 6106, 6107, 6108, 6109, 6110, 6111, 6112, 6113, 6114, 
6115, 6116, 6117, 6118, 6119, 6120, 6121, 6122, 6123, 6124, 
6125, 6126, 6127, 6128, 6129, 6130, 6131, 6132, 6133, 6134, 
6135, 6136, 6137, 6138, 6139, 6140, 6141, 6142, 6143, 6144, 
6145, 6146, 6147, 6148, 6149, 6150, 6151, 6152, 6153, 6154, 
6155, 6156, 6157, 6158, 6159, 6160, 6161, 6162, 6163, 6164, 
6165, 6166, 6167, 6168, 6169, 6170, 6789, 6790, 6791, 6792, 
6793, 6794, 6795, 6796, 6797, 6798, 6799, 6800, 6801, 6802, 
6803, 6804, 6805, 6806, 6807, 6808, 6809, 6810, 6811, 6812, 
6813, 6814, 6815, 6816, 6817, 6818, 6819, 6820, 6821, 6822, 
6823, 6824, 6825, 6826, 6827, 6828, 6829, 6830, 6831, 6832, 
6833, 6834, 6835, 6836, 6837, 6838, 6839, 6840, 6841, 6842, 
6843, 6844, 6845, 6846, 6847, 6848, 6849, 6850, 6851, 6852, 
6853, 6854, 6855, 6856, 6857, 6858, 6859, 6860, 6861, 6862, 
6863, 6864, 6865, 6866, 6867, 6868, 6869, 6870, 6871, 6872, 
6873, 6874, 6875, 6876, 6877, 6878, 6879, 6880, 6881, 6882, 
6883, 6884, 6885, 6886, 6887, 6888, 6889, 6890, 6891, 6892, 
6893, 6894, 6895, 6896, 6897, 6898, 6899, 6900, 6901, 6902, 
6903, 6904, 6905, 6906, 6907, 6908, 6909, 6910, 6911, 6912, 
6913, 6914, 6915, 6916, 6917, 6918, 6919, 6920, 6921, 6922, 
6923, 6924, 6925, 6926, 6927, 6928, 6929, 6930, 6931, 6932, 
6933, 6934, 6935, 6936, 6937, 6938, 6939, 6940, 6941, 6942, 
6943, 6944, 6945, 6946, 6947, 6948, 6949, 6950, 6951, 6952, 
6953, 6954, 6955, 6956, 6957, 6958, 6959, 6960, 6961, 6962, 
6963, 6964, 6965, 6966, 6967, 6968, 6969, 6970, 6971, 6972, 
6973, 6974, 6975, 6976, 6977, 6978, 6979, 6980, 6981, 6982, 
6983, 6984, 6985, 6986, 6987, 6988, 6989, 6990, 6991, 6992, 
6993, 6994, 6995, 6996, 6997, 6998, 6999, 7000, 7001, 7002, 
7003, 7004, 7005, 7006, 7007, 7008, 7009, 7010, 7011, 7012, 
7013, 7014, 7015, 7016, 7017, 7018, 7019, 7020, 7021, 7022, 
7023, 7024, 7025, 7026, 7027, 7028, 7029, 7030, 7031, 7032, 
7033, 7034, 7035, 7036, 7037, 7038, 7039, 7040, 7041, 7042, 
7043, 7044, 7045, 7046, 7047, 7048, 7049, 7050, 7051, 7052, 
7053, 7054, 7055, 7056, 7057, 7058, 7059, 7060, 7061, 7062, 
7063, 7064, 7065, 7066, 7067, 7068, 7069, 7070, 7071, 7072, 
7073, 7074, 7075, 7076, 10065, 10066, 10067, 10068, 10069, 10070, 
10071, 10072, 10073, 10074, 10075, 10076, 10077, 10078, 10079, 10080, 
10081, 10082, 10083, 10084, 10085, 10086, 10087, 10088, 10089, 10090, 
10091, 10092, 10093, 10094, 10095, 10096, 10097, 10098, 10099, 10100, 
10101, 10102, 10103, 10104, 10105, 10106, 10107, 10108, 10109, 10110, 
10111, 10112, 10113, 10114, 10115, 10116, 10117, 10118, 10119, 10120, 
10121, 10122, 10123, 10124, 10125, 10126, 10127, 10128, 10129, 10130, 
10131, 10132, 10133, 10134, 10135, 10136, 10137, 10138, 10139, 10140, 
10141, 10142, 10143, 10144, 10145, 10146, 10147, 10148, 10149, 10150, 
10151, 10152, 10153, 10154, 10155, 10156, 10157, 10158, 10159, 10160, 
10161, 10162, 10163, 10164, 10165, 10166, 10167, 10168, 10169, 10170, 
10171, 10172, 10173, 10174, 10175, 10176, 10177, 10178, 10179, 10180, 
10181, 10182, 10183, 10184, 10185, 10186, 10187, 10188, 10189, 10190, 
10191, 10192, 10193, 10194, 10195, 10196, 10197, 10198, 10199, 10200, 
10201, 10202, 10203, 10204, 10205, 10206, 10207, 10208, 10209, 10210, 
10211, 10212, 10213, 10214, 10215, 10216, 10217, 10218, 10219, 10220, 
10221, 10222, 10223, 10224, 10225, 10226, 10227, 10228, 10229, 10230, 
10231, 10232, 10233, 10234, 10235, 10236, 10237, 10238, 10239, 10240, 
10241, 10242, 10243, 10244, 10245, 10246, 10247, 10248, 10249, 10250, 
10251, 10252, 10253, 10254, 10255, 10256, 10257, 10258, 10259, 10260, 
10261, 10262, 10263, 10264, 10265, 10266, 10267, 10268, 10269, 10270, 
10271, 10272, 10273, 10274, 10275, 10276, 10277, 10278, 10279, 10280, 
10281, 10282, 10283, 10284, 10285, 10286, 10287, 10288, 10289, 10290, 
10291, 10292, 10293, 10294, 10295, 10296, 10297, 10298, 10299, 10300, 
10301, 10302, 10303, 10304, 10305, 10306, 10307, 10308, 10309, 10310, 
10311, 10312, 10313, 10314, 10315, 10316, 10317, 10318, 10319, 10320, 
10321, 10322, 10323, 10324, 10325, 10326, 10327, 10328, 10329, 10330, 
10331, 10332, 10333, 10334, 10335, 10336, 10337, 10338, 10339, 10340, 
10341, 10342, 10343, 10344, 10345, 10346, 10347, 10348, 10349, 10350, 
10351, 10352, 10371, 10372, 10373, 10374, 10375, 10376, 10377, 10378, 
10379, 10380, 10381, 10382, 10419, 10420, 10421, 10422, 10423, 10424, 
10425, 10426, 10427, 10428, 10429, 10430, 
*ELSET,ELSET=Contact_CeramicTop
5883, 5884, 5885, 5886, 5887, 5888, 5889, 5890, 5891, 5892, 
5893, 5894, 5895, 5896, 5897, 5898, 5899, 5900, 5901, 5902, 
5903, 5904, 5905, 5906, 5907, 5908, 5909, 5910, 5911, 5912, 
5913, 5914, 5915, 5916, 5917, 5918, 5919, 5920, 5921, 5922, 
5923, 5924, 5925, 5926, 5927, 5928, 5929, 5930, 5931, 5932, 
5933, 5934, 5935, 5936, 5937, 5938, 5939, 5940, 5941, 5942, 
5943, 5944, 5945, 5946, 5947, 5948, 5949, 5950, 5951, 5952, 
5953, 5954, 5955, 5956, 5957, 5958, 5959, 5960, 5961, 5962, 
5963, 5964, 5965, 5966, 5967, 5968, 5969, 5970, 5971, 5972, 
5973, 5974, 5975, 5976, 5977, 5978, 5979, 5980, 5981, 5982, 
5983, 5984, 5985, 5986, 5987, 5988, 5989, 5990, 5991, 5992, 
5993, 5994, 5995, 5996, 5997, 5998, 5999, 6000, 6001, 6002, 
6003, 6004, 6005, 6006, 6007, 6008, 6009, 6010, 6011, 6012, 
6013, 6014, 6015, 6016, 6017, 6018, 6019, 6020, 6021, 6022, 
6023, 6024, 6025, 6026, 6027, 6028, 6029, 6030, 6031, 6032, 
6033, 6034, 6035, 6036, 6037, 6038, 6039, 6040, 6041, 6042, 
6043, 6044, 6045, 6046, 6047, 6048, 6049, 6050, 6051, 6052, 
6053, 6054, 6055, 6056, 6057, 6058, 6059, 6060, 6061, 6062, 
6063, 6064, 6065, 6066, 6067, 6068, 6069, 6070, 6071, 6072, 
6073, 6074, 6075, 6076, 6077, 6078, 6079, 6080, 6081, 6082, 
6083, 6084, 6085, 6086, 6087, 6088, 6089, 6090, 6091, 6092, 
6093, 6094, 6095, 6096, 6097, 6098, 6099, 6100, 6101, 6102, 
6103, 6104, 6105, 6106, 6107, 6108, 6109, 6110, 6111, 6112, 
6113, 6114, 6115, 6116, 6117, 6118, 6119, 6120, 6121, 6122, 
6123, 6124, 6125, 6126, 6127, 6128, 6129, 6130, 6131, 6132, 
6133, 6134, 6135, 6136, 6137, 6138, 6139, 6140, 6141, 6142, 
6143, 6144, 6145, 6146, 6147, 6148, 6149, 6150, 6151, 6152, 
6153, 6154, 6155, 6156, 6157, 6158, 6159, 6160, 6161, 6162, 
6163, 6164, 6165, 6166, 6167, 6168, 6169, 6170, 6261, 6262, 
6263, 6264, 6265, 6266, 6267, 6268, 6269, 6270, 6271, 6272, 
6273, 6274, 6275, 6276, 6277, 6278, 6279, 6280, 6281, 6282, 
6283, 6284, 6285, 6286, 6287, 6288, 6289, 6290, 6291, 6292, 
6293, 6294, 6295, 6296, 6297, 6298, 6299, 6300, 6301, 6302, 
6303, 6304, 6305, 6306, 6307, 6308, 6309, 6310, 6311, 6312, 
6313, 6314, 6315, 6316, 6317, 6318, 6319, 6320, 6789, 6790, 
6791, 6792, 6793, 6794, 6795, 6796, 6797, 6798, 6799, 6800, 
6801, 6802, 6803, 6804, 6805, 6806, 6807, 6808, 6809, 6810, 
6811, 6812, 6813, 6814, 6815, 6816, 6817, 6818, 6819, 6820, 
6821, 6822, 6823, 6824, 6825, 6826, 6827, 6828, 6829, 6830, 
6831, 6832, 6833, 6834, 6835, 6836, 6837, 6838, 6839, 6840, 
6841, 6842, 6843, 6844, 6845, 6846, 6847, 6848, 6849, 6850, 
6851, 6852, 6853, 6854, 6855, 6856, 6857, 6858, 6859, 6860, 
6861, 6862, 6863, 6864, 6865, 6866, 6867, 6868, 6869, 6870, 
6871, 6872, 6873, 6874, 6875, 6876, 6877, 6878, 6879, 6880, 
6881, 6882, 6883, 6884, 6885, 6886, 6887, 6888, 6889, 6890, 
6891, 6892, 6893, 6894, 6895, 6896, 6897, 6898, 6899, 6900, 
6901, 6902, 6903, 6904, 6905, 6906, 6907, 6908, 6909, 6910, 
6911, 6912, 6913, 6914, 6915, 6916, 6917, 6918, 6919, 6920, 
6921, 6922, 6923, 6924, 6925, 6926, 6927, 6928, 6929, 6930, 
6931, 6932, 6933, 6934, 6935, 6936, 6937, 6938, 6939, 6940, 
6941, 6942, 6943, 6944, 6945, 6946, 6947, 6948, 6949, 6950, 
6951, 6952, 6953, 6954, 6955, 6956, 6957, 6958, 6959, 6960, 
6961, 6962, 6963, 6964, 6965, 6966, 6967, 6968, 6969, 6970, 
6971, 6972, 6973, 6974, 6975, 6976, 6977, 6978, 6979, 6980, 
6981, 6982, 6983, 6984, 6985, 6986, 6987, 6988, 6989, 6990, 
6991, 6992, 6993, 6994, 6995, 6996, 6997, 6998, 6999, 7000, 
7001, 7002, 7003, 7004, 7005, 7006, 7007, 7008, 7009, 7010, 
7011, 7012, 7013, 7014, 7015, 7016, 7017, 7018, 7019, 7020, 
7021, 7022, 7023, 7024, 7025, 7026, 7027, 7028, 7029, 7030, 
7031, 7032, 7033, 7034, 7035, 7036, 7037, 7038, 7039, 7040, 
7041, 7042, 7043, 7044, 7045, 7046, 7047, 7048, 7049, 7050, 
7051, 7052, 7053, 7054, 7055, 7056, 7057, 7058, 7059, 7060, 
7061, 7062, 7063, 7064, 7065, 7066, 7067, 7068, 7069, 7070, 
7071, 7072, 7073, 7074, 7075, 7076, 
*ELSET,ELSET=Contact_CeramicBottom
2211, 2212, 2213, 2214, 2215, 2216, 2217, 2218, 2219, 2220, 
2221, 2222, 2223, 2224, 2225, 2226, 2227, 2228, 2229, 2230, 
2231, 2232, 2233, 2234, 2235, 2236, 2237, 2238, 2239, 2240, 
2241, 2242, 2243, 2244, 2245, 2246, 2247, 2248, 2249, 2250, 
2251, 2252, 2253, 2254, 2255, 2256, 2257, 2258, 2259, 2260, 
2261, 2262, 2263, 2264, 2265, 2266, 2267, 2268, 2269, 2270, 
2271, 2272, 2273, 2274, 2275, 2276, 2277, 2278, 2279, 2280, 
2281, 2282, 2283, 2284, 2285, 2286, 2287, 2288, 2289, 2290, 
2291, 2292, 2293, 2294, 2295, 2296, 2297, 2298, 2299, 2300, 
2301, 2302, 2303, 2304, 2305, 2306, 2307, 2308, 2309, 2310, 
2311, 2312, 2313, 2314, 2315, 2316, 2317, 2318, 2319, 2320, 
2321, 2322, 2323, 2324, 2325, 2326, 2327, 2328, 2329, 2330, 
2331, 2332, 2333, 2334, 2335, 2336, 2337, 2338, 2339, 2340, 
2341, 2342, 2343, 2344, 2345, 2346, 2347, 2348, 2349, 2350, 
2351, 2352, 2353, 2354, 2355, 2356, 2357, 2358, 2359, 2360, 
2361, 2362, 2363, 2364, 2365, 2366, 2367, 2368, 2369, 2370, 
2371, 2372, 2373, 2374, 2375, 2376, 2377, 2378, 2379, 2380, 
2381, 2382, 2383, 2384, 2385, 2386, 2387, 2388, 2389, 2390, 
2391, 2392, 2393, 2394, 2395, 2396, 2397, 2398, 2399, 2400, 
2401, 2402, 2403, 2404, 2405, 2406, 2407, 2408, 2409, 2410, 
2411, 2412, 2413, 2414, 2415, 2416, 2417, 2418, 2419, 2420, 
2421, 2422, 2423, 2424, 2425, 2426, 2427, 2428, 2429, 2430, 
2431, 2432, 2433, 2434, 2435, 2436, 2437, 2438, 2439, 2440, 
2441, 2442, 2443, 2444, 2445, 2446, 2447, 2448, 2449, 2450, 
2451, 2452, 2453, 2454, 2455, 2456, 2457, 2458, 2459, 2460, 
2461, 2462, 2463, 2464, 2465, 2466, 2467, 2468, 2469, 2470, 
2471, 2472, 2473, 2474, 2475, 2476, 2477, 2478, 2479, 2480, 
2481, 2482, 2483, 2484, 2485, 2486, 2487, 2488, 2489, 2490, 
2491, 2492, 2493, 2494, 2495, 2496, 2497, 2498, 10065, 10066, 
10067, 10068, 10069, 10070, 10071, 10072, 10073, 10074, 10075, 10076, 
10077, 10078, 10079, 10080, 10081, 10082, 10083, 10084, 10085, 10086, 
10087, 10088, 10089, 10090, 10091, 10092, 10093, 10094, 10095, 10096, 
10097, 10098, 10099, 10100, 10101, 10102, 10103, 10104, 10105, 10106, 
10107, 10108, 10109, 10110, 10111, 10112, 10113, 10114, 10115, 10116, 
10117, 10118, 10119, 10120, 10121, 10122, 10123, 10124, 10125, 10126, 
10127, 10128, 10129, 10130, 10131, 10132, 10133, 10134, 10135, 10136, 
10137, 10138, 10139, 10140, 10141, 10142, 10143, 10144, 10145, 10146, 
10147, 10148, 10149, 10150, 10151, 10152, 10153, 10154, 10155, 10156, 
10157, 10158, 10159, 10160, 10161, 10162, 10163, 10164, 10165, 10166, 
10167, 10168, 10169, 10170, 10171, 10172, 10173, 10174, 10175, 10176, 
10177, 10178, 10179, 10180, 10181, 10182, 10183, 10184, 10185, 10186, 
10187, 10188, 10189, 10190, 10191, 10192, 10193, 10194, 10195, 10196, 
10197, 10198, 10199, 10200, 10201, 10202, 10203, 10204, 10205, 10206, 
10207, 10208, 10209, 10210, 10211, 10212, 10213, 10214, 10215, 10216, 
10217, 10218, 10219, 10220, 10221, 10222, 10223, 10224, 10225, 10226, 
10227, 10228, 10229, 10230, 10231, 10232, 10233, 10234, 10235, 10236, 
10237, 10238, 10239, 10240, 10241, 10242, 10243, 10244, 10245, 10246, 
10247, 10248, 10249, 10250, 10251, 10252, 10253, 10254, 10255, 10256, 
10257, 10258, 10259, 10260, 10261, 10262, 10263, 10264, 10265, 10266, 
10267, 10268, 10269, 10270, 10271, 10272, 10273, 10274, 10275, 10276, 
10277, 10278, 10279, 10280, 10281, 10282, 10283, 10284, 10285, 10286, 
10287, 10288, 10289, 10290, 10291, 10292, 10293, 10294, 10295, 10296, 
10297, 10298, 10299, 10300, 10301, 10302, 10303, 10304, 10305, 10306, 
10307, 10308, 10309, 10310, 10311, 10312, 10313, 10314, 10315, 10316, 
10317, 10318, 10319, 10320, 10321, 10322, 10323, 10324, 10325, 10326, 
10327, 10328, 10329, 10330, 10331, 10332, 10333, 10334, 10335, 10336, 
10337, 10338, 10339, 10340, 10341, 10342, 10343, 10344, 10345, 10346, 
10347, 10348, 10349, 10350, 10351, 10352, 10371, 10372, 10373, 10374, 
10375, 10376, 10377, 10378, 10379, 10380, 10381, 10382, 10419, 10420, 
10421, 10422, 10423, 10424, 10425, 10426, 10427, 10428, 10429, 10430, 
*ELSET,ELSET=Surface_2D
2859, 2860, 2861, 2862, 2863, 2864, 2865, 2866, 2867, 2868, 
2869, 2870, 2871, 2872, 2873, 2874, 2875, 2876, 2877, 2878, 
2879, 2880, 2881, 2882, 2883, 2884, 2885, 2886, 2887, 2888, 
2889, 2890, 2891, 2892, 2893, 2894, 2895, 2896, 2897, 2898, 
2899, 2900, 2901, 2902, 2903, 2904, 2905, 2906, 2907, 2908, 
2909, 2910, 2911, 2912, 2913, 2914, 2915, 2916, 2917, 2918, 
2919, 2920, 2921, 2922, 2923, 2924, 2925, 2926, 2927, 2928, 
2929, 2930, 2967, 2968, 2969, 2970, 2971, 2972, 2973, 2974, 
2975, 2976, 2977, 2978, 2979, 2980, 2981, 2982, 2983, 2984, 
2985, 2986, 2987, 2988, 2989, 2990, 4155, 4156, 4157, 4158, 
4159, 4160, 4161, 4162, 4163, 4164, 4165, 4166, 4167, 4168, 
4169, 4170, 4171, 4172, 4173, 4174, 4175, 4176, 4177, 4178, 
4179, 4180, 4181, 4182, 4183, 4184, 4185, 4186, 4187, 4188, 
4189, 4190, 4191, 4192, 4193, 4194, 4195, 4196, 4197, 4198, 
4199, 4200, 4201, 4202, 4203, 4204, 4205, 4206, 4207, 4208, 
4209, 4210, 4211, 4212, 4213, 4214, 4215, 4216, 4217, 4218, 
4219, 4220, 4221, 4222, 4223, 4224, 4225, 4226, 4227, 4228, 
4229, 4230, 4231, 4232, 4233, 4234, 4235, 4236, 4237, 4238, 
4239, 4240, 4241, 4242, 4243, 4244, 4245, 4246, 4247, 4248, 
4249, 4250, 4251, 4252, 4253, 4254, 4255, 4256, 4257, 4258, 
4259, 4260, 4261, 4262, 4263, 4264, 4265, 4266, 4267, 4268, 
4269, 4270, 4271, 4272, 4273, 4274, 4275, 4276, 4277, 4278, 
4279, 4280, 4281, 4282, 4283, 4284, 4285, 4286, 4287, 4288, 
4289, 4290, 4291, 4292, 4293, 4294, 4295, 4296, 4297, 4298, 
4299, 4300, 4301, 4302, 4303, 4304, 4305, 4306, 4307, 4308, 
4309, 4310, 4311, 4312, 4313, 4314, 4315, 4316, 4317, 4318, 
4319, 4320, 4321, 4322, 4323, 4324, 4325, 4326, 4327, 4328, 
4329, 4330, 4331, 4332, 4333, 4334, 4335, 4336, 4337, 4338, 
4339, 4340, 4341, 4342, 4343, 4344, 4345, 4346, 4347, 4348, 
4349, 4350, 4351, 4352, 4353, 4354, 4355, 4356, 4357, 4358, 
4359, 4360, 4361, 4362, 4363, 4364, 4365, 4366, 4367, 4368, 
4369, 4370, 4371, 4372, 4373, 4374, 4375, 4376, 4377, 4378, 
4379, 4380, 4381, 4382, 4383, 4384, 4385, 4386, 4387, 4388, 
4389, 4390, 4391, 4392, 4393, 4394, 4395, 4396, 4397, 4398, 
4399, 4400, 4401, 4402, 4403, 4404, 4405, 4406, 4407, 4408, 
4409, 4410, 4411, 4412, 4413, 4414, 4415, 4416, 4417, 4418, 
4419, 4420, 4421, 4422, 4423, 4424, 4425, 4426, 4427, 4428, 
4429, 4430, 4431, 4432, 4433, 4434, 4435, 4436, 4437, 4438, 
4439, 4440, 4441, 4442, 4443, 4444, 4445, 4446, 4447, 4448, 
4449, 4450, 4451, 4452, 4453, 4454, 4455, 4456, 4457, 4458, 
4459, 4460, 4461, 4462, 4463, 4464, 4465, 4466, 4467, 4468, 
4469, 4470, 4471, 4472, 4473, 4474, 4475, 4476, 4477, 4478, 
4479, 4480, 4481, 4482, 4483, 4484, 4485, 4486, 4487, 4488, 
4489, 4490, 4491, 4492, 4493, 4494, 4495, 4496, 4497, 4498, 
4499, 4500, 4501, 4502, 4503, 4504, 4505, 4506, 4507, 4508, 
4509, 4510, 4511, 4512, 4513, 4514, 4515, 4516, 4517, 4518, 
4519, 4520, 4521, 4522, 4523, 4524, 4525, 4526, 4527, 4528, 
4529, 4530, 4531, 4532, 4533, 4534, 4535, 4536, 4537, 4538, 
4539, 4540, 4541, 4542, 4543, 4544, 4545, 4546, 4547, 4548, 
4549, 4550, 4551, 4552, 4553, 4554, 4555, 4556, 4557, 4558, 
4559, 4560, 4561, 4562, 4563, 4564, 4565, 4566, 4567, 4568, 
4569, 4570, 4571, 4572, 4573, 4574, 4575, 4576, 4577, 4578, 
4579, 4580, 4581, 4582, 4583, 4584, 4585, 4586, 4587, 4588, 
4589, 4590, 4591, 4592, 4593, 4594, 4595, 4596, 4597, 4598, 
4599, 4600, 4601, 4602, 4603, 4604, 4605, 4606, 4607, 4608, 
4609, 4610, 4611, 4612, 4613, 4614, 4615, 4616, 4617, 4618, 
4619, 4620, 4621, 4622, 4623, 4624, 4625, 4626, 4627, 4628, 
4629, 4630, 4631, 4632, 4633, 4634, 4635, 4636, 4637, 4638, 
4639, 4640, 4641, 4642, 4643, 4644, 4645, 4646, 4647, 4648, 
4649, 4650, 4651, 4652, 4653, 4654, 4655, 4656, 4657, 4658, 
4659, 4660, 4661, 4662, 4663, 4664, 4665, 4666, 4667, 4668, 
4669, 4670, 4671, 4672, 4673, 4674, 4675, 4676, 4677, 4678, 
4679, 4680, 4681, 4682, 4683, 4684, 4685, 4686, 4687, 4688, 
4689, 4690, 4691, 4692, 4693, 4694, 4695, 4696, 4697, 4698, 
4699, 4700, 4701, 4702, 4703, 4704, 4705, 4706, 4707, 4708, 
4709, 4710, 4711, 4712, 4713, 4714, 4715, 4716, 4717, 4718, 
4719, 4720, 4721, 4722, 4723, 4724, 4725, 4726, 4727, 4728, 
4729, 4730, 5343, 5344, 5345, 5346, 5347, 5348, 5349, 5350, 
5351, 5352, 5353, 5354, 5355, 5356, 5357, 5358, 5359, 5360, 
5361, 5362, 5363, 5364, 5365, 5366, 5775, 5776, 5777, 5778, 
5779, 5780, 5781, 5782, 5783, 5784, 5785, 5786, 5787, 5788, 
5789, 5790, 5791, 5792, 5793, 5794, 5795, 5796, 5797, 5798, 
5799, 5800, 5801, 5802, 5803, 5804, 5805, 5806, 5807, 5808, 
5809, 5810, 5811, 5812, 5813, 5814, 5815, 5816, 5817, 5818, 
5819, 5820, 5821, 5822, 5823, 5824, 5825, 5826, 5827, 5828, 
5829, 5830, 5831, 5832, 5833, 5834, 5835, 5836, 5837, 5838, 
5839, 5840, 5841, 5842, 5843, 5844, 5845, 5846, 6171, 6172, 
6173, 6174, 6175, 6176, 6177, 6178, 6179, 6180, 6181, 6182, 
6183, 6184, 6185, 6357, 6358, 6359, 6360, 6361, 6362, 6363, 
6364, 6365, 6366, 6367, 6368, 6369, 6370, 6371, 6372, 6373, 
6374, 6375, 6376, 6377, 6378, 6379, 6380, 6381, 6382, 6383, 
6384, 6385, 6386, 6387, 6388, 6389, 6390, 6391, 6392, 6393, 
6394, 6395, 6396, 6397, 6398, 6399, 6400, 6401, 6402, 6403, 
6404, 6405, 6406, 6407, 6408, 6409, 6410, 6411, 6412, 6413, 
6414, 6415, 6416, 6417, 6418, 6419, 6420, 6421, 6422, 6423, 
6424, 6425, 6426, 6427, 6428, 7113, 7114, 7115, 7116, 7117, 
7118, 7119, 7120, 7121, 7122, 7123, 7124, 7125, 7126, 7127, 
7128, 7129, 7130, 7131, 7132, 7133, 7134, 7135, 7136, 7473, 
7474, 7475, 7476, 7477, 7478, 7479, 7480, 7481, 7482, 7483, 
7484, 7485, 7486, 7487, 7488, 7489, 7490, 7491, 7492, 7493, 
7494, 7495, 7496, 7497, 7498, 7499, 7500, 7501, 7502, 7503, 
7504, 7505, 7506, 7507, 7508, 7509, 7510, 7511, 7512, 7513, 
7514, 7515, 7516, 7517, 7518, 7519, 7520, 7521, 7522, 7523, 
7524, 7525, 7526, 7527, 7528, 7529, 7530, 7531, 7532, 7533, 
7534, 7535, 7536, 7537, 7538, 7539, 7540, 7541, 7542, 7543, 
7544, 7545, 7546, 7547, 7548, 7549, 7550, 7551, 7552, 7553, 
7554, 7555, 7556, 7557, 7558, 7559, 7560, 7561, 7562, 7563, 
7564, 7565, 7566, 7567, 7568, 7569, 7570, 7571, 7572, 7573, 
7574, 7575, 7576, 7577, 7578, 7579, 7580, 7581, 7582, 7583, 
7584, 7585, 7586, 7587, 7588, 7589, 7590, 7591, 7592, 7593, 
7594, 7595, 7596, 7597, 7598, 7599, 7600, 7601, 7602, 7603, 
7604, 7605, 7606, 7607, 7608, 7609, 7610, 7611, 7612, 7613, 
7614, 7615, 7616, 7617, 7618, 7619, 7620, 7621, 7622, 7623, 
7624, 7625, 7626, 7627, 7628, 7629, 7630, 7631, 7632, 7633, 
7634, 7635, 7636, 7637, 7638, 7639, 7640, 7641, 7642, 7643, 
7644, 7645, 7646, 7647, 7648, 7649, 7650, 7651, 7652, 7653, 
7654, 7655, 7656, 7657, 7658, 7659, 7660, 7661, 7662, 7663, 
7664, 7665, 7666, 7667, 7668, 7669, 7670, 7671, 7672, 7673, 
7674, 7675, 7676, 7677, 7678, 7679, 7680, 7681, 7682, 7683, 
7684, 7685, 7686, 7687, 7688, 7689, 7690, 7691, 7692, 7693, 
7694, 7695, 7696, 7697, 7698, 7699, 7700, 7701, 7702, 7703, 
7704, 7705, 7706, 7707, 7708, 7709, 7710, 7711, 7712, 7713, 
7714, 7715, 7716, 7717, 7718, 7719, 7720, 7721, 7722, 7723, 
7724, 7725, 7726, 7727, 7728, 7729, 7730, 7731, 7732, 7733, 
7734, 7735, 7736, 7737, 7738, 7739, 7740, 7741, 7742, 7743, 
7744, 7745, 7746, 7747, 7748, 7749, 7750, 7751, 7752, 7753, 
7754, 7755, 7756, 7757, 7758, 7759, 7760, 7761, 7762, 7763, 
7764, 7765, 7766, 7767, 7768, 7769, 7770, 7771, 7772, 7773, 
7774, 7775, 7776, 7777, 7778, 7779, 7780, 7781, 7782, 7783, 
7784, 7785, 7786, 7787, 7788, 7789, 7790, 7791, 7792, 7793, 
7794, 7795, 7796, 7797, 7798, 7799, 7800, 7801, 7802, 7803, 
7804, 7805, 7806, 7807, 7808, 7809, 7810, 7811, 7812, 7813, 
7814, 7815, 7816, 7817, 7818, 7819, 7820, 7821, 7822, 7823, 
7824, 7825, 7826, 7827, 7828, 7829, 7830, 7831, 7832, 7833, 
7834, 7835, 7836, 7837, 7838, 7839, 7840, 7841, 7842, 7843, 
7844, 7845, 7846, 7847, 7848, 7849, 7850, 7851, 7852, 7853, 
7854, 7855, 7856, 7857, 7858, 7859, 7860, 7861, 7862, 7863, 
7864, 7865, 7866, 7867, 7868, 7869, 7870, 7871, 7872, 7873, 
7874, 7875, 7876, 7877, 7878, 7879, 7880, 7881, 7882, 7883, 
7884, 7885, 7886, 7887, 7888, 7889, 7890, 7891, 7892, 7893, 
7894, 7895, 7896, 7897, 7898, 7899, 7900, 7901, 7902, 7903, 
7904, 7905, 7906, 7907, 7908, 7909, 7910, 7911, 7912, 7913, 
7914, 7915, 7916, 7917, 7918, 7919, 7920, 7921, 7922, 7923, 
7924, 7925, 7926, 7927, 7928, 7929, 7930, 7931, 7932, 7933, 
7934, 7935, 7936, 7937, 7938, 7939, 7940, 7941, 7942, 7943, 
7944, 7945, 7946, 7947, 7948, 7949, 7950, 7951, 7952, 7953, 
7954, 7955, 7956, 7957, 7958, 7959, 7960, 7961, 7962, 7963, 
7964, 7965, 7966, 7967, 7968, 7969, 7970, 7971, 7972, 7973, 
7974, 7975, 7976, 7977, 7978, 7979, 7980, 7981, 7982, 7983, 
7984, 7985, 7986, 7987, 7988, 7989, 7990, 7991, 7992, 7993, 
7994, 7995, 7996, 7997, 7998, 7999, 8000, 8001, 8002, 8003, 
8004, 8005, 8006, 8007, 8008, 8009, 8010, 8011, 8012, 8013, 
8014, 8015, 8016, 8017, 8018, 8019, 8020, 8021, 8022, 8023, 
8024, 8025, 8026, 8027, 8028, 8029, 8030, 8031, 8032, 8033, 
8034, 8035, 8036, 8037, 8038, 8039, 8040, 8041, 8042, 8043, 
8044, 8045, 8046, 8047, 8048, 9489, 9490, 9491, 9492, 9493, 
9494, 9495, 9496, 9497, 9498, 9499, 9500, 9501, 9502, 9503, 
9504, 9505, 9506, 9507, 9508, 9509, 9510, 9511, 9512, 9849, 
9850, 9851, 9852, 9853, 9854, 9855, 9856, 9857, 9858, 9859, 
9860, 9861, 9862, 9863, 9864, 9865, 9866, 9867, 9868, 9869, 
9870, 9871, 9872, 9873, 9874, 9875, 9876, 9877, 9878, 9879, 
9880, 9881, 9882, 9883, 9884, 9885, 9886, 9887, 9888, 9889, 
9890, 9891, 9892, 9893, 9894, 9895, 9896, 9897, 9898, 9899, 
9900, 9901, 9902, 9903, 9904, 9905, 9906, 9907, 9908, 9909, 
9910, 9911, 9912, 9913, 9914, 9915, 9916, 9917, 9918, 9919, 
9920, 10353, 10354, 10355, 10431, 10432, 10433, 12829, 12830, 12831, 
12832, 12833, 12834, 12835, 12836, 12837, 12838, 12839, 12840, 12841, 
12842, 12843, 12844, 12845, 12846, 12847, 12848, 12849, 12850, 12851, 
12852, 12853, 12854, 12855, 12856, 12857, 12858, 12859, 12860, 12861, 
12862, 12863, 12864, 12865, 12866, 12867, 12868, 12869, 12870, 12871, 
12872, 12873, 12874, 12875, 12876, 12877, 12878, 12879, 12880, 12881, 
12882, 12883, 12884, 12885, 12886, 12887, 12888, 12889, 12890, 12891, 
12892, 12893, 12894, 12895, 12896, 12897, 12898, 12899, 12900, 12901, 
12902, 12903, 12904, 12905, 12906, 12907, 12908, 12909, 12910, 12911, 
12912, 12913, 12914, 12915, 12916, 12917, 12918, 12919, 12920, 12921, 
12922, 12923, 12924, 12925, 12926, 12927, 12928, 12929, 12930, 12931, 
12932, 12933, 12934, 12935, 12936, 12937, 12938, 12939, 12940, 12941, 
12942, 12943, 12944, 12945, 12946, 12947, 12948, 13297, 13298, 13299, 
13300, 13301, 13302, 13303, 13304, 13305, 13306, 13307, 13308, 13309, 
13310, 13311, 13312, 13313, 13314, 13315, 13316, 13317, 13318, 13319, 
13320, 13321, 13467, 13468, 13469, 13470, 13471, 13472, 13473, 13474, 
13475, 13476, 13477, 13478, 13479, 13480, 13481, 13482, 13483, 13484, 
13485, 13486, 13487, 13488, 13489, 13490, 13491, 13492, 13493, 13494, 
13495, 13496, 13497, 13498, 13499, 13500, 13501, 13502, 13503, 13504, 
13505, 13506, 13507, 13508, 13509, 13510, 13511, 13512, 13513, 13514, 
13515, 13516, 13517, 13518, 13519, 13520, 13521, 13522, 13523, 13524, 
13525, 13526, 13527, 13528, 13529, 13530, 13531, 13532, 13533, 13534, 
13535, 13536, 13537, 13538, 13539, 13540, 13541, 13542, 13543, 13544, 
13545, 13546, 13547, 13548, 13549, 13550, 13551, 13552, 13553, 13554, 
13555, 13556, 13557, 13558, 13559, 13560, 13561, 13562, 13563, 13564, 
13565, 13566, 13567, 13568, 13569, 13570, 13571, 13572, 13573, 13574, 
13575, 13576, 13577, 13578, 13579, 13580, 13581, 13582, 13583, 13584, 
13585, 13586, 14235, 14236, 14237, 14238, 14239, 14240, 14241, 14242, 
14243, 14244, 14245, 14246, 14247, 14248, 14249, 14250, 14251, 14252, 
14253, 14254, 14255, 14256, 14257, 14258, 14259, 14260, 14261, 14262, 
14263, 14264, 14265, 14266, 14267, 14268, 14269, 14270, 14271, 14272, 
14273, 14274, 14275, 14276, 14277, 14278, 14279, 14280, 14281, 14282, 
14283, 14284, 14285, 14286, 14287, 14288, 14289, 14290, 14291, 14292, 
14293, 14294, 14295, 14296, 14297, 14298, 14299, 14300, 14301, 14302, 
14303, 14304, 14305, 14306, 14307, 14308, 14309, 14310, 14311, 14312, 
14313, 14314, 14315, 14316, 14317, 14318, 14319, 14320, 14321, 14322, 
14323, 14324, 14325, 14326, 14327, 14328, 14329, 14330, 14331, 14332, 
14333, 14334, 14335, 14336, 14337, 14338, 14339, 14340, 14341, 14342, 
14343, 14344, 14345, 14346, 14347, 14348, 14349, 14350, 14351, 14352, 
14353, 14354, 14703, 14704, 14705, 14706, 14707, 14785, 14786, 14787, 
14788, 14789, 14790, 14791, 14792, 14793, 14794, 14795, 14796, 14797, 
14798, 14799, 14800, 14801, 14802, 14803, 14804, 14805, 14806, 14807, 
14808, 14809, 14810, 14811, 14812, 14813, 14814, 14815, 14816, 14817, 
14818, 14819, 14820, 14821, 14822, 14823, 14824, 14825, 14826, 14827, 
14828, 14829, 14830, 14831, 14832, 14833, 14834, 14835, 14836, 14837, 
14838, 14839, 14840, 14841, 14842, 14843, 14844, 14845, 14846, 14847, 
14848, 14849, 14850, 14851, 14852, 14853, 14854, 14855, 14856, 14857, 
14858, 14859, 14860, 14861, 14862, 14863, 14864, 14865, 14866, 14867, 
14868, 14869, 14870, 14871, 14872, 14873, 14874, 14875, 14876, 14877, 
14878, 14879, 14880, 14881, 14882, 14883, 14884, 14885, 14886, 14887, 
14888, 14889, 14890, 14891, 14892, 14893, 14894, 14895, 14896, 14897, 
14898, 14899, 14900, 14901, 14902, 14903, 14904, 15433, 15434, 15435, 
15436, 15437, 
*ELSET,ELSET=Solder_2D
2967, 2968, 2969, 2970, 2971, 2972, 2973, 2974, 2975, 2976, 
2977, 2978, 2979, 2980, 2981, 2982, 2983, 2984, 2985, 2986, 
2987, 2988, 2989, 2990, 5343, 5344, 5345, 5346, 5347, 5348, 
5349, 5350, 5351, 5352, 5353, 5354, 5355, 5356, 5357, 5358, 
5359, 5360, 5361, 5362, 5363, 5364, 5365, 5366, 7113, 7114, 
7115, 7116, 7117, 7118, 7119, 7120, 7121, 7122, 7123, 7124, 
7125, 7126, 7127, 7128, 7129, 7130, 7131, 7132, 7133, 7134, 
7135, 7136, 9489, 9490, 9491, 9492, 9493, 9494, 9495, 9496, 
9497, 9498, 9499, 9500, 9501, 9502, 9503, 9504, 9505, 9506, 
9507, 9508, 9509, 9510, 9511, 9512, 
*ELSET,ELSET=Copper_2D
2859, 2860, 2861, 2862, 2863, 2864, 2865, 2866, 2867, 2868, 
2869, 2870, 2871, 2872, 2873, 2874, 2875, 2876, 2877, 2878, 
2879, 2880, 2881, 2882, 2883, 2884, 2885, 2886, 2887, 2888, 
2889, 2890, 2891, 2892, 2893, 2894, 2895, 2896, 2897, 2898, 
2899, 2900, 2901, 2902, 2903, 2904, 2905, 2906, 2907, 2908, 
2909, 2910, 2911, 2912, 2913, 2914, 2915, 2916, 2917, 2918, 
2919, 2920, 2921, 2922, 2923, 2924, 2925, 2926, 2927, 2928, 
2929, 2930, 5775, 5776, 5777, 5778, 5779, 5780, 5781, 5782, 
5783, 5784, 5785, 5786, 5787, 5788, 5789, 5790, 5791, 5792, 
5793, 5794, 5795, 5796, 5797, 5798, 5799, 5800, 5801, 5802, 
5803, 5804, 5805, 5806, 5807, 5808, 5809, 5810, 5811, 5812, 
5813, 5814, 5815, 5816, 5817, 5818, 5819, 5820, 5821, 5822, 
5823, 5824, 5825, 5826, 5827, 5828, 5829, 5830, 5831, 5832, 
5833, 5834, 5835, 5836, 5837, 5838, 5839, 5840, 5841, 5842, 
5843, 5844, 5845, 5846, 6171, 6172, 6173, 6174, 6175, 6176, 
6177, 6178, 6179, 6180, 6181, 6182, 6183, 6184, 6185, 6357, 
6358, 6359, 6360, 6361, 6362, 6363, 6364, 6365, 6366, 6367, 
6368, 6369, 6370, 6371, 6372, 6373, 6374, 6375, 6376, 6377, 
6378, 6379, 6380, 6381, 6382, 6383, 6384, 6385, 6386, 6387, 
6388, 6389, 6390, 6391, 6392, 6393, 6394, 6395, 6396, 6397, 
6398, 6399, 6400, 6401, 6402, 6403, 6404, 6405, 6406, 6407, 
6408, 6409, 6410, 6411, 6412, 6413, 6414, 6415, 6416, 6417, 
6418, 6419, 6420, 6421, 6422, 6423, 6424, 6425, 6426, 6427, 
6428, 9849, 9850, 9851, 9852, 9853, 9854, 9855, 9856, 9857, 
9858, 9859, 9860, 9861, 9862, 9863, 9864, 9865, 9866, 9867, 
9868, 9869, 9870, 9871, 9872, 9873, 9874, 9875, 9876, 9877, 
9878, 9879, 9880, 9881, 9882, 9883, 9884, 9885, 9886, 9887, 
9888, 9889, 9890, 9891, 9892, 9893, 9894, 9895, 9896, 9897, 
9898, 9899, 9900, 9901, 9902, 9903, 9904, 9905, 9906, 9907, 
9908, 9909, 9910, 9911, 9912, 9913, 9914, 9915, 9916, 9917, 
9918, 9919, 9920, 10353, 10354, 10355, 10431, 10432, 10433, 
*ELSET,ELSET=Ceramic_2D
12829, 12830, 12831, 12832, 12833, 12834, 12835, 12836, 12837, 12838, 
12839, 12840, 12841, 12842, 12843, 12844, 12845, 12846, 12847, 12848, 
12849, 12850, 12851, 12852, 12853, 12854, 12855, 12856, 12857, 12858, 
12859, 12860, 12861, 12862, 12863, 12864, 12865, 12866, 12867, 12868, 
12869, 12870, 12871, 12872, 12873, 12874, 12875, 12876, 12877, 12878, 
12879, 12880, 12881, 12882, 12883, 12884, 12885, 12886, 12887, 12888, 
12889, 12890, 12891, 12892, 12893, 12894, 12895, 12896, 12897, 12898, 
12899, 12900, 12901, 12902, 12903, 12904, 12905, 12906, 12907, 12908, 
12909, 12910, 12911, 12912, 12913, 12914, 12915, 12916, 12917, 12918, 
12919, 12920, 12921, 12922, 12923, 12924, 12925, 12926, 12927, 12928, 
12929, 12930, 12931, 12932, 12933, 12934, 12935, 12936, 12937, 12938, 
12939, 12940, 12941, 12942, 12943, 12944, 12945, 12946, 12947, 12948, 
13297, 13298, 13299, 13300, 13301, 13302, 13303, 13304, 13305, 13306, 
13307, 13308, 13309, 13310, 13311, 13312, 13313, 13314, 13315, 13316, 
13317, 13318, 13319, 13320, 13321, 13467, 13468, 13469, 13470, 13471, 
13472, 13473, 13474, 13475, 13476, 13477, 13478, 13479, 13480, 13481, 
13482, 13483, 13484, 13485, 13486, 13487, 13488, 13489, 13490, 13491, 
13492, 13493, 13494, 13495, 13496, 13497, 13498, 13499, 13500, 13501, 
13502, 13503, 13504, 13505, 13506, 13507, 13508, 13509, 13510, 13511, 
13512, 13513, 13514, 13515, 13516, 13517, 13518, 13519, 13520, 13521, 
13522, 13523, 13524, 13525, 13526, 13527, 13528, 13529, 13530, 13531, 
13532, 13533, 13534, 13535, 13536, 13537, 13538, 13539, 13540, 13541, 
13542, 13543, 13544, 13545, 13546, 13547, 13548, 13549, 13550, 13551, 
13552, 13553, 13554, 13555, 13556, 13557, 13558, 13559, 13560, 13561, 
13562, 13563, 13564, 13565, 13566, 13567, 13568, 13569, 13570, 13571, 
13572, 13573, 13574, 13575, 13576, 13577, 13578, 13579, 13580, 13581, 
13582, 13583, 13584, 13585, 13586, 14235, 14236, 14237, 14238, 14239, 
14240, 14241, 14242, 14243, 14244, 14245, 14246, 14247, 14248, 14249, 
14250, 14251, 14252, 14253, 14254, 14255, 14256, 14257, 14258, 14259, 
14260, 14261, 14262, 14263, 14264, 14265, 14266, 14267, 14268, 14269, 
14270, 14271, 14272, 14273, 14274, 14275, 14276, 14277, 14278, 14279, 
14280, 14281, 14282, 14283, 14284, 14285, 14286, 14287, 14288, 14289, 
14290, 14291, 14292, 14293, 14294, 14295, 14296, 14297, 14298, 14299, 
14300, 14301, 14302, 14303, 14304, 14305, 14306, 14307, 14308, 14309, 
14310, 14311, 14312, 14313, 14314, 14315, 14316, 14317, 14318, 14319, 
14320, 14321, 14322, 14323, 14324, 14325, 14326, 14327, 14328, 14329, 
14330, 14331, 14332, 14333, 14334, 14335, 14336, 14337, 14338, 14339, 
14340, 14341, 14342, 14343, 14344, 14345, 14346, 14347, 14348, 14349, 
14350, 14351, 14352, 14353, 14354, 14703, 14704, 14705, 14706, 14707, 
14785, 14786, 14787, 14788, 14789, 14790, 14791, 14792, 14793, 14794, 
14795, 14796, 14797, 14798, 14799, 14800, 14801, 14802, 14803, 14804, 
14805, 14806, 14807, 14808, 14809, 14810, 14811, 14812, 14813, 14814, 
14815, 14816, 14817, 14818, 14819, 14820, 14821, 14822, 14823, 14824, 
14825, 14826, 14827, 14828, 14829, 14830, 14831, 14832, 14833, 14834, 
14835, 14836, 14837, 14838, 14839, 14840, 14841, 14842, 14843, 14844, 
14845, 14846, 14847, 14848, 14849, 14850, 14851, 14852, 14853, 14854, 
14855, 14856, 14857, 14858, 14859, 14860, 14861, 14862, 14863, 14864, 
14865, 14866, 14867, 14868, 14869, 14870, 14871, 14872, 14873, 14874, 
14875, 14876, 14877, 14878, 14879, 14880, 14881, 14882, 14883, 14884, 
14885, 14886, 14887, 14888, 14889, 14890, 14891, 14892, 14893, 14894, 
14895, 14896, 14897, 14898, 14899, 14900, 14901, 14902, 14903, 14904, 
15433, 15434, 15435, 15436, 15437, 
*ELSET,ELSET=SemiconductorL_2D
4155, 4156, 4157, 4158, 4159, 4160, 4161, 4162, 4163, 4164, 
4165, 4166, 4167, 4168, 4169, 4170, 4171, 4172, 4173, 4174, 
4175, 4176, 4177, 4178, 4179, 4180, 4181, 4182, 4183, 4184, 
4185, 4186, 4187, 4188, 4189, 4190, 4191, 4192, 4193, 4194, 
4195, 4196, 4197, 4198, 4199, 4200, 4201, 4202, 4203, 4204, 
4205, 4206, 4207, 4208, 4209, 4210, 4211, 4212, 4213, 4214, 
4215, 4216, 4217, 4218, 4219, 4220, 4221, 4222, 4223, 4224, 
4225, 4226, 4227, 4228, 4229, 4230, 4231, 4232, 4233, 4234, 
4235, 4236, 4237, 4238, 4239, 4240, 4241, 4242, 4243, 4244, 
4245, 4246, 4247, 4248, 4249, 4250, 4251, 4252, 4253, 4254, 
4255, 4256, 4257, 4258, 4259, 4260, 4261, 4262, 4263, 4264, 
4265, 4266, 4267, 4268, 4269, 4270, 4271, 4272, 4273, 4274, 
4275, 4276, 4277, 4278, 4279, 4280, 4281, 4282, 4283, 4284, 
4285, 4286, 4287, 4288, 4289, 4290, 4291, 4292, 4293, 4294, 
4295, 4296, 4297, 4298, 4299, 4300, 4301, 4302, 4303, 4304, 
4305, 4306, 4307, 4308, 4309, 4310, 4311, 4312, 4313, 4314, 
4315, 4316, 4317, 4318, 4319, 4320, 4321, 4322, 4323, 4324, 
4325, 4326, 4327, 4328, 4329, 4330, 4331, 4332, 4333, 4334, 
4335, 4336, 4337, 4338, 4339, 4340, 4341, 4342, 4343, 4344, 
4345, 4346, 4347, 4348, 4349, 4350, 4351, 4352, 4353, 4354, 
4355, 4356, 4357, 4358, 4359, 4360, 4361, 4362, 4363, 4364, 
4365, 4366, 4367, 4368, 4369, 4370, 4371, 4372, 4373, 4374, 
4375, 4376, 4377, 4378, 4379, 4380, 4381, 4382, 4383, 4384, 
4385, 4386, 4387, 4388, 4389, 4390, 4391, 4392, 4393, 4394, 
4395, 4396, 4397, 4398, 4399, 4400, 4401, 4402, 4403, 4404, 
4405, 4406, 4407, 4408, 4409, 4410, 4411, 4412, 4413, 4414, 
4415, 4416, 4417, 4418, 4419, 4420, 4421, 4422, 4423, 4424, 
4425, 4426, 4427, 4428, 4429, 4430, 4431, 4432, 4433, 4434, 
4435, 4436, 4437, 4438, 4439, 4440, 4441, 4442, 4443, 4444, 
4445, 4446, 4447, 4448, 4449, 4450, 4451, 4452, 4453, 4454, 
4455, 4456, 4457, 4458, 4459, 4460, 4461, 4462, 4463, 4464, 
4465, 4466, 4467, 4468, 4469, 4470, 4471, 4472, 4473, 4474, 
4475, 4476, 4477, 4478, 4479, 4480, 4481, 4482, 4483, 4484, 
4485, 4486, 4487, 4488, 4489, 4490, 4491, 4492, 4493, 4494, 
4495, 4496, 4497, 4498, 4499, 4500, 4501, 4502, 4503, 4504, 
4505, 4506, 4507, 4508, 4509, 4510, 4511, 4512, 4513, 4514, 
4515, 4516, 4517, 4518, 4519, 4520, 4521, 4522, 4523, 4524, 
4525, 4526, 4527, 4528, 4529, 4530, 4531, 4532, 4533, 4534, 
4535, 4536, 4537, 4538, 4539, 4540, 4541, 4542, 4543, 4544, 
4545, 4546, 4547, 4548, 4549, 4550, 4551, 4552, 4553, 4554, 
4555, 4556, 4557, 4558, 4559, 4560, 4561, 4562, 4563, 4564, 
4565, 4566, 4567, 4568, 4569, 4570, 4571, 4572, 4573, 4574, 
4575, 4576, 4577, 4578, 4579, 4580, 4581, 4582, 4583, 4584, 
4585, 4586, 4587, 4588, 4589, 4590, 4591, 4592, 4593, 4594, 
4595, 4596, 4597, 4598, 4599, 4600, 4601, 4602, 4603, 4604, 
4605, 4606, 4607, 4608, 4609, 4610, 4611, 4612, 4613, 4614, 
4615, 4616, 4617, 4618, 4619, 4620, 4621, 4622, 4623, 4624, 
4625, 4626, 4627, 4628, 4629, 4630, 4631, 4632, 4633, 4634, 
4635, 4636, 4637, 4638, 4639, 4640, 4641, 4642, 4643, 4644, 
4645, 4646, 4647, 4648, 4649, 4650, 4651, 4652, 4653, 4654, 
4655, 4656, 4657, 4658, 4659, 4660, 4661, 4662, 4663, 4664, 
4665, 4666, 4667, 4668, 4669, 4670, 4671, 4672, 4673, 4674, 
4675, 4676, 4677, 4678, 4679, 4680, 4681, 4682, 4683, 4684, 
4685, 4686, 4687, 4688, 4689, 4690, 4691, 4692, 4693, 4694, 
4695, 4696, 4697, 4698, 4699, 4700, 4701, 4702, 4703, 4704, 
4705, 4706, 4707, 4708, 4709, 4710, 4711, 4712, 4713, 4714, 
4715, 4716, 4717, 4718, 4719, 4720, 4721, 4722, 4723, 4724, 
4725, 4726, 4727, 4728, 4729, 4730, 
*ELSET,ELSET=SemiconductorR_2D
7473, 7474, 7475, 7476, 7477, 7478, 7479, 7480, 7481, 7482, 
7483, 7484, 7485, 7486, 7487, 7488, 7489, 7490, 7491, 7492, 
7493, 7494, 7495, 7496, 7497, 7498, 7499, 7500, 7501, 7502, 
7503, 7504, 7505, 7506, 7507, 7508, 7509, 7510, 7511, 7512, 
7513, 7514, 7515, 7516, 7517, 7518, 7519, 7520, 7521, 7522, 
7523, 7524, 7525, 7526, 7527, 7528, 7529, 7530, 7531, 7532, 
7533, 7534, 7535, 7536, 7537, 7538, 7539, 7540, 7541, 7542, 
7543, 7544, 7545, 7546, 7547, 7548, 7549, 7550, 7551, 7552, 
7553, 7554, 7555, 7556, 7557, 7558, 7559, 7560, 7561, 7562, 
7563, 7564, 7565, 7566, 7567, 7568, 7569, 7570, 7571, 7572, 
7573, 7574, 7575, 7576, 7577, 7578, 7579, 7580, 7581, 7582, 
7583, 7584, 7585, 7586, 7587, 7588, 7589, 7590, 7591, 7592, 
7593, 7594, 7595, 7596, 7597, 7598, 7599, 7600, 7601, 7602, 
7603, 7604, 7605, 7606, 7607, 7608, 7609, 7610, 7611, 7612, 
7613, 7614, 7615, 7616, 7617, 7618, 7619, 7620, 7621, 7622, 
7623, 7624, 7625, 7626, 7627, 7628, 7629, 7630, 7631, 7632, 
7633, 7634, 7635, 7636, 7637, 7638, 7639, 7640, 7641, 7642, 
7643, 7644, 7645, 7646, 7647, 7648, 7649, 7650, 7651, 7652, 
7653, 7654, 7655, 7656, 7657, 7658, 7659, 7660, 7661, 7662, 
7663, 7664, 7665, 7666, 7667, 7668, 7669, 7670, 7671, 7672, 
7673, 7674, 7675, 7676, 7677, 7678, 7679, 7680, 7681, 7682, 
7683, 7684, 7685, 7686, 7687, 7688, 7689, 7690, 7691, 7692, 
7693, 7694, 7695, 7696, 7697, 7698, 7699, 7700, 7701, 7702, 
7703, 7704, 7705, 7706, 7707, 7708, 7709, 7710, 7711, 7712, 
7713, 7714, 7715, 7716, 7717, 7718, 7719, 7720, 7721, 7722, 
7723, 7724, 7725, 7726, 7727, 7728, 7729, 7730, 7731, 7732, 
7733, 7734, 7735, 7736, 7737, 7738, 7739, 7740, 7741, 7742, 
7743, 7744, 7745, 7746, 7747, 7748, 7749, 7750, 7751, 7752, 
7753, 7754, 7755, 7756, 7757, 7758, 7759, 7760, 7761, 7762, 
7763, 7764, 7765, 7766, 7767, 7768, 7769, 7770, 7771, 7772, 
7773, 7774, 7775, 7776, 7777, 7778, 7779, 7780, 7781, 7782, 
7783, 7784, 7785, 7786, 7787, 7788, 7789, 7790, 7791, 7792, 
7793, 7794, 7795, 7796, 7797, 7798, 7799, 7800, 7801, 7802, 
7803, 7804, 7805, 7806, 7807, 7808, 7809, 7810, 7811, 7812, 
7813, 7814, 7815, 7816, 7817, 7818, 7819, 7820, 7821, 7822, 
7823, 7824, 7825, 7826, 7827, 7828, 7829, 7830, 7831, 7832, 
7833, 7834, 7835, 7836, 7837, 7838, 7839, 7840, 7841, 7842, 
7843, 7844, 7845, 7846, 7847, 7848, 7849, 7850, 7851, 7852, 
7853, 7854, 7855, 7856, 7857, 7858, 7859, 7860, 7861, 7862, 
7863, 7864, 7865, 7866, 7867, 7868, 7869, 7870, 7871, 7872, 
7873, 7874, 7875, 7876, 7877, 7878, 7879, 7880, 7881, 7882, 
7883, 7884, 7885, 7886, 7887, 7888, 7889, 7890, 7891, 7892, 
7893, 7894, 7895, 7896, 7897, 7898, 7899, 7900, 7901, 7902, 
7903, 7904, 7905, 7906, 7907, 7908, 7909, 7910, 7911, 7912, 
7913, 7914, 7915, 7916, 7917, 7918, 7919, 7920, 7921, 7922, 
7923, 7924, 7925, 7926, 7927, 7928, 7929, 7930, 7931, 7932, 
7933, 7934, 7935, 7936, 7937, 7938, 7939, 7940, 7941, 7942, 
7943, 7944, 7945, 7946, 7947, 7948, 7949, 7950, 7951, 7952, 
7953, 7954, 7955, 7956, 7957, 7958, 7959, 7960, 7961, 7962, 
7963, 7964, 7965, 7966, 7967, 7968, 7969, 7970, 7971, 7972, 
7973, 7974, 7975, 7976, 7977, 7978, 7979, 7980, 7981, 7982, 
7983, 7984, 7985, 7986, 7987, 7988, 7989, 7990, 7991, 7992, 
7993, 7994, 7995, 7996, 7997, 7998, 7999, 8000, 8001, 8002, 
8003, 8004, 8005, 8006, 8007, 8008, 8009, 8010, 8011, 8012, 
8013, 8014, 8015, 8016, 8017, 8018, 8019, 8020, 8021, 8022, 
8023, 8024, 8025, 8026, 8027, 8028, 8029, 8030, 8031, 8032, 
8033, 8034, 8035, 8036, 8037, 8038, 8039, 8040, 8041, 8042, 
8043, 8044, 8045, 8046, 8047, 8048, 
*ELSET,ELSET=Symmetry
2859, 2860, 2861, 2862, 2863, 2864, 2865, 2866, 2867, 2868, 
2869, 2870, 2871, 2872, 2873, 2874, 2875, 2876, 2877, 2878, 
2879, 2880, 2881, 2882, 2883, 2884, 2885, 2886, 2887, 2888, 
2889, 2890, 2891, 2892, 2893, 2894, 2895, 2896, 2897, 2898, 
2899, 2900, 2901, 2902, 2903, 2904, 2905, 2906, 2907, 2908, 
2909, 2910, 2911, 2912, 2913, 2914, 2915, 2916, 2917, 2918, 
2919, 2920, 2921, 2922, 2923, 2924, 2925, 2926, 2927, 2928, 
2929, 2930, 2967, 2968, 2969, 2970, 2971, 2972, 2973, 2974, 
2975, 2976, 2977, 2978, 2979, 2980, 2981, 2982, 2983, 2984, 
2985, 2986, 2987, 2988, 2989, 2990, 4155, 4156, 4157, 4158, 
4159, 4160, 4161, 4162, 4163, 4164, 4165, 4166, 4167, 4168, 
4169, 4170, 4171, 4172, 4173, 4174, 4175, 4176, 4177, 4178, 
4179, 4180, 4181, 4182, 4183, 4184, 4185, 4186, 4187, 4188, 
4189, 4190, 4191, 4192, 4193, 4194, 4195, 4196, 4197, 4198, 
4199, 4200, 4201, 4202, 4203, 4204, 4205, 4206, 4207, 4208, 
4209, 4210, 4211, 4212, 4213, 4214, 4215, 4216, 4217, 4218, 
4219, 4220, 4221, 4222, 4223, 4224, 4225, 4226, 4227, 4228, 
4229, 4230, 4231, 4232, 4233, 4234, 4235, 4236, 4237, 4238, 
4239, 4240, 4241, 4242, 4243, 4244, 4245, 4246, 4247, 4248, 
4249, 4250, 4251, 4252, 4253, 4254, 4255, 4256, 4257, 4258, 
4259, 4260, 4261, 4262, 4263, 4264, 4265, 4266, 4267, 4268, 
4269, 4270, 4271, 4272, 4273, 4274, 4275, 4276, 4277, 4278, 
4279, 4280, 4281, 4282, 4283, 4284, 4285, 4286, 4287, 4288, 
4289, 4290, 4291, 4292, 4293, 4294, 4295, 4296, 4297, 4298, 
4299, 4300, 4301, 4302, 4303, 4304, 4305, 4306, 4307, 4308, 
4309, 4310, 4311, 4312, 4313, 4314, 4315, 4316, 4317, 4318, 
4319, 4320, 4321, 4322, 4323, 4324, 4325, 4326, 4327, 4328, 
4329, 4330, 4331, 4332, 4333, 4334, 4335, 4336, 4337, 4338, 
4339, 4340, 4341, 4342, 4343, 4344, 4345, 4346, 4347, 4348, 
4349, 4350, 4351, 4352, 4353, 4354, 4355, 4356, 4357, 4358, 
4359, 4360, 4361, 4362, 4363, 4364, 4365, 4366, 4367, 4368, 
4369, 4370, 4371, 4372, 4373, 4374, 4375, 4376, 4377, 4378, 
4379, 4380, 4381, 4382, 4383, 4384, 4385, 4386, 4387, 4388, 
4389, 4390, 4391, 4392, 4393, 4394, 4395, 4396, 4397, 4398, 
4399, 4400, 4401, 4402, 4403, 4404, 4405, 4406, 4407, 4408, 
4409, 4410, 4411, 4412, 4413, 4414, 4415, 4416, 4417, 4418, 
4419, 4420, 4421, 4422, 4423, 4424, 4425, 4426, 4427, 4428, 
4429, 4430, 4431, 4432, 4433, 4434, 4435, 4436, 4437, 4438, 
4439, 4440, 4441, 4442, 4443, 4444, 4445, 4446, 4447, 4448, 
4449, 4450, 4451, 4452, 4453, 4454, 4455, 4456, 4457, 4458, 
4459, 4460, 4461, 4462, 4463, 4464, 4465, 4466, 4467, 4468, 
4469, 4470, 4471, 4472, 4473, 4474, 4475, 4476, 4477, 4478, 
4479, 4480, 4481, 4482, 4483, 4484, 4485, 4486, 4487, 4488, 
4489, 4490, 4491, 4492, 4493, 4494, 4495, 4496, 4497, 4498, 
4499, 4500, 4501, 4502, 4503, 4504, 4505, 4506, 4507, 4508, 
4509, 4510, 4511, 4512, 4513, 4514, 4515, 4516, 4517, 4518, 
4519, 4520, 4521, 4522, 4523, 4524, 4525, 4526, 4527, 4528, 
4529, 4530, 4531, 4532, 4533, 4534, 4535, 4536, 4537, 4538, 
4539, 4540, 4541, 4542, 4543, 4544, 4545, 4546, 4547, 4548, 
4549, 4550, 4551, 4552, 4553, 4554, 4555, 4556, 4557, 4558, 
4559, 4560, 4561, 4562, 4563, 4564, 4565, 4566, 4567, 4568, 
4569, 4570, 4571, 4572, 4573, 4574, 4575, 4576, 4577, 4578, 
4579, 4580, 4581, 4582, 4583, 4584, 4585, 4586, 4587, 4588, 
4589, 4590, 4591, 4592, 4593, 4594, 4595, 4596, 4597, 4598, 
4599, 4600, 4601, 4602, 4603, 4604, 4605, 4606, 4607, 4608, 
4609, 4610, 4611, 4612, 4613, 4614, 4615, 4616, 4617, 4618, 
4619, 4620, 4621, 4622, 4623, 4624, 4625, 4626, 4627, 4628, 
4629, 4630, 4631, 4632, 4633, 4634, 4635, 4636, 4637, 4638, 
4639, 4640, 4641, 4642, 4643, 4644, 4645, 4646, 4647, 4648, 
4649, 4650, 4651, 4652, 4653, 4654, 4655, 4656, 4657, 4658, 
4659, 4660, 4661, 4662, 4663, 4664, 4665, 4666, 4667, 4668, 
4669, 4670, 4671, 4672, 4673, 4674, 4675, 4676, 4677, 4678, 
4679, 4680, 4681, 4682, 4683, 4684, 4685, 4686, 4687, 4688, 
4689, 4690, 4691, 4692, 4693, 4694, 4695, 4696, 4697, 4698, 
4699, 4700, 4701, 4702, 4703, 4704, 4705, 4706, 4707, 4708, 
4709, 4710, 4711, 4712, 4713, 4714, 4715, 4716, 4717, 4718, 
4719, 4720, 4721, 4722, 4723, 4724, 4725, 4726, 4727, 4728, 
4729, 4730, 5343, 5344, 5345, 5346, 5347, 5348, 5349, 5350, 
5351, 5352, 5353, 5354, 5355, 5356, 5357, 5358, 5359, 5360, 
5361, 5362, 5363, 5364, 5365, 5366, 5775, 5776, 5777, 5778, 
5779, 5780, 5781, 5782, 5783, 5784, 5785, 5786, 5787, 5788, 
5789, 5790, 5791, 5792, 5793, 5794, 5795, 5796, 5797, 5798, 
5799, 5800, 5801, 5802, 5803, 5804, 5805, 5806, 5807, 5808, 
5809, 5810, 5811, 5812, 5813, 5814, 5815, 5816, 5817, 5818, 
5819, 5820, 5821, 5822, 5823, 5824, 5825, 5826, 5827, 5828, 
5829, 5830, 5831, 5832, 5833, 5834, 5835, 5836, 5837, 5838, 
5839, 5840, 5841, 5842, 5843, 5844, 5845, 5846, 6171, 6172, 
6173, 6174, 6175, 6176, 6177, 6178, 6179, 6180, 6181, 6182, 
6183, 6184, 6185, 6357, 6358, 6359, 6360, 6361, 6362, 6363, 
6364, 6365, 6366, 6367, 6368, 6369, 6370, 6371, 6372, 6373, 
6374, 6375, 6376, 6377, 6378, 6379, 6380, 6381, 6382, 6383, 
6384, 6385, 6386, 6387, 6388, 6389, 6390, 6391, 6392, 6393, 
6394, 6395, 6396, 6397, 6398, 6399, 6400, 6401, 6402, 6403, 
6404, 6405, 6406, 6407, 6408, 6409, 6410, 6411, 6412, 6413, 
6414, 6415, 6416, 6417, 6418, 6419, 6420, 6421, 6422, 6423, 
6424, 6425, 6426, 6427, 6428, 7113, 7114, 7115, 7116, 7117, 
7118, 7119, 7120, 7121, 7122, 7123, 7124, 7125, 7126, 7127, 
7128, 7129, 7130, 7131, 7132, 7133, 7134, 7135, 7136, 7473, 
7474, 7475, 7476, 7477, 7478, 7479, 7480, 7481, 7482, 7483, 
7484, 7485, 7486, 7487, 7488, 7489, 7490, 7491, 7492, 7493, 
7494, 7495, 7496, 7497, 7498, 7499, 7500, 7501, 7502, 7503, 
7504, 7505, 7506, 7507, 7508, 7509, 7510, 7511, 7512, 7513, 
7514, 7515, 7516, 7517, 7518, 7519, 7520, 7521, 7522, 7523, 
7524, 7525, 7526, 7527, 7528, 7529, 7530, 7531, 7532, 7533, 
7534, 7535, 7536, 7537, 7538, 7539, 7540, 7541, 7542, 7543, 
7544, 7545, 7546, 7547, 7548, 7549, 7550, 7551, 7552, 7553, 
7554, 7555, 7556, 7557, 7558, 7559, 7560, 7561, 7562, 7563, 
7564, 7565, 7566, 7567, 7568, 7569, 7570, 7571, 7572, 7573, 
7574, 7575, 7576, 7577, 7578, 7579, 7580, 7581, 7582, 7583, 
7584, 7585, 7586, 7587, 7588, 7589, 7590, 7591, 7592, 7593, 
7594, 7595, 7596, 7597, 7598, 7599, 7600, 7601, 7602, 7603, 
7604, 7605, 7606, 7607, 7608, 7609, 7610, 7611, 7612, 7613, 
7614, 7615, 7616, 7617, 7618, 7619, 7620, 7621, 7622, 7623, 
7624, 7625, 7626, 7627, 7628, 7629, 7630, 7631, 7632, 7633, 
7634, 7635, 7636, 7637, 7638, 7639, 7640, 7641, 7642, 7643, 
7644, 7645, 7646, 7647, 7648, 7649, 7650, 7651, 7652, 7653, 
7654, 7655, 7656, 7657, 7658, 7659, 7660, 7661, 7662, 7663, 
7664, 7665, 7666, 7667, 7668, 7669, 7670, 7671, 7672, 7673, 
7674, 7675, 7676, 7677, 7678, 7679, 7680, 7681, 7682, 7683, 
7684, 7685, 7686, 7687, 7688, 7689, 7690, 7691, 7692, 7693, 
7694, 7695, 7696, 7697, 7698, 7699, 7700, 7701, 7702, 7703, 
7704, 7705, 7706, 7707, 7708, 7709, 7710, 7711, 7712, 7713, 
7714, 7715, 7716, 7717, 7718, 7719, 7720, 7721, 7722, 7723, 
7724, 7725, 7726, 7727, 7728, 7729, 7730, 7731, 7732, 7733, 
7734, 7735, 7736, 7737, 7738, 7739, 7740, 7741, 7742, 7743, 
7744, 7745, 7746, 7747, 7748, 7749, 7750, 7751, 7752, 7753, 
7754, 7755, 7756, 7757, 7758, 7759, 7760, 7761, 7762, 7763, 
7764, 7765, 7766, 7767, 7768, 7769, 7770, 7771, 7772, 7773, 
7774, 7775, 7776, 7777, 7778, 7779, 7780, 7781, 7782, 7783, 
7784, 7785, 7786, 7787, 7788, 7789, 7790, 7791, 7792, 7793, 
7794, 7795, 7796, 7797, 7798, 7799, 7800, 7801, 7802, 7803, 
7804, 7805, 7806, 7807, 7808, 7809, 7810, 7811, 7812, 7813, 
7814, 7815, 7816, 7817, 7818, 7819, 7820, 7821, 7822, 7823, 
7824, 7825, 7826, 7827, 7828, 7829, 7830, 7831, 7832, 7833, 
7834, 7835, 7836, 7837, 7838, 7839, 7840, 7841, 7842, 7843, 
7844, 7845, 7846, 7847, 7848, 7849, 7850, 7851, 7852, 7853, 
7854, 7855, 7856, 7857, 7858, 7859, 7860, 7861, 7862, 7863, 
7864, 7865, 7866, 7867, 7868, 7869, 7870, 7871, 7872, 7873, 
7874, 7875, 7876, 7877, 7878, 7879, 7880, 7881, 7882, 7883, 
7884, 7885, 7886, 7887, 7888, 7889, 7890, 7891, 7892, 7893, 
7894, 7895, 7896, 7897, 7898, 7899, 7900, 7901, 7902, 7903, 
7904, 7905, 7906, 7907, 7908, 7909, 7910, 7911, 7912, 7913, 
7914, 7915, 7916, 7917, 7918, 7919, 7920, 7921, 7922, 7923, 
7924, 7925, 7926, 7927, 7928, 7929, 7930, 7931, 7932, 7933, 
7934, 7935, 7936, 7937, 7938, 7939, 7940, 7941, 7942, 7943, 
7944, 7945, 7946, 7947, 7948, 7949, 7950, 7951, 7952, 7953, 
7954, 7955, 7956, 7957, 7958, 7959, 7960, 7961, 7962, 7963, 
7964, 7965, 7966, 7967, 7968, 7969, 7970, 7971, 7972, 7973, 
7974, 7975, 7976, 7977, 7978, 7979, 7980, 7981, 7982, 7983, 
7984, 7985, 7986, 7987, 7988, 7989, 7990, 7991, 7992, 7993, 
7994, 7995, 7996, 7997, 7998, 7999, 8000, 8001, 8002, 8003, 
8004, 8005, 8006, 8007, 8008, 8009, 8010, 8011, 8012, 8013, 
8014, 8015, 8016, 8017, 8018, 8019, 8020, 8021, 8022, 8023, 
8024, 8025, 8026, 8027, 8028, 8029, 8030, 8031, 8032, 8033, 
8034, 8035, 8036, 8037, 8038, 8039, 8040, 8041, 8042, 8043, 
8044, 8045, 8046, 8047, 8048, 9489, 9490, 9491, 9492, 9493, 
9494, 9495, 9496, 9497, 9498, 9499, 9500, 9501, 9502, 9503, 
9504, 9505, 9506, 9507, 9508, 9509, 9510, 9511, 9512, 9849, 
9850, 9851, 9852, 9853, 9854, 9855, 9856, 9857, 9858, 9859, 
9860, 9861, 9862, 9863, 9864, 9865, 9866, 9867, 9868, 9869, 
9870, 9871, 9872, 9873, 9874, 9875, 9876, 9877, 9878, 9879, 
9880, 9881, 9882, 9883, 9884, 9885, 9886, 9887, 9888, 9889, 
9890, 9891, 9892, 9893, 9894, 9895, 9896, 9897, 9898, 9899, 
9900, 9901, 9902, 9903, 9904, 9905, 9906, 9907, 9908, 9909, 
9910, 9911, 9912, 9913, 9914, 9915, 9916, 9917, 9918, 9919, 
9920, 10353, 10354, 10355, 10431, 10432, 10433, 10485, 10486, 10487, 
10488, 10489, 10490, 10491, 10492, 10493, 10494, 10495, 10496, 10497, 
10498, 10499, 10500, 10501, 10502, 10503, 10504, 10505, 10506, 10507, 
10508, 10845, 10846, 10847, 10848, 10849, 10850, 10851, 10852, 10853, 
10854, 10855, 10856, 10857, 10858, 10859, 10860, 10861, 10862, 10863, 
10864, 10865, 10866, 10867, 10868, 12829, 12830, 12831, 12832, 12833, 
12834, 12835, 12836, 12837, 12838, 12839, 12840, 12841, 12842, 12843, 
12844, 12845, 12846, 12847, 12848, 12849, 12850, 12851, 12852, 12853, 
12854, 12855, 12856, 12857, 12858, 12859, 12860, 12861, 12862, 12863, 
12864, 12865, 12866, 12867, 12868, 12869, 12870, 12871, 12872, 12873, 
12874, 12875, 12876, 12877, 12878, 12879, 12880, 12881, 12882, 12883, 
12884, 12885, 12886, 12887, 12888, 12889, 12890, 12891, 12892, 12893, 
12894, 12895, 12896, 12897, 12898, 12899, 12900, 12901, 12902, 12903, 
