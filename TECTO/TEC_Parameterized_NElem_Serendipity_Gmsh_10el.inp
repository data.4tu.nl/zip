9650, 0.58333333333333, 0.55, 0.5
9651, 0.58333333333333, 0.6, 0.5
9652, 0.58333333333333, 0.65, 0.5
9653, 0.58333333333333, 0.7, 0.5
9654, 0.58333333333333, 0.75, 0.5
9655, 0.58333333333333, 0.8, 0.5
9656, 0.58333333333333, 0.85, 0.5
9657, 0.58333333333333, 0.9, 0.5
9658, 0.58333333333333, 0.95, 0.5
9659, 0.58333333333333, 1, 0.5
9660, 0.58333333333333, 1.05, 0.5
9661, 0.58333333333333, 1.1, 0.5
9662, 0.58333333333333, 1.15, 0.5
9663, 0.58333333333333, 1.2, 0.5
9664, 0.58333333333333, 1.25, 0.5
9665, 0.58333333333333, 1.3, 0.5
9666, 0.625, 0.2, 0.5
9667, 0.625, 0.25, 0.5
9668, 0.625, 0.3, 0.5
9669, 0.625, 0.35, 0.5
9670, 0.625, 0.4, 0.5
9671, 0.625, 0.45, 0.5
9672, 0.625, 0.5, 0.5
9673, 0.625, 0.55, 0.5
9674, 0.625, 0.6, 0.5
9675, 0.625, 0.65, 0.5
9676, 0.625, 0.7, 0.5
9677, 0.625, 0.75, 0.5
9678, 0.625, 0.8, 0.5
9679, 0.625, 0.85, 0.5
9680, 0.625, 0.9, 0.5
9681, 0.625, 0.95, 0.5
9682, 0.625, 1, 0.5
9683, 0.625, 1.05, 0.5
9684, 0.625, 1.1, 0.5
9685, 0.625, 1.15, 0.5
9686, 0.625, 1.2, 0.5
9687, 0.625, 1.25, 0.5
9688, 0.625, 1.3, 0.5
9689, 0.66666666666667, 0.2, 0.5
9690, 0.66666666666667, 0.25, 0.5
9691, 0.66666666666667, 0.3, 0.5
9692, 0.66666666666667, 0.35, 0.5
9693, 0.66666666666667, 0.4, 0.5
9694, 0.66666666666667, 0.45, 0.5
9695, 0.66666666666667, 0.5, 0.5
9696, 0.66666666666667, 0.55, 0.5
9697, 0.66666666666667, 0.6, 0.5
9698, 0.66666666666667, 0.65, 0.5
9699, 0.66666666666667, 0.7, 0.5
9700, 0.66666666666667, 0.75, 0.5
9701, 0.66666666666667, 0.8, 0.5
9702, 0.66666666666667, 0.85, 0.5
9703, 0.66666666666667, 0.9, 0.5
9704, 0.66666666666667, 0.95, 0.5
9705, 0.66666666666667, 1, 0.5
9706, 0.66666666666667, 1.05, 0.5
9707, 0.66666666666667, 1.1, 0.5
9708, 0.66666666666667, 1.15, 0.5
9709, 0.66666666666667, 1.2, 0.5
9710, 0.66666666666667, 1.25, 0.5
9711, 0.66666666666667, 1.3, 0.5
9712, 0.70833333333333, 0.2, 0.5
9713, 0.70833333333333, 0.25, 0.5
9714, 0.70833333333333, 0.3, 0.5
9715, 0.70833333333333, 0.35, 0.5
9716, 0.70833333333333, 0.4, 0.5
9717, 0.70833333333333, 0.45, 0.5
9718, 0.70833333333333, 0.5, 0.5
9719, 0.70833333333333, 0.55, 0.5
9720, 0.70833333333333, 0.6, 0.5
9721, 0.70833333333333, 0.65, 0.5
9722, 0.70833333333333, 0.7, 0.5
9723, 0.70833333333333, 0.75, 0.5
9724, 0.70833333333333, 0.8, 0.5
9725, 0.70833333333333, 0.85, 0.5
9726, 0.70833333333333, 0.9, 0.5
9727, 0.70833333333333, 0.95, 0.5
9728, 0.70833333333333, 1, 0.5
9729, 0.70833333333333, 1.05, 0.5
9730, 0.70833333333333, 1.1, 0.5
9731, 0.70833333333333, 1.15, 0.5
9732, 0.70833333333333, 1.2, 0.5
9733, 0.70833333333333, 1.25, 0.5
9734, 0.70833333333333, 1.3, 0.5
9735, 0.75, 0.2, 0.5
9736, 0.75, 0.25, 0.5
9737, 0.75, 0.3, 0.5
9738, 0.75, 0.35, 0.5
9739, 0.75, 0.4, 0.5
9740, 0.75, 0.45, 0.5
9741, 0.75, 0.5, 0.5
9742, 0.75, 0.55, 0.5
9743, 0.75, 0.6, 0.5
9744, 0.75, 0.65, 0.5
9745, 0.75, 0.7, 0.5
9746, 0.75, 0.75, 0.5
9747, 0.75, 0.8, 0.5
9748, 0.75, 0.85, 0.5
9749, 0.75, 0.9, 0.5
9750, 0.75, 0.95, 0.5
9751, 0.75, 1, 0.5
9752, 0.75, 1.05, 0.5
9753, 0.75, 1.1, 0.5
9754, 0.75, 1.15, 0.5
9755, 0.75, 1.2, 0.5
9756, 0.75, 1.25, 0.5
9757, 0.75, 1.3, 0.5
9758, 0.79166666666667, 0.2, 0.5
9759, 0.79166666666667, 0.25, 0.5
9760, 0.79166666666667, 0.3, 0.5
9761, 0.79166666666667, 0.35, 0.5
9762, 0.79166666666667, 0.4, 0.5
9763, 0.79166666666667, 0.45, 0.5
9764, 0.79166666666667, 0.5, 0.5
9765, 0.79166666666667, 0.55, 0.5
9766, 0.79166666666667, 0.6, 0.5
9767, 0.79166666666667, 0.65, 0.5
9768, 0.79166666666667, 0.7, 0.5
9769, 0.79166666666667, 0.75, 0.5
9770, 0.79166666666667, 0.8, 0.5
9771, 0.79166666666667, 0.85, 0.5
9772, 0.79166666666667, 0.9, 0.5
9773, 0.79166666666667, 0.95, 0.5
9774, 0.79166666666667, 1, 0.5
9775, 0.79166666666667, 1.05, 0.5
9776, 0.79166666666667, 1.1, 0.5
9777, 0.79166666666667, 1.15, 0.5
9778, 0.79166666666667, 1.2, 0.5
9779, 0.79166666666667, 1.25, 0.5
9780, 0.79166666666667, 1.3, 0.5
9781, 0.83333333333333, 0.2, 0.5
9782, 0.83333333333333, 0.25, 0.5
9783, 0.83333333333333, 0.3, 0.5
9784, 0.83333333333333, 0.35, 0.5
9785, 0.83333333333333, 0.4, 0.5
9786, 0.83333333333333, 0.45, 0.5
9787, 0.83333333333333, 0.5, 0.5
9788, 0.83333333333333, 0.55, 0.5
9789, 0.83333333333333, 0.6, 0.5
9790, 0.83333333333333, 0.65, 0.5
9791, 0.83333333333333, 0.7, 0.5
9792, 0.83333333333333, 0.75, 0.5
9793, 0.83333333333333, 0.8, 0.5
9794, 0.83333333333333, 0.85, 0.5
9795, 0.83333333333333, 0.9, 0.5
9796, 0.83333333333333, 0.95, 0.5
9797, 0.83333333333333, 1, 0.5
9798, 0.83333333333333, 1.05, 0.5
9799, 0.83333333333333, 1.1, 0.5
9800, 0.83333333333333, 1.15, 0.5
9801, 0.83333333333333, 1.2, 0.5
9802, 0.83333333333333, 1.25, 0.5
9803, 0.83333333333333, 1.3, 0.5
9804, 0.875, 0.2, 0.5
9805, 0.875, 0.25, 0.5
9806, 0.875, 0.3, 0.5
9807, 0.875, 0.35, 0.5
9808, 0.875, 0.4, 0.5
9809, 0.875, 0.45, 0.5
9810, 0.875, 0.5, 0.5
9811, 0.875, 0.55, 0.5
9812, 0.875, 0.6, 0.5
9813, 0.875, 0.65, 0.5
9814, 0.875, 0.7, 0.5
9815, 0.875, 0.75, 0.5
9816, 0.875, 0.8, 0.5
9817, 0.875, 0.85, 0.5
9818, 0.875, 0.9, 0.5
9819, 0.875, 0.95, 0.5
9820, 0.875, 1, 0.5
9821, 0.875, 1.05, 0.5
9822, 0.875, 1.1, 0.5
9823, 0.875, 1.15, 0.5
9824, 0.875, 1.2, 0.5
9825, 0.875, 1.25, 0.5
9826, 0.875, 1.3, 0.5
9827, 0.91666666666667, 0.2, 0.5
9828, 0.91666666666667, 0.25, 0.5
9829, 0.91666666666667, 0.3, 0.5
9830, 0.91666666666667, 0.35, 0.5
9831, 0.91666666666667, 0.4, 0.5
9832, 0.91666666666667, 0.45, 0.5
9833, 0.91666666666667, 0.5, 0.5
9834, 0.91666666666667, 0.55, 0.5
9835, 0.91666666666667, 0.6, 0.5
9836, 0.91666666666667, 0.65, 0.5
9837, 0.91666666666667, 0.7, 0.5
9838, 0.91666666666667, 0.75, 0.5
9839, 0.91666666666667, 0.8, 0.5
9840, 0.91666666666667, 0.85, 0.5
9841, 0.91666666666667, 0.9, 0.5
9842, 0.91666666666667, 0.95, 0.5
9843, 0.91666666666667, 1, 0.5
9844, 0.91666666666667, 1.05, 0.5
9845, 0.91666666666667, 1.1, 0.5
9846, 0.91666666666667, 1.15, 0.5
9847, 0.91666666666667, 1.2, 0.5
9848, 0.91666666666667, 1.25, 0.5
9849, 0.91666666666667, 1.3, 0.5
9850, 0.95833333333333, 0.2, 0.5
9851, 0.95833333333333, 0.25, 0.5
9852, 0.95833333333333, 0.3, 0.5
9853, 0.95833333333333, 0.35, 0.5
9854, 0.95833333333333, 0.4, 0.5
9855, 0.95833333333333, 0.45, 0.5
9856, 0.95833333333333, 0.5, 0.5
9857, 0.95833333333333, 0.55, 0.5
9858, 0.95833333333333, 0.6, 0.5
9859, 0.95833333333333, 0.65, 0.5
9860, 0.95833333333333, 0.7, 0.5
9861, 0.95833333333333, 0.75, 0.5
9862, 0.95833333333333, 0.8, 0.5
9863, 0.95833333333333, 0.85, 0.5
9864, 0.95833333333333, 0.9, 0.5
9865, 0.95833333333333, 0.95, 0.5
9866, 0.95833333333333, 1, 0.5
9867, 0.95833333333333, 1.05, 0.5
9868, 0.95833333333333, 1.1, 0.5
9869, 0.95833333333333, 1.15, 0.5
9870, 0.95833333333333, 1.2, 0.5
9871, 0.95833333333333, 1.25, 0.5
9872, 0.95833333333333, 1.3, 0.5
9873, 0.041666666666667, 0.175, 0.5
9874, 0.020833333333333, 0.2, 0.5
9875, 0.041666666666667, 0.225, 0.5
9876, 0.020833333333333, 0.25, 0.5
9877, 0.041666666666667, 0.275, 0.5
9878, 0.020833333333333, 0.3, 0.5
9879, 0.041666666666667, 0.325, 0.5
9880, 0.020833333333333, 0.35, 0.5
9881, 0.041666666666667, 0.375, 0.5
9882, 0.020833333333333, 0.4, 0.5
9883, 0.041666666666667, 0.425, 0.5
9884, 0.020833333333333, 0.45, 0.5
9885, 0.041666666666667, 0.475, 0.5
9886, 0.020833333333333, 0.5, 0.5
9887, 0.041666666666667, 0.525, 0.5
9888, 0.020833333333333, 0.55, 0.5
9889, 0.041666666666667, 0.575, 0.5
9890, 0.020833333333333, 0.6, 0.5
9891, 0.041666666666667, 0.625, 0.5
9892, 0.020833333333333, 0.65, 0.5
9893, 0.041666666666667, 0.675, 0.5
9894, 0.020833333333333, 0.7, 0.5
9895, 0.041666666666667, 0.725, 0.5
9896, 0.020833333333333, 0.75, 0.5
9897, 0.041666666666667, 0.775, 0.5
9898, 0.020833333333333, 0.8, 0.5
9899, 0.041666666666667, 0.825, 0.5
9900, 0.020833333333333, 0.85, 0.5
9901, 0.041666666666667, 0.875, 0.5
9902, 0.020833333333333, 0.9, 0.5
9903, 0.041666666666667, 0.925, 0.5
9904, 0.020833333333333, 0.95, 0.5
9905, 0.041666666666667, 0.975, 0.5
9906, 0.020833333333333, 1, 0.5
9907, 0.041666666666667, 1.025, 0.5
9908, 0.020833333333333, 1.05, 0.5
9909, 0.041666666666667, 1.075, 0.5
9910, 0.020833333333333, 1.1, 0.5
9911, 0.041666666666667, 1.125, 0.5
9912, 0.020833333333333, 1.15, 0.5
9913, 0.041666666666667, 1.175, 0.5
9914, 0.020833333333333, 1.2, 0.5
9915, 0.041666666666667, 1.225, 0.5
9916, 0.020833333333333, 1.25, 0.5
9917, 0.041666666666667, 1.275, 0.5
9918, 0.020833333333333, 1.3, 0.5
9919, 0.041666666666667, 1.325, 0.5
9920, 0.083333333333333, 0.175, 0.5
9921, 0.0625, 0.2, 0.5
9922, 0.083333333333333, 0.225, 0.5
9923, 0.0625, 0.25, 0.5
9924, 0.083333333333333, 0.275, 0.5
9925, 0.0625, 0.3, 0.5
9926, 0.083333333333333, 0.325, 0.5
9927, 0.0625, 0.35, 0.5
9928, 0.083333333333333, 0.375, 0.5
9929, 0.0625, 0.4, 0.5
9930, 0.083333333333333, 0.425, 0.5
9931, 0.0625, 0.45, 0.5
9932, 0.083333333333333, 0.475, 0.5
9933, 0.0625, 0.5, 0.5
9934, 0.083333333333333, 0.525, 0.5
9935, 0.0625, 0.55, 0.5
9936, 0.083333333333333, 0.575, 0.5
9937, 0.0625, 0.6, 0.5
9938, 0.083333333333333, 0.625, 0.5
9939, 0.0625, 0.65, 0.5
9940, 0.083333333333333, 0.675, 0.5
9941, 0.0625, 0.7, 0.5
9942, 0.083333333333333, 0.725, 0.5
9943, 0.0625, 0.75, 0.5
9944, 0.083333333333333, 0.775, 0.5
9945, 0.0625, 0.8, 0.5
9946, 0.083333333333333, 0.825, 0.5
9947, 0.0625, 0.85, 0.5
9948, 0.083333333333333, 0.875, 0.5
9949, 0.0625, 0.9, 0.5
9950, 0.083333333333333, 0.925, 0.5
9951, 0.0625, 0.95, 0.5
9952, 0.083333333333333, 0.975, 0.5
9953, 0.0625, 1, 0.5
9954, 0.083333333333333, 1.025, 0.5
9955, 0.0625, 1.05, 0.5
9956, 0.083333333333333, 1.075, 0.5
9957, 0.0625, 1.1, 0.5
9958, 0.083333333333333, 1.125, 0.5
9959, 0.0625, 1.15, 0.5
9960, 0.083333333333333, 1.175, 0.5
9961, 0.0625, 1.2, 0.5
9962, 0.083333333333333, 1.225, 0.5
9963, 0.0625, 1.25, 0.5
9964, 0.083333333333333, 1.275, 0.5
9965, 0.0625, 1.3, 0.5
9966, 0.083333333333333, 1.325, 0.5
9967, 0.125, 0.175, 0.5
9968, 0.10416666666667, 0.2, 0.5
9969, 0.125, 0.225, 0.5
9970, 0.10416666666667, 0.25, 0.5
9971, 0.125, 0.275, 0.5
9972, 0.10416666666667, 0.3, 0.5
9973, 0.125, 0.325, 0.5
9974, 0.10416666666667, 0.35, 0.5
9975, 0.125, 0.375, 0.5
9976, 0.10416666666667, 0.4, 0.5
9977, 0.125, 0.425, 0.5
9978, 0.10416666666667, 0.45, 0.5
9979, 0.125, 0.475, 0.5
9980, 0.10416666666667, 0.5, 0.5
9981, 0.125, 0.525, 0.5
9982, 0.10416666666667, 0.55, 0.5
9983, 0.125, 0.575, 0.5
9984, 0.10416666666667, 0.6, 0.5
9985, 0.125, 0.625, 0.5
9986, 0.10416666666667, 0.65, 0.5
9987, 0.125, 0.675, 0.5
9988, 0.10416666666667, 0.7, 0.5
9989, 0.125, 0.725, 0.5
9990, 0.10416666666667, 0.75, 0.5
9991, 0.125, 0.775, 0.5
9992, 0.10416666666667, 0.8, 0.5
9993, 0.125, 0.825, 0.5
9994, 0.10416666666667, 0.85, 0.5
9995, 0.125, 0.875, 0.5
9996, 0.10416666666667, 0.9, 0.5
9997, 0.125, 0.925, 0.5
9998, 0.10416666666667, 0.95, 0.5
9999, 0.125, 0.975, 0.5
10000, 0.10416666666667, 1, 0.5
10001, 0.125, 1.025, 0.5
10002, 0.10416666666667, 1.05, 0.5
10003, 0.125, 1.075, 0.5
10004, 0.10416666666667, 1.1, 0.5
10005, 0.125, 1.125, 0.5
10006, 0.10416666666667, 1.15, 0.5
10007, 0.125, 1.175, 0.5
10008, 0.10416666666667, 1.2, 0.5
10009, 0.125, 1.225, 0.5
10010, 0.10416666666667, 1.25, 0.5
10011, 0.125, 1.275, 0.5
10012, 0.10416666666667, 1.3, 0.5
10013, 0.125, 1.325, 0.5
10014, 0.16666666666667, 0.175, 0.5
10015, 0.14583333333333, 0.2, 0.5
10016, 0.16666666666667, 0.225, 0.5
10017, 0.14583333333333, 0.25, 0.5
10018, 0.16666666666667, 0.275, 0.5
10019, 0.14583333333333, 0.3, 0.5
10020, 0.16666666666667, 0.325, 0.5
10021, 0.14583333333333, 0.35, 0.5
10022, 0.16666666666667, 0.375, 0.5
10023, 0.14583333333333, 0.4, 0.5
10024, 0.16666666666667, 0.425, 0.5
10025, 0.14583333333333, 0.45, 0.5
10026, 0.16666666666667, 0.475, 0.5
10027, 0.14583333333333, 0.5, 0.5
10028, 0.16666666666667, 0.525, 0.5
10029, 0.14583333333333, 0.55, 0.5
10030, 0.16666666666667, 0.575, 0.5
10031, 0.14583333333333, 0.6, 0.5
10032, 0.16666666666667, 0.625, 0.5
10033, 0.14583333333333, 0.65, 0.5
10034, 0.16666666666667, 0.675, 0.5
10035, 0.14583333333333, 0.7, 0.5
10036, 0.16666666666667, 0.725, 0.5
10037, 0.14583333333333, 0.75, 0.5
10038, 0.16666666666667, 0.775, 0.5
10039, 0.14583333333333, 0.8, 0.5
10040, 0.16666666666667, 0.825, 0.5
10041, 0.14583333333333, 0.85, 0.5
10042, 0.16666666666667, 0.875, 0.5
10043, 0.14583333333333, 0.9, 0.5
10044, 0.16666666666667, 0.925, 0.5
10045, 0.14583333333333, 0.95, 0.5
10046, 0.16666666666667, 0.975, 0.5
10047, 0.14583333333333, 1, 0.5
10048, 0.16666666666667, 1.025, 0.5
10049, 0.14583333333333, 1.05, 0.5
10050, 0.16666666666667, 1.075, 0.5
10051, 0.14583333333333, 1.1, 0.5
10052, 0.16666666666667, 1.125, 0.5
10053, 0.14583333333333, 1.15, 0.5
10054, 0.16666666666667, 1.175, 0.5
10055, 0.14583333333333, 1.2, 0.5
10056, 0.16666666666667, 1.225, 0.5
10057, 0.14583333333333, 1.25, 0.5
10058, 0.16666666666667, 1.275, 0.5
10059, 0.14583333333333, 1.3, 0.5
10060, 0.16666666666667, 1.325, 0.5
10061, 0.20833333333333, 0.175, 0.5
10062, 0.1875, 0.2, 0.5
10063, 0.20833333333333, 0.225, 0.5
10064, 0.1875, 0.25, 0.5
10065, 0.20833333333333, 0.275, 0.5
10066, 0.1875, 0.3, 0.5
10067, 0.20833333333333, 0.325, 0.5
10068, 0.1875, 0.35, 0.5
10069, 0.20833333333333, 0.375, 0.5
10070, 0.1875, 0.4, 0.5
10071, 0.20833333333333, 0.425, 0.5
10072, 0.1875, 0.45, 0.5
10073, 0.20833333333333, 0.475, 0.5
10074, 0.1875, 0.5, 0.5
10075, 0.20833333333333, 0.525, 0.5
10076, 0.1875, 0.55, 0.5
10077, 0.20833333333333, 0.575, 0.5
10078, 0.1875, 0.6, 0.5
10079, 0.20833333333333, 0.625, 0.5
10080, 0.1875, 0.65, 0.5
10081, 0.20833333333333, 0.675, 0.5
10082, 0.1875, 0.7, 0.5
10083, 0.20833333333333, 0.725, 0.5
10084, 0.1875, 0.75, 0.5
10085, 0.20833333333333, 0.775, 0.5
10086, 0.1875, 0.8, 0.5
10087, 0.20833333333333, 0.825, 0.5
10088, 0.1875, 0.85, 0.5
10089, 0.20833333333333, 0.875, 0.5
10090, 0.1875, 0.9, 0.5
10091, 0.20833333333333, 0.925, 0.5
10092, 0.1875, 0.95, 0.5
10093, 0.20833333333333, 0.975, 0.5
10094, 0.1875, 1, 0.5
10095, 0.20833333333333, 1.025, 0.5
10096, 0.1875, 1.05, 0.5
10097, 0.20833333333333, 1.075, 0.5
10098, 0.1875, 1.1, 0.5
10099, 0.20833333333333, 1.125, 0.5
10100, 0.1875, 1.15, 0.5
10101, 0.20833333333333, 1.175, 0.5
10102, 0.1875, 1.2, 0.5
10103, 0.20833333333333, 1.225, 0.5
10104, 0.1875, 1.25, 0.5
10105, 0.20833333333333, 1.275, 0.5
10106, 0.1875, 1.3, 0.5
10107, 0.20833333333333, 1.325, 0.5
10108, 0.25, 0.175, 0.5
10109, 0.22916666666667, 0.2, 0.5
10110, 0.25, 0.225, 0.5
10111, 0.22916666666667, 0.25, 0.5
10112, 0.25, 0.275, 0.5
10113, 0.22916666666667, 0.3, 0.5
10114, 0.25, 0.325, 0.5
10115, 0.22916666666667, 0.35, 0.5
10116, 0.25, 0.375, 0.5
10117, 0.22916666666667, 0.4, 0.5
10118, 0.25, 0.425, 0.5
10119, 0.22916666666667, 0.45, 0.5
10120, 0.25, 0.475, 0.5
10121, 0.22916666666667, 0.5, 0.5
10122, 0.25, 0.525, 0.5
10123, 0.22916666666667, 0.55, 0.5
10124, 0.25, 0.575, 0.5
10125, 0.22916666666667, 0.6, 0.5
10126, 0.25, 0.625, 0.5
10127, 0.22916666666667, 0.65, 0.5
10128, 0.25, 0.675, 0.5
10129, 0.22916666666667, 0.7, 0.5
10130, 0.25, 0.725, 0.5
10131, 0.22916666666667, 0.75, 0.5
10132, 0.25, 0.775, 0.5
10133, 0.22916666666667, 0.8, 0.5
10134, 0.25, 0.825, 0.5
10135, 0.22916666666667, 0.85, 0.5
10136, 0.25, 0.875, 0.5
10137, 0.22916666666667, 0.9, 0.5
10138, 0.25, 0.925, 0.5
10139, 0.22916666666667, 0.95, 0.5
10140, 0.25, 0.975, 0.5
10141, 0.22916666666667, 1, 0.5
10142, 0.25, 1.025, 0.5
10143, 0.22916666666667, 1.05, 0.5
10144, 0.25, 1.075, 0.5
10145, 0.22916666666667, 1.1, 0.5
10146, 0.25, 1.125, 0.5
10147, 0.22916666666667, 1.15, 0.5
10148, 0.25, 1.175, 0.5
10149, 0.22916666666667, 1.2, 0.5
10150, 0.25, 1.225, 0.5
10151, 0.22916666666667, 1.25, 0.5
10152, 0.25, 1.275, 0.5
10153, 0.22916666666667, 1.3, 0.5
10154, 0.25, 1.325, 0.5
10155, 0.29166666666667, 0.175, 0.5
10156, 0.27083333333333, 0.2, 0.5
10157, 0.29166666666667, 0.225, 0.5
10158, 0.27083333333333, 0.25, 0.5
10159, 0.29166666666667, 0.275, 0.5
10160, 0.27083333333333, 0.3, 0.5
10161, 0.29166666666667, 0.325, 0.5
10162, 0.27083333333333, 0.35, 0.5
10163, 0.29166666666667, 0.375, 0.5
10164, 0.27083333333333, 0.4, 0.5
10165, 0.29166666666667, 0.425, 0.5
10166, 0.27083333333333, 0.45, 0.5
10167, 0.29166666666667, 0.475, 0.5
10168, 0.27083333333333, 0.5, 0.5
10169, 0.29166666666667, 0.525, 0.5
10170, 0.27083333333333, 0.55, 0.5
10171, 0.29166666666667, 0.575, 0.5
10172, 0.27083333333333, 0.6, 0.5
10173, 0.29166666666667, 0.625, 0.5
10174, 0.27083333333333, 0.65, 0.5
10175, 0.29166666666667, 0.675, 0.5
10176, 0.27083333333333, 0.7, 0.5
10177, 0.29166666666667, 0.725, 0.5
10178, 0.27083333333333, 0.75, 0.5
10179, 0.29166666666667, 0.775, 0.5
10180, 0.27083333333333, 0.8, 0.5
10181, 0.29166666666667, 0.825, 0.5
10182, 0.27083333333333, 0.85, 0.5
10183, 0.29166666666667, 0.875, 0.5
10184, 0.27083333333333, 0.9, 0.5
10185, 0.29166666666667, 0.925, 0.5
10186, 0.27083333333333, 0.95, 0.5
10187, 0.29166666666667, 0.975, 0.5
10188, 0.27083333333333, 1, 0.5
10189, 0.29166666666667, 1.025, 0.5
10190, 0.27083333333333, 1.05, 0.5
10191, 0.29166666666667, 1.075, 0.5
10192, 0.27083333333333, 1.1, 0.5
10193, 0.29166666666667, 1.125, 0.5
10194, 0.27083333333333, 1.15, 0.5
10195, 0.29166666666667, 1.175, 0.5
10196, 0.27083333333333, 1.2, 0.5
10197, 0.29166666666667, 1.225, 0.5
10198, 0.27083333333333, 1.25, 0.5
10199, 0.29166666666667, 1.275, 0.5
10200, 0.27083333333333, 1.3, 0.5
10201, 0.29166666666667, 1.325, 0.5
10202, 0.33333333333333, 0.175, 0.5
10203, 0.3125, 0.2, 0.5
10204, 0.33333333333333, 0.225, 0.5
10205, 0.3125, 0.25, 0.5
10206, 0.33333333333333, 0.275, 0.5
10207, 0.3125, 0.3, 0.5
10208, 0.33333333333333, 0.325, 0.5
10209, 0.3125, 0.35, 0.5
10210, 0.33333333333333, 0.375, 0.5
10211, 0.3125, 0.4, 0.5
10212, 0.33333333333333, 0.425, 0.5
10213, 0.3125, 0.45, 0.5
10214, 0.33333333333333, 0.475, 0.5
10215, 0.3125, 0.5, 0.5
10216, 0.33333333333333, 0.525, 0.5
10217, 0.3125, 0.55, 0.5
10218, 0.33333333333333, 0.575, 0.5
10219, 0.3125, 0.6, 0.5
10220, 0.33333333333333, 0.625, 0.5
10221, 0.3125, 0.65, 0.5
10222, 0.33333333333333, 0.675, 0.5
10223, 0.3125, 0.7, 0.5
10224, 0.33333333333333, 0.725, 0.5
10225, 0.3125, 0.75, 0.5
10226, 0.33333333333333, 0.775, 0.5
10227, 0.3125, 0.8, 0.5
10228, 0.33333333333333, 0.825, 0.5
10229, 0.3125, 0.85, 0.5
10230, 0.33333333333333, 0.875, 0.5
10231, 0.3125, 0.9, 0.5
10232, 0.33333333333333, 0.925, 0.5
10233, 0.3125, 0.95, 0.5
10234, 0.33333333333333, 0.975, 0.5
10235, 0.3125, 1, 0.5
10236, 0.33333333333333, 1.025, 0.5
10237, 0.3125, 1.05, 0.5
10238, 0.33333333333333, 1.075, 0.5
10239, 0.3125, 1.1, 0.5
10240, 0.33333333333333, 1.125, 0.5
10241, 0.3125, 1.15, 0.5
10242, 0.33333333333333, 1.175, 0.5
10243, 0.3125, 1.2, 0.5
10244, 0.33333333333333, 1.225, 0.5
10245, 0.3125, 1.25, 0.5
10246, 0.33333333333333, 1.275, 0.5
10247, 0.3125, 1.3, 0.5
10248, 0.33333333333333, 1.325, 0.5
10249, 0.375, 0.175, 0.5
10250, 0.35416666666667, 0.2, 0.5
10251, 0.375, 0.225, 0.5
10252, 0.35416666666667, 0.25, 0.5
10253, 0.375, 0.275, 0.5
10254, 0.35416666666667, 0.3, 0.5
10255, 0.375, 0.325, 0.5
10256, 0.35416666666667, 0.35, 0.5
10257, 0.375, 0.375, 0.5
10258, 0.35416666666667, 0.4, 0.5
10259, 0.375, 0.425, 0.5
10260, 0.35416666666667, 0.45, 0.5
10261, 0.375, 0.475, 0.5
10262, 0.35416666666667, 0.5, 0.5
10263, 0.375, 0.525, 0.5
10264, 0.35416666666667, 0.55, 0.5
10265, 0.375, 0.575, 0.5
10266, 0.35416666666667, 0.6, 0.5
10267, 0.375, 0.625, 0.5
10268, 0.35416666666667, 0.65, 0.5
10269, 0.375, 0.675, 0.5
10270, 0.35416666666667, 0.7, 0.5
10271, 0.375, 0.725, 0.5
10272, 0.35416666666667, 0.75, 0.5
10273, 0.375, 0.775, 0.5
10274, 0.35416666666667, 0.8, 0.5
10275, 0.375, 0.825, 0.5
10276, 0.35416666666667, 0.85, 0.5
10277, 0.375, 0.875, 0.5
10278, 0.35416666666667, 0.9, 0.5
10279, 0.375, 0.925, 0.5
10280, 0.35416666666667, 0.95, 0.5
10281, 0.375, 0.975, 0.5
10282, 0.35416666666667, 1, 0.5
10283, 0.375, 1.025, 0.5
10284, 0.35416666666667, 1.05, 0.5
10285, 0.375, 1.075, 0.5
10286, 0.35416666666667, 1.1, 0.5
10287, 0.375, 1.125, 0.5
10288, 0.35416666666667, 1.15, 0.5
10289, 0.375, 1.175, 0.5
10290, 0.35416666666667, 1.2, 0.5
10291, 0.375, 1.225, 0.5
10292, 0.35416666666667, 1.25, 0.5
10293, 0.375, 1.275, 0.5
10294, 0.35416666666667, 1.3, 0.5
10295, 0.375, 1.325, 0.5
10296, 0.41666666666667, 0.175, 0.5
10297, 0.39583333333333, 0.2, 0.5
10298, 0.41666666666667, 0.225, 0.5
10299, 0.39583333333333, 0.25, 0.5
10300, 0.41666666666667, 0.275, 0.5
10301, 0.39583333333333, 0.3, 0.5
10302, 0.41666666666667, 0.325, 0.5
10303, 0.39583333333333, 0.35, 0.5
10304, 0.41666666666667, 0.375, 0.5
10305, 0.39583333333333, 0.4, 0.5
10306, 0.41666666666667, 0.425, 0.5
10307, 0.39583333333333, 0.45, 0.5
10308, 0.41666666666667, 0.475, 0.5
10309, 0.39583333333333, 0.5, 0.5
10310, 0.41666666666667, 0.525, 0.5
10311, 0.39583333333333, 0.55, 0.5
10312, 0.41666666666667, 0.575, 0.5
10313, 0.39583333333333, 0.6, 0.5
10314, 0.41666666666667, 0.625, 0.5
10315, 0.39583333333333, 0.65, 0.5
10316, 0.41666666666667, 0.675, 0.5
10317, 0.39583333333333, 0.7, 0.5
10318, 0.41666666666667, 0.725, 0.5
10319, 0.39583333333333, 0.75, 0.5
10320, 0.41666666666667, 0.775, 0.5
10321, 0.39583333333333, 0.8, 0.5
10322, 0.41666666666667, 0.825, 0.5
10323, 0.39583333333333, 0.85, 0.5
10324, 0.41666666666667, 0.875, 0.5
10325, 0.39583333333333, 0.9, 0.5
10326, 0.41666666666667, 0.925, 0.5
10327, 0.39583333333333, 0.95, 0.5
10328, 0.41666666666667, 0.975, 0.5
10329, 0.39583333333333, 1, 0.5
10330, 0.41666666666667, 1.025, 0.5
10331, 0.39583333333333, 1.05, 0.5
10332, 0.41666666666667, 1.075, 0.5
10333, 0.39583333333333, 1.1, 0.5
10334, 0.41666666666667, 1.125, 0.5
10335, 0.39583333333333, 1.15, 0.5
10336, 0.41666666666667, 1.175, 0.5
10337, 0.39583333333333, 1.2, 0.5
10338, 0.41666666666667, 1.225, 0.5
10339, 0.39583333333333, 1.25, 0.5
10340, 0.41666666666667, 1.275, 0.5
10341, 0.39583333333333, 1.3, 0.5
10342, 0.41666666666667, 1.325, 0.5
10343, 0.45833333333333, 0.175, 0.5
10344, 0.4375, 0.2, 0.5
10345, 0.45833333333333, 0.225, 0.5
10346, 0.4375, 0.25, 0.5
10347, 0.45833333333333, 0.275, 0.5
10348, 0.4375, 0.3, 0.5
10349, 0.45833333333333, 0.325, 0.5
10350, 0.4375, 0.35, 0.5
10351, 0.45833333333333, 0.375, 0.5
10352, 0.4375, 0.4, 0.5
10353, 0.45833333333333, 0.425, 0.5
10354, 0.4375, 0.45, 0.5
10355, 0.45833333333333, 0.475, 0.5
10356, 0.4375, 0.5, 0.5
10357, 0.45833333333333, 0.525, 0.5
10358, 0.4375, 0.55, 0.5
10359, 0.45833333333333, 0.575, 0.5
10360, 0.4375, 0.6, 0.5
10361, 0.45833333333333, 0.625, 0.5
10362, 0.4375, 0.65, 0.5
10363, 0.45833333333333, 0.675, 0.5
10364, 0.4375, 0.7, 0.5
10365, 0.45833333333333, 0.725, 0.5
10366, 0.4375, 0.75, 0.5
10367, 0.45833333333333, 0.775, 0.5
10368, 0.4375, 0.8, 0.5
10369, 0.45833333333333, 0.825, 0.5
10370, 0.4375, 0.85, 0.5
10371, 0.45833333333333, 0.875, 0.5
10372, 0.4375, 0.9, 0.5
10373, 0.45833333333333, 0.925, 0.5
10374, 0.4375, 0.95, 0.5
10375, 0.45833333333333, 0.975, 0.5
10376, 0.4375, 1, 0.5
10377, 0.45833333333333, 1.025, 0.5
10378, 0.4375, 1.05, 0.5
10379, 0.45833333333333, 1.075, 0.5
10380, 0.4375, 1.1, 0.5
10381, 0.45833333333333, 1.125, 0.5
10382, 0.4375, 1.15, 0.5
10383, 0.45833333333333, 1.175, 0.5
10384, 0.4375, 1.2, 0.5
10385, 0.45833333333333, 1.225, 0.5
10386, 0.4375, 1.25, 0.5
10387, 0.45833333333333, 1.275, 0.5
10388, 0.4375, 1.3, 0.5
10389, 0.45833333333333, 1.325, 0.5
10390, 0.5, 0.175, 0.5
10391, 0.47916666666667, 0.2, 0.5
10392, 0.5, 0.225, 0.5
10393, 0.47916666666667, 0.25, 0.5
10394, 0.5, 0.275, 0.5
10395, 0.47916666666667, 0.3, 0.5
10396, 0.5, 0.325, 0.5
10397, 0.47916666666667, 0.35, 0.5
10398, 0.5, 0.375, 0.5
10399, 0.47916666666667, 0.4, 0.5
10400, 0.5, 0.425, 0.5
10401, 0.47916666666667, 0.45, 0.5
10402, 0.5, 0.475, 0.5
10403, 0.47916666666667, 0.5, 0.5
10404, 0.5, 0.525, 0.5
10405, 0.47916666666667, 0.55, 0.5
10406, 0.5, 0.575, 0.5
10407, 0.47916666666667, 0.6, 0.5
10408, 0.5, 0.625, 0.5
10409, 0.47916666666667, 0.65, 0.5
10410, 0.5, 0.675, 0.5
10411, 0.47916666666667, 0.7, 0.5
10412, 0.5, 0.725, 0.5
10413, 0.47916666666667, 0.75, 0.5
10414, 0.5, 0.775, 0.5
10415, 0.47916666666667, 0.8, 0.5
10416, 0.5, 0.825, 0.5
10417, 0.47916666666667, 0.85, 0.5
10418, 0.5, 0.875, 0.5
10419, 0.47916666666667, 0.9, 0.5
10420, 0.5, 0.925, 0.5
10421, 0.47916666666667, 0.95, 0.5
10422, 0.5, 0.975, 0.5
10423, 0.47916666666667, 1, 0.5
10424, 0.5, 1.025, 0.5
10425, 0.47916666666667, 1.05, 0.5
10426, 0.5, 1.075, 0.5
10427, 0.47916666666667, 1.1, 0.5
10428, 0.5, 1.125, 0.5
10429, 0.47916666666667, 1.15, 0.5
10430, 0.5, 1.175, 0.5
10431, 0.47916666666667, 1.2, 0.5
10432, 0.5, 1.225, 0.5
10433, 0.47916666666667, 1.25, 0.5
10434, 0.5, 1.275, 0.5
10435, 0.47916666666667, 1.3, 0.5
10436, 0.5, 1.325, 0.5
10437, 0.54166666666667, 0.175, 0.5
10438, 0.52083333333333, 0.2, 0.5
10439, 0.54166666666667, 0.225, 0.5
10440, 0.52083333333333, 0.25, 0.5
10441, 0.54166666666667, 0.275, 0.5
10442, 0.52083333333333, 0.3, 0.5
10443, 0.54166666666667, 0.325, 0.5
10444, 0.52083333333333, 0.35, 0.5
10445, 0.54166666666667, 0.375, 0.5
10446, 0.52083333333333, 0.4, 0.5
10447, 0.54166666666667, 0.425, 0.5
10448, 0.52083333333333, 0.45, 0.5
10449, 0.54166666666667, 0.475, 0.5
10450, 0.52083333333333, 0.5, 0.5
10451, 0.54166666666667, 0.525, 0.5
10452, 0.52083333333333, 0.55, 0.5
10453, 0.54166666666667, 0.575, 0.5
10454, 0.52083333333333, 0.6, 0.5
10455, 0.54166666666667, 0.625, 0.5
10456, 0.52083333333333, 0.65, 0.5
10457, 0.54166666666667, 0.675, 0.5
10458, 0.52083333333333, 0.7, 0.5
10459, 0.54166666666667, 0.725, 0.5
10460, 0.52083333333333, 0.75, 0.5
10461, 0.54166666666667, 0.775, 0.5
10462, 0.52083333333333, 0.8, 0.5
10463, 0.54166666666667, 0.825, 0.5
10464, 0.52083333333333, 0.85, 0.5
10465, 0.54166666666667, 0.875, 0.5
10466, 0.52083333333333, 0.9, 0.5
10467, 0.54166666666667, 0.925, 0.5
10468, 0.52083333333333, 0.95, 0.5
10469, 0.54166666666667, 0.975, 0.5
10470, 0.52083333333333, 1, 0.5
10471, 0.54166666666667, 1.025, 0.5
10472, 0.52083333333333, 1.05, 0.5
10473, 0.54166666666667, 1.075, 0.5
10474, 0.52083333333333, 1.1, 0.5
10475, 0.54166666666667, 1.125, 0.5
10476, 0.52083333333333, 1.15, 0.5
10477, 0.54166666666667, 1.175, 0.5
10478, 0.52083333333333, 1.2, 0.5
10479, 0.54166666666667, 1.225, 0.5
10480, 0.52083333333333, 1.25, 0.5
10481, 0.54166666666667, 1.275, 0.5
10482, 0.52083333333333, 1.3, 0.5
10483, 0.54166666666667, 1.325, 0.5
10484, 0.58333333333333, 0.175, 0.5
10485, 0.5625, 0.2, 0.5
10486, 0.58333333333333, 0.225, 0.5
10487, 0.5625, 0.25, 0.5
10488, 0.58333333333333, 0.275, 0.5
10489, 0.5625, 0.3, 0.5
10490, 0.58333333333333, 0.325, 0.5
10491, 0.5625, 0.35, 0.5
10492, 0.58333333333333, 0.375, 0.5
10493, 0.5625, 0.4, 0.5
10494, 0.58333333333333, 0.425, 0.5
10495, 0.5625, 0.45, 0.5
10496, 0.58333333333333, 0.475, 0.5
10497, 0.5625, 0.5, 0.5
10498, 0.58333333333333, 0.525, 0.5
10499, 0.5625, 0.55, 0.5
10500, 0.58333333333333, 0.575, 0.5
10501, 0.5625, 0.6, 0.5
10502, 0.58333333333333, 0.625, 0.5
10503, 0.5625, 0.65, 0.5
10504, 0.58333333333333, 0.675, 0.5
10505, 0.5625, 0.7, 0.5
10506, 0.58333333333333, 0.725, 0.5
10507, 0.5625, 0.75, 0.5
10508, 0.58333333333333, 0.775, 0.5
10509, 0.5625, 0.8, 0.5
10510, 0.58333333333333, 0.825, 0.5
10511, 0.5625, 0.85, 0.5
10512, 0.58333333333333, 0.875, 0.5
10513, 0.5625, 0.9, 0.5
10514, 0.58333333333333, 0.925, 0.5
10515, 0.5625, 0.95, 0.5
10516, 0.58333333333333, 0.975, 0.5
10517, 0.5625, 1, 0.5
10518, 0.58333333333333, 1.025, 0.5
10519, 0.5625, 1.05, 0.5
10520, 0.58333333333333, 1.075, 0.5
10521, 0.5625, 1.1, 0.5
10522, 0.58333333333333, 1.125, 0.5
10523, 0.5625, 1.15, 0.5
10524, 0.58333333333333, 1.175, 0.5
10525, 0.5625, 1.2, 0.5
10526, 0.58333333333333, 1.225, 0.5
10527, 0.5625, 1.25, 0.5
10528, 0.58333333333333, 1.275, 0.5
10529, 0.5625, 1.3, 0.5
10530, 0.58333333333333, 1.325, 0.5
10531, 0.625, 0.175, 0.5
10532, 0.60416666666667, 0.2, 0.5
10533, 0.625, 0.225, 0.5
10534, 0.60416666666667, 0.25, 0.5
10535, 0.625, 0.275, 0.5
10536, 0.60416666666667, 0.3, 0.5
10537, 0.625, 0.325, 0.5
10538, 0.60416666666667, 0.35, 0.5
10539, 0.625, 0.375, 0.5
10540, 0.60416666666667, 0.4, 0.5
10541, 0.625, 0.425, 0.5
10542, 0.60416666666667, 0.45, 0.5
10543, 0.625, 0.475, 0.5
10544, 0.60416666666667, 0.5, 0.5
10545, 0.625, 0.525, 0.5
10546, 0.60416666666667, 0.55, 0.5
10547, 0.625, 0.575, 0.5
10548, 0.60416666666667, 0.6, 0.5
10549, 0.625, 0.625, 0.5
10550, 0.60416666666667, 0.65, 0.5
10551, 0.625, 0.675, 0.5
10552, 0.60416666666667, 0.7, 0.5
10553, 0.625, 0.725, 0.5
10554, 0.60416666666667, 0.75, 0.5
10555, 0.625, 0.775, 0.5
10556, 0.60416666666667, 0.8, 0.5
10557, 0.625, 0.825, 0.5
10558, 0.60416666666667, 0.85, 0.5
10559, 0.625, 0.875, 0.5
10560, 0.60416666666667, 0.9, 0.5
10561, 0.625, 0.925, 0.5
10562, 0.60416666666667, 0.95, 0.5
10563, 0.625, 0.975, 0.5
10564, 0.60416666666667, 1, 0.5
10565, 0.625, 1.025, 0.5
10566, 0.60416666666667, 1.05, 0.5
10567, 0.625, 1.075, 0.5
10568, 0.60416666666667, 1.1, 0.5
10569, 0.625, 1.125, 0.5
10570, 0.60416666666667, 1.15, 0.5
10571, 0.625, 1.175, 0.5
10572, 0.60416666666667, 1.2, 0.5
10573, 0.625, 1.225, 0.5
10574, 0.60416666666667, 1.25, 0.5
10575, 0.625, 1.275, 0.5
10576, 0.60416666666667, 1.3, 0.5
10577, 0.625, 1.325, 0.5
10578, 0.66666666666667, 0.175, 0.5
10579, 0.64583333333333, 0.2, 0.5
10580, 0.66666666666667, 0.225, 0.5
10581, 0.64583333333333, 0.25, 0.5
10582, 0.66666666666667, 0.275, 0.5
10583, 0.64583333333333, 0.3, 0.5
10584, 0.66666666666667, 0.325, 0.5
10585, 0.64583333333333, 0.35, 0.5
10586, 0.66666666666667, 0.375, 0.5
10587, 0.64583333333333, 0.4, 0.5
10588, 0.66666666666667, 0.425, 0.5
10589, 0.64583333333333, 0.45, 0.5
10590, 0.66666666666667, 0.475, 0.5
10591, 0.64583333333333, 0.5, 0.5
10592, 0.66666666666667, 0.525, 0.5
10593, 0.64583333333333, 0.55, 0.5
10594, 0.66666666666667, 0.575, 0.5
10595, 0.64583333333333, 0.6, 0.5
10596, 0.66666666666667, 0.625, 0.5
10597, 0.64583333333333, 0.65, 0.5
10598, 0.66666666666667, 0.675, 0.5
10599, 0.64583333333333, 0.7, 0.5
10600, 0.66666666666667, 0.725, 0.5
10601, 0.64583333333333, 0.75, 0.5
10602, 0.66666666666667, 0.775, 0.5
10603, 0.64583333333333, 0.8, 0.5
10604, 0.66666666666667, 0.825, 0.5
10605, 0.64583333333333, 0.85, 0.5
10606, 0.66666666666667, 0.875, 0.5
10607, 0.64583333333333, 0.9, 0.5
10608, 0.66666666666667, 0.925, 0.5
10609, 0.64583333333333, 0.95, 0.5
10610, 0.66666666666667, 0.975, 0.5
10611, 0.64583333333333, 1, 0.5
10612, 0.66666666666667, 1.025, 0.5
10613, 0.64583333333333, 1.05, 0.5
10614, 0.66666666666667, 1.075, 0.5
10615, 0.64583333333333, 1.1, 0.5
10616, 0.66666666666667, 1.125, 0.5
10617, 0.64583333333333, 1.15, 0.5
10618, 0.66666666666667, 1.175, 0.5
10619, 0.64583333333333, 1.2, 0.5
10620, 0.66666666666667, 1.225, 0.5
10621, 0.64583333333333, 1.25, 0.5
10622, 0.66666666666667, 1.275, 0.5
10623, 0.64583333333333, 1.3, 0.5
10624, 0.66666666666667, 1.325, 0.5
10625, 0.70833333333333, 0.175, 0.5
10626, 0.6875, 0.2, 0.5
10627, 0.70833333333333, 0.225, 0.5
10628, 0.6875, 0.25, 0.5
10629, 0.70833333333333, 0.275, 0.5
10630, 0.6875, 0.3, 0.5
10631, 0.70833333333333, 0.325, 0.5
10632, 0.6875, 0.35, 0.5
10633, 0.70833333333333, 0.375, 0.5
10634, 0.6875, 0.4, 0.5
10635, 0.70833333333333, 0.425, 0.5
10636, 0.6875, 0.45, 0.5
10637, 0.70833333333333, 0.475, 0.5
10638, 0.6875, 0.5, 0.5
10639, 0.70833333333333, 0.525, 0.5
10640, 0.6875, 0.55, 0.5
10641, 0.70833333333333, 0.575, 0.5
10642, 0.6875, 0.6, 0.5
10643, 0.70833333333333, 0.625, 0.5
10644, 0.6875, 0.65, 0.5
10645, 0.70833333333333, 0.675, 0.5
10646, 0.6875, 0.7, 0.5
10647, 0.70833333333333, 0.725, 0.5
10648, 0.6875, 0.75, 0.5
10649, 0.70833333333333, 0.775, 0.5
10650, 0.6875, 0.8, 0.5
10651, 0.70833333333333, 0.825, 0.5
10652, 0.6875, 0.85, 0.5
10653, 0.70833333333333, 0.875, 0.5
10654, 0.6875, 0.9, 0.5
10655, 0.70833333333333, 0.925, 0.5
10656, 0.6875, 0.95, 0.5
10657, 0.70833333333333, 0.975, 0.5
10658, 0.6875, 1, 0.5
10659, 0.70833333333333, 1.025, 0.5
10660, 0.6875, 1.05, 0.5
10661, 0.70833333333333, 1.075, 0.5
10662, 0.6875, 1.1, 0.5
10663, 0.70833333333333, 1.125, 0.5
10664, 0.6875, 1.15, 0.5
10665, 0.70833333333333, 1.175, 0.5
10666, 0.6875, 1.2, 0.5
10667, 0.70833333333333, 1.225, 0.5
10668, 0.6875, 1.25, 0.5
10669, 0.70833333333333, 1.275, 0.5
10670, 0.6875, 1.3, 0.5
10671, 0.70833333333333, 1.325, 0.5
10672, 0.75, 0.175, 0.5
10673, 0.72916666666667, 0.2, 0.5
10674, 0.75, 0.225, 0.5
10675, 0.72916666666667, 0.25, 0.5
10676, 0.75, 0.275, 0.5
10677, 0.72916666666667, 0.3, 0.5
10678, 0.75, 0.325, 0.5
10679, 0.72916666666667, 0.35, 0.5
10680, 0.75, 0.375, 0.5
10681, 0.72916666666667, 0.4, 0.5
10682, 0.75, 0.425, 0.5
10683, 0.72916666666667, 0.45, 0.5
10684, 0.75, 0.475, 0.5
10685, 0.72916666666667, 0.5, 0.5
10686, 0.75, 0.525, 0.5
10687, 0.72916666666667, 0.55, 0.5
10688, 0.75, 0.575, 0.5
10689, 0.72916666666667, 0.6, 0.5
10690, 0.75, 0.625, 0.5
10691, 0.72916666666667, 0.65, 0.5
10692, 0.75, 0.675, 0.5
10693, 0.72916666666667, 0.7, 0.5
10694, 0.75, 0.725, 0.5
10695, 0.72916666666667, 0.75, 0.5
10696, 0.75, 0.775, 0.5
10697, 0.72916666666667, 0.8, 0.5
10698, 0.75, 0.825, 0.5
10699, 0.72916666666667, 0.85, 0.5
10700, 0.75, 0.875, 0.5
10701, 0.72916666666667, 0.9, 0.5
10702, 0.75, 0.925, 0.5
10703, 0.72916666666667, 0.95, 0.5
10704, 0.75, 0.975, 0.5
10705, 0.72916666666667, 1, 0.5
10706, 0.75, 1.025, 0.5
10707, 0.72916666666667, 1.05, 0.5
10708, 0.75, 1.075, 0.5
10709, 0.72916666666667, 1.1, 0.5
10710, 0.75, 1.125, 0.5
10711, 0.72916666666667, 1.15, 0.5
10712, 0.75, 1.175, 0.5
10713, 0.72916666666667, 1.2, 0.5
10714, 0.75, 1.225, 0.5
10715, 0.72916666666667, 1.25, 0.5
10716, 0.75, 1.275, 0.5
10717, 0.72916666666667, 1.3, 0.5
10718, 0.75, 1.325, 0.5
10719, 0.79166666666667, 0.175, 0.5
10720, 0.77083333333333, 0.2, 0.5
10721, 0.79166666666667, 0.225, 0.5
10722, 0.77083333333333, 0.25, 0.5
10723, 0.79166666666667, 0.275, 0.5
10724, 0.77083333333333, 0.3, 0.5
10725, 0.79166666666667, 0.325, 0.5
10726, 0.77083333333333, 0.35, 0.5
10727, 0.79166666666667, 0.375, 0.5
10728, 0.77083333333333, 0.4, 0.5
10729, 0.79166666666667, 0.425, 0.5
10730, 0.77083333333333, 0.45, 0.5
10731, 0.79166666666667, 0.475, 0.5
10732, 0.77083333333333, 0.5, 0.5
10733, 0.79166666666667, 0.525, 0.5
10734, 0.77083333333333, 0.55, 0.5
10735, 0.79166666666667, 0.575, 0.5
10736, 0.77083333333333, 0.6, 0.5
10737, 0.79166666666667, 0.625, 0.5
10738, 0.77083333333333, 0.65, 0.5
10739, 0.79166666666667, 0.675, 0.5
10740, 0.77083333333333, 0.7, 0.5
10741, 0.79166666666667, 0.725, 0.5
10742, 0.77083333333333, 0.75, 0.5
10743, 0.79166666666667, 0.775, 0.5
10744, 0.77083333333333, 0.8, 0.5
10745, 0.79166666666667, 0.825, 0.5
10746, 0.77083333333333, 0.85, 0.5
10747, 0.79166666666667, 0.875, 0.5
10748, 0.77083333333333, 0.9, 0.5
10749, 0.79166666666667, 0.925, 0.5
10750, 0.77083333333333, 0.95, 0.5
10751, 0.79166666666667, 0.975, 0.5
10752, 0.77083333333333, 1, 0.5
10753, 0.79166666666667, 1.025, 0.5
10754, 0.77083333333333, 1.05, 0.5
10755, 0.79166666666667, 1.075, 0.5
10756, 0.77083333333333, 1.1, 0.5
10757, 0.79166666666667, 1.125, 0.5
10758, 0.77083333333333, 1.15, 0.5
10759, 0.79166666666667, 1.175, 0.5
10760, 0.77083333333333, 1.2, 0.5
10761, 0.79166666666667, 1.225, 0.5
10762, 0.77083333333333, 1.25, 0.5
10763, 0.79166666666667, 1.275, 0.5
10764, 0.77083333333333, 1.3, 0.5
10765, 0.79166666666667, 1.325, 0.5
10766, 0.83333333333333, 0.175, 0.5
10767, 0.8125, 0.2, 0.5
10768, 0.83333333333333, 0.225, 0.5
10769, 0.8125, 0.25, 0.5
10770, 0.83333333333333, 0.275, 0.5
10771, 0.8125, 0.3, 0.5
10772, 0.83333333333333, 0.325, 0.5
10773, 0.8125, 0.35, 0.5
10774, 0.83333333333333, 0.375, 0.5
10775, 0.8125, 0.4, 0.5
10776, 0.83333333333333, 0.425, 0.5
10777, 0.8125, 0.45, 0.5
10778, 0.83333333333333, 0.475, 0.5
10779, 0.8125, 0.5, 0.5
10780, 0.83333333333333, 0.525, 0.5
10781, 0.8125, 0.55, 0.5
10782, 0.83333333333333, 0.575, 0.5
10783, 0.8125, 0.6, 0.5
10784, 0.83333333333333, 0.625, 0.5
10785, 0.8125, 0.65, 0.5
10786, 0.83333333333333, 0.675, 0.5
10787, 0.8125, 0.7, 0.5
10788, 0.83333333333333, 0.725, 0.5
10789, 0.8125, 0.75, 0.5
10790, 0.83333333333333, 0.775, 0.5
10791, 0.8125, 0.8, 0.5
10792, 0.83333333333333, 0.825, 0.5
10793, 0.8125, 0.85, 0.5
10794, 0.83333333333333, 0.875, 0.5
10795, 0.8125, 0.9, 0.5
10796, 0.83333333333333, 0.925, 0.5
10797, 0.8125, 0.95, 0.5
10798, 0.83333333333333, 0.975, 0.5
10799, 0.8125, 1, 0.5
10800, 0.83333333333333, 1.025, 0.5
10801, 0.8125, 1.05, 0.5
10802, 0.83333333333333, 1.075, 0.5
10803, 0.8125, 1.1, 0.5
10804, 0.83333333333333, 1.125, 0.5
10805, 0.8125, 1.15, 0.5
10806, 0.83333333333333, 1.175, 0.5
10807, 0.8125, 1.2, 0.5
10808, 0.83333333333333, 1.225, 0.5
10809, 0.8125, 1.25, 0.5
10810, 0.83333333333333, 1.275, 0.5
10811, 0.8125, 1.3, 0.5
10812, 0.83333333333333, 1.325, 0.5
10813, 0.875, 0.175, 0.5
10814, 0.85416666666667, 0.2, 0.5
10815, 0.875, 0.225, 0.5
10816, 0.85416666666667, 0.25, 0.5
10817, 0.875, 0.275, 0.5
10818, 0.85416666666667, 0.3, 0.5
10819, 0.875, 0.325, 0.5
10820, 0.85416666666667, 0.35, 0.5
10821, 0.875, 0.375, 0.5
10822, 0.85416666666667, 0.4, 0.5
10823, 0.875, 0.425, 0.5
10824, 0.85416666666667, 0.45, 0.5
10825, 0.875, 0.475, 0.5
10826, 0.85416666666667, 0.5, 0.5
10827, 0.875, 0.525, 0.5
10828, 0.85416666666667, 0.55, 0.5
10829, 0.875, 0.575, 0.5
10830, 0.85416666666667, 0.6, 0.5
10831, 0.875, 0.625, 0.5
10832, 0.85416666666667, 0.65, 0.5
10833, 0.875, 0.675, 0.5
10834, 0.85416666666667, 0.7, 0.5
10835, 0.875, 0.725, 0.5
10836, 0.85416666666667, 0.75, 0.5
10837, 0.875, 0.775, 0.5
10838, 0.85416666666667, 0.8, 0.5
10839, 0.875, 0.825, 0.5
10840, 0.85416666666667, 0.85, 0.5
10841, 0.875, 0.875, 0.5
10842, 0.85416666666667, 0.9, 0.5
10843, 0.875, 0.925, 0.5
10844, 0.85416666666667, 0.95, 0.5
10845, 0.875, 0.975, 0.5
10846, 0.85416666666667, 1, 0.5
10847, 0.875, 1.025, 0.5
10848, 0.85416666666667, 1.05, 0.5
10849, 0.875, 1.075, 0.5
10850, 0.85416666666667, 1.1, 0.5
10851, 0.875, 1.125, 0.5
10852, 0.85416666666667, 1.15, 0.5
10853, 0.875, 1.175, 0.5
10854, 0.85416666666667, 1.2, 0.5
10855, 0.875, 1.225, 0.5
10856, 0.85416666666667, 1.25, 0.5
10857, 0.875, 1.275, 0.5
10858, 0.85416666666667, 1.3, 0.5
10859, 0.875, 1.325, 0.5
10860, 0.91666666666667, 0.175, 0.5
10861, 0.89583333333333, 0.2, 0.5
10862, 0.91666666666667, 0.225, 0.5
10863, 0.89583333333333, 0.25, 0.5
10864, 0.91666666666667, 0.275, 0.5
10865, 0.89583333333333, 0.3, 0.5
10866, 0.91666666666667, 0.325, 0.5
10867, 0.89583333333333, 0.35, 0.5
10868, 0.91666666666667, 0.375, 0.5
10869, 0.89583333333333, 0.4, 0.5
10870, 0.91666666666667, 0.425, 0.5
10871, 0.89583333333333, 0.45, 0.5
10872, 0.91666666666667, 0.475, 0.5
10873, 0.89583333333333, 0.5, 0.5
10874, 0.91666666666667, 0.525, 0.5
10875, 0.89583333333333, 0.55, 0.5
10876, 0.91666666666667, 0.575, 0.5
10877, 0.89583333333333, 0.6, 0.5
10878, 0.91666666666667, 0.625, 0.5
10879, 0.89583333333333, 0.65, 0.5
10880, 0.91666666666667, 0.675, 0.5
10881, 0.89583333333333, 0.7, 0.5
10882, 0.91666666666667, 0.725, 0.5
10883, 0.89583333333333, 0.75, 0.5
10884, 0.91666666666667, 0.775, 0.5
10885, 0.89583333333333, 0.8, 0.5
10886, 0.91666666666667, 0.825, 0.5
10887, 0.89583333333333, 0.85, 0.5
10888, 0.91666666666667, 0.875, 0.5
10889, 0.89583333333333, 0.9, 0.5
10890, 0.91666666666667, 0.925, 0.5
10891, 0.89583333333333, 0.95, 0.5
10892, 0.91666666666667, 0.975, 0.5
10893, 0.89583333333333, 1, 0.5
10894, 0.91666666666667, 1.025, 0.5
10895, 0.89583333333333, 1.05, 0.5
10896, 0.91666666666667, 1.075, 0.5
10897, 0.89583333333333, 1.1, 0.5
10898, 0.91666666666667, 1.125, 0.5
10899, 0.89583333333333, 1.15, 0.5
10900, 0.91666666666667, 1.175, 0.5
10901, 0.89583333333333, 1.2, 0.5
10902, 0.91666666666667, 1.225, 0.5
10903, 0.89583333333333, 1.25, 0.5
10904, 0.91666666666667, 1.275, 0.5
10905, 0.89583333333333, 1.3, 0.5
10906, 0.91666666666667, 1.325, 0.5
10907, 0.95833333333333, 0.175, 0.5
10908, 0.9375, 0.2, 0.5
10909, 0.95833333333333, 0.225, 0.5
10910, 0.9375, 0.25, 0.5
10911, 0.95833333333333, 0.275, 0.5
10912, 0.9375, 0.3, 0.5
10913, 0.95833333333333, 0.325, 0.5
10914, 0.9375, 0.35, 0.5
10915, 0.95833333333333, 0.375, 0.5
10916, 0.9375, 0.4, 0.5
10917, 0.95833333333333, 0.425, 0.5
10918, 0.9375, 0.45, 0.5
10919, 0.95833333333333, 0.475, 0.5
10920, 0.9375, 0.5, 0.5
10921, 0.95833333333333, 0.525, 0.5
10922, 0.9375, 0.55, 0.5
10923, 0.95833333333333, 0.575, 0.5
10924, 0.9375, 0.6, 0.5
10925, 0.95833333333333, 0.625, 0.5
10926, 0.9375, 0.65, 0.5
10927, 0.95833333333333, 0.675, 0.5
10928, 0.9375, 0.7, 0.5
10929, 0.95833333333333, 0.725, 0.5
10930, 0.9375, 0.75, 0.5
10931, 0.95833333333333, 0.775, 0.5
10932, 0.9375, 0.8, 0.5
10933, 0.95833333333333, 0.825, 0.5
10934, 0.9375, 0.85, 0.5
10935, 0.95833333333333, 0.875, 0.5
10936, 0.9375, 0.9, 0.5
10937, 0.95833333333333, 0.925, 0.5
10938, 0.9375, 0.95, 0.5
10939, 0.95833333333333, 0.975, 0.5
10940, 0.9375, 1, 0.5
10941, 0.95833333333333, 1.025, 0.5
10942, 0.9375, 1.05, 0.5
10943, 0.95833333333333, 1.075, 0.5
10944, 0.9375, 1.1, 0.5
10945, 0.95833333333333, 1.125, 0.5
10946, 0.9375, 1.15, 0.5
10947, 0.95833333333333, 1.175, 0.5
10948, 0.9375, 1.2, 0.5
10949, 0.95833333333333, 1.225, 0.5
10950, 0.9375, 1.25, 0.5
10951, 0.95833333333333, 1.275, 0.5
10952, 0.9375, 1.3, 0.5
10953, 0.95833333333333, 1.325, 0.5
10954, 0.97916666666667, 0.2, 0.5
10955, 0.97916666666667, 0.25, 0.5
10956, 0.97916666666667, 0.3, 0.5
10957, 0.97916666666667, 0.35, 0.5
10958, 0.97916666666667, 0.4, 0.5
10959, 0.97916666666667, 0.45, 0.5
10960, 0.97916666666667, 0.5, 0.5
10961, 0.97916666666667, 0.55, 0.5
10962, 0.97916666666667, 0.6, 0.5
10963, 0.97916666666667, 0.65, 0.5
10964, 0.97916666666667, 0.7, 0.5
10965, 0.97916666666667, 0.75, 0.5
10966, 0.97916666666667, 0.8, 0.5
10967, 0.97916666666667, 0.85, 0.5
10968, 0.97916666666667, 0.9, 0.5
10969, 0.97916666666667, 0.95, 0.5
10970, 0.97916666666667, 1, 0.5
10971, 0.97916666666667, 1.05, 0.5
10972, 0.97916666666667, 1.1, 0.5
10973, 0.97916666666667, 1.15, 0.5
10974, 0.97916666666667, 1.2, 0.5
10975, 0.97916666666667, 1.25, 0.5
10976, 0.97916666666667, 1.3, 0.5
10977, 0, 0.2, 0.041666666666667
10978, 0, 0.25, 0.041666666666667
10979, 0, 0.3, 0.041666666666667
10980, 0, 0.35, 0.041666666666667
10981, 0, 0.4, 0.041666666666667
10982, 0, 0.45, 0.041666666666667
10983, 0, 0.5, 0.041666666666667
10984, 0, 0.55, 0.041666666666667
10985, 0, 0.6, 0.041666666666667
10986, 0, 0.65, 0.041666666666667
10987, 0, 0.7, 0.041666666666667
10988, 0, 0.75, 0.041666666666667
10989, 0, 0.8, 0.041666666666667
10990, 0, 0.85, 0.041666666666667
10991, 0, 0.9, 0.041666666666667
10992, 0, 0.95, 0.041666666666667
10993, 0, 1, 0.041666666666667
10994, 0, 1.05, 0.041666666666667
10995, 0, 1.1, 0.041666666666667
10996, 0, 1.15, 0.041666666666667
10997, 0, 1.2, 0.041666666666667
10998, 0, 1.25, 0.041666666666667
10999, 0, 1.3, 0.041666666666667
11000, 0, 0.2, 0.083333333333333
11001, 0, 0.25, 0.083333333333333
11002, 0, 0.3, 0.083333333333333
11003, 0, 0.35, 0.083333333333333
11004, 0, 0.4, 0.083333333333333
11005, 0, 0.45, 0.083333333333333
11006, 0, 0.5, 0.083333333333333
11007, 0, 0.55, 0.083333333333333
11008, 0, 0.6, 0.083333333333333
11009, 0, 0.65, 0.083333333333333
11010, 0, 0.7, 0.083333333333333
11011, 0, 0.75, 0.083333333333333
11012, 0, 0.8, 0.083333333333333
11013, 0, 0.85, 0.083333333333333
11014, 0, 0.9, 0.083333333333333
11015, 0, 0.95, 0.083333333333333
11016, 0, 1, 0.083333333333333
11017, 0, 1.05, 0.083333333333333
11018, 0, 1.1, 0.083333333333333
11019, 0, 1.15, 0.083333333333333
11020, 0, 1.2, 0.083333333333333
11021, 0, 1.25, 0.083333333333333
11022, 0, 1.3, 0.083333333333333
11023, 0, 0.2, 0.125
11024, 0, 0.25, 0.125
11025, 0, 0.3, 0.125
11026, 0, 0.35, 0.125
11027, 0, 0.4, 0.125
11028, 0, 0.45, 0.125
11029, 0, 0.5, 0.125
11030, 0, 0.55, 0.125
11031, 0, 0.6, 0.125
11032, 0, 0.65, 0.125
11033, 0, 0.7, 0.125
11034, 0, 0.75, 0.125
11035, 0, 0.8, 0.125
11036, 0, 0.85, 0.125
11037, 0, 0.9, 0.125
11038, 0, 0.95, 0.125
11039, 0, 1, 0.125
11040, 0, 1.05, 0.125
11041, 0, 1.1, 0.125
11042, 0, 1.15, 0.125
11043, 0, 1.2, 0.125
11044, 0, 1.25, 0.125
11045, 0, 1.3, 0.125
11046, 0, 0.2, 0.16666666666667
11047, 0, 0.25, 0.16666666666667
11048, 0, 0.3, 0.16666666666667
11049, 0, 0.35, 0.16666666666667
11050, 0, 0.4, 0.16666666666667
11051, 0, 0.45, 0.16666666666667
11052, 0, 0.5, 0.16666666666667
11053, 0, 0.55, 0.16666666666667
11054, 0, 0.6, 0.16666666666667
11055, 0, 0.65, 0.16666666666667
11056, 0, 0.7, 0.16666666666667
11057, 0, 0.75, 0.16666666666667
11058, 0, 0.8, 0.16666666666667
11059, 0, 0.85, 0.16666666666667
11060, 0, 0.9, 0.16666666666667
11061, 0, 0.95, 0.16666666666667
11062, 0, 1, 0.16666666666667
11063, 0, 1.05, 0.16666666666667
11064, 0, 1.1, 0.16666666666667
11065, 0, 1.15, 0.16666666666667
11066, 0, 1.2, 0.16666666666667
11067, 0, 1.25, 0.16666666666667
11068, 0, 1.3, 0.16666666666667
11069, 0, 0.2, 0.20833333333333
11070, 0, 0.25, 0.20833333333333
11071, 0, 0.3, 0.20833333333333
11072, 0, 0.35, 0.20833333333333
11073, 0, 0.4, 0.20833333333333
11074, 0, 0.45, 0.20833333333333
11075, 0, 0.5, 0.20833333333333
11076, 0, 0.55, 0.20833333333333
11077, 0, 0.6, 0.20833333333333
11078, 0, 0.65, 0.20833333333333
11079, 0, 0.7, 0.20833333333333
11080, 0, 0.75, 0.20833333333333
11081, 0, 0.8, 0.20833333333333
11082, 0, 0.85, 0.20833333333333
11083, 0, 0.9, 0.20833333333333
11084, 0, 0.95, 0.20833333333333
11085, 0, 1, 0.20833333333333
11086, 0, 1.05, 0.20833333333333
11087, 0, 1.1, 0.20833333333333
11088, 0, 1.15, 0.20833333333333
11089, 0, 1.2, 0.20833333333333
11090, 0, 1.25, 0.20833333333333
11091, 0, 1.3, 0.20833333333333
11092, 0, 0.2, 0.25
11093, 0, 0.25, 0.25
11094, 0, 0.3, 0.25
11095, 0, 0.35, 0.25
11096, 0, 0.4, 0.25
11097, 0, 0.45, 0.25
11098, 0, 0.5, 0.25
11099, 0, 0.55, 0.25
11100, 0, 0.6, 0.25
11101, 0, 0.65, 0.25
11102, 0, 0.7, 0.25
11103, 0, 0.75, 0.25
11104, 0, 0.8, 0.25
11105, 0, 0.85, 0.25
11106, 0, 0.9, 0.25
11107, 0, 0.95, 0.25
11108, 0, 1, 0.25
11109, 0, 1.05, 0.25
11110, 0, 1.1, 0.25
11111, 0, 1.15, 0.25
11112, 0, 1.2, 0.25
11113, 0, 1.25, 0.25
11114, 0, 1.3, 0.25
11115, 0, 0.2, 0.29166666666667
11116, 0, 0.25, 0.29166666666667
11117, 0, 0.3, 0.29166666666667
11118, 0, 0.35, 0.29166666666667
11119, 0, 0.4, 0.29166666666667
11120, 0, 0.45, 0.29166666666667
11121, 0, 0.5, 0.29166666666667
11122, 0, 0.55, 0.29166666666667
11123, 0, 0.6, 0.29166666666667
11124, 0, 0.65, 0.29166666666667
11125, 0, 0.7, 0.29166666666667
11126, 0, 0.75, 0.29166666666667
11127, 0, 0.8, 0.29166666666667
11128, 0, 0.85, 0.29166666666667
11129, 0, 0.9, 0.29166666666667
11130, 0, 0.95, 0.29166666666667
11131, 0, 1, 0.29166666666667
11132, 0, 1.05, 0.29166666666667
11133, 0, 1.1, 0.29166666666667
11134, 0, 1.15, 0.29166666666667
11135, 0, 1.2, 0.29166666666667
11136, 0, 1.25, 0.29166666666667
11137, 0, 1.3, 0.29166666666667
11138, 0, 0.2, 0.33333333333333
11139, 0, 0.25, 0.33333333333333
11140, 0, 0.3, 0.33333333333333
11141, 0, 0.35, 0.33333333333333
11142, 0, 0.4, 0.33333333333333
11143, 0, 0.45, 0.33333333333333
11144, 0, 0.5, 0.33333333333333
11145, 0, 0.55, 0.33333333333333
11146, 0, 0.6, 0.33333333333333
11147, 0, 0.65, 0.33333333333333
11148, 0, 0.7, 0.33333333333333
11149, 0, 0.75, 0.33333333333333
11150, 0, 0.8, 0.33333333333333
11151, 0, 0.85, 0.33333333333333
11152, 0, 0.9, 0.33333333333333
11153, 0, 0.95, 0.33333333333333
11154, 0, 1, 0.33333333333333
11155, 0, 1.05, 0.33333333333333
11156, 0, 1.1, 0.33333333333333
11157, 0, 1.15, 0.33333333333333
11158, 0, 1.2, 0.33333333333333
11159, 0, 1.25, 0.33333333333333
11160, 0, 1.3, 0.33333333333333
11161, 0, 0.2, 0.375
11162, 0, 0.25, 0.375
11163, 0, 0.3, 0.375
11164, 0, 0.35, 0.375
11165, 0, 0.4, 0.375
11166, 0, 0.45, 0.375
11167, 0, 0.5, 0.375
11168, 0, 0.55, 0.375
11169, 0, 0.6, 0.375
11170, 0, 0.65, 0.375
11171, 0, 0.7, 0.375
11172, 0, 0.75, 0.375
11173, 0, 0.8, 0.375
11174, 0, 0.85, 0.375
11175, 0, 0.9, 0.375
11176, 0, 0.95, 0.375
11177, 0, 1, 0.375
11178, 0, 1.05, 0.375
11179, 0, 1.1, 0.375
11180, 0, 1.15, 0.375
11181, 0, 1.2, 0.375
11182, 0, 1.25, 0.375
11183, 0, 1.3, 0.375
11184, 0, 0.2, 0.41666666666667
11185, 0, 0.25, 0.41666666666667
11186, 0, 0.3, 0.41666666666667
11187, 0, 0.35, 0.41666666666667
11188, 0, 0.4, 0.41666666666667
11189, 0, 0.45, 0.41666666666667
11190, 0, 0.5, 0.41666666666667
11191, 0, 0.55, 0.41666666666667
11192, 0, 0.6, 0.41666666666667
11193, 0, 0.65, 0.41666666666667
11194, 0, 0.7, 0.41666666666667
11195, 0, 0.75, 0.41666666666667
11196, 0, 0.8, 0.41666666666667
11197, 0, 0.85, 0.41666666666667
11198, 0, 0.9, 0.41666666666667
11199, 0, 0.95, 0.41666666666667
11200, 0, 1, 0.41666666666667
11201, 0, 1.05, 0.41666666666667
11202, 0, 1.1, 0.41666666666667
11203, 0, 1.15, 0.41666666666667
11204, 0, 1.2, 0.41666666666667
11205, 0, 1.25, 0.41666666666667
11206, 0, 1.3, 0.41666666666667
11207, 0, 0.2, 0.45833333333333
11208, 0, 0.25, 0.45833333333333
11209, 0, 0.3, 0.45833333333333
11210, 0, 0.35, 0.45833333333333
11211, 0, 0.4, 0.45833333333333
11212, 0, 0.45, 0.45833333333333
11213, 0, 0.5, 0.45833333333333
11214, 0, 0.55, 0.45833333333333
11215, 0, 0.6, 0.45833333333333
11216, 0, 0.65, 0.45833333333333
11217, 0, 0.7, 0.45833333333333
11218, 0, 0.75, 0.45833333333333
11219, 0, 0.8, 0.45833333333333
11220, 0, 0.85, 0.45833333333333
11221, 0, 0.9, 0.45833333333333
11222, 0, 0.95, 0.45833333333333
11223, 0, 1, 0.45833333333333
11224, 0, 1.05, 0.45833333333333
11225, 0, 1.1, 0.45833333333333
11226, 0, 1.15, 0.45833333333333
11227, 0, 1.2, 0.45833333333333
11228, 0, 1.25, 0.45833333333333
11229, 0, 1.3, 0.45833333333333
11230, 0, 0.175, 0.041666666666667
11231, 0, 0.2, 0.020833333333333
11232, 0, 0.225, 0.041666666666667
11233, 0, 0.25, 0.020833333333333
11234, 0, 0.275, 0.041666666666667
11235, 0, 0.3, 0.020833333333333
11236, 0, 0.325, 0.041666666666667
11237, 0, 0.35, 0.020833333333333
11238, 0, 0.375, 0.041666666666667
11239, 0, 0.4, 0.020833333333333
11240, 0, 0.425, 0.041666666666667
11241, 0, 0.45, 0.020833333333333
11242, 0, 0.475, 0.041666666666667
11243, 0, 0.5, 0.020833333333333
11244, 0, 0.525, 0.041666666666667
11245, 0, 0.55, 0.020833333333333
11246, 0, 0.575, 0.041666666666667
11247, 0, 0.6, 0.020833333333333
11248, 0, 0.625, 0.041666666666667
11249, 0, 0.65, 0.020833333333333
11250, 0, 0.675, 0.041666666666667
11251, 0, 0.7, 0.020833333333333
11252, 0, 0.725, 0.041666666666667
11253, 0, 0.75, 0.020833333333333
11254, 0, 0.775, 0.041666666666667
11255, 0, 0.8, 0.020833333333333
11256, 0, 0.825, 0.041666666666667
11257, 0, 0.85, 0.020833333333333
11258, 0, 0.875, 0.041666666666667
11259, 0, 0.9, 0.020833333333333
11260, 0, 0.925, 0.041666666666667
11261, 0, 0.95, 0.020833333333333
11262, 0, 0.975, 0.041666666666667
11263, 0, 1, 0.020833333333333
11264, 0, 1.025, 0.041666666666667
11265, 0, 1.05, 0.020833333333333
11266, 0, 1.075, 0.041666666666667
11267, 0, 1.1, 0.020833333333333
11268, 0, 1.125, 0.041666666666667
11269, 0, 1.15, 0.020833333333333
11270, 0, 1.175, 0.041666666666667
11271, 0, 1.2, 0.020833333333333
11272, 0, 1.225, 0.041666666666667
11273, 0, 1.25, 0.020833333333333
11274, 0, 1.275, 0.041666666666667
11275, 0, 1.3, 0.020833333333333
11276, 0, 1.325, 0.041666666666667
11277, 0, 0.175, 0.083333333333333
11278, 0, 0.2, 0.0625
11279, 0, 0.225, 0.083333333333333
11280, 0, 0.25, 0.0625
11281, 0, 0.275, 0.083333333333333
11282, 0, 0.3, 0.0625
11283, 0, 0.325, 0.083333333333333
11284, 0, 0.35, 0.0625
11285, 0, 0.375, 0.083333333333333
11286, 0, 0.4, 0.0625
11287, 0, 0.425, 0.083333333333333
11288, 0, 0.45, 0.0625
11289, 0, 0.475, 0.083333333333333
11290, 0, 0.5, 0.0625
11291, 0, 0.525, 0.083333333333333
11292, 0, 0.55, 0.0625
11293, 0, 0.575, 0.083333333333333
11294, 0, 0.6, 0.0625
11295, 0, 0.625, 0.083333333333333
11296, 0, 0.65, 0.0625
11297, 0, 0.675, 0.083333333333333
11298, 0, 0.7, 0.0625
11299, 0, 0.725, 0.083333333333333
11300, 0, 0.75, 0.0625
11301, 0, 0.775, 0.083333333333333
11302, 0, 0.8, 0.0625
11303, 0, 0.825, 0.083333333333333
11304, 0, 0.85, 0.0625
11305, 0, 0.875, 0.083333333333333
11306, 0, 0.9, 0.0625
11307, 0, 0.925, 0.083333333333333
11308, 0, 0.95, 0.0625
11309, 0, 0.975, 0.083333333333333
11310, 0, 1, 0.0625
11311, 0, 1.025, 0.083333333333333
11312, 0, 1.05, 0.0625
11313, 0, 1.075, 0.083333333333333
11314, 0, 1.1, 0.0625
11315, 0, 1.125, 0.083333333333333
11316, 0, 1.15, 0.0625
11317, 0, 1.175, 0.083333333333333
11318, 0, 1.2, 0.0625
11319, 0, 1.225, 0.083333333333333
11320, 0, 1.25, 0.0625
11321, 0, 1.275, 0.083333333333333
11322, 0, 1.3, 0.0625
11323, 0, 1.325, 0.083333333333333
11324, 0, 0.175, 0.125
11325, 0, 0.2, 0.10416666666667
11326, 0, 0.225, 0.125
11327, 0, 0.25, 0.10416666666667
11328, 0, 0.275, 0.125
11329, 0, 0.3, 0.10416666666667
11330, 0, 0.325, 0.125
11331, 0, 0.35, 0.10416666666667
11332, 0, 0.375, 0.125
11333, 0, 0.4, 0.10416666666667
11334, 0, 0.425, 0.125
11335, 0, 0.45, 0.10416666666667
11336, 0, 0.475, 0.125
11337, 0, 0.5, 0.10416666666667
11338, 0, 0.525, 0.125
11339, 0, 0.55, 0.10416666666667
11340, 0, 0.575, 0.125
11341, 0, 0.6, 0.10416666666667
11342, 0, 0.625, 0.125
11343, 0, 0.65, 0.10416666666667
11344, 0, 0.675, 0.125
11345, 0, 0.7, 0.10416666666667
11346, 0, 0.725, 0.125
11347, 0, 0.75, 0.10416666666667
11348, 0, 0.775, 0.125
11349, 0, 0.8, 0.10416666666667
11350, 0, 0.825, 0.125
11351, 0, 0.85, 0.10416666666667
11352, 0, 0.875, 0.125
11353, 0, 0.9, 0.10416666666667
11354, 0, 0.925, 0.125
11355, 0, 0.95, 0.10416666666667
11356, 0, 0.975, 0.125
11357, 0, 1, 0.10416666666667
11358, 0, 1.025, 0.125
11359, 0, 1.05, 0.10416666666667
11360, 0, 1.075, 0.125
11361, 0, 1.1, 0.10416666666667
11362, 0, 1.125, 0.125
11363, 0, 1.15, 0.10416666666667
11364, 0, 1.175, 0.125
11365, 0, 1.2, 0.10416666666667
11366, 0, 1.225, 0.125
11367, 0, 1.25, 0.10416666666667
11368, 0, 1.275, 0.125
11369, 0, 1.3, 0.10416666666667
11370, 0, 1.325, 0.125
11371, 0, 0.175, 0.16666666666667
11372, 0, 0.2, 0.14583333333333
11373, 0, 0.225, 0.16666666666667
11374, 0, 0.25, 0.14583333333333
11375, 0, 0.275, 0.16666666666667
11376, 0, 0.3, 0.14583333333333
11377, 0, 0.325, 0.16666666666667
11378, 0, 0.35, 0.14583333333333
11379, 0, 0.375, 0.16666666666667
11380, 0, 0.4, 0.14583333333333
11381, 0, 0.425, 0.16666666666667
11382, 0, 0.45, 0.14583333333333
11383, 0, 0.475, 0.16666666666667
11384, 0, 0.5, 0.14583333333333
11385, 0, 0.525, 0.16666666666667
11386, 0, 0.55, 0.14583333333333
11387, 0, 0.575, 0.16666666666667
11388, 0, 0.6, 0.14583333333333
11389, 0, 0.625, 0.16666666666667
11390, 0, 0.65, 0.14583333333333
11391, 0, 0.675, 0.16666666666667
11392, 0, 0.7, 0.14583333333333
11393, 0, 0.725, 0.16666666666667
11394, 0, 0.75, 0.14583333333333
11395, 0, 0.775, 0.16666666666667
11396, 0, 0.8, 0.14583333333333
11397, 0, 0.825, 0.16666666666667
11398, 0, 0.85, 0.14583333333333
11399, 0, 0.875, 0.16666666666667
11400, 0, 0.9, 0.14583333333333
11401, 0, 0.925, 0.16666666666667
11402, 0, 0.95, 0.14583333333333
11403, 0, 0.975, 0.16666666666667
11404, 0, 1, 0.14583333333333
11405, 0, 1.025, 0.16666666666667
11406, 0, 1.05, 0.14583333333333
11407, 0, 1.075, 0.16666666666667
11408, 0, 1.1, 0.14583333333333
11409, 0, 1.125, 0.16666666666667
11410, 0, 1.15, 0.14583333333333
11411, 0, 1.175, 0.16666666666667
11412, 0, 1.2, 0.14583333333333
11413, 0, 1.225, 0.16666666666667
11414, 0, 1.25, 0.14583333333333
11415, 0, 1.275, 0.16666666666667
11416, 0, 1.3, 0.14583333333333
11417, 0, 1.325, 0.16666666666667
11418, 0, 0.175, 0.20833333333333
11419, 0, 0.2, 0.1875
11420, 0, 0.225, 0.20833333333333
11421, 0, 0.25, 0.1875
11422, 0, 0.275, 0.20833333333333
11423, 0, 0.3, 0.1875
11424, 0, 0.325, 0.20833333333333
11425, 0, 0.35, 0.1875
11426, 0, 0.375, 0.20833333333333
11427, 0, 0.4, 0.1875
11428, 0, 0.425, 0.20833333333333
11429, 0, 0.45, 0.1875
11430, 0, 0.475, 0.20833333333333
11431, 0, 0.5, 0.1875
11432, 0, 0.525, 0.20833333333333
11433, 0, 0.55, 0.1875
11434, 0, 0.575, 0.20833333333333
11435, 0, 0.6, 0.1875
11436, 0, 0.625, 0.20833333333333
11437, 0, 0.65, 0.1875
11438, 0, 0.675, 0.20833333333333
11439, 0, 0.7, 0.1875
11440, 0, 0.725, 0.20833333333333
11441, 0, 0.75, 0.1875
11442, 0, 0.775, 0.20833333333333
11443, 0, 0.8, 0.1875
11444, 0, 0.825, 0.20833333333333
11445, 0, 0.85, 0.1875
11446, 0, 0.875, 0.20833333333333
11447, 0, 0.9, 0.1875
11448, 0, 0.925, 0.20833333333333
11449, 0, 0.95, 0.1875
11450, 0, 0.975, 0.20833333333333
11451, 0, 1, 0.1875
11452, 0, 1.025, 0.20833333333333
11453, 0, 1.05, 0.1875
11454, 0, 1.075, 0.20833333333333
11455, 0, 1.1, 0.1875
11456, 0, 1.125, 0.20833333333333
11457, 0, 1.15, 0.1875
11458, 0, 1.175, 0.20833333333333
11459, 0, 1.2, 0.1875
11460, 0, 1.225, 0.20833333333333
11461, 0, 1.25, 0.1875
11462, 0, 1.275, 0.20833333333333
11463, 0, 1.3, 0.1875
11464, 0, 1.325, 0.20833333333333
11465, 0, 0.175, 0.25
11466, 0, 0.2, 0.22916666666667
11467, 0, 0.225, 0.25
11468, 0, 0.25, 0.22916666666667
11469, 0, 0.275, 0.25
11470, 0, 0.3, 0.22916666666667
11471, 0, 0.325, 0.25
11472, 0, 0.35, 0.22916666666667
11473, 0, 0.375, 0.25
11474, 0, 0.4, 0.22916666666667
11475, 0, 0.425, 0.25
11476, 0, 0.45, 0.22916666666667
11477, 0, 0.475, 0.25
11478, 0, 0.5, 0.22916666666667
11479, 0, 0.525, 0.25
11480, 0, 0.55, 0.22916666666667
11481, 0, 0.575, 0.25
11482, 0, 0.6, 0.22916666666667
11483, 0, 0.625, 0.25
11484, 0, 0.65, 0.22916666666667
11485, 0, 0.675, 0.25
11486, 0, 0.7, 0.22916666666667
11487, 0, 0.725, 0.25
11488, 0, 0.75, 0.22916666666667
11489, 0, 0.775, 0.25
11490, 0, 0.8, 0.22916666666667
11491, 0, 0.825, 0.25
11492, 0, 0.85, 0.22916666666667
11493, 0, 0.875, 0.25
11494, 0, 0.9, 0.22916666666667
11495, 0, 0.925, 0.25
11496, 0, 0.95, 0.22916666666667
11497, 0, 0.975, 0.25
11498, 0, 1, 0.22916666666667
11499, 0, 1.025, 0.25
11500, 0, 1.05, 0.22916666666667
11501, 0, 1.075, 0.25
11502, 0, 1.1, 0.22916666666667
11503, 0, 1.125, 0.25
11504, 0, 1.15, 0.22916666666667
11505, 0, 1.175, 0.25
11506, 0, 1.2, 0.22916666666667
11507, 0, 1.225, 0.25
11508, 0, 1.25, 0.22916666666667
11509, 0, 1.275, 0.25
11510, 0, 1.3, 0.22916666666667
11511, 0, 1.325, 0.25
11512, 0, 0.175, 0.29166666666667
11513, 0, 0.2, 0.27083333333333
11514, 0, 0.225, 0.29166666666667
11515, 0, 0.25, 0.27083333333333
11516, 0, 0.275, 0.29166666666667
11517, 0, 0.3, 0.27083333333333
11518, 0, 0.325, 0.29166666666667
11519, 0, 0.35, 0.27083333333333
11520, 0, 0.375, 0.29166666666667
11521, 0, 0.4, 0.27083333333333
11522, 0, 0.425, 0.29166666666667
11523, 0, 0.45, 0.27083333333333
11524, 0, 0.475, 0.29166666666667
11525, 0, 0.5, 0.27083333333333
11526, 0, 0.525, 0.29166666666667
11527, 0, 0.55, 0.27083333333333
11528, 0, 0.575, 0.29166666666667
11529, 0, 0.6, 0.27083333333333
11530, 0, 0.625, 0.29166666666667
11531, 0, 0.65, 0.27083333333333
11532, 0, 0.675, 0.29166666666667
11533, 0, 0.7, 0.27083333333333
11534, 0, 0.725, 0.29166666666667
11535, 0, 0.75, 0.27083333333333
11536, 0, 0.775, 0.29166666666667
11537, 0, 0.8, 0.27083333333333
11538, 0, 0.825, 0.29166666666667
11539, 0, 0.85, 0.27083333333333
11540, 0, 0.875, 0.29166666666667
11541, 0, 0.9, 0.27083333333333
11542, 0, 0.925, 0.29166666666667
11543, 0, 0.95, 0.27083333333333
11544, 0, 0.975, 0.29166666666667
11545, 0, 1, 0.27083333333333
11546, 0, 1.025, 0.29166666666667
11547, 0, 1.05, 0.27083333333333
11548, 0, 1.075, 0.29166666666667
11549, 0, 1.1, 0.27083333333333
11550, 0, 1.125, 0.29166666666667
11551, 0, 1.15, 0.27083333333333
11552, 0, 1.175, 0.29166666666667
11553, 0, 1.2, 0.27083333333333
11554, 0, 1.225, 0.29166666666667
11555, 0, 1.25, 0.27083333333333
11556, 0, 1.275, 0.29166666666667
11557, 0, 1.3, 0.27083333333333
11558, 0, 1.325, 0.29166666666667
11559, 0, 0.175, 0.33333333333333
11560, 0, 0.2, 0.3125
11561, 0, 0.225, 0.33333333333333
11562, 0, 0.25, 0.3125
11563, 0, 0.275, 0.33333333333333
11564, 0, 0.3, 0.3125
11565, 0, 0.325, 0.33333333333333
11566, 0, 0.35, 0.3125
11567, 0, 0.375, 0.33333333333333
11568, 0, 0.4, 0.3125
11569, 0, 0.425, 0.33333333333333
11570, 0, 0.45, 0.3125
11571, 0, 0.475, 0.33333333333333
11572, 0, 0.5, 0.3125
11573, 0, 0.525, 0.33333333333333
11574, 0, 0.55, 0.3125
11575, 0, 0.575, 0.33333333333333
11576, 0, 0.6, 0.3125
11577, 0, 0.625, 0.33333333333333
11578, 0, 0.65, 0.3125
11579, 0, 0.675, 0.33333333333333
11580, 0, 0.7, 0.3125
11581, 0, 0.725, 0.33333333333333
11582, 0, 0.75, 0.3125
11583, 0, 0.775, 0.33333333333333
11584, 0, 0.8, 0.3125
11585, 0, 0.825, 0.33333333333333
11586, 0, 0.85, 0.3125
11587, 0, 0.875, 0.33333333333333
11588, 0, 0.9, 0.3125
11589, 0, 0.925, 0.33333333333333
11590, 0, 0.95, 0.3125
11591, 0, 0.975, 0.33333333333333
11592, 0, 1, 0.3125
11593, 0, 1.025, 0.33333333333333
11594, 0, 1.05, 0.3125
11595, 0, 1.075, 0.33333333333333
11596, 0, 1.1, 0.3125
11597, 0, 1.125, 0.33333333333333
11598, 0, 1.15, 0.3125
11599, 0, 1.175, 0.33333333333333
11600, 0, 1.2, 0.3125
11601, 0, 1.225, 0.33333333333333
11602, 0, 1.25, 0.3125
11603, 0, 1.275, 0.33333333333333
11604, 0, 1.3, 0.3125
11605, 0, 1.325, 0.33333333333333
11606, 0, 0.175, 0.375
11607, 0, 0.2, 0.35416666666667
11608, 0, 0.225, 0.375
11609, 0, 0.25, 0.35416666666667
11610, 0, 0.275, 0.375
11611, 0, 0.3, 0.35416666666667
11612, 0, 0.325, 0.375
11613, 0, 0.35, 0.35416666666667
11614, 0, 0.375, 0.375
11615, 0, 0.4, 0.35416666666667
11616, 0, 0.425, 0.375
11617, 0, 0.45, 0.35416666666667
11618, 0, 0.475, 0.375
11619, 0, 0.5, 0.35416666666667
11620, 0, 0.525, 0.375
11621, 0, 0.55, 0.35416666666667
11622, 0, 0.575, 0.375
11623, 0, 0.6, 0.35416666666667
11624, 0, 0.625, 0.375
11625, 0, 0.65, 0.35416666666667
11626, 0, 0.675, 0.375
11627, 0, 0.7, 0.35416666666667
11628, 0, 0.725, 0.375
11629, 0, 0.75, 0.35416666666667
11630, 0, 0.775, 0.375
11631, 0, 0.8, 0.35416666666667
11632, 0, 0.825, 0.375
11633, 0, 0.85, 0.35416666666667
11634, 0, 0.875, 0.375
11635, 0, 0.9, 0.35416666666667
11636, 0, 0.925, 0.375
11637, 0, 0.95, 0.35416666666667
11638, 0, 0.975, 0.375
11639, 0, 1, 0.35416666666667
11640, 0, 1.025, 0.375
11641, 0, 1.05, 0.35416666666667
11642, 0, 1.075, 0.375
11643, 0, 1.1, 0.35416666666667
11644, 0, 1.125, 0.375
11645, 0, 1.15, 0.35416666666667
11646, 0, 1.175, 0.375
11647, 0, 1.2, 0.35416666666667
11648, 0, 1.225, 0.375
11649, 0, 1.25, 0.35416666666667
11650, 0, 1.275, 0.375
11651, 0, 1.3, 0.35416666666667
11652, 0, 1.325, 0.375
11653, 0, 0.175, 0.41666666666667
11654, 0, 0.2, 0.39583333333333
11655, 0, 0.225, 0.41666666666667
11656, 0, 0.25, 0.39583333333333
11657, 0, 0.275, 0.41666666666667
11658, 0, 0.3, 0.39583333333333
11659, 0, 0.325, 0.41666666666667
11660, 0, 0.35, 0.39583333333333
11661, 0, 0.375, 0.41666666666667
11662, 0, 0.4, 0.39583333333333
11663, 0, 0.425, 0.41666666666667
11664, 0, 0.45, 0.39583333333333
11665, 0, 0.475, 0.41666666666667
11666, 0, 0.5, 0.39583333333333
11667, 0, 0.525, 0.41666666666667
11668, 0, 0.55, 0.39583333333333
11669, 0, 0.575, 0.41666666666667
11670, 0, 0.6, 0.39583333333333
11671, 0, 0.625, 0.41666666666667
11672, 0, 0.65, 0.39583333333333
11673, 0, 0.675, 0.41666666666667
11674, 0, 0.7, 0.39583333333333
11675, 0, 0.725, 0.41666666666667
11676, 0, 0.75, 0.39583333333333
11677, 0, 0.775, 0.41666666666667
11678, 0, 0.8, 0.39583333333333
11679, 0, 0.825, 0.41666666666667
11680, 0, 0.85, 0.39583333333333
11681, 0, 0.875, 0.41666666666667
11682, 0, 0.9, 0.39583333333333
11683, 0, 0.925, 0.41666666666667
11684, 0, 0.95, 0.39583333333333
11685, 0, 0.975, 0.41666666666667
11686, 0, 1, 0.39583333333333
11687, 0, 1.025, 0.41666666666667
11688, 0, 1.05, 0.39583333333333
11689, 0, 1.075, 0.41666666666667
11690, 0, 1.1, 0.39583333333333
11691, 0, 1.125, 0.41666666666667
11692, 0, 1.15, 0.39583333333333
11693, 0, 1.175, 0.41666666666667
11694, 0, 1.2, 0.39583333333333
11695, 0, 1.225, 0.41666666666667
11696, 0, 1.25, 0.39583333333333
11697, 0, 1.275, 0.41666666666667
11698, 0, 1.3, 0.39583333333333
11699, 0, 1.325, 0.41666666666667
11700, 0, 0.175, 0.45833333333333
11701, 0, 0.2, 0.4375
11702, 0, 0.225, 0.45833333333333
11703, 0, 0.25, 0.4375
11704, 0, 0.275, 0.45833333333333
11705, 0, 0.3, 0.4375
11706, 0, 0.325, 0.45833333333333
11707, 0, 0.35, 0.4375
11708, 0, 0.375, 0.45833333333333
11709, 0, 0.4, 0.4375
11710, 0, 0.425, 0.45833333333333
11711, 0, 0.45, 0.4375
11712, 0, 0.475, 0.45833333333333
11713, 0, 0.5, 0.4375
11714, 0, 0.525, 0.45833333333333
11715, 0, 0.55, 0.4375
11716, 0, 0.575, 0.45833333333333
11717, 0, 0.6, 0.4375
11718, 0, 0.625, 0.45833333333333
11719, 0, 0.65, 0.4375
11720, 0, 0.675, 0.45833333333333
11721, 0, 0.7, 0.4375
11722, 0, 0.725, 0.45833333333333
11723, 0, 0.75, 0.4375
11724, 0, 0.775, 0.45833333333333
11725, 0, 0.8, 0.4375
11726, 0, 0.825, 0.45833333333333
11727, 0, 0.85, 0.4375
11728, 0, 0.875, 0.45833333333333
11729, 0, 0.9, 0.4375
11730, 0, 0.925, 0.45833333333333
11731, 0, 0.95, 0.4375
11732, 0, 0.975, 0.45833333333333
11733, 0, 1, 0.4375
11734, 0, 1.025, 0.45833333333333
11735, 0, 1.05, 0.4375
11736, 0, 1.075, 0.45833333333333
11737, 0, 1.1, 0.4375
11738, 0, 1.125, 0.45833333333333
11739, 0, 1.15, 0.4375
11740, 0, 1.175, 0.45833333333333
11741, 0, 1.2, 0.4375
11742, 0, 1.225, 0.45833333333333
11743, 0, 1.25, 0.4375
11744, 0, 1.275, 0.45833333333333
11745, 0, 1.3, 0.4375
11746, 0, 1.325, 0.45833333333333
11747, 0, 0.2, 0.47916666666667
11748, 0, 0.25, 0.47916666666667
11749, 0, 0.3, 0.47916666666667
11750, 0, 0.35, 0.47916666666667
11751, 0, 0.4, 0.47916666666667
11752, 0, 0.45, 0.47916666666667
11753, 0, 0.5, 0.47916666666667
11754, 0, 0.55, 0.47916666666667
11755, 0, 0.6, 0.47916666666667
11756, 0, 0.65, 0.47916666666667
11757, 0, 0.7, 0.47916666666667
11758, 0, 0.75, 0.47916666666667
11759, 0, 0.8, 0.47916666666667
11760, 0, 0.85, 0.47916666666667
11761, 0, 0.9, 0.47916666666667
11762, 0, 0.95, 0.47916666666667
11763, 0, 1, 0.47916666666667
11764, 0, 1.05, 0.47916666666667
11765, 0, 1.1, 0.47916666666667
11766, 0, 1.15, 0.47916666666667
11767, 0, 1.2, 0.47916666666667
11768, 0, 1.25, 0.47916666666667
11769, 0, 1.3, 0.47916666666667
11770, 0.041666666666667, 1.35, 0.041666666666667
11771, 0.041666666666667, 1.35, 0.083333333333333
11772, 0.041666666666667, 1.35, 0.125
11773, 0.041666666666667, 1.35, 0.16666666666667
11774, 0.041666666666667, 1.35, 0.20833333333333
11775, 0.041666666666667, 1.35, 0.25
11776, 0.041666666666667, 1.35, 0.29166666666667
11777, 0.041666666666667, 1.35, 0.33333333333333
11778, 0.041666666666667, 1.35, 0.375
11779, 0.041666666666667, 1.35, 0.41666666666667
11780, 0.041666666666667, 1.35, 0.45833333333333
11781, 0.083333333333333, 1.35, 0.041666666666667
11782, 0.083333333333333, 1.35, 0.083333333333333
11783, 0.083333333333333, 1.35, 0.125
11784, 0.083333333333333, 1.35, 0.16666666666667
11785, 0.083333333333333, 1.35, 0.20833333333333
11786, 0.083333333333333, 1.35, 0.25
11787, 0.083333333333333, 1.35, 0.29166666666667
11788, 0.083333333333333, 1.35, 0.33333333333333
11789, 0.083333333333333, 1.35, 0.375
11790, 0.083333333333333, 1.35, 0.41666666666667
11791, 0.083333333333333, 1.35, 0.45833333333333
11792, 0.125, 1.35, 0.041666666666667
11793, 0.125, 1.35, 0.083333333333333
11794, 0.125, 1.35, 0.125
11795, 0.125, 1.35, 0.16666666666667
11796, 0.125, 1.35, 0.20833333333333
11797, 0.125, 1.35, 0.25
11798, 0.125, 1.35, 0.29166666666667
11799, 0.125, 1.35, 0.33333333333333
11800, 0.125, 1.35, 0.375
11801, 0.125, 1.35, 0.41666666666667
11802, 0.125, 1.35, 0.45833333333333
11803, 0.16666666666667, 1.35, 0.041666666666667
11804, 0.16666666666667, 1.35, 0.083333333333333
11805, 0.16666666666667, 1.35, 0.125
11806, 0.16666666666667, 1.35, 0.16666666666667
11807, 0.16666666666667, 1.35, 0.20833333333333
11808, 0.16666666666667, 1.35, 0.25
11809, 0.16666666666667, 1.35, 0.29166666666667
11810, 0.16666666666667, 1.35, 0.33333333333333
11811, 0.16666666666667, 1.35, 0.375
11812, 0.16666666666667, 1.35, 0.41666666666667
11813, 0.16666666666667, 1.35, 0.45833333333333
11814, 0.20833333333333, 1.35, 0.041666666666667
11815, 0.20833333333333, 1.35, 0.083333333333333
11816, 0.20833333333333, 1.35, 0.125
11817, 0.20833333333333, 1.35, 0.16666666666667
11818, 0.20833333333333, 1.35, 0.20833333333333
11819, 0.20833333333333, 1.35, 0.25
11820, 0.20833333333333, 1.35, 0.29166666666667
11821, 0.20833333333333, 1.35, 0.33333333333333
11822, 0.20833333333333, 1.35, 0.375
11823, 0.20833333333333, 1.35, 0.41666666666667
11824, 0.20833333333333, 1.35, 0.45833333333333
11825, 0.25, 1.35, 0.041666666666667
11826, 0.25, 1.35, 0.083333333333333
11827, 0.25, 1.35, 0.125
11828, 0.25, 1.35, 0.16666666666667
11829, 0.25, 1.35, 0.20833333333333
11830, 0.25, 1.35, 0.25
11831, 0.25, 1.35, 0.29166666666667
11832, 0.25, 1.35, 0.33333333333333
11833, 0.25, 1.35, 0.375
11834, 0.25, 1.35, 0.41666666666667
11835, 0.25, 1.35, 0.45833333333333
11836, 0.29166666666667, 1.35, 0.041666666666667
11837, 0.29166666666667, 1.35, 0.083333333333333
11838, 0.29166666666667, 1.35, 0.125
11839, 0.29166666666667, 1.35, 0.16666666666667
11840, 0.29166666666667, 1.35, 0.20833333333333
11841, 0.29166666666667, 1.35, 0.25
11842, 0.29166666666667, 1.35, 0.29166666666667
11843, 0.29166666666667, 1.35, 0.33333333333333
11844, 0.29166666666667, 1.35, 0.375
11845, 0.29166666666667, 1.35, 0.41666666666667
11846, 0.29166666666667, 1.35, 0.45833333333333
11847, 0.33333333333333, 1.35, 0.041666666666667
11848, 0.33333333333333, 1.35, 0.083333333333333
11849, 0.33333333333333, 1.35, 0.125
11850, 0.33333333333333, 1.35, 0.16666666666667
11851, 0.33333333333333, 1.35, 0.20833333333333
11852, 0.33333333333333, 1.35, 0.25
11853, 0.33333333333333, 1.35, 0.29166666666667
11854, 0.33333333333333, 1.35, 0.33333333333333
11855, 0.33333333333333, 1.35, 0.375
11856, 0.33333333333333, 1.35, 0.41666666666667
11857, 0.33333333333333, 1.35, 0.45833333333333
11858, 0.375, 1.35, 0.041666666666667
11859, 0.375, 1.35, 0.083333333333333
11860, 0.375, 1.35, 0.125
11861, 0.375, 1.35, 0.16666666666667
11862, 0.375, 1.35, 0.20833333333333
11863, 0.375, 1.35, 0.25
11864, 0.375, 1.35, 0.29166666666667
11865, 0.375, 1.35, 0.33333333333333
11866, 0.375, 1.35, 0.375
11867, 0.375, 1.35, 0.41666666666667
11868, 0.375, 1.35, 0.45833333333333
11869, 0.41666666666667, 1.35, 0.041666666666667
11870, 0.41666666666667, 1.35, 0.083333333333333
11871, 0.41666666666667, 1.35, 0.125
11872, 0.41666666666667, 1.35, 0.16666666666667
11873, 0.41666666666667, 1.35, 0.20833333333333
11874, 0.41666666666667, 1.35, 0.25
11875, 0.41666666666667, 1.35, 0.29166666666667
11876, 0.41666666666667, 1.35, 0.33333333333333
11877, 0.41666666666667, 1.35, 0.375
11878, 0.41666666666667, 1.35, 0.41666666666667
11879, 0.41666666666667, 1.35, 0.45833333333333
11880, 0.45833333333333, 1.35, 0.041666666666667
11881, 0.45833333333333, 1.35, 0.083333333333333
11882, 0.45833333333333, 1.35, 0.125
11883, 0.45833333333333, 1.35, 0.16666666666667
11884, 0.45833333333333, 1.35, 0.20833333333333
11885, 0.45833333333333, 1.35, 0.25
11886, 0.45833333333333, 1.35, 0.29166666666667
11887, 0.45833333333333, 1.35, 0.33333333333333
11888, 0.45833333333333, 1.35, 0.375
11889, 0.45833333333333, 1.35, 0.41666666666667
11890, 0.45833333333333, 1.35, 0.45833333333333
11891, 0.5, 1.35, 0.041666666666667
11892, 0.5, 1.35, 0.083333333333333
11893, 0.5, 1.35, 0.125
11894, 0.5, 1.35, 0.16666666666667
11895, 0.5, 1.35, 0.20833333333333
11896, 0.5, 1.35, 0.25
11897, 0.5, 1.35, 0.29166666666667
11898, 0.5, 1.35, 0.33333333333333
11899, 0.5, 1.35, 0.375
11900, 0.5, 1.35, 0.41666666666667
11901, 0.5, 1.35, 0.45833333333333
11902, 0.54166666666667, 1.35, 0.041666666666667
11903, 0.54166666666667, 1.35, 0.083333333333333
11904, 0.54166666666667, 1.35, 0.125
11905, 0.54166666666667, 1.35, 0.16666666666667
11906, 0.54166666666667, 1.35, 0.20833333333333
11907, 0.54166666666667, 1.35, 0.25
11908, 0.54166666666667, 1.35, 0.29166666666667
11909, 0.54166666666667, 1.35, 0.33333333333333
11910, 0.54166666666667, 1.35, 0.375
11911, 0.54166666666667, 1.35, 0.41666666666667
11912, 0.54166666666667, 1.35, 0.45833333333333
11913, 0.58333333333333, 1.35, 0.041666666666667
11914, 0.58333333333333, 1.35, 0.083333333333333
11915, 0.58333333333333, 1.35, 0.125
11916, 0.58333333333333, 1.35, 0.16666666666667
11917, 0.58333333333333, 1.35, 0.20833333333333
11918, 0.58333333333333, 1.35, 0.25
11919, 0.58333333333333, 1.35, 0.29166666666667
11920, 0.58333333333333, 1.35, 0.33333333333333
11921, 0.58333333333333, 1.35, 0.375
11922, 0.58333333333333, 1.35, 0.41666666666667
11923, 0.58333333333333, 1.35, 0.45833333333333
11924, 0.625, 1.35, 0.041666666666667
11925, 0.625, 1.35, 0.083333333333333
11926, 0.625, 1.35, 0.125
11927, 0.625, 1.35, 0.16666666666667
11928, 0.625, 1.35, 0.20833333333333
11929, 0.625, 1.35, 0.25
11930, 0.625, 1.35, 0.29166666666667
11931, 0.625, 1.35, 0.33333333333333
11932, 0.625, 1.35, 0.375
11933, 0.625, 1.35, 0.41666666666667
11934, 0.625, 1.35, 0.45833333333333
11935, 0.66666666666667, 1.35, 0.041666666666667
11936, 0.66666666666667, 1.35, 0.083333333333333
11937, 0.66666666666667, 1.35, 0.125
11938, 0.66666666666667, 1.35, 0.16666666666667
11939, 0.66666666666667, 1.35, 0.20833333333333
11940, 0.66666666666667, 1.35, 0.25
11941, 0.66666666666667, 1.35, 0.29166666666667
11942, 0.66666666666667, 1.35, 0.33333333333333
11943, 0.66666666666667, 1.35, 0.375
11944, 0.66666666666667, 1.35, 0.41666666666667
11945, 0.66666666666667, 1.35, 0.45833333333333
11946, 0.70833333333333, 1.35, 0.041666666666667
11947, 0.70833333333333, 1.35, 0.083333333333333
11948, 0.70833333333333, 1.35, 0.125
11949, 0.70833333333333, 1.35, 0.16666666666667
11950, 0.70833333333333, 1.35, 0.20833333333333
11951, 0.70833333333333, 1.35, 0.25
11952, 0.70833333333333, 1.35, 0.29166666666667
11953, 0.70833333333333, 1.35, 0.33333333333333
11954, 0.70833333333333, 1.35, 0.375
11955, 0.70833333333333, 1.35, 0.41666666666667
11956, 0.70833333333333, 1.35, 0.45833333333333
11957, 0.75, 1.35, 0.041666666666667
11958, 0.75, 1.35, 0.083333333333333
11959, 0.75, 1.35, 0.125
11960, 0.75, 1.35, 0.16666666666667
11961, 0.75, 1.35, 0.20833333333333
11962, 0.75, 1.35, 0.25
11963, 0.75, 1.35, 0.29166666666667
11964, 0.75, 1.35, 0.33333333333333
11965, 0.75, 1.35, 0.375
11966, 0.75, 1.35, 0.41666666666667
11967, 0.75, 1.35, 0.45833333333333
11968, 0.79166666666667, 1.35, 0.041666666666667
11969, 0.79166666666667, 1.35, 0.083333333333333
11970, 0.79166666666667, 1.35, 0.125
11971, 0.79166666666667, 1.35, 0.16666666666667
11972, 0.79166666666667, 1.35, 0.20833333333333
11973, 0.79166666666667, 1.35, 0.25
11974, 0.79166666666667, 1.35, 0.29166666666667
11975, 0.79166666666667, 1.35, 0.33333333333333
11976, 0.79166666666667, 1.35, 0.375
11977, 0.79166666666667, 1.35, 0.41666666666667
11978, 0.79166666666667, 1.35, 0.45833333333333
11979, 0.83333333333333, 1.35, 0.041666666666667
11980, 0.83333333333333, 1.35, 0.083333333333333
11981, 0.83333333333333, 1.35, 0.125
11982, 0.83333333333333, 1.35, 0.16666666666667
11983, 0.83333333333333, 1.35, 0.20833333333333
11984, 0.83333333333333, 1.35, 0.25
11985, 0.83333333333333, 1.35, 0.29166666666667
11986, 0.83333333333333, 1.35, 0.33333333333333
11987, 0.83333333333333, 1.35, 0.375
11988, 0.83333333333333, 1.35, 0.41666666666667
11989, 0.83333333333333, 1.35, 0.45833333333333
11990, 0.875, 1.35, 0.041666666666667
11991, 0.875, 1.35, 0.083333333333333
11992, 0.875, 1.35, 0.125
11993, 0.875, 1.35, 0.16666666666667
11994, 0.875, 1.35, 0.20833333333333
11995, 0.875, 1.35, 0.25
11996, 0.875, 1.35, 0.29166666666667
11997, 0.875, 1.35, 0.33333333333333
11998, 0.875, 1.35, 0.375
11999, 0.875, 1.35, 0.41666666666667
12000, 0.875, 1.35, 0.45833333333333
12001, 0.91666666666667, 1.35, 0.041666666666667
12002, 0.91666666666667, 1.35, 0.083333333333333
12003, 0.91666666666667, 1.35, 0.125
12004, 0.91666666666667, 1.35, 0.16666666666667
12005, 0.91666666666667, 1.35, 0.20833333333333
12006, 0.91666666666667, 1.35, 0.25
12007, 0.91666666666667, 1.35, 0.29166666666667
12008, 0.91666666666667, 1.35, 0.33333333333333
12009, 0.91666666666667, 1.35, 0.375
12010, 0.91666666666667, 1.35, 0.41666666666667
12011, 0.91666666666667, 1.35, 0.45833333333333
12012, 0.95833333333333, 1.35, 0.041666666666667
12013, 0.95833333333333, 1.35, 0.083333333333333
12014, 0.95833333333333, 1.35, 0.125
12015, 0.95833333333333, 1.35, 0.16666666666667
12016, 0.95833333333333, 1.35, 0.20833333333333
12017, 0.95833333333333, 1.35, 0.25
12018, 0.95833333333333, 1.35, 0.29166666666667
12019, 0.95833333333333, 1.35, 0.33333333333333
12020, 0.95833333333333, 1.35, 0.375
12021, 0.95833333333333, 1.35, 0.41666666666667
12022, 0.95833333333333, 1.35, 0.45833333333333
12023, 0.020833333333333, 1.35, 0.041666666666667
12024, 0.041666666666667, 1.35, 0.020833333333333
12025, 0.020833333333333, 1.35, 0.083333333333333
12026, 0.041666666666667, 1.35, 0.0625
12027, 0.020833333333333, 1.35, 0.125
12028, 0.041666666666667, 1.35, 0.10416666666667
12029, 0.020833333333333, 1.35, 0.16666666666667
12030, 0.041666666666667, 1.35, 0.14583333333333
12031, 0.020833333333333, 1.35, 0.20833333333333
12032, 0.041666666666667, 1.35, 0.1875
12033, 0.020833333333333, 1.35, 0.25
12034, 0.041666666666667, 1.35, 0.22916666666667
12035, 0.020833333333333, 1.35, 0.29166666666667
12036, 0.041666666666667, 1.35, 0.27083333333333
12037, 0.020833333333333, 1.35, 0.33333333333333
12038, 0.041666666666667, 1.35, 0.3125
12039, 0.020833333333333, 1.35, 0.375
12040, 0.041666666666667, 1.35, 0.35416666666667
12041, 0.020833333333333, 1.35, 0.41666666666667
12042, 0.041666666666667, 1.35, 0.39583333333333
12043, 0.020833333333333, 1.35, 0.45833333333333
12044, 0.041666666666667, 1.35, 0.4375
12045, 0.041666666666667, 1.35, 0.47916666666667
12046, 0.0625, 1.35, 0.041666666666667
12047, 0.083333333333333, 1.35, 0.020833333333333
12048, 0.0625, 1.35, 0.083333333333333
12049, 0.083333333333333, 1.35, 0.0625
12050, 0.0625, 1.35, 0.125
12051, 0.083333333333333, 1.35, 0.10416666666667
12052, 0.0625, 1.35, 0.16666666666667
12053, 0.083333333333333, 1.35, 0.14583333333333
12054, 0.0625, 1.35, 0.20833333333333
12055, 0.083333333333333, 1.35, 0.1875
12056, 0.0625, 1.35, 0.25
12057, 0.083333333333333, 1.35, 0.22916666666667
12058, 0.0625, 1.35, 0.29166666666667
12059, 0.083333333333333, 1.35, 0.27083333333333
12060, 0.0625, 1.35, 0.33333333333333
12061, 0.083333333333333, 1.35, 0.3125
12062, 0.0625, 1.35, 0.375
12063, 0.083333333333333, 1.35, 0.35416666666667
12064, 0.0625, 1.35, 0.41666666666667
12065, 0.083333333333333, 1.35, 0.39583333333333
12066, 0.0625, 1.35, 0.45833333333333
12067, 0.083333333333333, 1.35, 0.4375
12068, 0.083333333333333, 1.35, 0.47916666666667
12069, 0.10416666666667, 1.35, 0.041666666666667
12070, 0.125, 1.35, 0.020833333333333
12071, 0.10416666666667, 1.35, 0.083333333333333
12072, 0.125, 1.35, 0.0625
12073, 0.10416666666667, 1.35, 0.125
12074, 0.125, 1.35, 0.10416666666667
12075, 0.10416666666667, 1.35, 0.16666666666667
12076, 0.125, 1.35, 0.14583333333333
12077, 0.10416666666667, 1.35, 0.20833333333333
12078, 0.125, 1.35, 0.1875
12079, 0.10416666666667, 1.35, 0.25
12080, 0.125, 1.35, 0.22916666666667
12081, 0.10416666666667, 1.35, 0.29166666666667
12082, 0.125, 1.35, 0.27083333333333
12083, 0.10416666666667, 1.35, 0.33333333333333
12084, 0.125, 1.35, 0.3125
12085, 0.10416666666667, 1.35, 0.375
12086, 0.125, 1.35, 0.35416666666667
12087, 0.10416666666667, 1.35, 0.41666666666667
12088, 0.125, 1.35, 0.39583333333333
12089, 0.10416666666667, 1.35, 0.45833333333333
12090, 0.125, 1.35, 0.4375
12091, 0.125, 1.35, 0.47916666666667
12092, 0.14583333333333, 1.35, 0.041666666666667
12093, 0.16666666666667, 1.35, 0.020833333333333
12094, 0.14583333333333, 1.35, 0.083333333333333
12095, 0.16666666666667, 1.35, 0.0625
12096, 0.14583333333333, 1.35, 0.125
12097, 0.16666666666667, 1.35, 0.10416666666667
12098, 0.14583333333333, 1.35, 0.16666666666667
12099, 0.16666666666667, 1.35, 0.14583333333333
12100, 0.14583333333333, 1.35, 0.20833333333333
12101, 0.16666666666667, 1.35, 0.1875
12102, 0.14583333333333, 1.35, 0.25
12103, 0.16666666666667, 1.35, 0.22916666666667
12104, 0.14583333333333, 1.35, 0.29166666666667
12105, 0.16666666666667, 1.35, 0.27083333333333
12106, 0.14583333333333, 1.35, 0.33333333333333
12107, 0.16666666666667, 1.35, 0.3125
12108, 0.14583333333333, 1.35, 0.375
12109, 0.16666666666667, 1.35, 0.35416666666667
12110, 0.14583333333333, 1.35, 0.41666666666667
12111, 0.16666666666667, 1.35, 0.39583333333333
12112, 0.14583333333333, 1.35, 0.45833333333333
12113, 0.16666666666667, 1.35, 0.4375
12114, 0.16666666666667, 1.35, 0.47916666666667
12115, 0.1875, 1.35, 0.041666666666667
12116, 0.20833333333333, 1.35, 0.020833333333333
12117, 0.1875, 1.35, 0.083333333333333
12118, 0.20833333333333, 1.35, 0.0625
12119, 0.1875, 1.35, 0.125
12120, 0.20833333333333, 1.35, 0.10416666666667
12121, 0.1875, 1.35, 0.16666666666667
12122, 0.20833333333333, 1.35, 0.14583333333333
12123, 0.1875, 1.35, 0.20833333333333
12124, 0.20833333333333, 1.35, 0.1875
12125, 0.1875, 1.35, 0.25
12126, 0.20833333333333, 1.35, 0.22916666666667
12127, 0.1875, 1.35, 0.29166666666667
12128, 0.20833333333333, 1.35, 0.27083333333333
12129, 0.1875, 1.35, 0.33333333333333
12130, 0.20833333333333, 1.35, 0.3125
12131, 0.1875, 1.35, 0.375
12132, 0.20833333333333, 1.35, 0.35416666666667
12133, 0.1875, 1.35, 0.41666666666667
12134, 0.20833333333333, 1.35, 0.39583333333333
12135, 0.1875, 1.35, 0.45833333333333
12136, 0.20833333333333, 1.35, 0.4375
12137, 0.20833333333333, 1.35, 0.47916666666667
12138, 0.22916666666667, 1.35, 0.041666666666667
12139, 0.25, 1.35, 0.020833333333333
12140, 0.22916666666667, 1.35, 0.083333333333333
12141, 0.25, 1.35, 0.0625
12142, 0.22916666666667, 1.35, 0.125
12143, 0.25, 1.35, 0.10416666666667
12144, 0.22916666666667, 1.35, 0.16666666666667
12145, 0.25, 1.35, 0.14583333333333
12146, 0.22916666666667, 1.35, 0.20833333333333
12147, 0.25, 1.35, 0.1875
12148, 0.22916666666667, 1.35, 0.25
12149, 0.25, 1.35, 0.22916666666667
12150, 0.22916666666667, 1.35, 0.29166666666667
12151, 0.25, 1.35, 0.27083333333333
12152, 0.22916666666667, 1.35, 0.33333333333333
12153, 0.25, 1.35, 0.3125
12154, 0.22916666666667, 1.35, 0.375
12155, 0.25, 1.35, 0.35416666666667
12156, 0.22916666666667, 1.35, 0.41666666666667
12157, 0.25, 1.35, 0.39583333333333
12158, 0.22916666666667, 1.35, 0.45833333333333
12159, 0.25, 1.35, 0.4375
12160, 0.25, 1.35, 0.47916666666667
12161, 0.27083333333333, 1.35, 0.041666666666667
12162, 0.29166666666667, 1.35, 0.020833333333333
12163, 0.27083333333333, 1.35, 0.083333333333333
12164, 0.29166666666667, 1.35, 0.0625
12165, 0.27083333333333, 1.35, 0.125
12166, 0.29166666666667, 1.35, 0.10416666666667
12167, 0.27083333333333, 1.35, 0.16666666666667
12168, 0.29166666666667, 1.35, 0.14583333333333
12169, 0.27083333333333, 1.35, 0.20833333333333
12170, 0.29166666666667, 1.35, 0.1875
12171, 0.27083333333333, 1.35, 0.25
12172, 0.29166666666667, 1.35, 0.22916666666667
12173, 0.27083333333333, 1.35, 0.29166666666667
12174, 0.29166666666667, 1.35, 0.27083333333333
12175, 0.27083333333333, 1.35, 0.33333333333333
12176, 0.29166666666667, 1.35, 0.3125
12177, 0.27083333333333, 1.35, 0.375
12178, 0.29166666666667, 1.35, 0.35416666666667
12179, 0.27083333333333, 1.35, 0.41666666666667
12180, 0.29166666666667, 1.35, 0.39583333333333
12181, 0.27083333333333, 1.35, 0.45833333333333
12182, 0.29166666666667, 1.35, 0.4375
12183, 0.29166666666667, 1.35, 0.47916666666667
12184, 0.3125, 1.35, 0.041666666666667
12185, 0.33333333333333, 1.35, 0.020833333333333
12186, 0.3125, 1.35, 0.083333333333333
12187, 0.33333333333333, 1.35, 0.0625
12188, 0.3125, 1.35, 0.125
12189, 0.33333333333333, 1.35, 0.10416666666667
12190, 0.3125, 1.35, 0.16666666666667
12191, 0.33333333333333, 1.35, 0.14583333333333
12192, 0.3125, 1.35, 0.20833333333333
12193, 0.33333333333333, 1.35, 0.1875
12194, 0.3125, 1.35, 0.25
12195, 0.33333333333333, 1.35, 0.22916666666667
12196, 0.3125, 1.35, 0.29166666666667
12197, 0.33333333333333, 1.35, 0.27083333333333
12198, 0.3125, 1.35, 0.33333333333333
12199, 0.33333333333333, 1.35, 0.3125
12200, 0.3125, 1.35, 0.375
12201, 0.33333333333333, 1.35, 0.35416666666667
12202, 0.3125, 1.35, 0.41666666666667
12203, 0.33333333333333, 1.35, 0.39583333333333
12204, 0.3125, 1.35, 0.45833333333333
12205, 0.33333333333333, 1.35, 0.4375
12206, 0.33333333333333, 1.35, 0.47916666666667
12207, 0.35416666666667, 1.35, 0.041666666666667
12208, 0.375, 1.35, 0.020833333333333
12209, 0.35416666666667, 1.35, 0.083333333333333
12210, 0.375, 1.35, 0.0625
12211, 0.35416666666667, 1.35, 0.125
12212, 0.375, 1.35, 0.10416666666667
12213, 0.35416666666667, 1.35, 0.16666666666667
12214, 0.375, 1.35, 0.14583333333333
12215, 0.35416666666667, 1.35, 0.20833333333333
12216, 0.375, 1.35, 0.1875
12217, 0.35416666666667, 1.35, 0.25
12218, 0.375, 1.35, 0.22916666666667
12219, 0.35416666666667, 1.35, 0.29166666666667
12220, 0.375, 1.35, 0.27083333333333
12221, 0.35416666666667, 1.35, 0.33333333333333
12222, 0.375, 1.35, 0.3125
12223, 0.35416666666667, 1.35, 0.375
12224, 0.375, 1.35, 0.35416666666667
12225, 0.35416666666667, 1.35, 0.41666666666667
12226, 0.375, 1.35, 0.39583333333333
12227, 0.35416666666667, 1.35, 0.45833333333333
12228, 0.375, 1.35, 0.4375
12229, 0.375, 1.35, 0.47916666666667
12230, 0.39583333333333, 1.35, 0.041666666666667
12231, 0.41666666666667, 1.35, 0.020833333333333
12232, 0.39583333333333, 1.35, 0.083333333333333
12233, 0.41666666666667, 1.35, 0.0625
12234, 0.39583333333333, 1.35, 0.125
12235, 0.41666666666667, 1.35, 0.10416666666667
12236, 0.39583333333333, 1.35, 0.16666666666667
12237, 0.41666666666667, 1.35, 0.14583333333333
12238, 0.39583333333333, 1.35, 0.20833333333333
12239, 0.41666666666667, 1.35, 0.1875
12240, 0.39583333333333, 1.35, 0.25
12241, 0.41666666666667, 1.35, 0.22916666666667
12242, 0.39583333333333, 1.35, 0.29166666666667
12243, 0.41666666666667, 1.35, 0.27083333333333
12244, 0.39583333333333, 1.35, 0.33333333333333
12245, 0.41666666666667, 1.35, 0.3125
12246, 0.39583333333333, 1.35, 0.375
12247, 0.41666666666667, 1.35, 0.35416666666667
12248, 0.39583333333333, 1.35, 0.41666666666667
12249, 0.41666666666667, 1.35, 0.39583333333333
12250, 0.39583333333333, 1.35, 0.45833333333333
12251, 0.41666666666667, 1.35, 0.4375
12252, 0.41666666666667, 1.35, 0.47916666666667
12253, 0.4375, 1.35, 0.041666666666667
12254, 0.45833333333333, 1.35, 0.020833333333333
12255, 0.4375, 1.35, 0.083333333333333
12256, 0.45833333333333, 1.35, 0.0625
12257, 0.4375, 1.35, 0.125
12258, 0.45833333333333, 1.35, 0.10416666666667
12259, 0.4375, 1.35, 0.16666666666667
12260, 0.45833333333333, 1.35, 0.14583333333333
12261, 0.4375, 1.35, 0.20833333333333
12262, 0.45833333333333, 1.35, 0.1875
12263, 0.4375, 1.35, 0.25
12264, 0.45833333333333, 1.35, 0.22916666666667
12265, 0.4375, 1.35, 0.29166666666667
12266, 0.45833333333333, 1.35, 0.27083333333333
12267, 0.4375, 1.35, 0.33333333333333
12268, 0.45833333333333, 1.35, 0.3125
12269, 0.4375, 1.35, 0.375
12270, 0.45833333333333, 1.35, 0.35416666666667
12271, 0.4375, 1.35, 0.41666666666667
12272, 0.45833333333333, 1.35, 0.39583333333333
12273, 0.4375, 1.35, 0.45833333333333
12274, 0.45833333333333, 1.35, 0.4375
12275, 0.45833333333333, 1.35, 0.47916666666667
12276, 0.47916666666667, 1.35, 0.041666666666667
12277, 0.5, 1.35, 0.020833333333333
12278, 0.47916666666667, 1.35, 0.083333333333333
12279, 0.5, 1.35, 0.0625
12280, 0.47916666666667, 1.35, 0.125
12281, 0.5, 1.35, 0.10416666666667
12282, 0.47916666666667, 1.35, 0.16666666666667
12283, 0.5, 1.35, 0.14583333333333
12284, 0.47916666666667, 1.35, 0.20833333333333
12285, 0.5, 1.35, 0.1875
12286, 0.47916666666667, 1.35, 0.25
12287, 0.5, 1.35, 0.22916666666667
12288, 0.47916666666667, 1.35, 0.29166666666667
12289, 0.5, 1.35, 0.27083333333333
12290, 0.47916666666667, 1.35, 0.33333333333333
12291, 0.5, 1.35, 0.3125
12292, 0.47916666666667, 1.35, 0.375
12293, 0.5, 1.35, 0.35416666666667
12294, 0.47916666666667, 1.35, 0.41666666666667
12295, 0.5, 1.35, 0.39583333333333
12296, 0.47916666666667, 1.35, 0.45833333333333
12297, 0.5, 1.35, 0.4375
12298, 0.5, 1.35, 0.47916666666667
12299, 0.52083333333333, 1.35, 0.041666666666667
12300, 0.54166666666667, 1.35, 0.020833333333333
12301, 0.52083333333333, 1.35, 0.083333333333333
12302, 0.54166666666667, 1.35, 0.0625
12303, 0.52083333333333, 1.35, 0.125
12304, 0.54166666666667, 1.35, 0.10416666666667
12305, 0.52083333333333, 1.35, 0.16666666666667
12306, 0.54166666666667, 1.35, 0.14583333333333
12307, 0.52083333333333, 1.35, 0.20833333333333
12308, 0.54166666666667, 1.35, 0.1875
12309, 0.52083333333333, 1.35, 0.25
12310, 0.54166666666667, 1.35, 0.22916666666667
12311, 0.52083333333333, 1.35, 0.29166666666667
12312, 0.54166666666667, 1.35, 0.27083333333333
12313, 0.52083333333333, 1.35, 0.33333333333333
12314, 0.54166666666667, 1.35, 0.3125
12315, 0.52083333333333, 1.35, 0.375
12316, 0.54166666666667, 1.35, 0.35416666666667
12317, 0.52083333333333, 1.35, 0.41666666666667
12318, 0.54166666666667, 1.35, 0.39583333333333
12319, 0.52083333333333, 1.35, 0.45833333333333
12320, 0.54166666666667, 1.35, 0.4375
12321, 0.54166666666667, 1.35, 0.47916666666667
12322, 0.5625, 1.35, 0.041666666666667
12323, 0.58333333333333, 1.35, 0.020833333333333
12324, 0.5625, 1.35, 0.083333333333333
12325, 0.58333333333333, 1.35, 0.0625
12326, 0.5625, 1.35, 0.125
12327, 0.58333333333333, 1.35, 0.10416666666667
12328, 0.5625, 1.35, 0.16666666666667
12329, 0.58333333333333, 1.35, 0.14583333333333
12330, 0.5625, 1.35, 0.20833333333333
12331, 0.58333333333333, 1.35, 0.1875
12332, 0.5625, 1.35, 0.25
12333, 0.58333333333333, 1.35, 0.22916666666667
12334, 0.5625, 1.35, 0.29166666666667
12335, 0.58333333333333, 1.35, 0.27083333333333
12336, 0.5625, 1.35, 0.33333333333333
12337, 0.58333333333333, 1.35, 0.3125
12338, 0.5625, 1.35, 0.375
12339, 0.58333333333333, 1.35, 0.35416666666667
12340, 0.5625, 1.35, 0.41666666666667
12341, 0.58333333333333, 1.35, 0.39583333333333
12342, 0.5625, 1.35, 0.45833333333333
12343, 0.58333333333333, 1.35, 0.4375
12344, 0.58333333333333, 1.35, 0.47916666666667
12345, 0.60416666666667, 1.35, 0.041666666666667
12346, 0.625, 1.35, 0.020833333333333
12347, 0.60416666666667, 1.35, 0.083333333333333
12348, 0.625, 1.35, 0.0625
12349, 0.60416666666667, 1.35, 0.125
12350, 0.625, 1.35, 0.10416666666667
12351, 0.60416666666667, 1.35, 0.16666666666667
12352, 0.625, 1.35, 0.14583333333333
12353, 0.60416666666667, 1.35, 0.20833333333333
12354, 0.625, 1.35, 0.1875
12355, 0.60416666666667, 1.35, 0.25
12356, 0.625, 1.35, 0.22916666666667
12357, 0.60416666666667, 1.35, 0.29166666666667
12358, 0.625, 1.35, 0.27083333333333
12359, 0.60416666666667, 1.35, 0.33333333333333
12360, 0.625, 1.35, 0.3125
12361, 0.60416666666667, 1.35, 0.375
12362, 0.625, 1.35, 0.35416666666667
12363, 0.60416666666667, 1.35, 0.41666666666667
12364, 0.625, 1.35, 0.39583333333333
12365, 0.60416666666667, 1.35, 0.45833333333333
12366, 0.625, 1.35, 0.4375
12367, 0.625, 1.35, 0.47916666666667
12368, 0.64583333333333, 1.35, 0.041666666666667
12369, 0.66666666666667, 1.35, 0.020833333333333
12370, 0.64583333333333, 1.35, 0.083333333333333
12371, 0.66666666666667, 1.35, 0.0625
12372, 0.64583333333333, 1.35, 0.125
12373, 0.66666666666667, 1.35, 0.10416666666667
12374, 0.64583333333333, 1.35, 0.16666666666667
12375, 0.66666666666667, 1.35, 0.14583333333333
12376, 0.64583333333333, 1.35, 0.20833333333333
12377, 0.66666666666667, 1.35, 0.1875
12378, 0.64583333333333, 1.35, 0.25
12379, 0.66666666666667, 1.35, 0.22916666666667
12380, 0.64583333333333, 1.35, 0.29166666666667
12381, 0.66666666666667, 1.35, 0.27083333333333
12382, 0.64583333333333, 1.35, 0.33333333333333
12383, 0.66666666666667, 1.35, 0.3125
12384, 0.64583333333333, 1.35, 0.375
12385, 0.66666666666667, 1.35, 0.35416666666667
12386, 0.64583333333333, 1.35, 0.41666666666667
12387, 0.66666666666667, 1.35, 0.39583333333333
12388, 0.64583333333333, 1.35, 0.45833333333333
12389, 0.66666666666667, 1.35, 0.4375
12390, 0.66666666666667, 1.35, 0.47916666666667
12391, 0.6875, 1.35, 0.041666666666667
12392, 0.70833333333333, 1.35, 0.020833333333333
12393, 0.6875, 1.35, 0.083333333333333
12394, 0.70833333333333, 1.35, 0.0625
12395, 0.6875, 1.35, 0.125
12396, 0.70833333333333, 1.35, 0.10416666666667
12397, 0.6875, 1.35, 0.16666666666667
12398, 0.70833333333333, 1.35, 0.14583333333333
12399, 0.6875, 1.35, 0.20833333333333
12400, 0.70833333333333, 1.35, 0.1875
12401, 0.6875, 1.35, 0.25
12402, 0.70833333333333, 1.35, 0.22916666666667
12403, 0.6875, 1.35, 0.29166666666667
12404, 0.70833333333333, 1.35, 0.27083333333333
12405, 0.6875, 1.35, 0.33333333333333
12406, 0.70833333333333, 1.35, 0.3125
12407, 0.6875, 1.35, 0.375
12408, 0.70833333333333, 1.35, 0.35416666666667
12409, 0.6875, 1.35, 0.41666666666667
12410, 0.70833333333333, 1.35, 0.39583333333333
12411, 0.6875, 1.35, 0.45833333333333
12412, 0.70833333333333, 1.35, 0.4375
12413, 0.70833333333333, 1.35, 0.47916666666667
12414, 0.72916666666667, 1.35, 0.041666666666667
12415, 0.75, 1.35, 0.020833333333333
12416, 0.72916666666667, 1.35, 0.083333333333333
12417, 0.75, 1.35, 0.0625
12418, 0.72916666666667, 1.35, 0.125
12419, 0.75, 1.35, 0.10416666666667
12420, 0.72916666666667, 1.35, 0.16666666666667
12421, 0.75, 1.35, 0.14583333333333
12422, 0.72916666666667, 1.35, 0.20833333333333
12423, 0.75, 1.35, 0.1875
12424, 0.72916666666667, 1.35, 0.25
12425, 0.75, 1.35, 0.22916666666667
12426, 0.72916666666667, 1.35, 0.29166666666667
12427, 0.75, 1.35, 0.27083333333333
12428, 0.72916666666667, 1.35, 0.33333333333333
12429, 0.75, 1.35, 0.3125
12430, 0.72916666666667, 1.35, 0.375
12431, 0.75, 1.35, 0.35416666666667
12432, 0.72916666666667, 1.35, 0.41666666666667
12433, 0.75, 1.35, 0.39583333333333
12434, 0.72916666666667, 1.35, 0.45833333333333
12435, 0.75, 1.35, 0.4375
12436, 0.75, 1.35, 0.47916666666667
12437, 0.77083333333333, 1.35, 0.041666666666667
12438, 0.79166666666667, 1.35, 0.020833333333333
12439, 0.77083333333333, 1.35, 0.083333333333333
12440, 0.79166666666667, 1.35, 0.0625
12441, 0.77083333333333, 1.35, 0.125
12442, 0.79166666666667, 1.35, 0.10416666666667
12443, 0.77083333333333, 1.35, 0.16666666666667
12444, 0.79166666666667, 1.35, 0.14583333333333
12445, 0.77083333333333, 1.35, 0.20833333333333
12446, 0.79166666666667, 1.35, 0.1875
12447, 0.77083333333333, 1.35, 0.25
12448, 0.79166666666667, 1.35, 0.22916666666667
12449, 0.77083333333333, 1.35, 0.29166666666667
12450, 0.79166666666667, 1.35, 0.27083333333333
12451, 0.77083333333333, 1.35, 0.33333333333333
12452, 0.79166666666667, 1.35, 0.3125
12453, 0.77083333333333, 1.35, 0.375
12454, 0.79166666666667, 1.35, 0.35416666666667
12455, 0.77083333333333, 1.35, 0.41666666666667
12456, 0.79166666666667, 1.35, 0.39583333333333
12457, 0.77083333333333, 1.35, 0.45833333333333
12458, 0.79166666666667, 1.35, 0.4375
12459, 0.79166666666667, 1.35, 0.47916666666667
12460, 0.8125, 1.35, 0.041666666666667
12461, 0.83333333333333, 1.35, 0.020833333333333
12462, 0.8125, 1.35, 0.083333333333333
12463, 0.83333333333333, 1.35, 0.0625
12464, 0.8125, 1.35, 0.125
12465, 0.83333333333333, 1.35, 0.10416666666667
12466, 0.8125, 1.35, 0.16666666666667
12467, 0.83333333333333, 1.35, 0.14583333333333
12468, 0.8125, 1.35, 0.20833333333333
12469, 0.83333333333333, 1.35, 0.1875
12470, 0.8125, 1.35, 0.25
12471, 0.83333333333333, 1.35, 0.22916666666667
12472, 0.8125, 1.35, 0.29166666666667
12473, 0.83333333333333, 1.35, 0.27083333333333
12474, 0.8125, 1.35, 0.33333333333333
12475, 0.83333333333333, 1.35, 0.3125
12476, 0.8125, 1.35, 0.375
12477, 0.83333333333333, 1.35, 0.35416666666667
12478, 0.8125, 1.35, 0.41666666666667
12479, 0.83333333333333, 1.35, 0.39583333333333
12480, 0.8125, 1.35, 0.45833333333333
12481, 0.83333333333333, 1.35, 0.4375
12482, 0.83333333333333, 1.35, 0.47916666666667
12483, 0.85416666666667, 1.35, 0.041666666666667
12484, 0.875, 1.35, 0.020833333333333
12485, 0.85416666666667, 1.35, 0.083333333333333
12486, 0.875, 1.35, 0.0625
12487, 0.85416666666667, 1.35, 0.125
12488, 0.875, 1.35, 0.10416666666667
12489, 0.85416666666667, 1.35, 0.16666666666667
12490, 0.875, 1.35, 0.14583333333333
12491, 0.85416666666667, 1.35, 0.20833333333333
12492, 0.875, 1.35, 0.1875
12493, 0.85416666666667, 1.35, 0.25
12494, 0.875, 1.35, 0.22916666666667
12495, 0.85416666666667, 1.35, 0.29166666666667
12496, 0.875, 1.35, 0.27083333333333
12497, 0.85416666666667, 1.35, 0.33333333333333
12498, 0.875, 1.35, 0.3125
12499, 0.85416666666667, 1.35, 0.375
12500, 0.875, 1.35, 0.35416666666667
12501, 0.85416666666667, 1.35, 0.41666666666667
12502, 0.875, 1.35, 0.39583333333333
12503, 0.85416666666667, 1.35, 0.45833333333333
12504, 0.875, 1.35, 0.4375
12505, 0.875, 1.35, 0.47916666666667
12506, 0.89583333333333, 1.35, 0.041666666666667
12507, 0.91666666666667, 1.35, 0.020833333333333
12508, 0.89583333333333, 1.35, 0.083333333333333
12509, 0.91666666666667, 1.35, 0.0625
12510, 0.89583333333333, 1.35, 0.125
12511, 0.91666666666667, 1.35, 0.10416666666667
12512, 0.89583333333333, 1.35, 0.16666666666667
12513, 0.91666666666667, 1.35, 0.14583333333333
12514, 0.89583333333333, 1.35, 0.20833333333333
12515, 0.91666666666667, 1.35, 0.1875
12516, 0.89583333333333, 1.35, 0.25
12517, 0.91666666666667, 1.35, 0.22916666666667
12518, 0.89583333333333, 1.35, 0.29166666666667
12519, 0.91666666666667, 1.35, 0.27083333333333
12520, 0.89583333333333, 1.35, 0.33333333333333
12521, 0.91666666666667, 1.35, 0.3125
12522, 0.89583333333333, 1.35, 0.375
12523, 0.91666666666667, 1.35, 0.35416666666667
12524, 0.89583333333333, 1.35, 0.41666666666667
12525, 0.91666666666667, 1.35, 0.39583333333333
12526, 0.89583333333333, 1.35, 0.45833333333333
12527, 0.91666666666667, 1.35, 0.4375
12528, 0.91666666666667, 1.35, 0.47916666666667
12529, 0.9375, 1.35, 0.041666666666667
12530, 0.95833333333333, 1.35, 0.020833333333333
12531, 0.9375, 1.35, 0.083333333333333
12532, 0.95833333333333, 1.35, 0.0625
12533, 0.9375, 1.35, 0.125
12534, 0.95833333333333, 1.35, 0.10416666666667
12535, 0.9375, 1.35, 0.16666666666667
12536, 0.95833333333333, 1.35, 0.14583333333333
12537, 0.9375, 1.35, 0.20833333333333
12538, 0.95833333333333, 1.35, 0.1875
12539, 0.9375, 1.35, 0.25
12540, 0.95833333333333, 1.35, 0.22916666666667
12541, 0.9375, 1.35, 0.29166666666667
12542, 0.95833333333333, 1.35, 0.27083333333333
12543, 0.9375, 1.35, 0.33333333333333
12544, 0.95833333333333, 1.35, 0.3125
12545, 0.9375, 1.35, 0.375
12546, 0.95833333333333, 1.35, 0.35416666666667
12547, 0.9375, 1.35, 0.41666666666667
12548, 0.95833333333333, 1.35, 0.39583333333333
12549, 0.9375, 1.35, 0.45833333333333
12550, 0.95833333333333, 1.35, 0.4375
12551, 0.95833333333333, 1.35, 0.47916666666667
12552, 0.97916666666667, 1.35, 0.041666666666667
12553, 0.97916666666667, 1.35, 0.083333333333333
12554, 0.97916666666667, 1.35, 0.125
12555, 0.97916666666667, 1.35, 0.16666666666667
12556, 0.97916666666667, 1.35, 0.20833333333333
12557, 0.97916666666667, 1.35, 0.25
12558, 0.97916666666667, 1.35, 0.29166666666667
12559, 0.97916666666667, 1.35, 0.33333333333333
12560, 0.97916666666667, 1.35, 0.375
12561, 0.97916666666667, 1.35, 0.41666666666667
12562, 0.97916666666667, 1.35, 0.45833333333333
12563, 0.041666666666667, 1.375, 0
12564, 0.083333333333333, 1.375, 0
12565, 0.125, 1.375, 0
12566, 0.16666666666667, 1.375, 0
12567, 0.20833333333333, 1.375, 0
12568, 0.25, 1.375, 0
12569, 0.29166666666667, 1.375, 0
12570, 0.33333333333333, 1.375, 0
12571, 0.375, 1.375, 0
12572, 0.41666666666667, 1.375, 0
12573, 0.45833333333333, 1.375, 0
12574, 0.5, 1.375, 0
12575, 0.54166666666667, 1.375, 0
12576, 0.58333333333333, 1.375, 0
12577, 0.625, 1.375, 0
12578, 0.66666666666667, 1.375, 0
12579, 0.70833333333333, 1.375, 0
12580, 0.75, 1.375, 0
12581, 0.79166666666667, 1.375, 0
12582, 0.83333333333333, 1.375, 0
12583, 0.875, 1.375, 0
12584, 0.91666666666667, 1.375, 0
12585, 0.95833333333333, 1.375, 0
12586, 1, 1.375, 0.041666666666667
12587, 1, 1.375, 0.083333333333333
12588, 1, 1.375, 0.125
12589, 1, 1.375, 0.16666666666667
12590, 1, 1.375, 0.20833333333333
12591, 1, 1.375, 0.25
12592, 1, 1.375, 0.29166666666667
12593, 1, 1.375, 0.33333333333333
12594, 1, 1.375, 0.375
12595, 1, 1.375, 0.41666666666667
12596, 1, 1.375, 0.45833333333333
12597, 0.041666666666667, 1.375, 0.5
12598, 0.083333333333333, 1.375, 0.5
12599, 0.125, 1.375, 0.5
12600, 0.16666666666667, 1.375, 0.5
12601, 0.20833333333333, 1.375, 0.5
12602, 0.25, 1.375, 0.5
12603, 0.29166666666667, 1.375, 0.5
12604, 0.33333333333333, 1.375, 0.5
12605, 0.375, 1.375, 0.5
12606, 0.41666666666667, 1.375, 0.5
12607, 0.45833333333333, 1.375, 0.5
12608, 0.5, 1.375, 0.5
12609, 0.54166666666667, 1.375, 0.5
12610, 0.58333333333333, 1.375, 0.5
12611, 0.625, 1.375, 0.5
12612, 0.66666666666667, 1.375, 0.5
12613, 0.70833333333333, 1.375, 0.5
12614, 0.75, 1.375, 0.5
