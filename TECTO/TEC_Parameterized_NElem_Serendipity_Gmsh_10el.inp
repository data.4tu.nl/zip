15164, 1.5333333333333, 1.4666666666667, 0.5
15165, 1.575, 1.4666666666667, 0.5
15166, 1.6166666666667, 1.4666666666667, 0.5
15167, 1.6583333333333, 1.4666666666667, 0.5
15168, 1.7, 1.4666666666667, 0.5
15169, 1.7416666666667, 1.4666666666667, 0.5
15170, 1.7833333333333, 1.4666666666667, 0.5
15171, 1.825, 1.4666666666667, 0.5
15172, 1.8666666666667, 1.4666666666667, 0.5
15173, 1.9083333333333, 1.4666666666667, 0.5
15174, 1.95, 1.4666666666667, 0.5
15175, 1.9916666666667, 1.4666666666667, 0.5
15176, 2.0333333333333, 1.4666666666667, 0.5
15177, 2.075, 1.4666666666667, 0.5
15178, 2.1166666666667, 1.4666666666667, 0.5
15179, 2.1583333333333, 1.4666666666667, 0.5
15180, 1.2416666666667, 1.4166666666667, 0.5
15181, 1.2208333333333, 1.4333333333333, 0.5
15182, 1.2833333333333, 1.4166666666667, 0.5
15183, 1.2625, 1.4333333333333, 0.5
15184, 1.325, 1.4166666666667, 0.5
15185, 1.3041666666667, 1.4333333333333, 0.5
15186, 1.3666666666667, 1.4166666666667, 0.5
15187, 1.3458333333333, 1.4333333333333, 0.5
15188, 1.4083333333333, 1.4166666666667, 0.5
15189, 1.3875, 1.4333333333333, 0.5
15190, 1.45, 1.4166666666667, 0.5
15191, 1.4291666666667, 1.4333333333333, 0.5
15192, 1.4916666666667, 1.4166666666667, 0.5
15193, 1.4708333333333, 1.4333333333333, 0.5
15194, 1.5333333333333, 1.4166666666667, 0.5
15195, 1.5125, 1.4333333333333, 0.5
15196, 1.575, 1.4166666666667, 0.5
15197, 1.5541666666667, 1.4333333333333, 0.5
15198, 1.6166666666667, 1.4166666666667, 0.5
15199, 1.5958333333333, 1.4333333333333, 0.5
15200, 1.6583333333333, 1.4166666666667, 0.5
15201, 1.6375, 1.4333333333333, 0.5
15202, 1.7, 1.4166666666667, 0.5
15203, 1.6791666666667, 1.4333333333333, 0.5
15204, 1.7416666666667, 1.4166666666667, 0.5
15205, 1.7208333333333, 1.4333333333333, 0.5
15206, 1.7833333333333, 1.4166666666667, 0.5
15207, 1.7625, 1.4333333333333, 0.5
15208, 1.825, 1.4166666666667, 0.5
15209, 1.8041666666667, 1.4333333333333, 0.5
15210, 1.8666666666667, 1.4166666666667, 0.5
15211, 1.8458333333333, 1.4333333333333, 0.5
15212, 1.9083333333333, 1.4166666666667, 0.5
15213, 1.8875, 1.4333333333333, 0.5
15214, 1.95, 1.4166666666667, 0.5
15215, 1.9291666666667, 1.4333333333333, 0.5
15216, 1.9916666666667, 1.4166666666667, 0.5
15217, 1.9708333333333, 1.4333333333333, 0.5
15218, 2.0333333333333, 1.4166666666667, 0.5
15219, 2.0125, 1.4333333333333, 0.5
15220, 2.075, 1.4166666666667, 0.5
15221, 2.0541666666667, 1.4333333333333, 0.5
15222, 2.1166666666667, 1.4166666666667, 0.5
15223, 2.0958333333333, 1.4333333333333, 0.5
15224, 2.1583333333333, 1.4166666666667, 0.5
15225, 2.1375, 1.4333333333333, 0.5
15226, 2.1791666666667, 1.4333333333333, 0.5
15227, 1.2416666666667, 1.45, 0.5
15228, 1.2208333333333, 1.4666666666667, 0.5
15229, 1.2833333333333, 1.45, 0.5
15230, 1.2625, 1.4666666666667, 0.5
15231, 1.325, 1.45, 0.5
15232, 1.3041666666667, 1.4666666666667, 0.5
15233, 1.3666666666667, 1.45, 0.5
15234, 1.3458333333333, 1.4666666666667, 0.5
15235, 1.4083333333333, 1.45, 0.5
15236, 1.3875, 1.4666666666667, 0.5
15237, 1.45, 1.45, 0.5
15238, 1.4291666666667, 1.4666666666667, 0.5
15239, 1.4916666666667, 1.45, 0.5
15240, 1.4708333333333, 1.4666666666667, 0.5
15241, 1.5333333333333, 1.45, 0.5
15242, 1.5125, 1.4666666666667, 0.5
15243, 1.575, 1.45, 0.5
15244, 1.5541666666667, 1.4666666666667, 0.5
15245, 1.6166666666667, 1.45, 0.5
15246, 1.5958333333333, 1.4666666666667, 0.5
15247, 1.6583333333333, 1.45, 0.5
15248, 1.6375, 1.4666666666667, 0.5
15249, 1.7, 1.45, 0.5
15250, 1.6791666666667, 1.4666666666667, 0.5
15251, 1.7416666666667, 1.45, 0.5
15252, 1.7208333333333, 1.4666666666667, 0.5
15253, 1.7833333333333, 1.45, 0.5
15254, 1.7625, 1.4666666666667, 0.5
15255, 1.825, 1.45, 0.5
15256, 1.8041666666667, 1.4666666666667, 0.5
15257, 1.8666666666667, 1.45, 0.5
15258, 1.8458333333333, 1.4666666666667, 0.5
15259, 1.9083333333333, 1.45, 0.5
15260, 1.8875, 1.4666666666667, 0.5
15261, 1.95, 1.45, 0.5
15262, 1.9291666666667, 1.4666666666667, 0.5
15263, 1.9916666666667, 1.45, 0.5
15264, 1.9708333333333, 1.4666666666667, 0.5
15265, 2.0333333333333, 1.45, 0.5
15266, 2.0125, 1.4666666666667, 0.5
15267, 2.075, 1.45, 0.5
15268, 2.0541666666667, 1.4666666666667, 0.5
15269, 2.1166666666667, 1.45, 0.5
15270, 2.0958333333333, 1.4666666666667, 0.5
15271, 2.1583333333333, 1.45, 0.5
15272, 2.1375, 1.4666666666667, 0.5
15273, 2.1791666666667, 1.4666666666667, 0.5
15274, 1.2416666666667, 1.4833333333333, 0.5
15275, 1.2833333333333, 1.4833333333333, 0.5
15276, 1.325, 1.4833333333333, 0.5
15277, 1.3666666666667, 1.4833333333333, 0.5
15278, 1.4083333333333, 1.4833333333333, 0.5
15279, 1.45, 1.4833333333333, 0.5
15280, 1.4916666666667, 1.4833333333333, 0.5
15281, 1.5333333333333, 1.4833333333333, 0.5
15282, 1.575, 1.4833333333333, 0.5
15283, 1.6166666666667, 1.4833333333333, 0.5
15284, 1.6583333333333, 1.4833333333333, 0.5
15285, 1.7, 1.4833333333333, 0.5
15286, 1.7416666666667, 1.4833333333333, 0.5
15287, 1.7833333333333, 1.4833333333333, 0.5
15288, 1.825, 1.4833333333333, 0.5
15289, 1.8666666666667, 1.4833333333333, 0.5
15290, 1.9083333333333, 1.4833333333333, 0.5
15291, 1.95, 1.4833333333333, 0.5
15292, 1.9916666666667, 1.4833333333333, 0.5
15293, 2.0333333333333, 1.4833333333333, 0.5
15294, 2.075, 1.4833333333333, 0.5
15295, 2.1166666666667, 1.4833333333333, 0.5
15296, 2.1583333333333, 1.4833333333333, 0.5
15297, 1.2416666666667, 1.4333333333333, 0
15298, 1.2833333333333, 1.4333333333333, 0
15299, 1.325, 1.4333333333333, 0
15300, 1.3666666666667, 1.4333333333333, 0
15301, 1.4083333333333, 1.4333333333333, 0
15302, 1.45, 1.4333333333333, 0
15303, 1.4916666666667, 1.4333333333333, 0
15304, 1.5333333333333, 1.4333333333333, 0
15305, 1.575, 1.4333333333333, 0
15306, 1.6166666666667, 1.4333333333333, 0
15307, 1.6583333333333, 1.4333333333333, 0
15308, 1.7, 1.4333333333333, 0
15309, 1.7416666666667, 1.4333333333333, 0
15310, 1.7833333333333, 1.4333333333333, 0
15311, 1.825, 1.4333333333333, 0
15312, 1.8666666666667, 1.4333333333333, 0
15313, 1.9083333333333, 1.4333333333333, 0
15314, 1.95, 1.4333333333333, 0
15315, 1.9916666666667, 1.4333333333333, 0
15316, 2.0333333333333, 1.4333333333333, 0
15317, 2.075, 1.4333333333333, 0
15318, 2.1166666666667, 1.4333333333333, 0
15319, 2.1583333333333, 1.4333333333333, 0
15320, 1.2416666666667, 1.4666666666667, 0
15321, 1.2833333333333, 1.4666666666667, 0
15322, 1.325, 1.4666666666667, 0
15323, 1.3666666666667, 1.4666666666667, 0
15324, 1.4083333333333, 1.4666666666667, 0
15325, 1.45, 1.4666666666667, 0
15326, 1.4916666666667, 1.4666666666667, 0
15327, 1.5333333333333, 1.4666666666667, 0
15328, 1.575, 1.4666666666667, 0
15329, 1.6166666666667, 1.4666666666667, 0
15330, 1.6583333333333, 1.4666666666667, 0
15331, 1.7, 1.4666666666667, 0
15332, 1.7416666666667, 1.4666666666667, 0
15333, 1.7833333333333, 1.4666666666667, 0
15334, 1.825, 1.4666666666667, 0
15335, 1.8666666666667, 1.4666666666667, 0
15336, 1.9083333333333, 1.4666666666667, 0
15337, 1.95, 1.4666666666667, 0
15338, 1.9916666666667, 1.4666666666667, 0
15339, 2.0333333333333, 1.4666666666667, 0
15340, 2.075, 1.4666666666667, 0
15341, 2.1166666666667, 1.4666666666667, 0
15342, 2.1583333333333, 1.4666666666667, 0
15343, 1.2208333333333, 1.4333333333333, 0
15344, 1.2416666666667, 1.4166666666667, 0
15345, 1.2625, 1.4333333333333, 0
15346, 1.2833333333333, 1.4166666666667, 0
15347, 1.3041666666667, 1.4333333333333, 0
15348, 1.325, 1.4166666666667, 0
15349, 1.3458333333333, 1.4333333333333, 0
15350, 1.3666666666667, 1.4166666666667, 0
15351, 1.3875, 1.4333333333333, 0
15352, 1.4083333333333, 1.4166666666667, 0
15353, 1.4291666666667, 1.4333333333333, 0
15354, 1.45, 1.4166666666667, 0
15355, 1.4708333333333, 1.4333333333333, 0
15356, 1.4916666666667, 1.4166666666667, 0
15357, 1.5125, 1.4333333333333, 0
15358, 1.5333333333333, 1.4166666666667, 0
15359, 1.5541666666667, 1.4333333333333, 0
15360, 1.575, 1.4166666666667, 0
15361, 1.5958333333333, 1.4333333333333, 0
15362, 1.6166666666667, 1.4166666666667, 0
15363, 1.6375, 1.4333333333333, 0
15364, 1.6583333333333, 1.4166666666667, 0
15365, 1.6791666666667, 1.4333333333333, 0
15366, 1.7, 1.4166666666667, 0
15367, 1.7208333333333, 1.4333333333333, 0
15368, 1.7416666666667, 1.4166666666667, 0
15369, 1.7625, 1.4333333333333, 0
15370, 1.7833333333333, 1.4166666666667, 0
15371, 1.8041666666667, 1.4333333333333, 0
15372, 1.825, 1.4166666666667, 0
15373, 1.8458333333333, 1.4333333333333, 0
15374, 1.8666666666667, 1.4166666666667, 0
15375, 1.8875, 1.4333333333333, 0
15376, 1.9083333333333, 1.4166666666667, 0
15377, 1.9291666666667, 1.4333333333333, 0
15378, 1.95, 1.4166666666667, 0
15379, 1.9708333333333, 1.4333333333333, 0
15380, 1.9916666666667, 1.4166666666667, 0
15381, 2.0125, 1.4333333333333, 0
15382, 2.0333333333333, 1.4166666666667, 0
15383, 2.0541666666667, 1.4333333333333, 0
15384, 2.075, 1.4166666666667, 0
15385, 2.0958333333333, 1.4333333333333, 0
15386, 2.1166666666667, 1.4166666666667, 0
15387, 2.1375, 1.4333333333333, 0
15388, 2.1583333333333, 1.4166666666667, 0
15389, 2.1791666666667, 1.4333333333333, 0
15390, 1.2208333333333, 1.4666666666667, 0
15391, 1.2416666666667, 1.45, 0
15392, 1.2625, 1.4666666666667, 0
15393, 1.2833333333333, 1.45, 0
15394, 1.3041666666667, 1.4666666666667, 0
15395, 1.325, 1.45, 0
15396, 1.3458333333333, 1.4666666666667, 0
15397, 1.3666666666667, 1.45, 0
15398, 1.3875, 1.4666666666667, 0
15399, 1.4083333333333, 1.45, 0
15400, 1.4291666666667, 1.4666666666667, 0
15401, 1.45, 1.45, 0
15402, 1.4708333333333, 1.4666666666667, 0
15403, 1.4916666666667, 1.45, 0
15404, 1.5125, 1.4666666666667, 0
15405, 1.5333333333333, 1.45, 0
15406, 1.5541666666667, 1.4666666666667, 0
15407, 1.575, 1.45, 0
15408, 1.5958333333333, 1.4666666666667, 0
15409, 1.6166666666667, 1.45, 0
15410, 1.6375, 1.4666666666667, 0
15411, 1.6583333333333, 1.45, 0
15412, 1.6791666666667, 1.4666666666667, 0
15413, 1.7, 1.45, 0
15414, 1.7208333333333, 1.4666666666667, 0
15415, 1.7416666666667, 1.45, 0
15416, 1.7625, 1.4666666666667, 0
15417, 1.7833333333333, 1.45, 0
15418, 1.8041666666667, 1.4666666666667, 0
15419, 1.825, 1.45, 0
15420, 1.8458333333333, 1.4666666666667, 0
15421, 1.8666666666667, 1.45, 0
15422, 1.8875, 1.4666666666667, 0
15423, 1.9083333333333, 1.45, 0
15424, 1.9291666666667, 1.4666666666667, 0
15425, 1.95, 1.45, 0
15426, 1.9708333333333, 1.4666666666667, 0
15427, 1.9916666666667, 1.45, 0
15428, 2.0125, 1.4666666666667, 0
15429, 2.0333333333333, 1.45, 0
15430, 2.0541666666667, 1.4666666666667, 0
15431, 2.075, 1.45, 0
15432, 2.0958333333333, 1.4666666666667, 0
15433, 2.1166666666667, 1.45, 0
15434, 2.1375, 1.4666666666667, 0
15435, 2.1583333333333, 1.45, 0
15436, 2.1791666666667, 1.4666666666667, 0
15437, 1.2416666666667, 1.4833333333333, 0
15438, 1.2833333333333, 1.4833333333333, 0
15439, 1.325, 1.4833333333333, 0
15440, 1.3666666666667, 1.4833333333333, 0
15441, 1.4083333333333, 1.4833333333333, 0
15442, 1.45, 1.4833333333333, 0
15443, 1.4916666666667, 1.4833333333333, 0
15444, 1.5333333333333, 1.4833333333333, 0
15445, 1.575, 1.4833333333333, 0
15446, 1.6166666666667, 1.4833333333333, 0
15447, 1.6583333333333, 1.4833333333333, 0
15448, 1.7, 1.4833333333333, 0
15449, 1.7416666666667, 1.4833333333333, 0
15450, 1.7833333333333, 1.4833333333333, 0
15451, 1.825, 1.4833333333333, 0
15452, 1.8666666666667, 1.4833333333333, 0
15453, 1.9083333333333, 1.4833333333333, 0
15454, 1.95, 1.4833333333333, 0
15455, 1.9916666666667, 1.4833333333333, 0
15456, 2.0333333333333, 1.4833333333333, 0
15457, 2.075, 1.4833333333333, 0
15458, 2.1166666666667, 1.4833333333333, 0
15459, 2.1583333333333, 1.4833333333333, 0
15460, 1.2416666666667, 1.4, 0.041666666666667
15461, 1.2833333333333, 1.4, 0.041666666666667
15462, 1.325, 1.4, 0.041666666666667
15463, 1.3666666666667, 1.4, 0.041666666666667
15464, 1.4083333333333, 1.4, 0.041666666666667
15465, 1.45, 1.4, 0.041666666666667
15466, 1.4916666666667, 1.4, 0.041666666666667
15467, 1.5333333333333, 1.4, 0.041666666666667
15468, 1.575, 1.4, 0.041666666666667
15469, 1.6166666666667, 1.4, 0.041666666666667
15470, 1.6583333333333, 1.4, 0.041666666666667
15471, 1.7, 1.4, 0.041666666666667
15472, 1.7416666666667, 1.4, 0.041666666666667
15473, 1.7833333333333, 1.4, 0.041666666666667
15474, 1.825, 1.4, 0.041666666666667
15475, 1.8666666666667, 1.4, 0.041666666666667
15476, 1.9083333333333, 1.4, 0.041666666666667
15477, 1.95, 1.4, 0.041666666666667
15478, 1.9916666666667, 1.4, 0.041666666666667
15479, 2.0333333333333, 1.4, 0.041666666666667
15480, 2.075, 1.4, 0.041666666666667
15481, 2.1166666666667, 1.4, 0.041666666666667
15482, 2.1583333333333, 1.4, 0.041666666666667
15483, 1.2416666666667, 1.4, 0.083333333333333
15484, 1.2833333333333, 1.4, 0.083333333333333
15485, 1.325, 1.4, 0.083333333333333
15486, 1.3666666666667, 1.4, 0.083333333333333
15487, 1.4083333333333, 1.4, 0.083333333333333
15488, 1.45, 1.4, 0.083333333333333
15489, 1.4916666666667, 1.4, 0.083333333333333
15490, 1.5333333333333, 1.4, 0.083333333333333
15491, 1.575, 1.4, 0.083333333333333
15492, 1.6166666666667, 1.4, 0.083333333333333
15493, 1.6583333333333, 1.4, 0.083333333333333
15494, 1.7, 1.4, 0.083333333333333
15495, 1.7416666666667, 1.4, 0.083333333333333
15496, 1.7833333333333, 1.4, 0.083333333333333
15497, 1.825, 1.4, 0.083333333333333
15498, 1.8666666666667, 1.4, 0.083333333333333
15499, 1.9083333333333, 1.4, 0.083333333333333
15500, 1.95, 1.4, 0.083333333333333
15501, 1.9916666666667, 1.4, 0.083333333333333
15502, 2.0333333333333, 1.4, 0.083333333333333
15503, 2.075, 1.4, 0.083333333333333
15504, 2.1166666666667, 1.4, 0.083333333333333
15505, 2.1583333333333, 1.4, 0.083333333333333
15506, 1.2416666666667, 1.4, 0.125
15507, 1.2833333333333, 1.4, 0.125
15508, 1.325, 1.4, 0.125
15509, 1.3666666666667, 1.4, 0.125
15510, 1.4083333333333, 1.4, 0.125
15511, 1.45, 1.4, 0.125
15512, 1.4916666666667, 1.4, 0.125
15513, 1.5333333333333, 1.4, 0.125
15514, 1.575, 1.4, 0.125
15515, 1.6166666666667, 1.4, 0.125
15516, 1.6583333333333, 1.4, 0.125
15517, 1.7, 1.4, 0.125
15518, 1.7416666666667, 1.4, 0.125
15519, 1.7833333333333, 1.4, 0.125
15520, 1.825, 1.4, 0.125
15521, 1.8666666666667, 1.4, 0.125
15522, 1.9083333333333, 1.4, 0.125
15523, 1.95, 1.4, 0.125
15524, 1.9916666666667, 1.4, 0.125
15525, 2.0333333333333, 1.4, 0.125
15526, 2.075, 1.4, 0.125
15527, 2.1166666666667, 1.4, 0.125
15528, 2.1583333333333, 1.4, 0.125
15529, 1.2416666666667, 1.4, 0.16666666666667
15530, 1.2833333333333, 1.4, 0.16666666666667
15531, 1.325, 1.4, 0.16666666666667
15532, 1.3666666666667, 1.4, 0.16666666666667
15533, 1.4083333333333, 1.4, 0.16666666666667
15534, 1.45, 1.4, 0.16666666666667
15535, 1.4916666666667, 1.4, 0.16666666666667
15536, 1.5333333333333, 1.4, 0.16666666666667
15537, 1.575, 1.4, 0.16666666666667
15538, 1.6166666666667, 1.4, 0.16666666666667
15539, 1.6583333333333, 1.4, 0.16666666666667
15540, 1.7, 1.4, 0.16666666666667
15541, 1.7416666666667, 1.4, 0.16666666666667
15542, 1.7833333333333, 1.4, 0.16666666666667
15543, 1.825, 1.4, 0.16666666666667
15544, 1.8666666666667, 1.4, 0.16666666666667
15545, 1.9083333333333, 1.4, 0.16666666666667
15546, 1.95, 1.4, 0.16666666666667
15547, 1.9916666666667, 1.4, 0.16666666666667
15548, 2.0333333333333, 1.4, 0.16666666666667
15549, 2.075, 1.4, 0.16666666666667
15550, 2.1166666666667, 1.4, 0.16666666666667
15551, 2.1583333333333, 1.4, 0.16666666666667
15552, 1.2416666666667, 1.4, 0.20833333333333
15553, 1.2833333333333, 1.4, 0.20833333333333
15554, 1.325, 1.4, 0.20833333333333
15555, 1.3666666666667, 1.4, 0.20833333333333
15556, 1.4083333333333, 1.4, 0.20833333333333
15557, 1.45, 1.4, 0.20833333333333
15558, 1.4916666666667, 1.4, 0.20833333333333
15559, 1.5333333333333, 1.4, 0.20833333333333
15560, 1.575, 1.4, 0.20833333333333
15561, 1.6166666666667, 1.4, 0.20833333333333
15562, 1.6583333333333, 1.4, 0.20833333333333
15563, 1.7, 1.4, 0.20833333333333
15564, 1.7416666666667, 1.4, 0.20833333333333
15565, 1.7833333333333, 1.4, 0.20833333333333
15566, 1.825, 1.4, 0.20833333333333
15567, 1.8666666666667, 1.4, 0.20833333333333
15568, 1.9083333333333, 1.4, 0.20833333333333
15569, 1.95, 1.4, 0.20833333333333
15570, 1.9916666666667, 1.4, 0.20833333333333
15571, 2.0333333333333, 1.4, 0.20833333333333
15572, 2.075, 1.4, 0.20833333333333
15573, 2.1166666666667, 1.4, 0.20833333333333
15574, 2.1583333333333, 1.4, 0.20833333333333
15575, 1.2416666666667, 1.4, 0.25
15576, 1.2833333333333, 1.4, 0.25
15577, 1.325, 1.4, 0.25
15578, 1.3666666666667, 1.4, 0.25
15579, 1.4083333333333, 1.4, 0.25
15580, 1.45, 1.4, 0.25
15581, 1.4916666666667, 1.4, 0.25
15582, 1.5333333333333, 1.4, 0.25
15583, 1.575, 1.4, 0.25
15584, 1.6166666666667, 1.4, 0.25
15585, 1.6583333333333, 1.4, 0.25
15586, 1.7, 1.4, 0.25
15587, 1.7416666666667, 1.4, 0.25
15588, 1.7833333333333, 1.4, 0.25
15589, 1.825, 1.4, 0.25
15590, 1.8666666666667, 1.4, 0.25
15591, 1.9083333333333, 1.4, 0.25
15592, 1.95, 1.4, 0.25
15593, 1.9916666666667, 1.4, 0.25
15594, 2.0333333333333, 1.4, 0.25
15595, 2.075, 1.4, 0.25
15596, 2.1166666666667, 1.4, 0.25
15597, 2.1583333333333, 1.4, 0.25
15598, 1.2416666666667, 1.4, 0.29166666666667
15599, 1.2833333333333, 1.4, 0.29166666666667
15600, 1.325, 1.4, 0.29166666666667
15601, 1.3666666666667, 1.4, 0.29166666666667
15602, 1.4083333333333, 1.4, 0.29166666666667
15603, 1.45, 1.4, 0.29166666666667
15604, 1.4916666666667, 1.4, 0.29166666666667
15605, 1.5333333333333, 1.4, 0.29166666666667
15606, 1.575, 1.4, 0.29166666666667
15607, 1.6166666666667, 1.4, 0.29166666666667
15608, 1.6583333333333, 1.4, 0.29166666666667
15609, 1.7, 1.4, 0.29166666666667
15610, 1.7416666666667, 1.4, 0.29166666666667
15611, 1.7833333333333, 1.4, 0.29166666666667
15612, 1.825, 1.4, 0.29166666666667
15613, 1.8666666666667, 1.4, 0.29166666666667
15614, 1.9083333333333, 1.4, 0.29166666666667
15615, 1.95, 1.4, 0.29166666666667
15616, 1.9916666666667, 1.4, 0.29166666666667
15617, 2.0333333333333, 1.4, 0.29166666666667
15618, 2.075, 1.4, 0.29166666666667
15619, 2.1166666666667, 1.4, 0.29166666666667
15620, 2.1583333333333, 1.4, 0.29166666666667
15621, 1.2416666666667, 1.4, 0.33333333333333
15622, 1.2833333333333, 1.4, 0.33333333333333
15623, 1.325, 1.4, 0.33333333333333
15624, 1.3666666666667, 1.4, 0.33333333333333
15625, 1.4083333333333, 1.4, 0.33333333333333
15626, 1.45, 1.4, 0.33333333333333
15627, 1.4916666666667, 1.4, 0.33333333333333
15628, 1.5333333333333, 1.4, 0.33333333333333
15629, 1.575, 1.4, 0.33333333333333
15630, 1.6166666666667, 1.4, 0.33333333333333
15631, 1.6583333333333, 1.4, 0.33333333333333
15632, 1.7, 1.4, 0.33333333333333
15633, 1.7416666666667, 1.4, 0.33333333333333
15634, 1.7833333333333, 1.4, 0.33333333333333
15635, 1.825, 1.4, 0.33333333333333
15636, 1.8666666666667, 1.4, 0.33333333333333
15637, 1.9083333333333, 1.4, 0.33333333333333
15638, 1.95, 1.4, 0.33333333333333
15639, 1.9916666666667, 1.4, 0.33333333333333
15640, 2.0333333333333, 1.4, 0.33333333333333
15641, 2.075, 1.4, 0.33333333333333
15642, 2.1166666666667, 1.4, 0.33333333333333
15643, 2.1583333333333, 1.4, 0.33333333333333
15644, 1.2416666666667, 1.4, 0.375
15645, 1.2833333333333, 1.4, 0.375
15646, 1.325, 1.4, 0.375
15647, 1.3666666666667, 1.4, 0.375
15648, 1.4083333333333, 1.4, 0.375
15649, 1.45, 1.4, 0.375
15650, 1.4916666666667, 1.4, 0.375
15651, 1.5333333333333, 1.4, 0.375
15652, 1.575, 1.4, 0.375
15653, 1.6166666666667, 1.4, 0.375
15654, 1.6583333333333, 1.4, 0.375
15655, 1.7, 1.4, 0.375
15656, 1.7416666666667, 1.4, 0.375
15657, 1.7833333333333, 1.4, 0.375
15658, 1.825, 1.4, 0.375
15659, 1.8666666666667, 1.4, 0.375
15660, 1.9083333333333, 1.4, 0.375
15661, 1.95, 1.4, 0.375
15662, 1.9916666666667, 1.4, 0.375
15663, 2.0333333333333, 1.4, 0.375
15664, 2.075, 1.4, 0.375
15665, 2.1166666666667, 1.4, 0.375
15666, 2.1583333333333, 1.4, 0.375
15667, 1.2416666666667, 1.4, 0.41666666666667
15668, 1.2833333333333, 1.4, 0.41666666666667
15669, 1.325, 1.4, 0.41666666666667
15670, 1.3666666666667, 1.4, 0.41666666666667
15671, 1.4083333333333, 1.4, 0.41666666666667
15672, 1.45, 1.4, 0.41666666666667
15673, 1.4916666666667, 1.4, 0.41666666666667
15674, 1.5333333333333, 1.4, 0.41666666666667
15675, 1.575, 1.4, 0.41666666666667
15676, 1.6166666666667, 1.4, 0.41666666666667
15677, 1.6583333333333, 1.4, 0.41666666666667
15678, 1.7, 1.4, 0.41666666666667
15679, 1.7416666666667, 1.4, 0.41666666666667
15680, 1.7833333333333, 1.4, 0.41666666666667
15681, 1.825, 1.4, 0.41666666666667
15682, 1.8666666666667, 1.4, 0.41666666666667
15683, 1.9083333333333, 1.4, 0.41666666666667
15684, 1.95, 1.4, 0.41666666666667
15685, 1.9916666666667, 1.4, 0.41666666666667
15686, 2.0333333333333, 1.4, 0.41666666666667
15687, 2.075, 1.4, 0.41666666666667
15688, 2.1166666666667, 1.4, 0.41666666666667
15689, 2.1583333333333, 1.4, 0.41666666666667
15690, 1.2416666666667, 1.4, 0.45833333333333
15691, 1.2833333333333, 1.4, 0.45833333333333
15692, 1.325, 1.4, 0.45833333333333
15693, 1.3666666666667, 1.4, 0.45833333333333
15694, 1.4083333333333, 1.4, 0.45833333333333
15695, 1.45, 1.4, 0.45833333333333
15696, 1.4916666666667, 1.4, 0.45833333333333
15697, 1.5333333333333, 1.4, 0.45833333333333
15698, 1.575, 1.4, 0.45833333333333
15699, 1.6166666666667, 1.4, 0.45833333333333
15700, 1.6583333333333, 1.4, 0.45833333333333
15701, 1.7, 1.4, 0.45833333333333
15702, 1.7416666666667, 1.4, 0.45833333333333
15703, 1.7833333333333, 1.4, 0.45833333333333
15704, 1.825, 1.4, 0.45833333333333
15705, 1.8666666666667, 1.4, 0.45833333333333
15706, 1.9083333333333, 1.4, 0.45833333333333
15707, 1.95, 1.4, 0.45833333333333
15708, 1.9916666666667, 1.4, 0.45833333333333
15709, 2.0333333333333, 1.4, 0.45833333333333
15710, 2.075, 1.4, 0.45833333333333
15711, 2.1166666666667, 1.4, 0.45833333333333
15712, 2.1583333333333, 1.4, 0.45833333333333
15713, 1.2416666666667, 1.4, 0.020833333333333
15714, 1.2208333333333, 1.4, 0.041666666666667
15715, 1.2833333333333, 1.4, 0.020833333333333
15716, 1.2625, 1.4, 0.041666666666667
15717, 1.325, 1.4, 0.020833333333333
15718, 1.3041666666667, 1.4, 0.041666666666667
15719, 1.3666666666667, 1.4, 0.020833333333333
15720, 1.3458333333333, 1.4, 0.041666666666667
15721, 1.4083333333333, 1.4, 0.020833333333333
15722, 1.3875, 1.4, 0.041666666666667
15723, 1.45, 1.4, 0.020833333333333
15724, 1.4291666666667, 1.4, 0.041666666666667
15725, 1.4916666666667, 1.4, 0.020833333333333
15726, 1.4708333333333, 1.4, 0.041666666666667
15727, 1.5333333333333, 1.4, 0.020833333333333
15728, 1.5125, 1.4, 0.041666666666667
15729, 1.575, 1.4, 0.020833333333333
15730, 1.5541666666667, 1.4, 0.041666666666667
15731, 1.6166666666667, 1.4, 0.020833333333333
15732, 1.5958333333333, 1.4, 0.041666666666667
15733, 1.6583333333333, 1.4, 0.020833333333333
15734, 1.6375, 1.4, 0.041666666666667
15735, 1.7, 1.4, 0.020833333333333
15736, 1.6791666666667, 1.4, 0.041666666666667
15737, 1.7416666666667, 1.4, 0.020833333333333
15738, 1.7208333333333, 1.4, 0.041666666666667
15739, 1.7833333333333, 1.4, 0.020833333333333
15740, 1.7625, 1.4, 0.041666666666667
15741, 1.825, 1.4, 0.020833333333333
15742, 1.8041666666667, 1.4, 0.041666666666667
15743, 1.8666666666667, 1.4, 0.020833333333333
15744, 1.8458333333333, 1.4, 0.041666666666667
15745, 1.9083333333333, 1.4, 0.020833333333333
15746, 1.8875, 1.4, 0.041666666666667
15747, 1.95, 1.4, 0.020833333333333
15748, 1.9291666666667, 1.4, 0.041666666666667
15749, 1.9916666666667, 1.4, 0.020833333333333
15750, 1.9708333333333, 1.4, 0.041666666666667
15751, 2.0333333333333, 1.4, 0.020833333333333
15752, 2.0125, 1.4, 0.041666666666667
15753, 2.075, 1.4, 0.020833333333333
15754, 2.0541666666667, 1.4, 0.041666666666667
15755, 2.1166666666667, 1.4, 0.020833333333333
15756, 2.0958333333333, 1.4, 0.041666666666667
15757, 2.1583333333333, 1.4, 0.020833333333333
15758, 2.1375, 1.4, 0.041666666666667
15759, 2.1791666666667, 1.4, 0.041666666666667
15760, 1.2416666666667, 1.4, 0.0625
15761, 1.2208333333333, 1.4, 0.083333333333333
15762, 1.2833333333333, 1.4, 0.0625
15763, 1.2625, 1.4, 0.083333333333333
15764, 1.325, 1.4, 0.0625
15765, 1.3041666666667, 1.4, 0.083333333333333
15766, 1.3666666666667, 1.4, 0.0625
15767, 1.3458333333333, 1.4, 0.083333333333333
15768, 1.4083333333333, 1.4, 0.0625
15769, 1.3875, 1.4, 0.083333333333333
15770, 1.45, 1.4, 0.0625
15771, 1.4291666666667, 1.4, 0.083333333333333
15772, 1.4916666666667, 1.4, 0.0625
15773, 1.4708333333333, 1.4, 0.083333333333333
15774, 1.5333333333333, 1.4, 0.0625
15775, 1.5125, 1.4, 0.083333333333333
15776, 1.575, 1.4, 0.0625
15777, 1.5541666666667, 1.4, 0.083333333333333
15778, 1.6166666666667, 1.4, 0.0625
15779, 1.5958333333333, 1.4, 0.083333333333333
15780, 1.6583333333333, 1.4, 0.0625
15781, 1.6375, 1.4, 0.083333333333333
15782, 1.7, 1.4, 0.0625
15783, 1.6791666666667, 1.4, 0.083333333333333
15784, 1.7416666666667, 1.4, 0.0625
15785, 1.7208333333333, 1.4, 0.083333333333333
15786, 1.7833333333333, 1.4, 0.0625
15787, 1.7625, 1.4, 0.083333333333333
15788, 1.825, 1.4, 0.0625
15789, 1.8041666666667, 1.4, 0.083333333333333
15790, 1.8666666666667, 1.4, 0.0625
15791, 1.8458333333333, 1.4, 0.083333333333333
15792, 1.9083333333333, 1.4, 0.0625
15793, 1.8875, 1.4, 0.083333333333333
15794, 1.95, 1.4, 0.0625
15795, 1.9291666666667, 1.4, 0.083333333333333
15796, 1.9916666666667, 1.4, 0.0625
15797, 1.9708333333333, 1.4, 0.083333333333333
15798, 2.0333333333333, 1.4, 0.0625
15799, 2.0125, 1.4, 0.083333333333333
15800, 2.075, 1.4, 0.0625
15801, 2.0541666666667, 1.4, 0.083333333333333
15802, 2.1166666666667, 1.4, 0.0625
15803, 2.0958333333333, 1.4, 0.083333333333333
15804, 2.1583333333333, 1.4, 0.0625
15805, 2.1375, 1.4, 0.083333333333333
15806, 2.1791666666667, 1.4, 0.083333333333333
15807, 1.2416666666667, 1.4, 0.10416666666667
15808, 1.2208333333333, 1.4, 0.125
15809, 1.2833333333333, 1.4, 0.10416666666667
15810, 1.2625, 1.4, 0.125
15811, 1.325, 1.4, 0.10416666666667
15812, 1.3041666666667, 1.4, 0.125
15813, 1.3666666666667, 1.4, 0.10416666666667
15814, 1.3458333333333, 1.4, 0.125
15815, 1.4083333333333, 1.4, 0.10416666666667
15816, 1.3875, 1.4, 0.125
15817, 1.45, 1.4, 0.10416666666667
15818, 1.4291666666667, 1.4, 0.125
15819, 1.4916666666667, 1.4, 0.10416666666667
15820, 1.4708333333333, 1.4, 0.125
15821, 1.5333333333333, 1.4, 0.10416666666667
15822, 1.5125, 1.4, 0.125
15823, 1.575, 1.4, 0.10416666666667
15824, 1.5541666666667, 1.4, 0.125
15825, 1.6166666666667, 1.4, 0.10416666666667
15826, 1.5958333333333, 1.4, 0.125
15827, 1.6583333333333, 1.4, 0.10416666666667
15828, 1.6375, 1.4, 0.125
15829, 1.7, 1.4, 0.10416666666667
15830, 1.6791666666667, 1.4, 0.125
15831, 1.7416666666667, 1.4, 0.10416666666667
15832, 1.7208333333333, 1.4, 0.125
15833, 1.7833333333333, 1.4, 0.10416666666667
15834, 1.7625, 1.4, 0.125
15835, 1.825, 1.4, 0.10416666666667
15836, 1.8041666666667, 1.4, 0.125
15837, 1.8666666666667, 1.4, 0.10416666666667
15838, 1.8458333333333, 1.4, 0.125
15839, 1.9083333333333, 1.4, 0.10416666666667
15840, 1.8875, 1.4, 0.125
15841, 1.95, 1.4, 0.10416666666667
15842, 1.9291666666667, 1.4, 0.125
15843, 1.9916666666667, 1.4, 0.10416666666667
15844, 1.9708333333333, 1.4, 0.125
15845, 2.0333333333333, 1.4, 0.10416666666667
15846, 2.0125, 1.4, 0.125
15847, 2.075, 1.4, 0.10416666666667
15848, 2.0541666666667, 1.4, 0.125
15849, 2.1166666666667, 1.4, 0.10416666666667
15850, 2.0958333333333, 1.4, 0.125
15851, 2.1583333333333, 1.4, 0.10416666666667
15852, 2.1375, 1.4, 0.125
15853, 2.1791666666667, 1.4, 0.125
15854, 1.2416666666667, 1.4, 0.14583333333333
15855, 1.2208333333333, 1.4, 0.16666666666667
15856, 1.2833333333333, 1.4, 0.14583333333333
15857, 1.2625, 1.4, 0.16666666666667
15858, 1.325, 1.4, 0.14583333333333
15859, 1.3041666666667, 1.4, 0.16666666666667
15860, 1.3666666666667, 1.4, 0.14583333333333
15861, 1.3458333333333, 1.4, 0.16666666666667
15862, 1.4083333333333, 1.4, 0.14583333333333
15863, 1.3875, 1.4, 0.16666666666667
15864, 1.45, 1.4, 0.14583333333333
15865, 1.4291666666667, 1.4, 0.16666666666667
15866, 1.4916666666667, 1.4, 0.14583333333333
15867, 1.4708333333333, 1.4, 0.16666666666667
15868, 1.5333333333333, 1.4, 0.14583333333333
15869, 1.5125, 1.4, 0.16666666666667
15870, 1.575, 1.4, 0.14583333333333
15871, 1.5541666666667, 1.4, 0.16666666666667
15872, 1.6166666666667, 1.4, 0.14583333333333
15873, 1.5958333333333, 1.4, 0.16666666666667
15874, 1.6583333333333, 1.4, 0.14583333333333
15875, 1.6375, 1.4, 0.16666666666667
15876, 1.7, 1.4, 0.14583333333333
15877, 1.6791666666667, 1.4, 0.16666666666667
15878, 1.7416666666667, 1.4, 0.14583333333333
15879, 1.7208333333333, 1.4, 0.16666666666667
15880, 1.7833333333333, 1.4, 0.14583333333333
15881, 1.7625, 1.4, 0.16666666666667
15882, 1.825, 1.4, 0.14583333333333
15883, 1.8041666666667, 1.4, 0.16666666666667
15884, 1.8666666666667, 1.4, 0.14583333333333
15885, 1.8458333333333, 1.4, 0.16666666666667
15886, 1.9083333333333, 1.4, 0.14583333333333
15887, 1.8875, 1.4, 0.16666666666667
15888, 1.95, 1.4, 0.14583333333333
15889, 1.9291666666667, 1.4, 0.16666666666667
15890, 1.9916666666667, 1.4, 0.14583333333333
15891, 1.9708333333333, 1.4, 0.16666666666667
15892, 2.0333333333333, 1.4, 0.14583333333333
15893, 2.0125, 1.4, 0.16666666666667
15894, 2.075, 1.4, 0.14583333333333
15895, 2.0541666666667, 1.4, 0.16666666666667
15896, 2.1166666666667, 1.4, 0.14583333333333
15897, 2.0958333333333, 1.4, 0.16666666666667
15898, 2.1583333333333, 1.4, 0.14583333333333
15899, 2.1375, 1.4, 0.16666666666667
15900, 2.1791666666667, 1.4, 0.16666666666667
15901, 1.2416666666667, 1.4, 0.1875
15902, 1.2208333333333, 1.4, 0.20833333333333
15903, 1.2833333333333, 1.4, 0.1875
15904, 1.2625, 1.4, 0.20833333333333
15905, 1.325, 1.4, 0.1875
15906, 1.3041666666667, 1.4, 0.20833333333333
15907, 1.3666666666667, 1.4, 0.1875
15908, 1.3458333333333, 1.4, 0.20833333333333
15909, 1.4083333333333, 1.4, 0.1875
15910, 1.3875, 1.4, 0.20833333333333
15911, 1.45, 1.4, 0.1875
15912, 1.4291666666667, 1.4, 0.20833333333333
15913, 1.4916666666667, 1.4, 0.1875
15914, 1.4708333333333, 1.4, 0.20833333333333
15915, 1.5333333333333, 1.4, 0.1875
15916, 1.5125, 1.4, 0.20833333333333
15917, 1.575, 1.4, 0.1875
15918, 1.5541666666667, 1.4, 0.20833333333333
15919, 1.6166666666667, 1.4, 0.1875
15920, 1.5958333333333, 1.4, 0.20833333333333
15921, 1.6583333333333, 1.4, 0.1875
15922, 1.6375, 1.4, 0.20833333333333
15923, 1.7, 1.4, 0.1875
15924, 1.6791666666667, 1.4, 0.20833333333333
15925, 1.7416666666667, 1.4, 0.1875
15926, 1.7208333333333, 1.4, 0.20833333333333
15927, 1.7833333333333, 1.4, 0.1875
15928, 1.7625, 1.4, 0.20833333333333
15929, 1.825, 1.4, 0.1875
15930, 1.8041666666667, 1.4, 0.20833333333333
15931, 1.8666666666667, 1.4, 0.1875
15932, 1.8458333333333, 1.4, 0.20833333333333
15933, 1.9083333333333, 1.4, 0.1875
15934, 1.8875, 1.4, 0.20833333333333
15935, 1.95, 1.4, 0.1875
15936, 1.9291666666667, 1.4, 0.20833333333333
15937, 1.9916666666667, 1.4, 0.1875
15938, 1.9708333333333, 1.4, 0.20833333333333
15939, 2.0333333333333, 1.4, 0.1875
15940, 2.0125, 1.4, 0.20833333333333
15941, 2.075, 1.4, 0.1875
15942, 2.0541666666667, 1.4, 0.20833333333333
15943, 2.1166666666667, 1.4, 0.1875
15944, 2.0958333333333, 1.4, 0.20833333333333
15945, 2.1583333333333, 1.4, 0.1875
15946, 2.1375, 1.4, 0.20833333333333
15947, 2.1791666666667, 1.4, 0.20833333333333
15948, 1.2416666666667, 1.4, 0.22916666666667
15949, 1.2208333333333, 1.4, 0.25
15950, 1.2833333333333, 1.4, 0.22916666666667
15951, 1.2625, 1.4, 0.25
15952, 1.325, 1.4, 0.22916666666667
15953, 1.3041666666667, 1.4, 0.25
15954, 1.3666666666667, 1.4, 0.22916666666667
15955, 1.3458333333333, 1.4, 0.25
15956, 1.4083333333333, 1.4, 0.22916666666667
15957, 1.3875, 1.4, 0.25
15958, 1.45, 1.4, 0.22916666666667
15959, 1.4291666666667, 1.4, 0.25
15960, 1.4916666666667, 1.4, 0.22916666666667
15961, 1.4708333333333, 1.4, 0.25
15962, 1.5333333333333, 1.4, 0.22916666666667
15963, 1.5125, 1.4, 0.25
15964, 1.575, 1.4, 0.22916666666667
15965, 1.5541666666667, 1.4, 0.25
15966, 1.6166666666667, 1.4, 0.22916666666667
15967, 1.5958333333333, 1.4, 0.25
15968, 1.6583333333333, 1.4, 0.22916666666667
15969, 1.6375, 1.4, 0.25
15970, 1.7, 1.4, 0.22916666666667
15971, 1.6791666666667, 1.4, 0.25
15972, 1.7416666666667, 1.4, 0.22916666666667
15973, 1.7208333333333, 1.4, 0.25
15974, 1.7833333333333, 1.4, 0.22916666666667
15975, 1.7625, 1.4, 0.25
15976, 1.825, 1.4, 0.22916666666667
15977, 1.8041666666667, 1.4, 0.25
15978, 1.8666666666667, 1.4, 0.22916666666667
15979, 1.8458333333333, 1.4, 0.25
15980, 1.9083333333333, 1.4, 0.22916666666667
15981, 1.8875, 1.4, 0.25
15982, 1.95, 1.4, 0.22916666666667
15983, 1.9291666666667, 1.4, 0.25
15984, 1.9916666666667, 1.4, 0.22916666666667
15985, 1.9708333333333, 1.4, 0.25
15986, 2.0333333333333, 1.4, 0.22916666666667
15987, 2.0125, 1.4, 0.25
15988, 2.075, 1.4, 0.22916666666667
15989, 2.0541666666667, 1.4, 0.25
15990, 2.1166666666667, 1.4, 0.22916666666667
15991, 2.0958333333333, 1.4, 0.25
15992, 2.1583333333333, 1.4, 0.22916666666667
15993, 2.1375, 1.4, 0.25
15994, 2.1791666666667, 1.4, 0.25
15995, 1.2416666666667, 1.4, 0.27083333333333
15996, 1.2208333333333, 1.4, 0.29166666666667
15997, 1.2833333333333, 1.4, 0.27083333333333
15998, 1.2625, 1.4, 0.29166666666667
15999, 1.325, 1.4, 0.27083333333333
16000, 1.3041666666667, 1.4, 0.29166666666667
16001, 1.3666666666667, 1.4, 0.27083333333333
16002, 1.3458333333333, 1.4, 0.29166666666667
16003, 1.4083333333333, 1.4, 0.27083333333333
16004, 1.3875, 1.4, 0.29166666666667
16005, 1.45, 1.4, 0.27083333333333
16006, 1.4291666666667, 1.4, 0.29166666666667
16007, 1.4916666666667, 1.4, 0.27083333333333
16008, 1.4708333333333, 1.4, 0.29166666666667
16009, 1.5333333333333, 1.4, 0.27083333333333
16010, 1.5125, 1.4, 0.29166666666667
16011, 1.575, 1.4, 0.27083333333333
16012, 1.5541666666667, 1.4, 0.29166666666667
16013, 1.6166666666667, 1.4, 0.27083333333333
16014, 1.5958333333333, 1.4, 0.29166666666667
16015, 1.6583333333333, 1.4, 0.27083333333333
16016, 1.6375, 1.4, 0.29166666666667
16017, 1.7, 1.4, 0.27083333333333
16018, 1.6791666666667, 1.4, 0.29166666666667
16019, 1.7416666666667, 1.4, 0.27083333333333
16020, 1.7208333333333, 1.4, 0.29166666666667
16021, 1.7833333333333, 1.4, 0.27083333333333
16022, 1.7625, 1.4, 0.29166666666667
16023, 1.825, 1.4, 0.27083333333333
16024, 1.8041666666667, 1.4, 0.29166666666667
16025, 1.8666666666667, 1.4, 0.27083333333333
16026, 1.8458333333333, 1.4, 0.29166666666667
16027, 1.9083333333333, 1.4, 0.27083333333333
16028, 1.8875, 1.4, 0.29166666666667
16029, 1.95, 1.4, 0.27083333333333
16030, 1.9291666666667, 1.4, 0.29166666666667
16031, 1.9916666666667, 1.4, 0.27083333333333
16032, 1.9708333333333, 1.4, 0.29166666666667
16033, 2.0333333333333, 1.4, 0.27083333333333
16034, 2.0125, 1.4, 0.29166666666667
16035, 2.075, 1.4, 0.27083333333333
16036, 2.0541666666667, 1.4, 0.29166666666667
16037, 2.1166666666667, 1.4, 0.27083333333333
16038, 2.0958333333333, 1.4, 0.29166666666667
16039, 2.1583333333333, 1.4, 0.27083333333333
16040, 2.1375, 1.4, 0.29166666666667
16041, 2.1791666666667, 1.4, 0.29166666666667
16042, 1.2416666666667, 1.4, 0.3125
16043, 1.2208333333333, 1.4, 0.33333333333333
16044, 1.2833333333333, 1.4, 0.3125
16045, 1.2625, 1.4, 0.33333333333333
16046, 1.325, 1.4, 0.3125
16047, 1.3041666666667, 1.4, 0.33333333333333
16048, 1.3666666666667, 1.4, 0.3125
16049, 1.3458333333333, 1.4, 0.33333333333333
16050, 1.4083333333333, 1.4, 0.3125
16051, 1.3875, 1.4, 0.33333333333333
16052, 1.45, 1.4, 0.3125
16053, 1.4291666666667, 1.4, 0.33333333333333
16054, 1.4916666666667, 1.4, 0.3125
16055, 1.4708333333333, 1.4, 0.33333333333333
16056, 1.5333333333333, 1.4, 0.3125
16057, 1.5125, 1.4, 0.33333333333333
16058, 1.575, 1.4, 0.3125
16059, 1.5541666666667, 1.4, 0.33333333333333
16060, 1.6166666666667, 1.4, 0.3125
16061, 1.5958333333333, 1.4, 0.33333333333333
16062, 1.6583333333333, 1.4, 0.3125
16063, 1.6375, 1.4, 0.33333333333333
16064, 1.7, 1.4, 0.3125
16065, 1.6791666666667, 1.4, 0.33333333333333
16066, 1.7416666666667, 1.4, 0.3125
16067, 1.7208333333333, 1.4, 0.33333333333333
16068, 1.7833333333333, 1.4, 0.3125
16069, 1.7625, 1.4, 0.33333333333333
16070, 1.825, 1.4, 0.3125
16071, 1.8041666666667, 1.4, 0.33333333333333
16072, 1.8666666666667, 1.4, 0.3125
16073, 1.8458333333333, 1.4, 0.33333333333333
16074, 1.9083333333333, 1.4, 0.3125
16075, 1.8875, 1.4, 0.33333333333333
16076, 1.95, 1.4, 0.3125
16077, 1.9291666666667, 1.4, 0.33333333333333
16078, 1.9916666666667, 1.4, 0.3125
16079, 1.9708333333333, 1.4, 0.33333333333333
16080, 2.0333333333333, 1.4, 0.3125
16081, 2.0125, 1.4, 0.33333333333333
16082, 2.075, 1.4, 0.3125
16083, 2.0541666666667, 1.4, 0.33333333333333
16084, 2.1166666666667, 1.4, 0.3125
16085, 2.0958333333333, 1.4, 0.33333333333333
16086, 2.1583333333333, 1.4, 0.3125
16087, 2.1375, 1.4, 0.33333333333333
16088, 2.1791666666667, 1.4, 0.33333333333333
16089, 1.2416666666667, 1.4, 0.35416666666667
16090, 1.2208333333333, 1.4, 0.375
16091, 1.2833333333333, 1.4, 0.35416666666667
16092, 1.2625, 1.4, 0.375
16093, 1.325, 1.4, 0.35416666666667
16094, 1.3041666666667, 1.4, 0.375
16095, 1.3666666666667, 1.4, 0.35416666666667
16096, 1.3458333333333, 1.4, 0.375
16097, 1.4083333333333, 1.4, 0.35416666666667
16098, 1.3875, 1.4, 0.375
16099, 1.45, 1.4, 0.35416666666667
16100, 1.4291666666667, 1.4, 0.375
16101, 1.4916666666667, 1.4, 0.35416666666667
16102, 1.4708333333333, 1.4, 0.375
16103, 1.5333333333333, 1.4, 0.35416666666667
16104, 1.5125, 1.4, 0.375
16105, 1.575, 1.4, 0.35416666666667
16106, 1.5541666666667, 1.4, 0.375
16107, 1.6166666666667, 1.4, 0.35416666666667
16108, 1.5958333333333, 1.4, 0.375
16109, 1.6583333333333, 1.4, 0.35416666666667
16110, 1.6375, 1.4, 0.375
16111, 1.7, 1.4, 0.35416666666667
16112, 1.6791666666667, 1.4, 0.375
16113, 1.7416666666667, 1.4, 0.35416666666667
16114, 1.7208333333333, 1.4, 0.375
16115, 1.7833333333333, 1.4, 0.35416666666667
16116, 1.7625, 1.4, 0.375
16117, 1.825, 1.4, 0.35416666666667
16118, 1.8041666666667, 1.4, 0.375
16119, 1.8666666666667, 1.4, 0.35416666666667
16120, 1.8458333333333, 1.4, 0.375
16121, 1.9083333333333, 1.4, 0.35416666666667
16122, 1.8875, 1.4, 0.375
16123, 1.95, 1.4, 0.35416666666667
16124, 1.9291666666667, 1.4, 0.375
16125, 1.9916666666667, 1.4, 0.35416666666667
16126, 1.9708333333333, 1.4, 0.375
16127, 2.0333333333333, 1.4, 0.35416666666667
16128, 2.0125, 1.4, 0.375
16129, 2.075, 1.4, 0.35416666666667
16130, 2.0541666666667, 1.4, 0.375
16131, 2.1166666666667, 1.4, 0.35416666666667
16132, 2.0958333333333, 1.4, 0.375
16133, 2.1583333333333, 1.4, 0.35416666666667
16134, 2.1375, 1.4, 0.375
16135, 2.1791666666667, 1.4, 0.375
16136, 1.2416666666667, 1.4, 0.39583333333333
16137, 1.2208333333333, 1.4, 0.41666666666667
16138, 1.2833333333333, 1.4, 0.39583333333333
16139, 1.2625, 1.4, 0.41666666666667
16140, 1.325, 1.4, 0.39583333333333
16141, 1.3041666666667, 1.4, 0.41666666666667
16142, 1.3666666666667, 1.4, 0.39583333333333
16143, 1.3458333333333, 1.4, 0.41666666666667
16144, 1.4083333333333, 1.4, 0.39583333333333
16145, 1.3875, 1.4, 0.41666666666667
16146, 1.45, 1.4, 0.39583333333333
16147, 1.4291666666667, 1.4, 0.41666666666667
16148, 1.4916666666667, 1.4, 0.39583333333333
16149, 1.4708333333333, 1.4, 0.41666666666667
16150, 1.5333333333333, 1.4, 0.39583333333333
16151, 1.5125, 1.4, 0.41666666666667
16152, 1.575, 1.4, 0.39583333333333
16153, 1.5541666666667, 1.4, 0.41666666666667
16154, 1.6166666666667, 1.4, 0.39583333333333
16155, 1.5958333333333, 1.4, 0.41666666666667
16156, 1.6583333333333, 1.4, 0.39583333333333
16157, 1.6375, 1.4, 0.41666666666667
16158, 1.7, 1.4, 0.39583333333333
16159, 1.6791666666667, 1.4, 0.41666666666667
16160, 1.7416666666667, 1.4, 0.39583333333333
16161, 1.7208333333333, 1.4, 0.41666666666667
16162, 1.7833333333333, 1.4, 0.39583333333333
16163, 1.7625, 1.4, 0.41666666666667
16164, 1.825, 1.4, 0.39583333333333
16165, 1.8041666666667, 1.4, 0.41666666666667
16166, 1.8666666666667, 1.4, 0.39583333333333
16167, 1.8458333333333, 1.4, 0.41666666666667
16168, 1.9083333333333, 1.4, 0.39583333333333
16169, 1.8875, 1.4, 0.41666666666667
16170, 1.95, 1.4, 0.39583333333333
16171, 1.9291666666667, 1.4, 0.41666666666667
16172, 1.9916666666667, 1.4, 0.39583333333333
16173, 1.9708333333333, 1.4, 0.41666666666667
16174, 2.0333333333333, 1.4, 0.39583333333333
16175, 2.0125, 1.4, 0.41666666666667
16176, 2.075, 1.4, 0.39583333333333
16177, 2.0541666666667, 1.4, 0.41666666666667
16178, 2.1166666666667, 1.4, 0.39583333333333
16179, 2.0958333333333, 1.4, 0.41666666666667
16180, 2.1583333333333, 1.4, 0.39583333333333
16181, 2.1375, 1.4, 0.41666666666667
16182, 2.1791666666667, 1.4, 0.41666666666667
16183, 1.2416666666667, 1.4, 0.4375
16184, 1.2208333333333, 1.4, 0.45833333333333
16185, 1.2833333333333, 1.4, 0.4375
16186, 1.2625, 1.4, 0.45833333333333
16187, 1.325, 1.4, 0.4375
16188, 1.3041666666667, 1.4, 0.45833333333333
16189, 1.3666666666667, 1.4, 0.4375
16190, 1.3458333333333, 1.4, 0.45833333333333
16191, 1.4083333333333, 1.4, 0.4375
16192, 1.3875, 1.4, 0.45833333333333
16193, 1.45, 1.4, 0.4375
16194, 1.4291666666667, 1.4, 0.45833333333333
16195, 1.4916666666667, 1.4, 0.4375
16196, 1.4708333333333, 1.4, 0.45833333333333
16197, 1.5333333333333, 1.4, 0.4375
16198, 1.5125, 1.4, 0.45833333333333
16199, 1.575, 1.4, 0.4375
16200, 1.5541666666667, 1.4, 0.45833333333333
16201, 1.6166666666667, 1.4, 0.4375
16202, 1.5958333333333, 1.4, 0.45833333333333
16203, 1.6583333333333, 1.4, 0.4375
16204, 1.6375, 1.4, 0.45833333333333
16205, 1.7, 1.4, 0.4375
16206, 1.6791666666667, 1.4, 0.45833333333333
16207, 1.7416666666667, 1.4, 0.4375
16208, 1.7208333333333, 1.4, 0.45833333333333
16209, 1.7833333333333, 1.4, 0.4375
16210, 1.7625, 1.4, 0.45833333333333
16211, 1.825, 1.4, 0.4375
16212, 1.8041666666667, 1.4, 0.45833333333333
16213, 1.8666666666667, 1.4, 0.4375
16214, 1.8458333333333, 1.4, 0.45833333333333
16215, 1.9083333333333, 1.4, 0.4375
16216, 1.8875, 1.4, 0.45833333333333
16217, 1.95, 1.4, 0.4375
16218, 1.9291666666667, 1.4, 0.45833333333333
16219, 1.9916666666667, 1.4, 0.4375
16220, 1.9708333333333, 1.4, 0.45833333333333
16221, 2.0333333333333, 1.4, 0.4375
16222, 2.0125, 1.4, 0.45833333333333
16223, 2.075, 1.4, 0.4375
16224, 2.0541666666667, 1.4, 0.45833333333333
16225, 2.1166666666667, 1.4, 0.4375
16226, 2.0958333333333, 1.4, 0.45833333333333
16227, 2.1583333333333, 1.4, 0.4375
16228, 2.1375, 1.4, 0.45833333333333
16229, 2.1791666666667, 1.4, 0.45833333333333
16230, 1.2416666666667, 1.4, 0.47916666666667
16231, 1.2833333333333, 1.4, 0.47916666666667
16232, 1.325, 1.4, 0.47916666666667
16233, 1.3666666666667, 1.4, 0.47916666666667
16234, 1.4083333333333, 1.4, 0.47916666666667
16235, 1.45, 1.4, 0.47916666666667
16236, 1.4916666666667, 1.4, 0.47916666666667
16237, 1.5333333333333, 1.4, 0.47916666666667
16238, 1.575, 1.4, 0.47916666666667
16239, 1.6166666666667, 1.4, 0.47916666666667
16240, 1.6583333333333, 1.4, 0.47916666666667
16241, 1.7, 1.4, 0.47916666666667
16242, 1.7416666666667, 1.4, 0.47916666666667
16243, 1.7833333333333, 1.4, 0.47916666666667
16244, 1.825, 1.4, 0.47916666666667
16245, 1.8666666666667, 1.4, 0.47916666666667
16246, 1.9083333333333, 1.4, 0.47916666666667
16247, 1.95, 1.4, 0.47916666666667
16248, 1.9916666666667, 1.4, 0.47916666666667
16249, 2.0333333333333, 1.4, 0.47916666666667
16250, 2.075, 1.4, 0.47916666666667
16251, 2.1166666666667, 1.4, 0.47916666666667
16252, 2.1583333333333, 1.4, 0.47916666666667
16253, 1.2416666666667, 1.5, 0.041666666666667
16254, 1.2833333333333, 1.5, 0.041666666666667
16255, 1.325, 1.5, 0.041666666666667
16256, 1.3666666666667, 1.5, 0.041666666666667
16257, 1.4083333333333, 1.5, 0.041666666666667
16258, 1.45, 1.5, 0.041666666666667
16259, 1.4916666666667, 1.5, 0.041666666666667
16260, 1.5333333333333, 1.5, 0.041666666666667
16261, 1.575, 1.5, 0.041666666666667
16262, 1.6166666666667, 1.5, 0.041666666666667
16263, 1.6583333333333, 1.5, 0.041666666666667
16264, 1.7, 1.5, 0.041666666666667
16265, 1.7416666666667, 1.5, 0.041666666666667
16266, 1.7833333333333, 1.5, 0.041666666666667
16267, 1.825, 1.5, 0.041666666666667
16268, 1.8666666666667, 1.5, 0.041666666666667
16269, 1.9083333333333, 1.5, 0.041666666666667
16270, 1.95, 1.5, 0.041666666666667
16271, 1.9916666666667, 1.5, 0.041666666666667
16272, 2.0333333333333, 1.5, 0.041666666666667
16273, 2.075, 1.5, 0.041666666666667
16274, 2.1166666666667, 1.5, 0.041666666666667
16275, 2.1583333333333, 1.5, 0.041666666666667
16276, 1.2416666666667, 1.5, 0.083333333333333
16277, 1.2833333333333, 1.5, 0.083333333333333
16278, 1.325, 1.5, 0.083333333333333
16279, 1.3666666666667, 1.5, 0.083333333333333
16280, 1.4083333333333, 1.5, 0.083333333333333
16281, 1.45, 1.5, 0.083333333333333
16282, 1.4916666666667, 1.5, 0.083333333333333
16283, 1.5333333333333, 1.5, 0.083333333333333
16284, 1.575, 1.5, 0.083333333333333
16285, 1.6166666666667, 1.5, 0.083333333333333
16286, 1.6583333333333, 1.5, 0.083333333333333
16287, 1.7, 1.5, 0.083333333333333
16288, 1.7416666666667, 1.5, 0.083333333333333
16289, 1.7833333333333, 1.5, 0.083333333333333
16290, 1.825, 1.5, 0.083333333333333
16291, 1.8666666666667, 1.5, 0.083333333333333
16292, 1.9083333333333, 1.5, 0.083333333333333
16293, 1.95, 1.5, 0.083333333333333
16294, 1.9916666666667, 1.5, 0.083333333333333
16295, 2.0333333333333, 1.5, 0.083333333333333
16296, 2.075, 1.5, 0.083333333333333
16297, 2.1166666666667, 1.5, 0.083333333333333
16298, 2.1583333333333, 1.5, 0.083333333333333
16299, 1.2416666666667, 1.5, 0.125
16300, 1.2833333333333, 1.5, 0.125
16301, 1.325, 1.5, 0.125
16302, 1.3666666666667, 1.5, 0.125
16303, 1.4083333333333, 1.5, 0.125
16304, 1.45, 1.5, 0.125
16305, 1.4916666666667, 1.5, 0.125
16306, 1.5333333333333, 1.5, 0.125
16307, 1.575, 1.5, 0.125
16308, 1.6166666666667, 1.5, 0.125
16309, 1.6583333333333, 1.5, 0.125
16310, 1.7, 1.5, 0.125
16311, 1.7416666666667, 1.5, 0.125
16312, 1.7833333333333, 1.5, 0.125
16313, 1.825, 1.5, 0.125
16314, 1.8666666666667, 1.5, 0.125
16315, 1.9083333333333, 1.5, 0.125
16316, 1.95, 1.5, 0.125
16317, 1.9916666666667, 1.5, 0.125
16318, 2.0333333333333, 1.5, 0.125
16319, 2.075, 1.5, 0.125
16320, 2.1166666666667, 1.5, 0.125
16321, 2.1583333333333, 1.5, 0.125
16322, 1.2416666666667, 1.5, 0.16666666666667
16323, 1.2833333333333, 1.5, 0.16666666666667
16324, 1.325, 1.5, 0.16666666666667
16325, 1.3666666666667, 1.5, 0.16666666666667
16326, 1.4083333333333, 1.5, 0.16666666666667
16327, 1.45, 1.5, 0.16666666666667
16328, 1.4916666666667, 1.5, 0.16666666666667
16329, 1.5333333333333, 1.5, 0.16666666666667
16330, 1.575, 1.5, 0.16666666666667
16331, 1.6166666666667, 1.5, 0.16666666666667
16332, 1.6583333333333, 1.5, 0.16666666666667
16333, 1.7, 1.5, 0.16666666666667
16334, 1.7416666666667, 1.5, 0.16666666666667
16335, 1.7833333333333, 1.5, 0.16666666666667
16336, 1.825, 1.5, 0.16666666666667
16337, 1.8666666666667, 1.5, 0.16666666666667
16338, 1.9083333333333, 1.5, 0.16666666666667
16339, 1.95, 1.5, 0.16666666666667
16340, 1.9916666666667, 1.5, 0.16666666666667
16341, 2.0333333333333, 1.5, 0.16666666666667
16342, 2.075, 1.5, 0.16666666666667
16343, 2.1166666666667, 1.5, 0.16666666666667
16344, 2.1583333333333, 1.5, 0.16666666666667
16345, 1.2416666666667, 1.5, 0.20833333333333
16346, 1.2833333333333, 1.5, 0.20833333333333
16347, 1.325, 1.5, 0.20833333333333
16348, 1.3666666666667, 1.5, 0.20833333333333
16349, 1.4083333333333, 1.5, 0.20833333333333
16350, 1.45, 1.5, 0.20833333333333
16351, 1.4916666666667, 1.5, 0.20833333333333
16352, 1.5333333333333, 1.5, 0.20833333333333
16353, 1.575, 1.5, 0.20833333333333
16354, 1.6166666666667, 1.5, 0.20833333333333
16355, 1.6583333333333, 1.5, 0.20833333333333
16356, 1.7, 1.5, 0.20833333333333
16357, 1.7416666666667, 1.5, 0.20833333333333
16358, 1.7833333333333, 1.5, 0.20833333333333
16359, 1.825, 1.5, 0.20833333333333
16360, 1.8666666666667, 1.5, 0.20833333333333
16361, 1.9083333333333, 1.5, 0.20833333333333
16362, 1.95, 1.5, 0.20833333333333
16363, 1.9916666666667, 1.5, 0.20833333333333
16364, 2.0333333333333, 1.5, 0.20833333333333
16365, 2.075, 1.5, 0.20833333333333
16366, 2.1166666666667, 1.5, 0.20833333333333
16367, 2.1583333333333, 1.5, 0.20833333333333
16368, 1.2416666666667, 1.5, 0.25
16369, 1.2833333333333, 1.5, 0.25
16370, 1.325, 1.5, 0.25
16371, 1.3666666666667, 1.5, 0.25
16372, 1.4083333333333, 1.5, 0.25
16373, 1.45, 1.5, 0.25
16374, 1.4916666666667, 1.5, 0.25
16375, 1.5333333333333, 1.5, 0.25
16376, 1.575, 1.5, 0.25
16377, 1.6166666666667, 1.5, 0.25
16378, 1.6583333333333, 1.5, 0.25
16379, 1.7, 1.5, 0.25
16380, 1.7416666666667, 1.5, 0.25
16381, 1.7833333333333, 1.5, 0.25
16382, 1.825, 1.5, 0.25
16383, 1.8666666666667, 1.5, 0.25
16384, 1.9083333333333, 1.5, 0.25
16385, 1.95, 1.5, 0.25
16386, 1.9916666666667, 1.5, 0.25
16387, 2.0333333333333, 1.5, 0.25
16388, 2.075, 1.5, 0.25
16389, 2.1166666666667, 1.5, 0.25
16390, 2.1583333333333, 1.5, 0.25
16391, 1.2416666666667, 1.5, 0.29166666666667
16392, 1.2833333333333, 1.5, 0.29166666666667
16393, 1.325, 1.5, 0.29166666666667
16394, 1.3666666666667, 1.5, 0.29166666666667
16395, 1.4083333333333, 1.5, 0.29166666666667
16396, 1.45, 1.5, 0.29166666666667
16397, 1.4916666666667, 1.5, 0.29166666666667
16398, 1.5333333333333, 1.5, 0.29166666666667
16399, 1.575, 1.5, 0.29166666666667
16400, 1.6166666666667, 1.5, 0.29166666666667
16401, 1.6583333333333, 1.5, 0.29166666666667
16402, 1.7, 1.5, 0.29166666666667
16403, 1.7416666666667, 1.5, 0.29166666666667
16404, 1.7833333333333, 1.5, 0.29166666666667
16405, 1.825, 1.5, 0.29166666666667
16406, 1.8666666666667, 1.5, 0.29166666666667
16407, 1.9083333333333, 1.5, 0.29166666666667
16408, 1.95, 1.5, 0.29166666666667
16409, 1.9916666666667, 1.5, 0.29166666666667
16410, 2.0333333333333, 1.5, 0.29166666666667
16411, 2.075, 1.5, 0.29166666666667
16412, 2.1166666666667, 1.5, 0.29166666666667
16413, 2.1583333333333, 1.5, 0.29166666666667
16414, 1.2416666666667, 1.5, 0.33333333333333
16415, 1.2833333333333, 1.5, 0.33333333333333
16416, 1.325, 1.5, 0.33333333333333
16417, 1.3666666666667, 1.5, 0.33333333333333
16418, 1.4083333333333, 1.5, 0.33333333333333
16419, 1.45, 1.5, 0.33333333333333
16420, 1.4916666666667, 1.5, 0.33333333333333
16421, 1.5333333333333, 1.5, 0.33333333333333
16422, 1.575, 1.5, 0.33333333333333
16423, 1.6166666666667, 1.5, 0.33333333333333
16424, 1.6583333333333, 1.5, 0.33333333333333
16425, 1.7, 1.5, 0.33333333333333
16426, 1.7416666666667, 1.5, 0.33333333333333
16427, 1.7833333333333, 1.5, 0.33333333333333
16428, 1.825, 1.5, 0.33333333333333
16429, 1.8666666666667, 1.5, 0.33333333333333
16430, 1.9083333333333, 1.5, 0.33333333333333
16431, 1.95, 1.5, 0.33333333333333
16432, 1.9916666666667, 1.5, 0.33333333333333
16433, 2.0333333333333, 1.5, 0.33333333333333
16434, 2.075, 1.5, 0.33333333333333
16435, 2.1166666666667, 1.5, 0.33333333333333
16436, 2.1583333333333, 1.5, 0.33333333333333
16437, 1.2416666666667, 1.5, 0.375
16438, 1.2833333333333, 1.5, 0.375
16439, 1.325, 1.5, 0.375
16440, 1.3666666666667, 1.5, 0.375
16441, 1.4083333333333, 1.5, 0.375
16442, 1.45, 1.5, 0.375
16443, 1.4916666666667, 1.5, 0.375
16444, 1.5333333333333, 1.5, 0.375
16445, 1.575, 1.5, 0.375
16446, 1.6166666666667, 1.5, 0.375
16447, 1.6583333333333, 1.5, 0.375
16448, 1.7, 1.5, 0.375
16449, 1.7416666666667, 1.5, 0.375
16450, 1.7833333333333, 1.5, 0.375
16451, 1.825, 1.5, 0.375
16452, 1.8666666666667, 1.5, 0.375
16453, 1.9083333333333, 1.5, 0.375
16454, 1.95, 1.5, 0.375
16455, 1.9916666666667, 1.5, 0.375
16456, 2.0333333333333, 1.5, 0.375
16457, 2.075, 1.5, 0.375
16458, 2.1166666666667, 1.5, 0.375
16459, 2.1583333333333, 1.5, 0.375
16460, 1.2416666666667, 1.5, 0.41666666666667
16461, 1.2833333333333, 1.5, 0.41666666666667
16462, 1.325, 1.5, 0.41666666666667
16463, 1.3666666666667, 1.5, 0.41666666666667
16464, 1.4083333333333, 1.5, 0.41666666666667
16465, 1.45, 1.5, 0.41666666666667
16466, 1.4916666666667, 1.5, 0.41666666666667
16467, 1.5333333333333, 1.5, 0.41666666666667
16468, 1.575, 1.5, 0.41666666666667
16469, 1.6166666666667, 1.5, 0.41666666666667
16470, 1.6583333333333, 1.5, 0.41666666666667
16471, 1.7, 1.5, 0.41666666666667
16472, 1.7416666666667, 1.5, 0.41666666666667
16473, 1.7833333333333, 1.5, 0.41666666666667
16474, 1.825, 1.5, 0.41666666666667
16475, 1.8666666666667, 1.5, 0.41666666666667
16476, 1.9083333333333, 1.5, 0.41666666666667
16477, 1.95, 1.5, 0.41666666666667
16478, 1.9916666666667, 1.5, 0.41666666666667
16479, 2.0333333333333, 1.5, 0.41666666666667
16480, 2.075, 1.5, 0.41666666666667
16481, 2.1166666666667, 1.5, 0.41666666666667
16482, 2.1583333333333, 1.5, 0.41666666666667
16483, 1.2416666666667, 1.5, 0.45833333333333
16484, 1.2833333333333, 1.5, 0.45833333333333
16485, 1.325, 1.5, 0.45833333333333
16486, 1.3666666666667, 1.5, 0.45833333333333
16487, 1.4083333333333, 1.5, 0.45833333333333
16488, 1.45, 1.5, 0.45833333333333
16489, 1.4916666666667, 1.5, 0.45833333333333
16490, 1.5333333333333, 1.5, 0.45833333333333
16491, 1.575, 1.5, 0.45833333333333
16492, 1.6166666666667, 1.5, 0.45833333333333
16493, 1.6583333333333, 1.5, 0.45833333333333
16494, 1.7, 1.5, 0.45833333333333
16495, 1.7416666666667, 1.5, 0.45833333333333
16496, 1.7833333333333, 1.5, 0.45833333333333
16497, 1.825, 1.5, 0.45833333333333
16498, 1.8666666666667, 1.5, 0.45833333333333
16499, 1.9083333333333, 1.5, 0.45833333333333
16500, 1.95, 1.5, 0.45833333333333
16501, 1.9916666666667, 1.5, 0.45833333333333
16502, 2.0333333333333, 1.5, 0.45833333333333
16503, 2.075, 1.5, 0.45833333333333
16504, 2.1166666666667, 1.5, 0.45833333333333
16505, 2.1583333333333, 1.5, 0.45833333333333
16506, 1.2208333333333, 1.5, 0.041666666666667
16507, 1.2416666666667, 1.5, 0.020833333333333
16508, 1.2625, 1.5, 0.041666666666667
16509, 1.2833333333333, 1.5, 0.020833333333333
16510, 1.3041666666667, 1.5, 0.041666666666667
16511, 1.325, 1.5, 0.020833333333333
16512, 1.3458333333333, 1.5, 0.041666666666667
16513, 1.3666666666667, 1.5, 0.020833333333333
16514, 1.3875, 1.5, 0.041666666666667
16515, 1.4083333333333, 1.5, 0.020833333333333
16516, 1.4291666666667, 1.5, 0.041666666666667
16517, 1.45, 1.5, 0.020833333333333
16518, 1.4708333333333, 1.5, 0.041666666666667
16519, 1.4916666666667, 1.5, 0.020833333333333
16520, 1.5125, 1.5, 0.041666666666667
16521, 1.5333333333333, 1.5, 0.020833333333333
16522, 1.5541666666667, 1.5, 0.041666666666667
16523, 1.575, 1.5, 0.020833333333333
16524, 1.5958333333333, 1.5, 0.041666666666667
16525, 1.6166666666667, 1.5, 0.020833333333333
16526, 1.6375, 1.5, 0.041666666666667
16527, 1.6583333333333, 1.5, 0.020833333333333
16528, 1.6791666666667, 1.5, 0.041666666666667
16529, 1.7, 1.5, 0.020833333333333
16530, 1.7208333333333, 1.5, 0.041666666666667
16531, 1.7416666666667, 1.5, 0.020833333333333
16532, 1.7625, 1.5, 0.041666666666667
16533, 1.7833333333333, 1.5, 0.020833333333333
16534, 1.8041666666667, 1.5, 0.041666666666667
16535, 1.825, 1.5, 0.020833333333333
16536, 1.8458333333333, 1.5, 0.041666666666667
16537, 1.8666666666667, 1.5, 0.020833333333333
16538, 1.8875, 1.5, 0.041666666666667
16539, 1.9083333333333, 1.5, 0.020833333333333
16540, 1.9291666666667, 1.5, 0.041666666666667
16541, 1.95, 1.5, 0.020833333333333
16542, 1.9708333333333, 1.5, 0.041666666666667
16543, 1.9916666666667, 1.5, 0.020833333333333
16544, 2.0125, 1.5, 0.041666666666667
16545, 2.0333333333333, 1.5, 0.020833333333333
16546, 2.0541666666667, 1.5, 0.041666666666667
16547, 2.075, 1.5, 0.020833333333333
16548, 2.0958333333333, 1.5, 0.041666666666667
16549, 2.1166666666667, 1.5, 0.020833333333333
16550, 2.1375, 1.5, 0.041666666666667
16551, 2.1583333333333, 1.5, 0.020833333333333
16552, 2.1791666666667, 1.5, 0.041666666666667
16553, 1.2208333333333, 1.5, 0.083333333333333
16554, 1.2416666666667, 1.5, 0.0625
16555, 1.2625, 1.5, 0.083333333333333
16556, 1.2833333333333, 1.5, 0.0625
16557, 1.3041666666667, 1.5, 0.083333333333333
16558, 1.325, 1.5, 0.0625
16559, 1.3458333333333, 1.5, 0.083333333333333
16560, 1.3666666666667, 1.5, 0.0625
16561, 1.3875, 1.5, 0.083333333333333
16562, 1.4083333333333, 1.5, 0.0625
16563, 1.4291666666667, 1.5, 0.083333333333333
16564, 1.45, 1.5, 0.0625
16565, 1.4708333333333, 1.5, 0.083333333333333
16566, 1.4916666666667, 1.5, 0.0625
16567, 1.5125, 1.5, 0.083333333333333
16568, 1.5333333333333, 1.5, 0.0625
16569, 1.5541666666667, 1.5, 0.083333333333333
16570, 1.575, 1.5, 0.0625
16571, 1.5958333333333, 1.5, 0.083333333333333
16572, 1.6166666666667, 1.5, 0.0625
16573, 1.6375, 1.5, 0.083333333333333
16574, 1.6583333333333, 1.5, 0.0625
16575, 1.6791666666667, 1.5, 0.083333333333333
16576, 1.7, 1.5, 0.0625
16577, 1.7208333333333, 1.5, 0.083333333333333
16578, 1.7416666666667, 1.5, 0.0625
16579, 1.7625, 1.5, 0.083333333333333
16580, 1.7833333333333, 1.5, 0.0625
16581, 1.8041666666667, 1.5, 0.083333333333333
16582, 1.825, 1.5, 0.0625
16583, 1.8458333333333, 1.5, 0.083333333333333
16584, 1.8666666666667, 1.5, 0.0625
16585, 1.8875, 1.5, 0.083333333333333
16586, 1.9083333333333, 1.5, 0.0625
16587, 1.9291666666667, 1.5, 0.083333333333333
16588, 1.95, 1.5, 0.0625
16589, 1.9708333333333, 1.5, 0.083333333333333
16590, 1.9916666666667, 1.5, 0.0625
16591, 2.0125, 1.5, 0.083333333333333
16592, 2.0333333333333, 1.5, 0.0625
16593, 2.0541666666667, 1.5, 0.083333333333333
16594, 2.075, 1.5, 0.0625
16595, 2.0958333333333, 1.5, 0.083333333333333
16596, 2.1166666666667, 1.5, 0.0625
16597, 2.1375, 1.5, 0.083333333333333
16598, 2.1583333333333, 1.5, 0.0625
16599, 2.1791666666667, 1.5, 0.083333333333333
16600, 1.2208333333333, 1.5, 0.125
16601, 1.2416666666667, 1.5, 0.10416666666667
16602, 1.2625, 1.5, 0.125
16603, 1.2833333333333, 1.5, 0.10416666666667
16604, 1.3041666666667, 1.5, 0.125
16605, 1.325, 1.5, 0.10416666666667
16606, 1.3458333333333, 1.5, 0.125
16607, 1.3666666666667, 1.5, 0.10416666666667
16608, 1.3875, 1.5, 0.125
16609, 1.4083333333333, 1.5, 0.10416666666667
16610, 1.4291666666667, 1.5, 0.125
16611, 1.45, 1.5, 0.10416666666667
16612, 1.4708333333333, 1.5, 0.125
16613, 1.4916666666667, 1.5, 0.10416666666667
16614, 1.5125, 1.5, 0.125
16615, 1.5333333333333, 1.5, 0.10416666666667
16616, 1.5541666666667, 1.5, 0.125
16617, 1.575, 1.5, 0.10416666666667
16618, 1.5958333333333, 1.5, 0.125
16619, 1.6166666666667, 1.5, 0.10416666666667
16620, 1.6375, 1.5, 0.125
16621, 1.6583333333333, 1.5, 0.10416666666667
16622, 1.6791666666667, 1.5, 0.125
16623, 1.7, 1.5, 0.10416666666667
16624, 1.7208333333333, 1.5, 0.125
16625, 1.7416666666667, 1.5, 0.10416666666667
16626, 1.7625, 1.5, 0.125
16627, 1.7833333333333, 1.5, 0.10416666666667
16628, 1.8041666666667, 1.5, 0.125
16629, 1.825, 1.5, 0.10416666666667
16630, 1.8458333333333, 1.5, 0.125
16631, 1.8666666666667, 1.5, 0.10416666666667
16632, 1.8875, 1.5, 0.125
16633, 1.9083333333333, 1.5, 0.10416666666667
16634, 1.9291666666667, 1.5, 0.125
16635, 1.95, 1.5, 0.10416666666667
16636, 1.9708333333333, 1.5, 0.125
16637, 1.9916666666667, 1.5, 0.10416666666667
16638, 2.0125, 1.5, 0.125
16639, 2.0333333333333, 1.5, 0.10416666666667
16640, 2.0541666666667, 1.5, 0.125
16641, 2.075, 1.5, 0.10416666666667
16642, 2.0958333333333, 1.5, 0.125
16643, 2.1166666666667, 1.5, 0.10416666666667
16644, 2.1375, 1.5, 0.125
16645, 2.1583333333333, 1.5, 0.10416666666667
16646, 2.1791666666667, 1.5, 0.125
16647, 1.2208333333333, 1.5, 0.16666666666667
16648, 1.2416666666667, 1.5, 0.14583333333333
16649, 1.2625, 1.5, 0.16666666666667
16650, 1.2833333333333, 1.5, 0.14583333333333
16651, 1.3041666666667, 1.5, 0.16666666666667
16652, 1.325, 1.5, 0.14583333333333
16653, 1.3458333333333, 1.5, 0.16666666666667
16654, 1.3666666666667, 1.5, 0.14583333333333
16655, 1.3875, 1.5, 0.16666666666667
16656, 1.4083333333333, 1.5, 0.14583333333333
16657, 1.4291666666667, 1.5, 0.16666666666667
16658, 1.45, 1.5, 0.14583333333333
16659, 1.4708333333333, 1.5, 0.16666666666667
16660, 1.4916666666667, 1.5, 0.14583333333333
16661, 1.5125, 1.5, 0.16666666666667
16662, 1.5333333333333, 1.5, 0.14583333333333
16663, 1.5541666666667, 1.5, 0.16666666666667
16664, 1.575, 1.5, 0.14583333333333
16665, 1.5958333333333, 1.5, 0.16666666666667
16666, 1.6166666666667, 1.5, 0.14583333333333
16667, 1.6375, 1.5, 0.16666666666667
16668, 1.6583333333333, 1.5, 0.14583333333333
16669, 1.6791666666667, 1.5, 0.16666666666667
16670, 1.7, 1.5, 0.14583333333333
16671, 1.7208333333333, 1.5, 0.16666666666667
16672, 1.7416666666667, 1.5, 0.14583333333333
16673, 1.7625, 1.5, 0.16666666666667
16674, 1.7833333333333, 1.5, 0.14583333333333
16675, 1.8041666666667, 1.5, 0.16666666666667
16676, 1.825, 1.5, 0.14583333333333
16677, 1.8458333333333, 1.5, 0.16666666666667
16678, 1.8666666666667, 1.5, 0.14583333333333
16679, 1.8875, 1.5, 0.16666666666667
16680, 1.9083333333333, 1.5, 0.14583333333333
16681, 1.9291666666667, 1.5, 0.16666666666667
16682, 1.95, 1.5, 0.14583333333333
16683, 1.9708333333333, 1.5, 0.16666666666667
16684, 1.9916666666667, 1.5, 0.14583333333333
16685, 2.0125, 1.5, 0.16666666666667
16686, 2.0333333333333, 1.5, 0.14583333333333
16687, 2.0541666666667, 1.5, 0.16666666666667
16688, 2.075, 1.5, 0.14583333333333
16689, 2.0958333333333, 1.5, 0.16666666666667
16690, 2.1166666666667, 1.5, 0.14583333333333
16691, 2.1375, 1.5, 0.16666666666667
16692, 2.1583333333333, 1.5, 0.14583333333333
16693, 2.1791666666667, 1.5, 0.16666666666667
16694, 1.2208333333333, 1.5, 0.20833333333333
16695, 1.2416666666667, 1.5, 0.1875
16696, 1.2625, 1.5, 0.20833333333333
16697, 1.2833333333333, 1.5, 0.1875
16698, 1.3041666666667, 1.5, 0.20833333333333
16699, 1.325, 1.5, 0.1875
16700, 1.3458333333333, 1.5, 0.20833333333333
16701, 1.3666666666667, 1.5, 0.1875
16702, 1.3875, 1.5, 0.20833333333333
16703, 1.4083333333333, 1.5, 0.1875
16704, 1.4291666666667, 1.5, 0.20833333333333
16705, 1.45, 1.5, 0.1875
16706, 1.4708333333333, 1.5, 0.20833333333333
16707, 1.4916666666667, 1.5, 0.1875
16708, 1.5125, 1.5, 0.20833333333333
16709, 1.5333333333333, 1.5, 0.1875
16710, 1.5541666666667, 1.5, 0.20833333333333
16711, 1.575, 1.5, 0.1875
16712, 1.5958333333333, 1.5, 0.20833333333333
16713, 1.6166666666667, 1.5, 0.1875
16714, 1.6375, 1.5, 0.20833333333333
16715, 1.6583333333333, 1.5, 0.1875
16716, 1.6791666666667, 1.5, 0.20833333333333
16717, 1.7, 1.5, 0.1875
16718, 1.7208333333333, 1.5, 0.20833333333333
16719, 1.7416666666667, 1.5, 0.1875
16720, 1.7625, 1.5, 0.20833333333333
16721, 1.7833333333333, 1.5, 0.1875
16722, 1.8041666666667, 1.5, 0.20833333333333
16723, 1.825, 1.5, 0.1875
16724, 1.8458333333333, 1.5, 0.20833333333333
16725, 1.8666666666667, 1.5, 0.1875
16726, 1.8875, 1.5, 0.20833333333333
16727, 1.9083333333333, 1.5, 0.1875
16728, 1.9291666666667, 1.5, 0.20833333333333
16729, 1.95, 1.5, 0.1875
16730, 1.9708333333333, 1.5, 0.20833333333333
16731, 1.9916666666667, 1.5, 0.1875
16732, 2.0125, 1.5, 0.20833333333333
16733, 2.0333333333333, 1.5, 0.1875
16734, 2.0541666666667, 1.5, 0.20833333333333
16735, 2.075, 1.5, 0.1875
16736, 2.0958333333333, 1.5, 0.20833333333333
16737, 2.1166666666667, 1.5, 0.1875
16738, 2.1375, 1.5, 0.20833333333333
16739, 2.1583333333333, 1.5, 0.1875
16740, 2.1791666666667, 1.5, 0.20833333333333
16741, 1.2208333333333, 1.5, 0.25
16742, 1.2416666666667, 1.5, 0.22916666666667
16743, 1.2625, 1.5, 0.25
16744, 1.2833333333333, 1.5, 0.22916666666667
16745, 1.3041666666667, 1.5, 0.25
16746, 1.325, 1.5, 0.22916666666667
16747, 1.3458333333333, 1.5, 0.25
16748, 1.3666666666667, 1.5, 0.22916666666667
16749, 1.3875, 1.5, 0.25
16750, 1.4083333333333, 1.5, 0.22916666666667
16751, 1.4291666666667, 1.5, 0.25
16752, 1.45, 1.5, 0.22916666666667
16753, 1.4708333333333, 1.5, 0.25
16754, 1.4916666666667, 1.5, 0.22916666666667
16755, 1.5125, 1.5, 0.25
16756, 1.5333333333333, 1.5, 0.22916666666667
16757, 1.5541666666667, 1.5, 0.25
16758, 1.575, 1.5, 0.22916666666667
16759, 1.5958333333333, 1.5, 0.25
16760, 1.6166666666667, 1.5, 0.22916666666667
16761, 1.6375, 1.5, 0.25
16762, 1.6583333333333, 1.5, 0.22916666666667
16763, 1.6791666666667, 1.5, 0.25
16764, 1.7, 1.5, 0.22916666666667
16765, 1.7208333333333, 1.5, 0.25
16766, 1.7416666666667, 1.5, 0.22916666666667
16767, 1.7625, 1.5, 0.25
16768, 1.7833333333333, 1.5, 0.22916666666667
16769, 1.8041666666667, 1.5, 0.25
16770, 1.825, 1.5, 0.22916666666667
16771, 1.8458333333333, 1.5, 0.25
16772, 1.8666666666667, 1.5, 0.22916666666667
16773, 1.8875, 1.5, 0.25
16774, 1.9083333333333, 1.5, 0.22916666666667
16775, 1.9291666666667, 1.5, 0.25
16776, 1.95, 1.5, 0.22916666666667
16777, 1.9708333333333, 1.5, 0.25
16778, 1.9916666666667, 1.5, 0.22916666666667
16779, 2.0125, 1.5, 0.25
16780, 2.0333333333333, 1.5, 0.22916666666667
16781, 2.0541666666667, 1.5, 0.25
16782, 2.075, 1.5, 0.22916666666667
16783, 2.0958333333333, 1.5, 0.25
16784, 2.1166666666667, 1.5, 0.22916666666667
16785, 2.1375, 1.5, 0.25
16786, 2.1583333333333, 1.5, 0.22916666666667
16787, 2.1791666666667, 1.5, 0.25
16788, 1.2208333333333, 1.5, 0.29166666666667
16789, 1.2416666666667, 1.5, 0.27083333333333
16790, 1.2625, 1.5, 0.29166666666667
16791, 1.2833333333333, 1.5, 0.27083333333333
16792, 1.3041666666667, 1.5, 0.29166666666667
16793, 1.325, 1.5, 0.27083333333333
16794, 1.3458333333333, 1.5, 0.29166666666667
16795, 1.3666666666667, 1.5, 0.27083333333333
16796, 1.3875, 1.5, 0.29166666666667
16797, 1.4083333333333, 1.5, 0.27083333333333
16798, 1.4291666666667, 1.5, 0.29166666666667
16799, 1.45, 1.5, 0.27083333333333
16800, 1.4708333333333, 1.5, 0.29166666666667
16801, 1.4916666666667, 1.5, 0.27083333333333
16802, 1.5125, 1.5, 0.29166666666667
16803, 1.5333333333333, 1.5, 0.27083333333333
16804, 1.5541666666667, 1.5, 0.29166666666667
16805, 1.575, 1.5, 0.27083333333333
16806, 1.5958333333333, 1.5, 0.29166666666667
16807, 1.6166666666667, 1.5, 0.27083333333333
16808, 1.6375, 1.5, 0.29166666666667
16809, 1.6583333333333, 1.5, 0.27083333333333
16810, 1.6791666666667, 1.5, 0.29166666666667
16811, 1.7, 1.5, 0.27083333333333
16812, 1.7208333333333, 1.5, 0.29166666666667
16813, 1.7416666666667, 1.5, 0.27083333333333
16814, 1.7625, 1.5, 0.29166666666667
16815, 1.7833333333333, 1.5, 0.27083333333333
16816, 1.8041666666667, 1.5, 0.29166666666667
16817, 1.825, 1.5, 0.27083333333333
16818, 1.8458333333333, 1.5, 0.29166666666667
16819, 1.8666666666667, 1.5, 0.27083333333333
16820, 1.8875, 1.5, 0.29166666666667
16821, 1.9083333333333, 1.5, 0.27083333333333
16822, 1.9291666666667, 1.5, 0.29166666666667
16823, 1.95, 1.5, 0.27083333333333
16824, 1.9708333333333, 1.5, 0.29166666666667
16825, 1.9916666666667, 1.5, 0.27083333333333
16826, 2.0125, 1.5, 0.29166666666667
16827, 2.0333333333333, 1.5, 0.27083333333333
16828, 2.0541666666667, 1.5, 0.29166666666667
16829, 2.075, 1.5, 0.27083333333333
16830, 2.0958333333333, 1.5, 0.29166666666667
16831, 2.1166666666667, 1.5, 0.27083333333333
16832, 2.1375, 1.5, 0.29166666666667
16833, 2.1583333333333, 1.5, 0.27083333333333
16834, 2.1791666666667, 1.5, 0.29166666666667
16835, 1.2208333333333, 1.5, 0.33333333333333
16836, 1.2416666666667, 1.5, 0.3125
16837, 1.2625, 1.5, 0.33333333333333
16838, 1.2833333333333, 1.5, 0.3125
16839, 1.3041666666667, 1.5, 0.33333333333333
16840, 1.325, 1.5, 0.3125
16841, 1.3458333333333, 1.5, 0.33333333333333
16842, 1.3666666666667, 1.5, 0.3125
16843, 1.3875, 1.5, 0.33333333333333
16844, 1.4083333333333, 1.5, 0.3125
16845, 1.4291666666667, 1.5, 0.33333333333333
16846, 1.45, 1.5, 0.3125
16847, 1.4708333333333, 1.5, 0.33333333333333
16848, 1.4916666666667, 1.5, 0.3125
16849, 1.5125, 1.5, 0.33333333333333
16850, 1.5333333333333, 1.5, 0.3125
16851, 1.5541666666667, 1.5, 0.33333333333333
16852, 1.575, 1.5, 0.3125
16853, 1.5958333333333, 1.5, 0.33333333333333
16854, 1.6166666666667, 1.5, 0.3125
16855, 1.6375, 1.5, 0.33333333333333
16856, 1.6583333333333, 1.5, 0.3125
16857, 1.6791666666667, 1.5, 0.33333333333333
16858, 1.7, 1.5, 0.3125
16859, 1.7208333333333, 1.5, 0.33333333333333
16860, 1.7416666666667, 1.5, 0.3125
16861, 1.7625, 1.5, 0.33333333333333
16862, 1.7833333333333, 1.5, 0.3125
16863, 1.8041666666667, 1.5, 0.33333333333333
16864, 1.825, 1.5, 0.3125
16865, 1.8458333333333, 1.5, 0.33333333333333
16866, 1.8666666666667, 1.5, 0.3125
16867, 1.8875, 1.5, 0.33333333333333
16868, 1.9083333333333, 1.5, 0.3125
16869, 1.9291666666667, 1.5, 0.33333333333333
16870, 1.95, 1.5, 0.3125
16871, 1.9708333333333, 1.5, 0.33333333333333
16872, 1.9916666666667, 1.5, 0.3125
16873, 2.0125, 1.5, 0.33333333333333
16874, 2.0333333333333, 1.5, 0.3125
16875, 2.0541666666667, 1.5, 0.33333333333333
16876, 2.075, 1.5, 0.3125
16877, 2.0958333333333, 1.5, 0.33333333333333
16878, 2.1166666666667, 1.5, 0.3125
16879, 2.1375, 1.5, 0.33333333333333
16880, 2.1583333333333, 1.5, 0.3125
16881, 2.1791666666667, 1.5, 0.33333333333333
16882, 1.2208333333333, 1.5, 0.375
16883, 1.2416666666667, 1.5, 0.35416666666667
16884, 1.2625, 1.5, 0.375
16885, 1.2833333333333, 1.5, 0.35416666666667
16886, 1.3041666666667, 1.5, 0.375
16887, 1.325, 1.5, 0.35416666666667
16888, 1.3458333333333, 1.5, 0.375
16889, 1.3666666666667, 1.5, 0.35416666666667
16890, 1.3875, 1.5, 0.375
16891, 1.4083333333333, 1.5, 0.35416666666667
16892, 1.4291666666667, 1.5, 0.375
16893, 1.45, 1.5, 0.35416666666667
16894, 1.4708333333333, 1.5, 0.375
16895, 1.4916666666667, 1.5, 0.35416666666667
16896, 1.5125, 1.5, 0.375
16897, 1.5333333333333, 1.5, 0.35416666666667
16898, 1.5541666666667, 1.5, 0.375
16899, 1.575, 1.5, 0.35416666666667
16900, 1.5958333333333, 1.5, 0.375
16901, 1.6166666666667, 1.5, 0.35416666666667
16902, 1.6375, 1.5, 0.375
16903, 1.6583333333333, 1.5, 0.35416666666667
16904, 1.6791666666667, 1.5, 0.375
16905, 1.7, 1.5, 0.35416666666667
16906, 1.7208333333333, 1.5, 0.375
16907, 1.7416666666667, 1.5, 0.35416666666667
16908, 1.7625, 1.5, 0.375
16909, 1.7833333333333, 1.5, 0.35416666666667
16910, 1.8041666666667, 1.5, 0.375
16911, 1.825, 1.5, 0.35416666666667
16912, 1.8458333333333, 1.5, 0.375
16913, 1.8666666666667, 1.5, 0.35416666666667
16914, 1.8875, 1.5, 0.375
16915, 1.9083333333333, 1.5, 0.35416666666667
16916, 1.9291666666667, 1.5, 0.375
16917, 1.95, 1.5, 0.35416666666667
16918, 1.9708333333333, 1.5, 0.375
16919, 1.9916666666667, 1.5, 0.35416666666667
16920, 2.0125, 1.5, 0.375
16921, 2.0333333333333, 1.5, 0.35416666666667
16922, 2.0541666666667, 1.5, 0.375
16923, 2.075, 1.5, 0.35416666666667
16924, 2.0958333333333, 1.5, 0.375
16925, 2.1166666666667, 1.5, 0.35416666666667
16926, 2.1375, 1.5, 0.375
16927, 2.1583333333333, 1.5, 0.35416666666667
16928, 2.1791666666667, 1.5, 0.375
16929, 1.2208333333333, 1.5, 0.41666666666667
16930, 1.2416666666667, 1.5, 0.39583333333333
16931, 1.2625, 1.5, 0.41666666666667
16932, 1.2833333333333, 1.5, 0.39583333333333
16933, 1.3041666666667, 1.5, 0.41666666666667
16934, 1.325, 1.5, 0.39583333333333
16935, 1.3458333333333, 1.5, 0.41666666666667
16936, 1.3666666666667, 1.5, 0.39583333333333
16937, 1.3875, 1.5, 0.41666666666667
16938, 1.4083333333333, 1.5, 0.39583333333333
16939, 1.4291666666667, 1.5, 0.41666666666667
16940, 1.45, 1.5, 0.39583333333333
16941, 1.4708333333333, 1.5, 0.41666666666667
16942, 1.4916666666667, 1.5, 0.39583333333333
16943, 1.5125, 1.5, 0.41666666666667
16944, 1.5333333333333, 1.5, 0.39583333333333
16945, 1.5541666666667, 1.5, 0.41666666666667
16946, 1.575, 1.5, 0.39583333333333
16947, 1.5958333333333, 1.5, 0.41666666666667
16948, 1.6166666666667, 1.5, 0.39583333333333
16949, 1.6375, 1.5, 0.41666666666667
16950, 1.6583333333333, 1.5, 0.39583333333333
16951, 1.6791666666667, 1.5, 0.41666666666667
16952, 1.7, 1.5, 0.39583333333333
16953, 1.7208333333333, 1.5, 0.41666666666667
16954, 1.7416666666667, 1.5, 0.39583333333333
16955, 1.7625, 1.5, 0.41666666666667
16956, 1.7833333333333, 1.5, 0.39583333333333
16957, 1.8041666666667, 1.5, 0.41666666666667
16958, 1.825, 1.5, 0.39583333333333
16959, 1.8458333333333, 1.5, 0.41666666666667
16960, 1.8666666666667, 1.5, 0.39583333333333
16961, 1.8875, 1.5, 0.41666666666667
16962, 1.9083333333333, 1.5, 0.39583333333333
16963, 1.9291666666667, 1.5, 0.41666666666667
16964, 1.95, 1.5, 0.39583333333333
16965, 1.9708333333333, 1.5, 0.41666666666667
16966, 1.9916666666667, 1.5, 0.39583333333333
16967, 2.0125, 1.5, 0.41666666666667
16968, 2.0333333333333, 1.5, 0.39583333333333
16969, 2.0541666666667, 1.5, 0.41666666666667
16970, 2.075, 1.5, 0.39583333333333
16971, 2.0958333333333, 1.5, 0.41666666666667
16972, 2.1166666666667, 1.5, 0.39583333333333
16973, 2.1375, 1.5, 0.41666666666667
16974, 2.1583333333333, 1.5, 0.39583333333333
16975, 2.1791666666667, 1.5, 0.41666666666667
16976, 1.2208333333333, 1.5, 0.45833333333333
16977, 1.2416666666667, 1.5, 0.4375
16978, 1.2625, 1.5, 0.45833333333333
16979, 1.2833333333333, 1.5, 0.4375
16980, 1.3041666666667, 1.5, 0.45833333333333
16981, 1.325, 1.5, 0.4375
16982, 1.3458333333333, 1.5, 0.45833333333333
16983, 1.3666666666667, 1.5, 0.4375
16984, 1.3875, 1.5, 0.45833333333333
16985, 1.4083333333333, 1.5, 0.4375
16986, 1.4291666666667, 1.5, 0.45833333333333
16987, 1.45, 1.5, 0.4375
16988, 1.4708333333333, 1.5, 0.45833333333333
16989, 1.4916666666667, 1.5, 0.4375
16990, 1.5125, 1.5, 0.45833333333333
16991, 1.5333333333333, 1.5, 0.4375
16992, 1.5541666666667, 1.5, 0.45833333333333
16993, 1.575, 1.5, 0.4375
16994, 1.5958333333333, 1.5, 0.45833333333333
16995, 1.6166666666667, 1.5, 0.4375
16996, 1.6375, 1.5, 0.45833333333333
16997, 1.6583333333333, 1.5, 0.4375
16998, 1.6791666666667, 1.5, 0.45833333333333
16999, 1.7, 1.5, 0.4375
17000, 1.7208333333333, 1.5, 0.45833333333333
17001, 1.7416666666667, 1.5, 0.4375
17002, 1.7625, 1.5, 0.45833333333333
17003, 1.7833333333333, 1.5, 0.4375
17004, 1.8041666666667, 1.5, 0.45833333333333
17005, 1.825, 1.5, 0.4375
17006, 1.8458333333333, 1.5, 0.45833333333333
17007, 1.8666666666667, 1.5, 0.4375
17008, 1.8875, 1.5, 0.45833333333333
17009, 1.9083333333333, 1.5, 0.4375
17010, 1.9291666666667, 1.5, 0.45833333333333
17011, 1.95, 1.5, 0.4375
17012, 1.9708333333333, 1.5, 0.45833333333333
17013, 1.9916666666667, 1.5, 0.4375
17014, 2.0125, 1.5, 0.45833333333333
17015, 2.0333333333333, 1.5, 0.4375
17016, 2.0541666666667, 1.5, 0.45833333333333
17017, 2.075, 1.5, 0.4375
17018, 2.0958333333333, 1.5, 0.45833333333333
17019, 2.1166666666667, 1.5, 0.4375
17020, 2.1375, 1.5, 0.45833333333333
17021, 2.1583333333333, 1.5, 0.4375
17022, 2.1791666666667, 1.5, 0.45833333333333
17023, 1.2416666666667, 1.5, 0.47916666666667
17024, 1.2833333333333, 1.5, 0.47916666666667
17025, 1.325, 1.5, 0.47916666666667
17026, 1.3666666666667, 1.5, 0.47916666666667
17027, 1.4083333333333, 1.5, 0.47916666666667
17028, 1.45, 1.5, 0.47916666666667
17029, 1.4916666666667, 1.5, 0.47916666666667
17030, 1.5333333333333, 1.5, 0.47916666666667
17031, 1.575, 1.5, 0.47916666666667
17032, 1.6166666666667, 1.5, 0.47916666666667
17033, 1.6583333333333, 1.5, 0.47916666666667
17034, 1.7, 1.5, 0.47916666666667
17035, 1.7416666666667, 1.5, 0.47916666666667
17036, 1.7833333333333, 1.5, 0.47916666666667
17037, 1.825, 1.5, 0.47916666666667
17038, 1.8666666666667, 1.5, 0.47916666666667
17039, 1.9083333333333, 1.5, 0.47916666666667
17040, 1.95, 1.5, 0.47916666666667
17041, 1.9916666666667, 1.5, 0.47916666666667
17042, 2.0333333333333, 1.5, 0.47916666666667
17043, 2.075, 1.5, 0.47916666666667
17044, 2.1166666666667, 1.5, 0.47916666666667
17045, 2.1583333333333, 1.5, 0.47916666666667
17046, 2.2, 1.4333333333333, 0.041666666666667
17047, 2.2, 1.4666666666667, 0.041666666666667
17048, 2.2, 1.4333333333333, 0.083333333333333
17049, 2.2, 1.4666666666667, 0.083333333333333
17050, 2.2, 1.4333333333333, 0.125
17051, 2.2, 1.4666666666667, 0.125
17052, 2.2, 1.4333333333333, 0.16666666666667
17053, 2.2, 1.4666666666667, 0.16666666666667
17054, 2.2, 1.4333333333333, 0.20833333333333
17055, 2.2, 1.4666666666667, 0.20833333333333
17056, 2.2, 1.4333333333333, 0.25
17057, 2.2, 1.4666666666667, 0.25
17058, 2.2, 1.4333333333333, 0.29166666666667
17059, 2.2, 1.4666666666667, 0.29166666666667
17060, 2.2, 1.4333333333333, 0.33333333333333
17061, 2.2, 1.4666666666667, 0.33333333333333
17062, 2.2, 1.4333333333333, 0.375
17063, 2.2, 1.4666666666667, 0.375
17064, 2.2, 1.4333333333333, 0.41666666666667
17065, 2.2, 1.4666666666667, 0.41666666666667
17066, 2.2, 1.4333333333333, 0.45833333333333
17067, 2.2, 1.4666666666667, 0.45833333333333
17068, 2.2, 1.4333333333333, 0.020833333333333
17069, 2.2, 1.4166666666667, 0.041666666666667
17070, 2.2, 1.4666666666667, 0.020833333333333
17071, 2.2, 1.45, 0.041666666666667
17072, 2.2, 1.4833333333333, 0.041666666666667
17073, 2.2, 1.4333333333333, 0.0625
17074, 2.2, 1.4166666666667, 0.083333333333333
17075, 2.2, 1.4666666666667, 0.0625
17076, 2.2, 1.45, 0.083333333333333
17077, 2.2, 1.4833333333333, 0.083333333333333
17078, 2.2, 1.4333333333333, 0.10416666666667
17079, 2.2, 1.4166666666667, 0.125
17080, 2.2, 1.4666666666667, 0.10416666666667
17081, 2.2, 1.45, 0.125
17082, 2.2, 1.4833333333333, 0.125
17083, 2.2, 1.4333333333333, 0.14583333333333
17084, 2.2, 1.4166666666667, 0.16666666666667
17085, 2.2, 1.4666666666667, 0.14583333333333
17086, 2.2, 1.45, 0.16666666666667
17087, 2.2, 1.4833333333333, 0.16666666666667
17088, 2.2, 1.4333333333333, 0.1875
17089, 2.2, 1.4166666666667, 0.20833333333333
17090, 2.2, 1.4666666666667, 0.1875
17091, 2.2, 1.45, 0.20833333333333
17092, 2.2, 1.4833333333333, 0.20833333333333
17093, 2.2, 1.4333333333333, 0.22916666666667
17094, 2.2, 1.4166666666667, 0.25
17095, 2.2, 1.4666666666667, 0.22916666666667
17096, 2.2, 1.45, 0.25
17097, 2.2, 1.4833333333333, 0.25
17098, 2.2, 1.4333333333333, 0.27083333333333
17099, 2.2, 1.4166666666667, 0.29166666666667
17100, 2.2, 1.4666666666667, 0.27083333333333
17101, 2.2, 1.45, 0.29166666666667
17102, 2.2, 1.4833333333333, 0.29166666666667
17103, 2.2, 1.4333333333333, 0.3125
17104, 2.2, 1.4166666666667, 0.33333333333333
17105, 2.2, 1.4666666666667, 0.3125
17106, 2.2, 1.45, 0.33333333333333
17107, 2.2, 1.4833333333333, 0.33333333333333
17108, 2.2, 1.4333333333333, 0.35416666666667
17109, 2.2, 1.4166666666667, 0.375
17110, 2.2, 1.4666666666667, 0.35416666666667
17111, 2.2, 1.45, 0.375
17112, 2.2, 1.4833333333333, 0.375
17113, 2.2, 1.4333333333333, 0.39583333333333
17114, 2.2, 1.4166666666667, 0.41666666666667
17115, 2.2, 1.4666666666667, 0.39583333333333
17116, 2.2, 1.45, 0.41666666666667
17117, 2.2, 1.4833333333333, 0.41666666666667
17118, 2.2, 1.4333333333333, 0.4375
17119, 2.2, 1.4166666666667, 0.45833333333333
17120, 2.2, 1.4666666666667, 0.4375
17121, 2.2, 1.45, 0.45833333333333
17122, 2.2, 1.4833333333333, 0.45833333333333
17123, 2.2, 1.4333333333333, 0.47916666666667
17124, 2.2, 1.4666666666667, 0.47916666666667
17125, 1.2416666666667, 1.375, 0.5
17126, 1.2833333333333, 1.375, 0.5
17127, 1.325, 1.375, 0.5
17128, 1.3666666666667, 1.375, 0.5
17129, 1.4083333333333, 1.375, 0.5
17130, 1.45, 1.375, 0.5
17131, 1.4916666666667, 1.375, 0.5
17132, 1.5333333333333, 1.375, 0.5
17133, 1.575, 1.375, 0.5
17134, 1.6166666666667, 1.375, 0.5
17135, 1.6583333333333, 1.375, 0.5
17136, 1.7, 1.375, 0.5
17137, 1.7416666666667, 1.375, 0.5
17138, 1.7833333333333, 1.375, 0.5
17139, 1.825, 1.375, 0.5
17140, 1.8666666666667, 1.375, 0.5
17141, 1.9083333333333, 1.375, 0.5
17142, 1.95, 1.375, 0.5
17143, 1.9916666666667, 1.375, 0.5
17144, 2.0333333333333, 1.375, 0.5
17145, 2.075, 1.375, 0.5
17146, 2.1166666666667, 1.375, 0.5
17147, 2.1583333333333, 1.375, 0.5
17148, 1.2416666666667, 1.375, 0
17149, 1.2833333333333, 1.375, 0
17150, 1.325, 1.375, 0
17151, 1.3666666666667, 1.375, 0
17152, 1.4083333333333, 1.375, 0
17153, 1.45, 1.375, 0
17154, 1.4916666666667, 1.375, 0
17155, 1.5333333333333, 1.375, 0
17156, 1.575, 1.375, 0
17157, 1.6166666666667, 1.375, 0
17158, 1.6583333333333, 1.375, 0
17159, 1.7, 1.375, 0
17160, 1.7416666666667, 1.375, 0
17161, 1.7833333333333, 1.375, 0
17162, 1.825, 1.375, 0
17163, 1.8666666666667, 1.375, 0
17164, 1.9083333333333, 1.375, 0
17165, 1.95, 1.375, 0
17166, 1.9916666666667, 1.375, 0
17167, 2.0333333333333, 1.375, 0
17168, 2.075, 1.375, 0
17169, 2.1166666666667, 1.375, 0
17170, 2.1583333333333, 1.375, 0
17171, 1.2, 1.375, 0.041666666666667
17172, 1.2, 1.375, 0.083333333333333
17173, 1.2, 1.375, 0.125
17174, 1.2, 1.375, 0.16666666666667
17175, 1.2, 1.375, 0.20833333333333
17176, 1.2, 1.375, 0.25
17177, 1.2, 1.375, 0.29166666666667
17178, 1.2, 1.375, 0.33333333333333
17179, 1.2, 1.375, 0.375
17180, 1.2, 1.375, 0.41666666666667
17181, 1.2, 1.375, 0.45833333333333
17182, 2.2, 1.375, 0.041666666666667
17183, 2.2, 1.375, 0.083333333333333
17184, 2.2, 1.375, 0.125
17185, 2.2, 1.375, 0.16666666666667
17186, 2.2, 1.375, 0.20833333333333
17187, 2.2, 1.375, 0.25
17188, 2.2, 1.375, 0.29166666666667
17189, 2.2, 1.375, 0.33333333333333
17190, 2.2, 1.375, 0.375
17191, 2.2, 1.375, 0.41666666666667
17192, 2.2, 1.375, 0.45833333333333
17193, 1.2416666666667, 1.35, 0.041666666666667
17194, 1.2833333333333, 1.35, 0.041666666666667
17195, 1.325, 1.35, 0.041666666666667
17196, 1.3666666666667, 1.35, 0.041666666666667
17197, 1.4083333333333, 1.35, 0.041666666666667
17198, 1.45, 1.35, 0.041666666666667
17199, 1.4916666666667, 1.35, 0.041666666666667
17200, 1.5333333333333, 1.35, 0.041666666666667
17201, 1.575, 1.35, 0.041666666666667
17202, 1.6166666666667, 1.35, 0.041666666666667
17203, 1.6583333333333, 1.35, 0.041666666666667
17204, 1.7, 1.35, 0.041666666666667
17205, 1.7416666666667, 1.35, 0.041666666666667
17206, 1.7833333333333, 1.35, 0.041666666666667
17207, 1.825, 1.35, 0.041666666666667
17208, 1.8666666666667, 1.35, 0.041666666666667
17209, 1.9083333333333, 1.35, 0.041666666666667
17210, 1.95, 1.35, 0.041666666666667
17211, 1.9916666666667, 1.35, 0.041666666666667
17212, 2.0333333333333, 1.35, 0.041666666666667
17213, 2.075, 1.35, 0.041666666666667
17214, 2.1166666666667, 1.35, 0.041666666666667
17215, 2.1583333333333, 1.35, 0.041666666666667
17216, 1.2416666666667, 1.35, 0.083333333333333
17217, 1.2833333333333, 1.35, 0.083333333333333
17218, 1.325, 1.35, 0.083333333333333
17219, 1.3666666666667, 1.35, 0.083333333333333
17220, 1.4083333333333, 1.35, 0.083333333333333
17221, 1.45, 1.35, 0.083333333333333
17222, 1.4916666666667, 1.35, 0.083333333333333
17223, 1.5333333333333, 1.35, 0.083333333333333
17224, 1.575, 1.35, 0.083333333333333
17225, 1.6166666666667, 1.35, 0.083333333333333
17226, 1.6583333333333, 1.35, 0.083333333333333
17227, 1.7, 1.35, 0.083333333333333
17228, 1.7416666666667, 1.35, 0.083333333333333
17229, 1.7833333333333, 1.35, 0.083333333333333
17230, 1.825, 1.35, 0.083333333333333
17231, 1.8666666666667, 1.35, 0.083333333333333
17232, 1.9083333333333, 1.35, 0.083333333333333
17233, 1.95, 1.35, 0.083333333333333
17234, 1.9916666666667, 1.35, 0.083333333333333
17235, 2.0333333333333, 1.35, 0.083333333333333
17236, 2.075, 1.35, 0.083333333333333
17237, 2.1166666666667, 1.35, 0.083333333333333
17238, 2.1583333333333, 1.35, 0.083333333333333
17239, 1.2416666666667, 1.35, 0.125
17240, 1.2833333333333, 1.35, 0.125
17241, 1.325, 1.35, 0.125
17242, 1.3666666666667, 1.35, 0.125
17243, 1.4083333333333, 1.35, 0.125
17244, 1.45, 1.35, 0.125
17245, 1.4916666666667, 1.35, 0.125
17246, 1.5333333333333, 1.35, 0.125
17247, 1.575, 1.35, 0.125
17248, 1.6166666666667, 1.35, 0.125
17249, 1.6583333333333, 1.35, 0.125
17250, 1.7, 1.35, 0.125
17251, 1.7416666666667, 1.35, 0.125
17252, 1.7833333333333, 1.35, 0.125
17253, 1.825, 1.35, 0.125
17254, 1.8666666666667, 1.35, 0.125
17255, 1.9083333333333, 1.35, 0.125
17256, 1.95, 1.35, 0.125
17257, 1.9916666666667, 1.35, 0.125
17258, 2.0333333333333, 1.35, 0.125
17259, 2.075, 1.35, 0.125
17260, 2.1166666666667, 1.35, 0.125
17261, 2.1583333333333, 1.35, 0.125
17262, 1.2416666666667, 1.35, 0.16666666666667
17263, 1.2833333333333, 1.35, 0.16666666666667
17264, 1.325, 1.35, 0.16666666666667
17265, 1.3666666666667, 1.35, 0.16666666666667
17266, 1.4083333333333, 1.35, 0.16666666666667
17267, 1.45, 1.35, 0.16666666666667
17268, 1.4916666666667, 1.35, 0.16666666666667
17269, 1.5333333333333, 1.35, 0.16666666666667
17270, 1.575, 1.35, 0.16666666666667
17271, 1.6166666666667, 1.35, 0.16666666666667
17272, 1.6583333333333, 1.35, 0.16666666666667
17273, 1.7, 1.35, 0.16666666666667
17274, 1.7416666666667, 1.35, 0.16666666666667
17275, 1.7833333333333, 1.35, 0.16666666666667
17276, 1.825, 1.35, 0.16666666666667
17277, 1.8666666666667, 1.35, 0.16666666666667
17278, 1.9083333333333, 1.35, 0.16666666666667
17279, 1.95, 1.35, 0.16666666666667
17280, 1.9916666666667, 1.35, 0.16666666666667
17281, 2.0333333333333, 1.35, 0.16666666666667
17282, 2.075, 1.35, 0.16666666666667
17283, 2.1166666666667, 1.35, 0.16666666666667
17284, 2.1583333333333, 1.35, 0.16666666666667
17285, 1.2416666666667, 1.35, 0.20833333333333
17286, 1.2833333333333, 1.35, 0.20833333333333
17287, 1.325, 1.35, 0.20833333333333
17288, 1.3666666666667, 1.35, 0.20833333333333
17289, 1.4083333333333, 1.35, 0.20833333333333
17290, 1.45, 1.35, 0.20833333333333
17291, 1.4916666666667, 1.35, 0.20833333333333
17292, 1.5333333333333, 1.35, 0.20833333333333
17293, 1.575, 1.35, 0.20833333333333
17294, 1.6166666666667, 1.35, 0.20833333333333
17295, 1.6583333333333, 1.35, 0.20833333333333
17296, 1.7, 1.35, 0.20833333333333
17297, 1.7416666666667, 1.35, 0.20833333333333
17298, 1.7833333333333, 1.35, 0.20833333333333
17299, 1.825, 1.35, 0.20833333333333
17300, 1.8666666666667, 1.35, 0.20833333333333
17301, 1.9083333333333, 1.35, 0.20833333333333
17302, 1.95, 1.35, 0.20833333333333
17303, 1.9916666666667, 1.35, 0.20833333333333
17304, 2.0333333333333, 1.35, 0.20833333333333
17305, 2.075, 1.35, 0.20833333333333
17306, 2.1166666666667, 1.35, 0.20833333333333
17307, 2.1583333333333, 1.35, 0.20833333333333
17308, 1.2416666666667, 1.35, 0.25
17309, 1.2833333333333, 1.35, 0.25
17310, 1.325, 1.35, 0.25
17311, 1.3666666666667, 1.35, 0.25
17312, 1.4083333333333, 1.35, 0.25
17313, 1.45, 1.35, 0.25
17314, 1.4916666666667, 1.35, 0.25
17315, 1.5333333333333, 1.35, 0.25
17316, 1.575, 1.35, 0.25
17317, 1.6166666666667, 1.35, 0.25
17318, 1.6583333333333, 1.35, 0.25
17319, 1.7, 1.35, 0.25
17320, 1.7416666666667, 1.35, 0.25
17321, 1.7833333333333, 1.35, 0.25
17322, 1.825, 1.35, 0.25
17323, 1.8666666666667, 1.35, 0.25
17324, 1.9083333333333, 1.35, 0.25
17325, 1.95, 1.35, 0.25
17326, 1.9916666666667, 1.35, 0.25
17327, 2.0333333333333, 1.35, 0.25
17328, 2.075, 1.35, 0.25
17329, 2.1166666666667, 1.35, 0.25
17330, 2.1583333333333, 1.35, 0.25
17331, 1.2416666666667, 1.35, 0.29166666666667
17332, 1.2833333333333, 1.35, 0.29166666666667
17333, 1.325, 1.35, 0.29166666666667
17334, 1.3666666666667, 1.35, 0.29166666666667
17335, 1.4083333333333, 1.35, 0.29166666666667
17336, 1.45, 1.35, 0.29166666666667
17337, 1.4916666666667, 1.35, 0.29166666666667
17338, 1.5333333333333, 1.35, 0.29166666666667
17339, 1.575, 1.35, 0.29166666666667
17340, 1.6166666666667, 1.35, 0.29166666666667
17341, 1.6583333333333, 1.35, 0.29166666666667
17342, 1.7, 1.35, 0.29166666666667
17343, 1.7416666666667, 1.35, 0.29166666666667
17344, 1.7833333333333, 1.35, 0.29166666666667
17345, 1.825, 1.35, 0.29166666666667
17346, 1.8666666666667, 1.35, 0.29166666666667
17347, 1.9083333333333, 1.35, 0.29166666666667
17348, 1.95, 1.35, 0.29166666666667
17349, 1.9916666666667, 1.35, 0.29166666666667
17350, 2.0333333333333, 1.35, 0.29166666666667
17351, 2.075, 1.35, 0.29166666666667
17352, 2.1166666666667, 1.35, 0.29166666666667
17353, 2.1583333333333, 1.35, 0.29166666666667
17354, 1.2416666666667, 1.35, 0.33333333333333
17355, 1.2833333333333, 1.35, 0.33333333333333
17356, 1.325, 1.35, 0.33333333333333
17357, 1.3666666666667, 1.35, 0.33333333333333
17358, 1.4083333333333, 1.35, 0.33333333333333
17359, 1.45, 1.35, 0.33333333333333
17360, 1.4916666666667, 1.35, 0.33333333333333
17361, 1.5333333333333, 1.35, 0.33333333333333
17362, 1.575, 1.35, 0.33333333333333
17363, 1.6166666666667, 1.35, 0.33333333333333
17364, 1.6583333333333, 1.35, 0.33333333333333
17365, 1.7, 1.35, 0.33333333333333
17366, 1.7416666666667, 1.35, 0.33333333333333
17367, 1.7833333333333, 1.35, 0.33333333333333
17368, 1.825, 1.35, 0.33333333333333
17369, 1.8666666666667, 1.35, 0.33333333333333
17370, 1.9083333333333, 1.35, 0.33333333333333
17371, 1.95, 1.35, 0.33333333333333
17372, 1.9916666666667, 1.35, 0.33333333333333
17373, 2.0333333333333, 1.35, 0.33333333333333
17374, 2.075, 1.35, 0.33333333333333
17375, 2.1166666666667, 1.35, 0.33333333333333
17376, 2.1583333333333, 1.35, 0.33333333333333
17377, 1.2416666666667, 1.35, 0.375
17378, 1.2833333333333, 1.35, 0.375
17379, 1.325, 1.35, 0.375
17380, 1.3666666666667, 1.35, 0.375
17381, 1.4083333333333, 1.35, 0.375
17382, 1.45, 1.35, 0.375
17383, 1.4916666666667, 1.35, 0.375
17384, 1.5333333333333, 1.35, 0.375
17385, 1.575, 1.35, 0.375
17386, 1.6166666666667, 1.35, 0.375
17387, 1.6583333333333, 1.35, 0.375
17388, 1.7, 1.35, 0.375
17389, 1.7416666666667, 1.35, 0.375
17390, 1.7833333333333, 1.35, 0.375
17391, 1.825, 1.35, 0.375
17392, 1.8666666666667, 1.35, 0.375
17393, 1.9083333333333, 1.35, 0.375
17394, 1.95, 1.35, 0.375
17395, 1.9916666666667, 1.35, 0.375
17396, 2.0333333333333, 1.35, 0.375
17397, 2.075, 1.35, 0.375
17398, 2.1166666666667, 1.35, 0.375
17399, 2.1583333333333, 1.35, 0.375
17400, 1.2416666666667, 1.35, 0.41666666666667
17401, 1.2833333333333, 1.35, 0.41666666666667
17402, 1.325, 1.35, 0.41666666666667
17403, 1.3666666666667, 1.35, 0.41666666666667
17404, 1.4083333333333, 1.35, 0.41666666666667
17405, 1.45, 1.35, 0.41666666666667
17406, 1.4916666666667, 1.35, 0.41666666666667
17407, 1.5333333333333, 1.35, 0.41666666666667
17408, 1.575, 1.35, 0.41666666666667
17409, 1.6166666666667, 1.35, 0.41666666666667
17410, 1.6583333333333, 1.35, 0.41666666666667
17411, 1.7, 1.35, 0.41666666666667
17412, 1.7416666666667, 1.35, 0.41666666666667
17413, 1.7833333333333, 1.35, 0.41666666666667
17414, 1.825, 1.35, 0.41666666666667
17415, 1.8666666666667, 1.35, 0.41666666666667
17416, 1.9083333333333, 1.35, 0.41666666666667
17417, 1.95, 1.35, 0.41666666666667
17418, 1.9916666666667, 1.35, 0.41666666666667
17419, 2.0333333333333, 1.35, 0.41666666666667
17420, 2.075, 1.35, 0.41666666666667
17421, 2.1166666666667, 1.35, 0.41666666666667
17422, 2.1583333333333, 1.35, 0.41666666666667
17423, 1.2416666666667, 1.35, 0.45833333333333
17424, 1.2833333333333, 1.35, 0.45833333333333
17425, 1.325, 1.35, 0.45833333333333
17426, 1.3666666666667, 1.35, 0.45833333333333
17427, 1.4083333333333, 1.35, 0.45833333333333
17428, 1.45, 1.35, 0.45833333333333
17429, 1.4916666666667, 1.35, 0.45833333333333
17430, 1.5333333333333, 1.35, 0.45833333333333
17431, 1.575, 1.35, 0.45833333333333
17432, 1.6166666666667, 1.35, 0.45833333333333
17433, 1.6583333333333, 1.35, 0.45833333333333
17434, 1.7, 1.35, 0.45833333333333
17435, 1.7416666666667, 1.35, 0.45833333333333
17436, 1.7833333333333, 1.35, 0.45833333333333
17437, 1.825, 1.35, 0.45833333333333
17438, 1.8666666666667, 1.35, 0.45833333333333
17439, 1.9083333333333, 1.35, 0.45833333333333
17440, 1.95, 1.35, 0.45833333333333
17441, 1.9916666666667, 1.35, 0.45833333333333
17442, 2.0333333333333, 1.35, 0.45833333333333
17443, 2.075, 1.35, 0.45833333333333
17444, 2.1166666666667, 1.35, 0.45833333333333
17445, 2.1583333333333, 1.35, 0.45833333333333
17446, 1.2416666666667, 1.35, 0.020833333333333
17447, 1.2208333333333, 1.35, 0.041666666666667
17448, 1.2833333333333, 1.35, 0.020833333333333
17449, 1.2625, 1.35, 0.041666666666667
17450, 1.325, 1.35, 0.020833333333333
17451, 1.3041666666667, 1.35, 0.041666666666667
17452, 1.3666666666667, 1.35, 0.020833333333333
17453, 1.3458333333333, 1.35, 0.041666666666667
17454, 1.4083333333333, 1.35, 0.020833333333333
17455, 1.3875, 1.35, 0.041666666666667
17456, 1.45, 1.35, 0.020833333333333
17457, 1.4291666666667, 1.35, 0.041666666666667
17458, 1.4916666666667, 1.35, 0.020833333333333
17459, 1.4708333333333, 1.35, 0.041666666666667
17460, 1.5333333333333, 1.35, 0.020833333333333
17461, 1.5125, 1.35, 0.041666666666667
17462, 1.575, 1.35, 0.020833333333333
17463, 1.5541666666667, 1.35, 0.041666666666667
17464, 1.6166666666667, 1.35, 0.020833333333333
17465, 1.5958333333333, 1.35, 0.041666666666667
17466, 1.6583333333333, 1.35, 0.020833333333333
17467, 1.6375, 1.35, 0.041666666666667
17468, 1.7, 1.35, 0.020833333333333
17469, 1.6791666666667, 1.35, 0.041666666666667
17470, 1.7416666666667, 1.35, 0.020833333333333
17471, 1.7208333333333, 1.35, 0.041666666666667
17472, 1.7833333333333, 1.35, 0.020833333333333
17473, 1.7625, 1.35, 0.041666666666667
17474, 1.825, 1.35, 0.020833333333333
17475, 1.8041666666667, 1.35, 0.041666666666667
17476, 1.8666666666667, 1.35, 0.020833333333333
17477, 1.8458333333333, 1.35, 0.041666666666667
17478, 1.9083333333333, 1.35, 0.020833333333333
17479, 1.8875, 1.35, 0.041666666666667
17480, 1.95, 1.35, 0.020833333333333
17481, 1.9291666666667, 1.35, 0.041666666666667
17482, 1.9916666666667, 1.35, 0.020833333333333
17483, 1.9708333333333, 1.35, 0.041666666666667
17484, 2.0333333333333, 1.35, 0.020833333333333
17485, 2.0125, 1.35, 0.041666666666667
17486, 2.075, 1.35, 0.020833333333333
17487, 2.0541666666667, 1.35, 0.041666666666667
17488, 2.1166666666667, 1.35, 0.020833333333333
17489, 2.0958333333333, 1.35, 0.041666666666667
17490, 2.1583333333333, 1.35, 0.020833333333333
17491, 2.1375, 1.35, 0.041666666666667
17492, 2.1791666666667, 1.35, 0.041666666666667
17493, 1.2416666666667, 1.35, 0.0625
17494, 1.2208333333333, 1.35, 0.083333333333333
17495, 1.2833333333333, 1.35, 0.0625
17496, 1.2625, 1.35, 0.083333333333333
17497, 1.325, 1.35, 0.0625
17498, 1.3041666666667, 1.35, 0.083333333333333
17499, 1.3666666666667, 1.35, 0.0625
17500, 1.3458333333333, 1.35, 0.083333333333333
17501, 1.4083333333333, 1.35, 0.0625
17502, 1.3875, 1.35, 0.083333333333333
17503, 1.45, 1.35, 0.0625
17504, 1.4291666666667, 1.35, 0.083333333333333
17505, 1.4916666666667, 1.35, 0.0625
17506, 1.4708333333333, 1.35, 0.083333333333333
17507, 1.5333333333333, 1.35, 0.0625
17508, 1.5125, 1.35, 0.083333333333333
17509, 1.575, 1.35, 0.0625
17510, 1.5541666666667, 1.35, 0.083333333333333
17511, 1.6166666666667, 1.35, 0.0625
17512, 1.5958333333333, 1.35, 0.083333333333333
17513, 1.6583333333333, 1.35, 0.0625
17514, 1.6375, 1.35, 0.083333333333333
17515, 1.7, 1.35, 0.0625
17516, 1.6791666666667, 1.35, 0.083333333333333
17517, 1.7416666666667, 1.35, 0.0625
17518, 1.7208333333333, 1.35, 0.083333333333333
17519, 1.7833333333333, 1.35, 0.0625
17520, 1.7625, 1.35, 0.083333333333333
17521, 1.825, 1.35, 0.0625
17522, 1.8041666666667, 1.35, 0.083333333333333
17523, 1.8666666666667, 1.35, 0.0625
17524, 1.8458333333333, 1.35, 0.083333333333333
17525, 1.9083333333333, 1.35, 0.0625
17526, 1.8875, 1.35, 0.083333333333333
17527, 1.95, 1.35, 0.0625
17528, 1.9291666666667, 1.35, 0.083333333333333
17529, 1.9916666666667, 1.35, 0.0625
17530, 1.9708333333333, 1.35, 0.083333333333333
17531, 2.0333333333333, 1.35, 0.0625
17532, 2.0125, 1.35, 0.083333333333333
17533, 2.075, 1.35, 0.0625
17534, 2.0541666666667, 1.35, 0.083333333333333
17535, 2.1166666666667, 1.35, 0.0625
17536, 2.0958333333333, 1.35, 0.083333333333333
17537, 2.1583333333333, 1.35, 0.0625
17538, 2.1375, 1.35, 0.083333333333333
17539, 2.1791666666667, 1.35, 0.083333333333333
17540, 1.2416666666667, 1.35, 0.10416666666667
17541, 1.2208333333333, 1.35, 0.125
17542, 1.2833333333333, 1.35, 0.10416666666667
17543, 1.2625, 1.35, 0.125
17544, 1.325, 1.35, 0.10416666666667
17545, 1.3041666666667, 1.35, 0.125
17546, 1.3666666666667, 1.35, 0.10416666666667
17547, 1.3458333333333, 1.35, 0.125
17548, 1.4083333333333, 1.35, 0.10416666666667
17549, 1.3875, 1.35, 0.125
17550, 1.45, 1.35, 0.10416666666667
17551, 1.4291666666667, 1.35, 0.125
17552, 1.4916666666667, 1.35, 0.10416666666667
17553, 1.4708333333333, 1.35, 0.125
17554, 1.5333333333333, 1.35, 0.10416666666667
17555, 1.5125, 1.35, 0.125
17556, 1.575, 1.35, 0.10416666666667
17557, 1.5541666666667, 1.35, 0.125
17558, 1.6166666666667, 1.35, 0.10416666666667
17559, 1.5958333333333, 1.35, 0.125
17560, 1.6583333333333, 1.35, 0.10416666666667
17561, 1.6375, 1.35, 0.125
17562, 1.7, 1.35, 0.10416666666667
17563, 1.6791666666667, 1.35, 0.125
17564, 1.7416666666667, 1.35, 0.10416666666667
17565, 1.7208333333333, 1.35, 0.125
17566, 1.7833333333333, 1.35, 0.10416666666667
17567, 1.7625, 1.35, 0.125
17568, 1.825, 1.35, 0.10416666666667
17569, 1.8041666666667, 1.35, 0.125
17570, 1.8666666666667, 1.35, 0.10416666666667
17571, 1.8458333333333, 1.35, 0.125
17572, 1.9083333333333, 1.35, 0.10416666666667
17573, 1.8875, 1.35, 0.125
17574, 1.95, 1.35, 0.10416666666667
17575, 1.9291666666667, 1.35, 0.125
17576, 1.9916666666667, 1.35, 0.10416666666667
17577, 1.9708333333333, 1.35, 0.125
17578, 2.0333333333333, 1.35, 0.10416666666667
17579, 2.0125, 1.35, 0.125
17580, 2.075, 1.35, 0.10416666666667
17581, 2.0541666666667, 1.35, 0.125
17582, 2.1166666666667, 1.35, 0.10416666666667
17583, 2.0958333333333, 1.35, 0.125
17584, 2.1583333333333, 1.35, 0.10416666666667
17585, 2.1375, 1.35, 0.125
17586, 2.1791666666667, 1.35, 0.125
17587, 1.2416666666667, 1.35, 0.14583333333333
17588, 1.2208333333333, 1.35, 0.16666666666667
17589, 1.2833333333333, 1.35, 0.14583333333333
17590, 1.2625, 1.35, 0.16666666666667
17591, 1.325, 1.35, 0.14583333333333
17592, 1.3041666666667, 1.35, 0.16666666666667
17593, 1.3666666666667, 1.35, 0.14583333333333
17594, 1.3458333333333, 1.35, 0.16666666666667
17595, 1.4083333333333, 1.35, 0.14583333333333
17596, 1.3875, 1.35, 0.16666666666667
17597, 1.45, 1.35, 0.14583333333333
17598, 1.4291666666667, 1.35, 0.16666666666667
17599, 1.4916666666667, 1.35, 0.14583333333333
17600, 1.4708333333333, 1.35, 0.16666666666667
17601, 1.5333333333333, 1.35, 0.14583333333333
17602, 1.5125, 1.35, 0.16666666666667
17603, 1.575, 1.35, 0.14583333333333
17604, 1.5541666666667, 1.35, 0.16666666666667
17605, 1.6166666666667, 1.35, 0.14583333333333
17606, 1.5958333333333, 1.35, 0.16666666666667
17607, 1.6583333333333, 1.35, 0.14583333333333
17608, 1.6375, 1.35, 0.16666666666667
17609, 1.7, 1.35, 0.14583333333333
17610, 1.6791666666667, 1.35, 0.16666666666667
17611, 1.7416666666667, 1.35, 0.14583333333333
17612, 1.7208333333333, 1.35, 0.16666666666667
17613, 1.7833333333333, 1.35, 0.14583333333333
17614, 1.7625, 1.35, 0.16666666666667
17615, 1.825, 1.35, 0.14583333333333
17616, 1.8041666666667, 1.35, 0.16666666666667
17617, 1.8666666666667, 1.35, 0.14583333333333
17618, 1.8458333333333, 1.35, 0.16666666666667
17619, 1.9083333333333, 1.35, 0.14583333333333
17620, 1.8875, 1.35, 0.16666666666667
17621, 1.95, 1.35, 0.14583333333333
17622, 1.9291666666667, 1.35, 0.16666666666667
17623, 1.9916666666667, 1.35, 0.14583333333333
17624, 1.9708333333333, 1.35, 0.16666666666667
17625, 2.0333333333333, 1.35, 0.14583333333333
17626, 2.0125, 1.35, 0.16666666666667
17627, 2.075, 1.35, 0.14583333333333
17628, 2.0541666666667, 1.35, 0.16666666666667
17629, 2.1166666666667, 1.35, 0.14583333333333
17630, 2.0958333333333, 1.35, 0.16666666666667
17631, 2.1583333333333, 1.35, 0.14583333333333
17632, 2.1375, 1.35, 0.16666666666667
17633, 2.1791666666667, 1.35, 0.16666666666667
17634, 1.2416666666667, 1.35, 0.1875
17635, 1.2208333333333, 1.35, 0.20833333333333
17636, 1.2833333333333, 1.35, 0.1875
17637, 1.2625, 1.35, 0.20833333333333
17638, 1.325, 1.35, 0.1875
17639, 1.3041666666667, 1.35, 0.20833333333333
17640, 1.3666666666667, 1.35, 0.1875
17641, 1.3458333333333, 1.35, 0.20833333333333
17642, 1.4083333333333, 1.35, 0.1875
17643, 1.3875, 1.35, 0.20833333333333
17644, 1.45, 1.35, 0.1875
17645, 1.4291666666667, 1.35, 0.20833333333333
17646, 1.4916666666667, 1.35, 0.1875
17647, 1.4708333333333, 1.35, 0.20833333333333
17648, 1.5333333333333, 1.35, 0.1875
17649, 1.5125, 1.35, 0.20833333333333
17650, 1.575, 1.35, 0.1875
17651, 1.5541666666667, 1.35, 0.20833333333333
17652, 1.6166666666667, 1.35, 0.1875
17653, 1.5958333333333, 1.35, 0.20833333333333
17654, 1.6583333333333, 1.35, 0.1875
17655, 1.6375, 1.35, 0.20833333333333
17656, 1.7, 1.35, 0.1875
17657, 1.6791666666667, 1.35, 0.20833333333333
17658, 1.7416666666667, 1.35, 0.1875
17659, 1.7208333333333, 1.35, 0.20833333333333
17660, 1.7833333333333, 1.35, 0.1875
17661, 1.7625, 1.35, 0.20833333333333
17662, 1.825, 1.35, 0.1875
17663, 1.8041666666667, 1.35, 0.20833333333333
17664, 1.8666666666667, 1.35, 0.1875
17665, 1.8458333333333, 1.35, 0.20833333333333
17666, 1.9083333333333, 1.35, 0.1875
17667, 1.8875, 1.35, 0.20833333333333
17668, 1.95, 1.35, 0.1875
17669, 1.9291666666667, 1.35, 0.20833333333333
17670, 1.9916666666667, 1.35, 0.1875
17671, 1.9708333333333, 1.35, 0.20833333333333
17672, 2.0333333333333, 1.35, 0.1875
17673, 2.0125, 1.35, 0.20833333333333
17674, 2.075, 1.35, 0.1875
17675, 2.0541666666667, 1.35, 0.20833333333333
17676, 2.1166666666667, 1.35, 0.1875
