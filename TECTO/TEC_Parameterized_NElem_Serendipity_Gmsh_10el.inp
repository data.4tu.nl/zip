6607, 15538, 15539, 15562, 15561, 15875, 15921, 15922, 15919
6608, 15539, 15540, 15563, 15562, 15877, 15923, 15924, 15921
6609, 15540, 15541, 15564, 15563, 15879, 15925, 15926, 15923
6610, 15541, 15542, 15565, 15564, 15881, 15927, 15928, 15925
6611, 15542, 15543, 15566, 15565, 15883, 15929, 15930, 15927
6612, 15543, 15544, 15567, 15566, 15885, 15931, 15932, 15929
6613, 15544, 15545, 15568, 15567, 15887, 15933, 15934, 15931
6614, 15545, 15546, 15569, 15568, 15889, 15935, 15936, 15933
6615, 15546, 15547, 15570, 15569, 15891, 15937, 15938, 15935
6616, 15547, 15548, 15571, 15570, 15893, 15939, 15940, 15937
6617, 15548, 15549, 15572, 15571, 15895, 15941, 15942, 15939
6618, 15549, 15550, 15573, 15572, 15897, 15943, 15944, 15941
6619, 15550, 15551, 15574, 15573, 15899, 15945, 15946, 15943
6620, 15551, 1466, 1467, 15574, 15900, 1478, 15947, 15945
6621, 1223, 15552, 15575, 1224, 15902, 15948, 15949, 1235
6622, 15552, 15553, 15576, 15575, 15904, 15950, 15951, 15948
6623, 15553, 15554, 15577, 15576, 15906, 15952, 15953, 15950
6624, 15554, 15555, 15578, 15577, 15908, 15954, 15955, 15952
6625, 15555, 15556, 15579, 15578, 15910, 15956, 15957, 15954
6626, 15556, 15557, 15580, 15579, 15912, 15958, 15959, 15956
6627, 15557, 15558, 15581, 15580, 15914, 15960, 15961, 15958
6628, 15558, 15559, 15582, 15581, 15916, 15962, 15963, 15960
6629, 15559, 15560, 15583, 15582, 15918, 15964, 15965, 15962
6630, 15560, 15561, 15584, 15583, 15920, 15966, 15967, 15964
6631, 15561, 15562, 15585, 15584, 15922, 15968, 15969, 15966
6632, 15562, 15563, 15586, 15585, 15924, 15970, 15971, 15968
6633, 15563, 15564, 15587, 15586, 15926, 15972, 15973, 15970
6634, 15564, 15565, 15588, 15587, 15928, 15974, 15975, 15972
6635, 15565, 15566, 15589, 15588, 15930, 15976, 15977, 15974
6636, 15566, 15567, 15590, 15589, 15932, 15978, 15979, 15976
6637, 15567, 15568, 15591, 15590, 15934, 15980, 15981, 15978
6638, 15568, 15569, 15592, 15591, 15936, 15982, 15983, 15980
6639, 15569, 15570, 15593, 15592, 15938, 15984, 15985, 15982
6640, 15570, 15571, 15594, 15593, 15940, 15986, 15987, 15984
6641, 15571, 15572, 15595, 15594, 15942, 15988, 15989, 15986
6642, 15572, 15573, 15596, 15595, 15944, 15990, 15991, 15988
6643, 15573, 15574, 15597, 15596, 15946, 15992, 15993, 15990
6644, 15574, 1467, 1468, 15597, 15947, 1479, 15994, 15992
6645, 1224, 15575, 15598, 1225, 15949, 15995, 15996, 1236
6646, 15575, 15576, 15599, 15598, 15951, 15997, 15998, 15995
6647, 15576, 15577, 15600, 15599, 15953, 15999, 16000, 15997
6648, 15577, 15578, 15601, 15600, 15955, 16001, 16002, 15999
6649, 15578, 15579, 15602, 15601, 15957, 16003, 16004, 16001
6650, 15579, 15580, 15603, 15602, 15959, 16005, 16006, 16003
6651, 15580, 15581, 15604, 15603, 15961, 16007, 16008, 16005
6652, 15581, 15582, 15605, 15604, 15963, 16009, 16010, 16007
6653, 15582, 15583, 15606, 15605, 15965, 16011, 16012, 16009
6654, 15583, 15584, 15607, 15606, 15967, 16013, 16014, 16011
6655, 15584, 15585, 15608, 15607, 15969, 16015, 16016, 16013
6656, 15585, 15586, 15609, 15608, 15971, 16017, 16018, 16015
6657, 15586, 15587, 15610, 15609, 15973, 16019, 16020, 16017
6658, 15587, 15588, 15611, 15610, 15975, 16021, 16022, 16019
6659, 15588, 15589, 15612, 15611, 15977, 16023, 16024, 16021
6660, 15589, 15590, 15613, 15612, 15979, 16025, 16026, 16023
6661, 15590, 15591, 15614, 15613, 15981, 16027, 16028, 16025
6662, 15591, 15592, 15615, 15614, 15983, 16029, 16030, 16027
6663, 15592, 15593, 15616, 15615, 15985, 16031, 16032, 16029
6664, 15593, 15594, 15617, 15616, 15987, 16033, 16034, 16031
6665, 15594, 15595, 15618, 15617, 15989, 16035, 16036, 16033
6666, 15595, 15596, 15619, 15618, 15991, 16037, 16038, 16035
6667, 15596, 15597, 15620, 15619, 15993, 16039, 16040, 16037
6668, 15597, 1468, 1469, 15620, 15994, 1480, 16041, 16039
6669, 1225, 15598, 15621, 1226, 15996, 16042, 16043, 1237
6670, 15598, 15599, 15622, 15621, 15998, 16044, 16045, 16042
6671, 15599, 15600, 15623, 15622, 16000, 16046, 16047, 16044
6672, 15600, 15601, 15624, 15623, 16002, 16048, 16049, 16046
6673, 15601, 15602, 15625, 15624, 16004, 16050, 16051, 16048
6674, 15602, 15603, 15626, 15625, 16006, 16052, 16053, 16050
6675, 15603, 15604, 15627, 15626, 16008, 16054, 16055, 16052
6676, 15604, 15605, 15628, 15627, 16010, 16056, 16057, 16054
6677, 15605, 15606, 15629, 15628, 16012, 16058, 16059, 16056
6678, 15606, 15607, 15630, 15629, 16014, 16060, 16061, 16058
6679, 15607, 15608, 15631, 15630, 16016, 16062, 16063, 16060
6680, 15608, 15609, 15632, 15631, 16018, 16064, 16065, 16062
6681, 15609, 15610, 15633, 15632, 16020, 16066, 16067, 16064
6682, 15610, 15611, 15634, 15633, 16022, 16068, 16069, 16066
6683, 15611, 15612, 15635, 15634, 16024, 16070, 16071, 16068
6684, 15612, 15613, 15636, 15635, 16026, 16072, 16073, 16070
6685, 15613, 15614, 15637, 15636, 16028, 16074, 16075, 16072
6686, 15614, 15615, 15638, 15637, 16030, 16076, 16077, 16074
6687, 15615, 15616, 15639, 15638, 16032, 16078, 16079, 16076
6688, 15616, 15617, 15640, 15639, 16034, 16080, 16081, 16078
6689, 15617, 15618, 15641, 15640, 16036, 16082, 16083, 16080
6690, 15618, 15619, 15642, 15641, 16038, 16084, 16085, 16082
6691, 15619, 15620, 15643, 15642, 16040, 16086, 16087, 16084
6692, 15620, 1469, 1470, 15643, 16041, 1481, 16088, 16086
6693, 1226, 15621, 15644, 1227, 16043, 16089, 16090, 1238
6694, 15621, 15622, 15645, 15644, 16045, 16091, 16092, 16089
6695, 15622, 15623, 15646, 15645, 16047, 16093, 16094, 16091
6696, 15623, 15624, 15647, 15646, 16049, 16095, 16096, 16093
6697, 15624, 15625, 15648, 15647, 16051, 16097, 16098, 16095
6698, 15625, 15626, 15649, 15648, 16053, 16099, 16100, 16097
6699, 15626, 15627, 15650, 15649, 16055, 16101, 16102, 16099
6700, 15627, 15628, 15651, 15650, 16057, 16103, 16104, 16101
6701, 15628, 15629, 15652, 15651, 16059, 16105, 16106, 16103
6702, 15629, 15630, 15653, 15652, 16061, 16107, 16108, 16105
6703, 15630, 15631, 15654, 15653, 16063, 16109, 16110, 16107
6704, 15631, 15632, 15655, 15654, 16065, 16111, 16112, 16109
6705, 15632, 15633, 15656, 15655, 16067, 16113, 16114, 16111
6706, 15633, 15634, 15657, 15656, 16069, 16115, 16116, 16113
6707, 15634, 15635, 15658, 15657, 16071, 16117, 16118, 16115
6708, 15635, 15636, 15659, 15658, 16073, 16119, 16120, 16117
6709, 15636, 15637, 15660, 15659, 16075, 16121, 16122, 16119
6710, 15637, 15638, 15661, 15660, 16077, 16123, 16124, 16121
6711, 15638, 15639, 15662, 15661, 16079, 16125, 16126, 16123
6712, 15639, 15640, 15663, 15662, 16081, 16127, 16128, 16125
6713, 15640, 15641, 15664, 15663, 16083, 16129, 16130, 16127
6714, 15641, 15642, 15665, 15664, 16085, 16131, 16132, 16129
6715, 15642, 15643, 15666, 15665, 16087, 16133, 16134, 16131
6716, 15643, 1470, 1471, 15666, 16088, 1482, 16135, 16133
6717, 1227, 15644, 15667, 1228, 16090, 16136, 16137, 1239
6718, 15644, 15645, 15668, 15667, 16092, 16138, 16139, 16136
6719, 15645, 15646, 15669, 15668, 16094, 16140, 16141, 16138
6720, 15646, 15647, 15670, 15669, 16096, 16142, 16143, 16140
6721, 15647, 15648, 15671, 15670, 16098, 16144, 16145, 16142
6722, 15648, 15649, 15672, 15671, 16100, 16146, 16147, 16144
6723, 15649, 15650, 15673, 15672, 16102, 16148, 16149, 16146
6724, 15650, 15651, 15674, 15673, 16104, 16150, 16151, 16148
6725, 15651, 15652, 15675, 15674, 16106, 16152, 16153, 16150
6726, 15652, 15653, 15676, 15675, 16108, 16154, 16155, 16152
6727, 15653, 15654, 15677, 15676, 16110, 16156, 16157, 16154
6728, 15654, 15655, 15678, 15677, 16112, 16158, 16159, 16156
6729, 15655, 15656, 15679, 15678, 16114, 16160, 16161, 16158
6730, 15656, 15657, 15680, 15679, 16116, 16162, 16163, 16160
6731, 15657, 15658, 15681, 15680, 16118, 16164, 16165, 16162
6732, 15658, 15659, 15682, 15681, 16120, 16166, 16167, 16164
6733, 15659, 15660, 15683, 15682, 16122, 16168, 16169, 16166
6734, 15660, 15661, 15684, 15683, 16124, 16170, 16171, 16168
6735, 15661, 15662, 15685, 15684, 16126, 16172, 16173, 16170
6736, 15662, 15663, 15686, 15685, 16128, 16174, 16175, 16172
6737, 15663, 15664, 15687, 15686, 16130, 16176, 16177, 16174
6738, 15664, 15665, 15688, 15687, 16132, 16178, 16179, 16176
6739, 15665, 15666, 15689, 15688, 16134, 16180, 16181, 16178
6740, 15666, 1471, 1472, 15689, 16135, 1483, 16182, 16180
6741, 1228, 15667, 15690, 1229, 16137, 16183, 16184, 1240
6742, 15667, 15668, 15691, 15690, 16139, 16185, 16186, 16183
6743, 15668, 15669, 15692, 15691, 16141, 16187, 16188, 16185
6744, 15669, 15670, 15693, 15692, 16143, 16189, 16190, 16187
6745, 15670, 15671, 15694, 15693, 16145, 16191, 16192, 16189
6746, 15671, 15672, 15695, 15694, 16147, 16193, 16194, 16191
6747, 15672, 15673, 15696, 15695, 16149, 16195, 16196, 16193
6748, 15673, 15674, 15697, 15696, 16151, 16197, 16198, 16195
6749, 15674, 15675, 15698, 15697, 16153, 16199, 16200, 16197
6750, 15675, 15676, 15699, 15698, 16155, 16201, 16202, 16199
6751, 15676, 15677, 15700, 15699, 16157, 16203, 16204, 16201
6752, 15677, 15678, 15701, 15700, 16159, 16205, 16206, 16203
6753, 15678, 15679, 15702, 15701, 16161, 16207, 16208, 16205
6754, 15679, 15680, 15703, 15702, 16163, 16209, 16210, 16207
6755, 15680, 15681, 15704, 15703, 16165, 16211, 16212, 16209
6756, 15681, 15682, 15705, 15704, 16167, 16213, 16214, 16211
6757, 15682, 15683, 15706, 15705, 16169, 16215, 16216, 16213
6758, 15683, 15684, 15707, 15706, 16171, 16217, 16218, 16215
6759, 15684, 15685, 15708, 15707, 16173, 16219, 16220, 16217
6760, 15685, 15686, 15709, 15708, 16175, 16221, 16222, 16219
6761, 15686, 15687, 15710, 15709, 16177, 16223, 16224, 16221
6762, 15687, 15688, 15711, 15710, 16179, 16225, 16226, 16223
6763, 15688, 15689, 15712, 15711, 16181, 16227, 16228, 16225
6764, 15689, 1472, 1473, 15712, 16182, 1484, 16229, 16227
6765, 1229, 15690, 1265, 25, 16184, 16230, 1288, 1241
6766, 15690, 15691, 1266, 1265, 16186, 16231, 1289, 16230
6767, 15691, 15692, 1267, 1266, 16188, 16232, 1290, 16231
6768, 15692, 15693, 1268, 1267, 16190, 16233, 1291, 16232
6769, 15693, 15694, 1269, 1268, 16192, 16234, 1292, 16233
6770, 15694, 15695, 1270, 1269, 16194, 16235, 1293, 16234
6771, 15695, 15696, 1271, 1270, 16196, 16236, 1294, 16235
6772, 15696, 15697, 1272, 1271, 16198, 16237, 1295, 16236
6773, 15697, 15698, 1273, 1272, 16200, 16238, 1296, 16237
6774, 15698, 15699, 1274, 1273, 16202, 16239, 1297, 16238
6775, 15699, 15700, 1275, 1274, 16204, 16240, 1298, 16239
6776, 15700, 15701, 1276, 1275, 16206, 16241, 1299, 16240
6777, 15701, 15702, 1277, 1276, 16208, 16242, 1300, 16241
6778, 15702, 15703, 1278, 1277, 16210, 16243, 1301, 16242
6779, 15703, 15704, 1279, 1278, 16212, 16244, 1302, 16243
6780, 15704, 15705, 1280, 1279, 16214, 16245, 1303, 16244
6781, 15705, 15706, 1281, 1280, 16216, 16246, 1304, 16245
6782, 15706, 15707, 1282, 1281, 16218, 16247, 1305, 16246
6783, 15707, 15708, 1283, 1282, 16220, 16248, 1306, 16247
6784, 15708, 15709, 1284, 1283, 16222, 16249, 1307, 16248
6785, 15709, 15710, 1285, 1284, 16224, 16250, 1308, 16249
6786, 15710, 15711, 1286, 1285, 16226, 16251, 1309, 16250
6787, 15711, 15712, 1287, 1286, 16228, 16252, 1310, 16251
6788, 15712, 1473, 29, 1287, 16229, 1485, 1311, 16252
*ELEMENT, type=CPS8, ELSET=Surface35
6789, 28, 1242, 16253, 1411, 1253, 16506, 16507, 1434
6790, 1411, 16253, 16254, 1412, 16507, 16508, 16509, 1435
6791, 1412, 16254, 16255, 1413, 16509, 16510, 16511, 1436
6792, 1413, 16255, 16256, 1414, 16511, 16512, 16513, 1437
6793, 1414, 16256, 16257, 1415, 16513, 16514, 16515, 1438
6794, 1415, 16257, 16258, 1416, 16515, 16516, 16517, 1439
6795, 1416, 16258, 16259, 1417, 16517, 16518, 16519, 1440
6796, 1417, 16259, 16260, 1418, 16519, 16520, 16521, 1441
6797, 1418, 16260, 16261, 1419, 16521, 16522, 16523, 1442
6798, 1419, 16261, 16262, 1420, 16523, 16524, 16525, 1443
6799, 1420, 16262, 16263, 1421, 16525, 16526, 16527, 1444
6800, 1421, 16263, 16264, 1422, 16527, 16528, 16529, 1445
6801, 1422, 16264, 16265, 1423, 16529, 16530, 16531, 1446
6802, 1423, 16265, 16266, 1424, 16531, 16532, 16533, 1447
6803, 1424, 16266, 16267, 1425, 16533, 16534, 16535, 1448
6804, 1425, 16267, 16268, 1426, 16535, 16536, 16537, 1449
6805, 1426, 16268, 16269, 1427, 16537, 16538, 16539, 1450
6806, 1427, 16269, 16270, 1428, 16539, 16540, 16541, 1451
6807, 1428, 16270, 16271, 1429, 16541, 16542, 16543, 1452
6808, 1429, 16271, 16272, 1430, 16543, 16544, 16545, 1453
6809, 1430, 16272, 16273, 1431, 16545, 16546, 16547, 1454
6810, 1431, 16273, 16274, 1432, 16547, 16548, 16549, 1455
6811, 1432, 16274, 16275, 1433, 16549, 16550, 16551, 1456
6812, 1433, 16275, 1486, 32, 16551, 16552, 1497, 1457
6813, 1242, 1243, 16276, 16253, 1254, 16553, 16554, 16506
6814, 16253, 16276, 16277, 16254, 16554, 16555, 16556, 16508
6815, 16254, 16277, 16278, 16255, 16556, 16557, 16558, 16510
6816, 16255, 16278, 16279, 16256, 16558, 16559, 16560, 16512
6817, 16256, 16279, 16280, 16257, 16560, 16561, 16562, 16514
6818, 16257, 16280, 16281, 16258, 16562, 16563, 16564, 16516
6819, 16258, 16281, 16282, 16259, 16564, 16565, 16566, 16518
6820, 16259, 16282, 16283, 16260, 16566, 16567, 16568, 16520
6821, 16260, 16283, 16284, 16261, 16568, 16569, 16570, 16522
6822, 16261, 16284, 16285, 16262, 16570, 16571, 16572, 16524
6823, 16262, 16285, 16286, 16263, 16572, 16573, 16574, 16526
6824, 16263, 16286, 16287, 16264, 16574, 16575, 16576, 16528
6825, 16264, 16287, 16288, 16265, 16576, 16577, 16578, 16530
6826, 16265, 16288, 16289, 16266, 16578, 16579, 16580, 16532
6827, 16266, 16289, 16290, 16267, 16580, 16581, 16582, 16534
6828, 16267, 16290, 16291, 16268, 16582, 16583, 16584, 16536
6829, 16268, 16291, 16292, 16269, 16584, 16585, 16586, 16538
6830, 16269, 16292, 16293, 16270, 16586, 16587, 16588, 16540
6831, 16270, 16293, 16294, 16271, 16588, 16589, 16590, 16542
6832, 16271, 16294, 16295, 16272, 16590, 16591, 16592, 16544
6833, 16272, 16295, 16296, 16273, 16592, 16593, 16594, 16546
6834, 16273, 16296, 16297, 16274, 16594, 16595, 16596, 16548
6835, 16274, 16297, 16298, 16275, 16596, 16597, 16598, 16550
6836, 16275, 16298, 1487, 1486, 16598, 16599, 1498, 16552
6837, 1243, 1244, 16299, 16276, 1255, 16600, 16601, 16553
6838, 16276, 16299, 16300, 16277, 16601, 16602, 16603, 16555
6839, 16277, 16300, 16301, 16278, 16603, 16604, 16605, 16557
6840, 16278, 16301, 16302, 16279, 16605, 16606, 16607, 16559
6841, 16279, 16302, 16303, 16280, 16607, 16608, 16609, 16561
6842, 16280, 16303, 16304, 16281, 16609, 16610, 16611, 16563
6843, 16281, 16304, 16305, 16282, 16611, 16612, 16613, 16565
6844, 16282, 16305, 16306, 16283, 16613, 16614, 16615, 16567
6845, 16283, 16306, 16307, 16284, 16615, 16616, 16617, 16569
6846, 16284, 16307, 16308, 16285, 16617, 16618, 16619, 16571
6847, 16285, 16308, 16309, 16286, 16619, 16620, 16621, 16573
6848, 16286, 16309, 16310, 16287, 16621, 16622, 16623, 16575
6849, 16287, 16310, 16311, 16288, 16623, 16624, 16625, 16577
6850, 16288, 16311, 16312, 16289, 16625, 16626, 16627, 16579
6851, 16289, 16312, 16313, 16290, 16627, 16628, 16629, 16581
6852, 16290, 16313, 16314, 16291, 16629, 16630, 16631, 16583
6853, 16291, 16314, 16315, 16292, 16631, 16632, 16633, 16585
6854, 16292, 16315, 16316, 16293, 16633, 16634, 16635, 16587
6855, 16293, 16316, 16317, 16294, 16635, 16636, 16637, 16589
6856, 16294, 16317, 16318, 16295, 16637, 16638, 16639, 16591
6857, 16295, 16318, 16319, 16296, 16639, 16640, 16641, 16593
6858, 16296, 16319, 16320, 16297, 16641, 16642, 16643, 16595
6859, 16297, 16320, 16321, 16298, 16643, 16644, 16645, 16597
6860, 16298, 16321, 1488, 1487, 16645, 16646, 1499, 16599
6861, 1244, 1245, 16322, 16299, 1256, 16647, 16648, 16600
6862, 16299, 16322, 16323, 16300, 16648, 16649, 16650, 16602
6863, 16300, 16323, 16324, 16301, 16650, 16651, 16652, 16604
6864, 16301, 16324, 16325, 16302, 16652, 16653, 16654, 16606
6865, 16302, 16325, 16326, 16303, 16654, 16655, 16656, 16608
6866, 16303, 16326, 16327, 16304, 16656, 16657, 16658, 16610
6867, 16304, 16327, 16328, 16305, 16658, 16659, 16660, 16612
6868, 16305, 16328, 16329, 16306, 16660, 16661, 16662, 16614
6869, 16306, 16329, 16330, 16307, 16662, 16663, 16664, 16616
6870, 16307, 16330, 16331, 16308, 16664, 16665, 16666, 16618
6871, 16308, 16331, 16332, 16309, 16666, 16667, 16668, 16620
6872, 16309, 16332, 16333, 16310, 16668, 16669, 16670, 16622
6873, 16310, 16333, 16334, 16311, 16670, 16671, 16672, 16624
6874, 16311, 16334, 16335, 16312, 16672, 16673, 16674, 16626
6875, 16312, 16335, 16336, 16313, 16674, 16675, 16676, 16628
6876, 16313, 16336, 16337, 16314, 16676, 16677, 16678, 16630
6877, 16314, 16337, 16338, 16315, 16678, 16679, 16680, 16632
6878, 16315, 16338, 16339, 16316, 16680, 16681, 16682, 16634
6879, 16316, 16339, 16340, 16317, 16682, 16683, 16684, 16636
6880, 16317, 16340, 16341, 16318, 16684, 16685, 16686, 16638
6881, 16318, 16341, 16342, 16319, 16686, 16687, 16688, 16640
6882, 16319, 16342, 16343, 16320, 16688, 16689, 16690, 16642
6883, 16320, 16343, 16344, 16321, 16690, 16691, 16692, 16644
6884, 16321, 16344, 1489, 1488, 16692, 16693, 1500, 16646
6885, 1245, 1246, 16345, 16322, 1257, 16694, 16695, 16647
6886, 16322, 16345, 16346, 16323, 16695, 16696, 16697, 16649
6887, 16323, 16346, 16347, 16324, 16697, 16698, 16699, 16651
6888, 16324, 16347, 16348, 16325, 16699, 16700, 16701, 16653
6889, 16325, 16348, 16349, 16326, 16701, 16702, 16703, 16655
6890, 16326, 16349, 16350, 16327, 16703, 16704, 16705, 16657
6891, 16327, 16350, 16351, 16328, 16705, 16706, 16707, 16659
6892, 16328, 16351, 16352, 16329, 16707, 16708, 16709, 16661
6893, 16329, 16352, 16353, 16330, 16709, 16710, 16711, 16663
6894, 16330, 16353, 16354, 16331, 16711, 16712, 16713, 16665
6895, 16331, 16354, 16355, 16332, 16713, 16714, 16715, 16667
6896, 16332, 16355, 16356, 16333, 16715, 16716, 16717, 16669
6897, 16333, 16356, 16357, 16334, 16717, 16718, 16719, 16671
6898, 16334, 16357, 16358, 16335, 16719, 16720, 16721, 16673
6899, 16335, 16358, 16359, 16336, 16721, 16722, 16723, 16675
6900, 16336, 16359, 16360, 16337, 16723, 16724, 16725, 16677
6901, 16337, 16360, 16361, 16338, 16725, 16726, 16727, 16679
6902, 16338, 16361, 16362, 16339, 16727, 16728, 16729, 16681
6903, 16339, 16362, 16363, 16340, 16729, 16730, 16731, 16683
6904, 16340, 16363, 16364, 16341, 16731, 16732, 16733, 16685
6905, 16341, 16364, 16365, 16342, 16733, 16734, 16735, 16687
6906, 16342, 16365, 16366, 16343, 16735, 16736, 16737, 16689
6907, 16343, 16366, 16367, 16344, 16737, 16738, 16739, 16691
6908, 16344, 16367, 1490, 1489, 16739, 16740, 1501, 16693
6909, 1246, 1247, 16368, 16345, 1258, 16741, 16742, 16694
6910, 16345, 16368, 16369, 16346, 16742, 16743, 16744, 16696
6911, 16346, 16369, 16370, 16347, 16744, 16745, 16746, 16698
6912, 16347, 16370, 16371, 16348, 16746, 16747, 16748, 16700
6913, 16348, 16371, 16372, 16349, 16748, 16749, 16750, 16702
6914, 16349, 16372, 16373, 16350, 16750, 16751, 16752, 16704
6915, 16350, 16373, 16374, 16351, 16752, 16753, 16754, 16706
6916, 16351, 16374, 16375, 16352, 16754, 16755, 16756, 16708
6917, 16352, 16375, 16376, 16353, 16756, 16757, 16758, 16710
6918, 16353, 16376, 16377, 16354, 16758, 16759, 16760, 16712
6919, 16354, 16377, 16378, 16355, 16760, 16761, 16762, 16714
6920, 16355, 16378, 16379, 16356, 16762, 16763, 16764, 16716
6921, 16356, 16379, 16380, 16357, 16764, 16765, 16766, 16718
6922, 16357, 16380, 16381, 16358, 16766, 16767, 16768, 16720
6923, 16358, 16381, 16382, 16359, 16768, 16769, 16770, 16722
6924, 16359, 16382, 16383, 16360, 16770, 16771, 16772, 16724
6925, 16360, 16383, 16384, 16361, 16772, 16773, 16774, 16726
6926, 16361, 16384, 16385, 16362, 16774, 16775, 16776, 16728
6927, 16362, 16385, 16386, 16363, 16776, 16777, 16778, 16730
6928, 16363, 16386, 16387, 16364, 16778, 16779, 16780, 16732
6929, 16364, 16387, 16388, 16365, 16780, 16781, 16782, 16734
6930, 16365, 16388, 16389, 16366, 16782, 16783, 16784, 16736
6931, 16366, 16389, 16390, 16367, 16784, 16785, 16786, 16738
6932, 16367, 16390, 1491, 1490, 16786, 16787, 1502, 16740
6933, 1247, 1248, 16391, 16368, 1259, 16788, 16789, 16741
6934, 16368, 16391, 16392, 16369, 16789, 16790, 16791, 16743
6935, 16369, 16392, 16393, 16370, 16791, 16792, 16793, 16745
6936, 16370, 16393, 16394, 16371, 16793, 16794, 16795, 16747
6937, 16371, 16394, 16395, 16372, 16795, 16796, 16797, 16749
6938, 16372, 16395, 16396, 16373, 16797, 16798, 16799, 16751
6939, 16373, 16396, 16397, 16374, 16799, 16800, 16801, 16753
6940, 16374, 16397, 16398, 16375, 16801, 16802, 16803, 16755
6941, 16375, 16398, 16399, 16376, 16803, 16804, 16805, 16757
6942, 16376, 16399, 16400, 16377, 16805, 16806, 16807, 16759
6943, 16377, 16400, 16401, 16378, 16807, 16808, 16809, 16761
6944, 16378, 16401, 16402, 16379, 16809, 16810, 16811, 16763
6945, 16379, 16402, 16403, 16380, 16811, 16812, 16813, 16765
6946, 16380, 16403, 16404, 16381, 16813, 16814, 16815, 16767
6947, 16381, 16404, 16405, 16382, 16815, 16816, 16817, 16769
6948, 16382, 16405, 16406, 16383, 16817, 16818, 16819, 16771
6949, 16383, 16406, 16407, 16384, 16819, 16820, 16821, 16773
6950, 16384, 16407, 16408, 16385, 16821, 16822, 16823, 16775
6951, 16385, 16408, 16409, 16386, 16823, 16824, 16825, 16777
6952, 16386, 16409, 16410, 16387, 16825, 16826, 16827, 16779
6953, 16387, 16410, 16411, 16388, 16827, 16828, 16829, 16781
6954, 16388, 16411, 16412, 16389, 16829, 16830, 16831, 16783
6955, 16389, 16412, 16413, 16390, 16831, 16832, 16833, 16785
6956, 16390, 16413, 1492, 1491, 16833, 16834, 1503, 16787
6957, 1248, 1249, 16414, 16391, 1260, 16835, 16836, 16788
6958, 16391, 16414, 16415, 16392, 16836, 16837, 16838, 16790
6959, 16392, 16415, 16416, 16393, 16838, 16839, 16840, 16792
6960, 16393, 16416, 16417, 16394, 16840, 16841, 16842, 16794
6961, 16394, 16417, 16418, 16395, 16842, 16843, 16844, 16796
6962, 16395, 16418, 16419, 16396, 16844, 16845, 16846, 16798
6963, 16396, 16419, 16420, 16397, 16846, 16847, 16848, 16800
6964, 16397, 16420, 16421, 16398, 16848, 16849, 16850, 16802
6965, 16398, 16421, 16422, 16399, 16850, 16851, 16852, 16804
6966, 16399, 16422, 16423, 16400, 16852, 16853, 16854, 16806
6967, 16400, 16423, 16424, 16401, 16854, 16855, 16856, 16808
6968, 16401, 16424, 16425, 16402, 16856, 16857, 16858, 16810
6969, 16402, 16425, 16426, 16403, 16858, 16859, 16860, 16812
6970, 16403, 16426, 16427, 16404, 16860, 16861, 16862, 16814
6971, 16404, 16427, 16428, 16405, 16862, 16863, 16864, 16816
6972, 16405, 16428, 16429, 16406, 16864, 16865, 16866, 16818
6973, 16406, 16429, 16430, 16407, 16866, 16867, 16868, 16820
6974, 16407, 16430, 16431, 16408, 16868, 16869, 16870, 16822
6975, 16408, 16431, 16432, 16409, 16870, 16871, 16872, 16824
6976, 16409, 16432, 16433, 16410, 16872, 16873, 16874, 16826
6977, 16410, 16433, 16434, 16411, 16874, 16875, 16876, 16828
6978, 16411, 16434, 16435, 16412, 16876, 16877, 16878, 16830
6979, 16412, 16435, 16436, 16413, 16878, 16879, 16880, 16832
6980, 16413, 16436, 1493, 1492, 16880, 16881, 1504, 16834
6981, 1249, 1250, 16437, 16414, 1261, 16882, 16883, 16835
6982, 16414, 16437, 16438, 16415, 16883, 16884, 16885, 16837
6983, 16415, 16438, 16439, 16416, 16885, 16886, 16887, 16839
6984, 16416, 16439, 16440, 16417, 16887, 16888, 16889, 16841
6985, 16417, 16440, 16441, 16418, 16889, 16890, 16891, 16843
6986, 16418, 16441, 16442, 16419, 16891, 16892, 16893, 16845
6987, 16419, 16442, 16443, 16420, 16893, 16894, 16895, 16847
6988, 16420, 16443, 16444, 16421, 16895, 16896, 16897, 16849
6989, 16421, 16444, 16445, 16422, 16897, 16898, 16899, 16851
6990, 16422, 16445, 16446, 16423, 16899, 16900, 16901, 16853
6991, 16423, 16446, 16447, 16424, 16901, 16902, 16903, 16855
6992, 16424, 16447, 16448, 16425, 16903, 16904, 16905, 16857
6993, 16425, 16448, 16449, 16426, 16905, 16906, 16907, 16859
6994, 16426, 16449, 16450, 16427, 16907, 16908, 16909, 16861
6995, 16427, 16450, 16451, 16428, 16909, 16910, 16911, 16863
6996, 16428, 16451, 16452, 16429, 16911, 16912, 16913, 16865
6997, 16429, 16452, 16453, 16430, 16913, 16914, 16915, 16867
6998, 16430, 16453, 16454, 16431, 16915, 16916, 16917, 16869
6999, 16431, 16454, 16455, 16432, 16917, 16918, 16919, 16871
7000, 16432, 16455, 16456, 16433, 16919, 16920, 16921, 16873
7001, 16433, 16456, 16457, 16434, 16921, 16922, 16923, 16875
7002, 16434, 16457, 16458, 16435, 16923, 16924, 16925, 16877
7003, 16435, 16458, 16459, 16436, 16925, 16926, 16927, 16879
7004, 16436, 16459, 1494, 1493, 16927, 16928, 1505, 16881
7005, 1250, 1251, 16460, 16437, 1262, 16929, 16930, 16882
7006, 16437, 16460, 16461, 16438, 16930, 16931, 16932, 16884
7007, 16438, 16461, 16462, 16439, 16932, 16933, 16934, 16886
7008, 16439, 16462, 16463, 16440, 16934, 16935, 16936, 16888
7009, 16440, 16463, 16464, 16441, 16936, 16937, 16938, 16890
7010, 16441, 16464, 16465, 16442, 16938, 16939, 16940, 16892
7011, 16442, 16465, 16466, 16443, 16940, 16941, 16942, 16894
7012, 16443, 16466, 16467, 16444, 16942, 16943, 16944, 16896
7013, 16444, 16467, 16468, 16445, 16944, 16945, 16946, 16898
7014, 16445, 16468, 16469, 16446, 16946, 16947, 16948, 16900
7015, 16446, 16469, 16470, 16447, 16948, 16949, 16950, 16902
7016, 16447, 16470, 16471, 16448, 16950, 16951, 16952, 16904
7017, 16448, 16471, 16472, 16449, 16952, 16953, 16954, 16906
7018, 16449, 16472, 16473, 16450, 16954, 16955, 16956, 16908
7019, 16450, 16473, 16474, 16451, 16956, 16957, 16958, 16910
7020, 16451, 16474, 16475, 16452, 16958, 16959, 16960, 16912
7021, 16452, 16475, 16476, 16453, 16960, 16961, 16962, 16914
7022, 16453, 16476, 16477, 16454, 16962, 16963, 16964, 16916
7023, 16454, 16477, 16478, 16455, 16964, 16965, 16966, 16918
7024, 16455, 16478, 16479, 16456, 16966, 16967, 16968, 16920
7025, 16456, 16479, 16480, 16457, 16968, 16969, 16970, 16922
7026, 16457, 16480, 16481, 16458, 16970, 16971, 16972, 16924
7027, 16458, 16481, 16482, 16459, 16972, 16973, 16974, 16926
7028, 16459, 16482, 1495, 1494, 16974, 16975, 1506, 16928
7029, 1251, 1252, 16483, 16460, 1263, 16976, 16977, 16929
7030, 16460, 16483, 16484, 16461, 16977, 16978, 16979, 16931
7031, 16461, 16484, 16485, 16462, 16979, 16980, 16981, 16933
7032, 16462, 16485, 16486, 16463, 16981, 16982, 16983, 16935
7033, 16463, 16486, 16487, 16464, 16983, 16984, 16985, 16937
7034, 16464, 16487, 16488, 16465, 16985, 16986, 16987, 16939
7035, 16465, 16488, 16489, 16466, 16987, 16988, 16989, 16941
7036, 16466, 16489, 16490, 16467, 16989, 16990, 16991, 16943
7037, 16467, 16490, 16491, 16468, 16991, 16992, 16993, 16945
7038, 16468, 16491, 16492, 16469, 16993, 16994, 16995, 16947
7039, 16469, 16492, 16493, 16470, 16995, 16996, 16997, 16949
7040, 16470, 16493, 16494, 16471, 16997, 16998, 16999, 16951
7041, 16471, 16494, 16495, 16472, 16999, 17000, 17001, 16953
7042, 16472, 16495, 16496, 16473, 17001, 17002, 17003, 16955
7043, 16473, 16496, 16497, 16474, 17003, 17004, 17005, 16957
7044, 16474, 16497, 16498, 16475, 17005, 17006, 17007, 16959
7045, 16475, 16498, 16499, 16476, 17007, 17008, 17009, 16961
7046, 16476, 16499, 16500, 16477, 17009, 17010, 17011, 16963
7047, 16477, 16500, 16501, 16478, 17011, 17012, 17013, 16965
7048, 16478, 16501, 16502, 16479, 17013, 17014, 17015, 16967
7049, 16479, 16502, 16503, 16480, 17015, 17016, 17017, 16969
7050, 16480, 16503, 16504, 16481, 17017, 17018, 17019, 16971
7051, 16481, 16504, 16505, 16482, 17019, 17020, 17021, 16973
7052, 16482, 16505, 1496, 1495, 17021, 17022, 1507, 16975
7053, 1252, 26, 1312, 16483, 1264, 1335, 17023, 16976
7054, 16483, 1312, 1313, 16484, 17023, 1336, 17024, 16978
7055, 16484, 1313, 1314, 16485, 17024, 1337, 17025, 16980
7056, 16485, 1314, 1315, 16486, 17025, 1338, 17026, 16982
7057, 16486, 1315, 1316, 16487, 17026, 1339, 17027, 16984
7058, 16487, 1316, 1317, 16488, 17027, 1340, 17028, 16986
7059, 16488, 1317, 1318, 16489, 17028, 1341, 17029, 16988
7060, 16489, 1318, 1319, 16490, 17029, 1342, 17030, 16990
7061, 16490, 1319, 1320, 16491, 17030, 1343, 17031, 16992
7062, 16491, 1320, 1321, 16492, 17031, 1344, 17032, 16994
7063, 16492, 1321, 1322, 16493, 17032, 1345, 17033, 16996
7064, 16493, 1322, 1323, 16494, 17033, 1346, 17034, 16998
7065, 16494, 1323, 1324, 16495, 17034, 1347, 17035, 17000
7066, 16495, 1324, 1325, 16496, 17035, 1348, 17036, 17002
7067, 16496, 1325, 1326, 16497, 17036, 1349, 17037, 17004
7068, 16497, 1326, 1327, 16498, 17037, 1350, 17038, 17006
7069, 16498, 1327, 1328, 16499, 17038, 1351, 17039, 17008
7070, 16499, 1328, 1329, 16500, 17039, 1352, 17040, 17010
7071, 16500, 1329, 1330, 16501, 17040, 1353, 17041, 17012
7072, 16501, 1330, 1331, 16502, 17041, 1354, 17042, 17014
7073, 16502, 1331, 1332, 16503, 17042, 1355, 17043, 17016
7074, 16503, 1332, 1333, 16504, 17043, 1356, 17044, 17018
7075, 16504, 1333, 1334, 16505, 17044, 1357, 17045, 17020
7076, 16505, 1334, 30, 1496, 17045, 1358, 1508, 17022
*ELEMENT, type=CPS8, ELSET=Surface36
7077, 31, 1458, 17046, 1463, 1460, 17068, 17069, 1474
7078, 1458, 1459, 17047, 17046, 1461, 17070, 17071, 17068
7079, 1459, 32, 1486, 17047, 1462, 1497, 17072, 17070
7080, 1463, 17046, 17048, 1464, 17069, 17073, 17074, 1475
7081, 17046, 17047, 17049, 17048, 17071, 17075, 17076, 17073
7082, 17047, 1486, 1487, 17049, 17072, 1498, 17077, 17075
7083, 1464, 17048, 17050, 1465, 17074, 17078, 17079, 1476
7084, 17048, 17049, 17051, 17050, 17076, 17080, 17081, 17078
7085, 17049, 1487, 1488, 17051, 17077, 1499, 17082, 17080
7086, 1465, 17050, 17052, 1466, 17079, 17083, 17084, 1477
7087, 17050, 17051, 17053, 17052, 17081, 17085, 17086, 17083
7088, 17051, 1488, 1489, 17053, 17082, 1500, 17087, 17085
7089, 1466, 17052, 17054, 1467, 17084, 17088, 17089, 1478
7090, 17052, 17053, 17055, 17054, 17086, 17090, 17091, 17088
7091, 17053, 1489, 1490, 17055, 17087, 1501, 17092, 17090
7092, 1467, 17054, 17056, 1468, 17089, 17093, 17094, 1479
7093, 17054, 17055, 17057, 17056, 17091, 17095, 17096, 17093
7094, 17055, 1490, 1491, 17057, 17092, 1502, 17097, 17095
7095, 1468, 17056, 17058, 1469, 17094, 17098, 17099, 1480
7096, 17056, 17057, 17059, 17058, 17096, 17100, 17101, 17098
7097, 17057, 1491, 1492, 17059, 17097, 1503, 17102, 17100
7098, 1469, 17058, 17060, 1470, 17099, 17103, 17104, 1481
7099, 17058, 17059, 17061, 17060, 17101, 17105, 17106, 17103
7100, 17059, 1492, 1493, 17061, 17102, 1504, 17107, 17105
7101, 1470, 17060, 17062, 1471, 17104, 17108, 17109, 1482
7102, 17060, 17061, 17063, 17062, 17106, 17110, 17111, 17108
7103, 17061, 1493, 1494, 17063, 17107, 1505, 17112, 17110
7104, 1471, 17062, 17064, 1472, 17109, 17113, 17114, 1483
7105, 17062, 17063, 17065, 17064, 17111, 17115, 17116, 17113
7106, 17063, 1494, 1495, 17065, 17112, 1506, 17117, 17115
7107, 1472, 17064, 17066, 1473, 17114, 17118, 17119, 1484
7108, 17064, 17065, 17067, 17066, 17116, 17120, 17121, 17118
7109, 17065, 1495, 1496, 17067, 17117, 1507, 17122, 17120
7110, 1473, 17066, 1359, 29, 17119, 17123, 1361, 1485
7111, 17066, 17067, 1360, 1359, 17121, 17124, 1362, 17123
7112, 17067, 1496, 30, 1360, 17122, 1508, 1363, 17124
*ELEMENT, type=CPS8, ELSET=Surface37
7113, 25, 33, 1511, 1265, 1509, 1534, 17125, 1288
7114, 1265, 1511, 1512, 1266, 17125, 1535, 17126, 1289
7115, 1266, 1512, 1513, 1267, 17126, 1536, 17127, 1290
7116, 1267, 1513, 1514, 1268, 17127, 1537, 17128, 1291
7117, 1268, 1514, 1515, 1269, 17128, 1538, 17129, 1292
7118, 1269, 1515, 1516, 1270, 17129, 1539, 17130, 1293
7119, 1270, 1516, 1517, 1271, 17130, 1540, 17131, 1294
7120, 1271, 1517, 1518, 1272, 17131, 1541, 17132, 1295
7121, 1272, 1518, 1519, 1273, 17132, 1542, 17133, 1296
7122, 1273, 1519, 1520, 1274, 17133, 1543, 17134, 1297
7123, 1274, 1520, 1521, 1275, 17134, 1544, 17135, 1298
7124, 1275, 1521, 1522, 1276, 17135, 1545, 17136, 1299
7125, 1276, 1522, 1523, 1277, 17136, 1546, 17137, 1300
7126, 1277, 1523, 1524, 1278, 17137, 1547, 17138, 1301
7127, 1278, 1524, 1525, 1279, 17138, 1548, 17139, 1302
7128, 1279, 1525, 1526, 1280, 17139, 1549, 17140, 1303
7129, 1280, 1526, 1527, 1281, 17140, 1550, 17141, 1304
7130, 1281, 1527, 1528, 1282, 17141, 1551, 17142, 1305
7131, 1282, 1528, 1529, 1283, 17142, 1552, 17143, 1306
7132, 1283, 1529, 1530, 1284, 17143, 1553, 17144, 1307
7133, 1284, 1530, 1531, 1285, 17144, 1554, 17145, 1308
7134, 1285, 1531, 1532, 1286, 17145, 1555, 17146, 1309
7135, 1286, 1532, 1533, 1287, 17146, 1556, 17147, 1310
7136, 1287, 1533, 34, 29, 17147, 1557, 1510, 1311
*ELEMENT, type=CPS8, ELSET=Surface38
7137, 27, 1364, 1560, 35, 1387, 17148, 1583, 1558
7138, 1364, 1365, 1561, 1560, 1388, 17149, 1584, 17148
7139, 1365, 1366, 1562, 1561, 1389, 17150, 1585, 17149
7140, 1366, 1367, 1563, 1562, 1390, 17151, 1586, 17150
7141, 1367, 1368, 1564, 1563, 1391, 17152, 1587, 17151
7142, 1368, 1369, 1565, 1564, 1392, 17153, 1588, 17152
7143, 1369, 1370, 1566, 1565, 1393, 17154, 1589, 17153
7144, 1370, 1371, 1567, 1566, 1394, 17155, 1590, 17154
7145, 1371, 1372, 1568, 1567, 1395, 17156, 1591, 17155
7146, 1372, 1373, 1569, 1568, 1396, 17157, 1592, 17156
7147, 1373, 1374, 1570, 1569, 1397, 17158, 1593, 17157
7148, 1374, 1375, 1571, 1570, 1398, 17159, 1594, 17158
7149, 1375, 1376, 1572, 1571, 1399, 17160, 1595, 17159
7150, 1376, 1377, 1573, 1572, 1400, 17161, 1596, 17160
7151, 1377, 1378, 1574, 1573, 1401, 17162, 1597, 17161
7152, 1378, 1379, 1575, 1574, 1402, 17163, 1598, 17162
7153, 1379, 1380, 1576, 1575, 1403, 17164, 1599, 17163
7154, 1380, 1381, 1577, 1576, 1404, 17165, 1600, 17164
7155, 1381, 1382, 1578, 1577, 1405, 17166, 1601, 17165
7156, 1382, 1383, 1579, 1578, 1406, 17167, 1602, 17166
7157, 1383, 1384, 1580, 1579, 1407, 17168, 1603, 17167
7158, 1384, 1385, 1581, 1580, 1408, 17169, 1604, 17168
7159, 1385, 1386, 1582, 1581, 1409, 17170, 1605, 17169
7160, 1386, 31, 36, 1582, 1410, 1559, 1606, 17170
*ELEMENT, type=CPS8, ELSET=Surface39
7161, 27, 35, 1607, 1219, 1558, 1618, 17171, 1230
7162, 1219, 1607, 1608, 1220, 17171, 1619, 17172, 1231
7163, 1220, 1608, 1609, 1221, 17172, 1620, 17173, 1232
7164, 1221, 1609, 1610, 1222, 17173, 1621, 17174, 1233
7165, 1222, 1610, 1611, 1223, 17174, 1622, 17175, 1234
7166, 1223, 1611, 1612, 1224, 17175, 1623, 17176, 1235
7167, 1224, 1612, 1613, 1225, 17176, 1624, 17177, 1236
7168, 1225, 1613, 1614, 1226, 17177, 1625, 17178, 1237
7169, 1226, 1614, 1615, 1227, 17178, 1626, 17179, 1238
7170, 1227, 1615, 1616, 1228, 17179, 1627, 17180, 1239
7171, 1228, 1616, 1617, 1229, 17180, 1628, 17181, 1240
7172, 1229, 1617, 33, 25, 17181, 1629, 1509, 1241
*ELEMENT, type=CPS8, ELSET=Surface40
7173, 31, 1463, 1630, 36, 1474, 17182, 1641, 1559
7174, 1463, 1464, 1631, 1630, 1475, 17183, 1642, 17182
7175, 1464, 1465, 1632, 1631, 1476, 17184, 1643, 17183
7176, 1465, 1466, 1633, 1632, 1477, 17185, 1644, 17184
7177, 1466, 1467, 1634, 1633, 1478, 17186, 1645, 17185
7178, 1467, 1468, 1635, 1634, 1479, 17187, 1646, 17186
7179, 1468, 1469, 1636, 1635, 1480, 17188, 1647, 17187
7180, 1469, 1470, 1637, 1636, 1481, 17189, 1648, 17188
7181, 1470, 1471, 1638, 1637, 1482, 17190, 1649, 17189
7182, 1471, 1472, 1639, 1638, 1483, 17191, 1650, 17190
7183, 1472, 1473, 1640, 1639, 1484, 17192, 1651, 17191
7184, 1473, 29, 34, 1640, 1485, 1510, 1652, 17192
*ELEMENT, type=CPS8, ELSET=Surface41
7185, 35, 1560, 17193, 1607, 1583, 17446, 17447, 1618
7186, 1560, 1561, 17194, 17193, 1584, 17448, 17449, 17446
7187, 1561, 1562, 17195, 17194, 1585, 17450, 17451, 17448
7188, 1562, 1563, 17196, 17195, 1586, 17452, 17453, 17450
7189, 1563, 1564, 17197, 17196, 1587, 17454, 17455, 17452
7190, 1564, 1565, 17198, 17197, 1588, 17456, 17457, 17454
7191, 1565, 1566, 17199, 17198, 1589, 17458, 17459, 17456
7192, 1566, 1567, 17200, 17199, 1590, 17460, 17461, 17458
7193, 1567, 1568, 17201, 17200, 1591, 17462, 17463, 17460
7194, 1568, 1569, 17202, 17201, 1592, 17464, 17465, 17462
7195, 1569, 1570, 17203, 17202, 1593, 17466, 17467, 17464
7196, 1570, 1571, 17204, 17203, 1594, 17468, 17469, 17466
7197, 1571, 1572, 17205, 17204, 1595, 17470, 17471, 17468
7198, 1572, 1573, 17206, 17205, 1596, 17472, 17473, 17470
7199, 1573, 1574, 17207, 17206, 1597, 17474, 17475, 17472
7200, 1574, 1575, 17208, 17207, 1598, 17476, 17477, 17474
7201, 1575, 1576, 17209, 17208, 1599, 17478, 17479, 17476
7202, 1576, 1577, 17210, 17209, 1600, 17480, 17481, 17478
7203, 1577, 1578, 17211, 17210, 1601, 17482, 17483, 17480
7204, 1578, 1579, 17212, 17211, 1602, 17484, 17485, 17482
7205, 1579, 1580, 17213, 17212, 1603, 17486, 17487, 17484
7206, 1580, 1581, 17214, 17213, 1604, 17488, 17489, 17486
7207, 1581, 1582, 17215, 17214, 1605, 17490, 17491, 17488
7208, 1582, 36, 1630, 17215, 1606, 1641, 17492, 17490
7209, 1607, 17193, 17216, 1608, 17447, 17493, 17494, 1619
7210, 17193, 17194, 17217, 17216, 17449, 17495, 17496, 17493
7211, 17194, 17195, 17218, 17217, 17451, 17497, 17498, 17495
7212, 17195, 17196, 17219, 17218, 17453, 17499, 17500, 17497
7213, 17196, 17197, 17220, 17219, 17455, 17501, 17502, 17499
7214, 17197, 17198, 17221, 17220, 17457, 17503, 17504, 17501
7215, 17198, 17199, 17222, 17221, 17459, 17505, 17506, 17503
7216, 17199, 17200, 17223, 17222, 17461, 17507, 17508, 17505
7217, 17200, 17201, 17224, 17223, 17463, 17509, 17510, 17507
7218, 17201, 17202, 17225, 17224, 17465, 17511, 17512, 17509
7219, 17202, 17203, 17226, 17225, 17467, 17513, 17514, 17511
7220, 17203, 17204, 17227, 17226, 17469, 17515, 17516, 17513
7221, 17204, 17205, 17228, 17227, 17471, 17517, 17518, 17515
7222, 17205, 17206, 17229, 17228, 17473, 17519, 17520, 17517
7223, 17206, 17207, 17230, 17229, 17475, 17521, 17522, 17519
7224, 17207, 17208, 17231, 17230, 17477, 17523, 17524, 17521
7225, 17208, 17209, 17232, 17231, 17479, 17525, 17526, 17523
7226, 17209, 17210, 17233, 17232, 17481, 17527, 17528, 17525
7227, 17210, 17211, 17234, 17233, 17483, 17529, 17530, 17527
7228, 17211, 17212, 17235, 17234, 17485, 17531, 17532, 17529
7229, 17212, 17213, 17236, 17235, 17487, 17533, 17534, 17531
7230, 17213, 17214, 17237, 17236, 17489, 17535, 17536, 17533
7231, 17214, 17215, 17238, 17237, 17491, 17537, 17538, 17535
7232, 17215, 1630, 1631, 17238, 17492, 1642, 17539, 17537
7233, 1608, 17216, 17239, 1609, 17494, 17540, 17541, 1620
7234, 17216, 17217, 17240, 17239, 17496, 17542, 17543, 17540
7235, 17217, 17218, 17241, 17240, 17498, 17544, 17545, 17542
7236, 17218, 17219, 17242, 17241, 17500, 17546, 17547, 17544
7237, 17219, 17220, 17243, 17242, 17502, 17548, 17549, 17546
7238, 17220, 17221, 17244, 17243, 17504, 17550, 17551, 17548
7239, 17221, 17222, 17245, 17244, 17506, 17552, 17553, 17550
7240, 17222, 17223, 17246, 17245, 17508, 17554, 17555, 17552
7241, 17223, 17224, 17247, 17246, 17510, 17556, 17557, 17554
7242, 17224, 17225, 17248, 17247, 17512, 17558, 17559, 17556
7243, 17225, 17226, 17249, 17248, 17514, 17560, 17561, 17558
7244, 17226, 17227, 17250, 17249, 17516, 17562, 17563, 17560
7245, 17227, 17228, 17251, 17250, 17518, 17564, 17565, 17562
7246, 17228, 17229, 17252, 17251, 17520, 17566, 17567, 17564
7247, 17229, 17230, 17253, 17252, 17522, 17568, 17569, 17566
7248, 17230, 17231, 17254, 17253, 17524, 17570, 17571, 17568
7249, 17231, 17232, 17255, 17254, 17526, 17572, 17573, 17570
7250, 17232, 17233, 17256, 17255, 17528, 17574, 17575, 17572
7251, 17233, 17234, 17257, 17256, 17530, 17576, 17577, 17574
7252, 17234, 17235, 17258, 17257, 17532, 17578, 17579, 17576
7253, 17235, 17236, 17259, 17258, 17534, 17580, 17581, 17578
7254, 17236, 17237, 17260, 17259, 17536, 17582, 17583, 17580
7255, 17237, 17238, 17261, 17260, 17538, 17584, 17585, 17582
7256, 17238, 1631, 1632, 17261, 17539, 1643, 17586, 17584
7257, 1609, 17239, 17262, 1610, 17541, 17587, 17588, 1621
7258, 17239, 17240, 17263, 17262, 17543, 17589, 17590, 17587
7259, 17240, 17241, 17264, 17263, 17545, 17591, 17592, 17589
7260, 17241, 17242, 17265, 17264, 17547, 17593, 17594, 17591
7261, 17242, 17243, 17266, 17265, 17549, 17595, 17596, 17593
7262, 17243, 17244, 17267, 17266, 17551, 17597, 17598, 17595
7263, 17244, 17245, 17268, 17267, 17553, 17599, 17600, 17597
7264, 17245, 17246, 17269, 17268, 17555, 17601, 17602, 17599
7265, 17246, 17247, 17270, 17269, 17557, 17603, 17604, 17601
7266, 17247, 17248, 17271, 17270, 17559, 17605, 17606, 17603
7267, 17248, 17249, 17272, 17271, 17561, 17607, 17608, 17605
7268, 17249, 17250, 17273, 17272, 17563, 17609, 17610, 17607
7269, 17250, 17251, 17274, 17273, 17565, 17611, 17612, 17609
7270, 17251, 17252, 17275, 17274, 17567, 17613, 17614, 17611
7271, 17252, 17253, 17276, 17275, 17569, 17615, 17616, 17613
7272, 17253, 17254, 17277, 17276, 17571, 17617, 17618, 17615
7273, 17254, 17255, 17278, 17277, 17573, 17619, 17620, 17617
7274, 17255, 17256, 17279, 17278, 17575, 17621, 17622, 17619
7275, 17256, 17257, 17280, 17279, 17577, 17623, 17624, 17621
7276, 17257, 17258, 17281, 17280, 17579, 17625, 17626, 17623
7277, 17258, 17259, 17282, 17281, 17581, 17627, 17628, 17625
7278, 17259, 17260, 17283, 17282, 17583, 17629, 17630, 17627
7279, 17260, 17261, 17284, 17283, 17585, 17631, 17632, 17629
7280, 17261, 1632, 1633, 17284, 17586, 1644, 17633, 17631
7281, 1610, 17262, 17285, 1611, 17588, 17634, 17635, 1622
7282, 17262, 17263, 17286, 17285, 17590, 17636, 17637, 17634
7283, 17263, 17264, 17287, 17286, 17592, 17638, 17639, 17636
7284, 17264, 17265, 17288, 17287, 17594, 17640, 17641, 17638
7285, 17265, 17266, 17289, 17288, 17596, 17642, 17643, 17640
7286, 17266, 17267, 17290, 17289, 17598, 17644, 17645, 17642
7287, 17267, 17268, 17291, 17290, 17600, 17646, 17647, 17644
7288, 17268, 17269, 17292, 17291, 17602, 17648, 17649, 17646
7289, 17269, 17270, 17293, 17292, 17604, 17650, 17651, 17648
7290, 17270, 17271, 17294, 17293, 17606, 17652, 17653, 17650
7291, 17271, 17272, 17295, 17294, 17608, 17654, 17655, 17652
7292, 17272, 17273, 17296, 17295, 17610, 17656, 17657, 17654
7293, 17273, 17274, 17297, 17296, 17612, 17658, 17659, 17656
7294, 17274, 17275, 17298, 17297, 17614, 17660, 17661, 17658
7295, 17275, 17276, 17299, 17298, 17616, 17662, 17663, 17660
7296, 17276, 17277, 17300, 17299, 17618, 17664, 17665, 17662
7297, 17277, 17278, 17301, 17300, 17620, 17666, 17667, 17664
7298, 17278, 17279, 17302, 17301, 17622, 17668, 17669, 17666
7299, 17279, 17280, 17303, 17302, 17624, 17670, 17671, 17668
7300, 17280, 17281, 17304, 17303, 17626, 17672, 17673, 17670
7301, 17281, 17282, 17305, 17304, 17628, 17674, 17675, 17672
7302, 17282, 17283, 17306, 17305, 17630, 17676, 17677, 17674
7303, 17283, 17284, 17307, 17306, 17632, 17678, 17679, 17676
7304, 17284, 1633, 1634, 17307, 17633, 1645, 17680, 17678
7305, 1611, 17285, 17308, 1612, 17635, 17681, 17682, 1623
7306, 17285, 17286, 17309, 17308, 17637, 17683, 17684, 17681
7307, 17286, 17287, 17310, 17309, 17639, 17685, 17686, 17683
7308, 17287, 17288, 17311, 17310, 17641, 17687, 17688, 17685
7309, 17288, 17289, 17312, 17311, 17643, 17689, 17690, 17687
7310, 17289, 17290, 17313, 17312, 17645, 17691, 17692, 17689
7311, 17290, 17291, 17314, 17313, 17647, 17693, 17694, 17691
7312, 17291, 17292, 17315, 17314, 17649, 17695, 17696, 17693
7313, 17292, 17293, 17316, 17315, 17651, 17697, 17698, 17695
7314, 17293, 17294, 17317, 17316, 17653, 17699, 17700, 17697
7315, 17294, 17295, 17318, 17317, 17655, 17701, 17702, 17699
7316, 17295, 17296, 17319, 17318, 17657, 17703, 17704, 17701
7317, 17296, 17297, 17320, 17319, 17659, 17705, 17706, 17703
7318, 17297, 17298, 17321, 17320, 17661, 17707, 17708, 17705
7319, 17298, 17299, 17322, 17321, 17663, 17709, 17710, 17707
7320, 17299, 17300, 17323, 17322, 17665, 17711, 17712, 17709
7321, 17300, 17301, 17324, 17323, 17667, 17713, 17714, 17711
7322, 17301, 17302, 17325, 17324, 17669, 17715, 17716, 17713
7323, 17302, 17303, 17326, 17325, 17671, 17717, 17718, 17715
7324, 17303, 17304, 17327, 17326, 17673, 17719, 17720, 17717
7325, 17304, 17305, 17328, 17327, 17675, 17721, 17722, 17719
7326, 17305, 17306, 17329, 17328, 17677, 17723, 17724, 17721
7327, 17306, 17307, 17330, 17329, 17679, 17725, 17726, 17723
7328, 17307, 1634, 1635, 17330, 17680, 1646, 17727, 17725
7329, 1612, 17308, 17331, 1613, 17682, 17728, 17729, 1624
7330, 17308, 17309, 17332, 17331, 17684, 17730, 17731, 17728
7331, 17309, 17310, 17333, 17332, 17686, 17732, 17733, 17730
7332, 17310, 17311, 17334, 17333, 17688, 17734, 17735, 17732
7333, 17311, 17312, 17335, 17334, 17690, 17736, 17737, 17734
7334, 17312, 17313, 17336, 17335, 17692, 17738, 17739, 17736
7335, 17313, 17314, 17337, 17336, 17694, 17740, 17741, 17738
7336, 17314, 17315, 17338, 17337, 17696, 17742, 17743, 17740
7337, 17315, 17316, 17339, 17338, 17698, 17744, 17745, 17742
7338, 17316, 17317, 17340, 17339, 17700, 17746, 17747, 17744
7339, 17317, 17318, 17341, 17340, 17702, 17748, 17749, 17746
7340, 17318, 17319, 17342, 17341, 17704, 17750, 17751, 17748
7341, 17319, 17320, 17343, 17342, 17706, 17752, 17753, 17750
7342, 17320, 17321, 17344, 17343, 17708, 17754, 17755, 17752
7343, 17321, 17322, 17345, 17344, 17710, 17756, 17757, 17754
7344, 17322, 17323, 17346, 17345, 17712, 17758, 17759, 17756
7345, 17323, 17324, 17347, 17346, 17714, 17760, 17761, 17758
7346, 17324, 17325, 17348, 17347, 17716, 17762, 17763, 17760
7347, 17325, 17326, 17349, 17348, 17718, 17764, 17765, 17762
7348, 17326, 17327, 17350, 17349, 17720, 17766, 17767, 17764
7349, 17327, 17328, 17351, 17350, 17722, 17768, 17769, 17766
7350, 17328, 17329, 17352, 17351, 17724, 17770, 17771, 17768
7351, 17329, 17330, 17353, 17352, 17726, 17772, 17773, 17770
7352, 17330, 1635, 1636, 17353, 17727, 1647, 17774, 17772
7353, 1613, 17331, 17354, 1614, 17729, 17775, 17776, 1625
7354, 17331, 17332, 17355, 17354, 17731, 17777, 17778, 17775
7355, 17332, 17333, 17356, 17355, 17733, 17779, 17780, 17777
7356, 17333, 17334, 17357, 17356, 17735, 17781, 17782, 17779
7357, 17334, 17335, 17358, 17357, 17737, 17783, 17784, 17781
7358, 17335, 17336, 17359, 17358, 17739, 17785, 17786, 17783
7359, 17336, 17337, 17360, 17359, 17741, 17787, 17788, 17785
7360, 17337, 17338, 17361, 17360, 17743, 17789, 17790, 17787
7361, 17338, 17339, 17362, 17361, 17745, 17791, 17792, 17789
7362, 17339, 17340, 17363, 17362, 17747, 17793, 17794, 17791
7363, 17340, 17341, 17364, 17363, 17749, 17795, 17796, 17793
7364, 17341, 17342, 17365, 17364, 17751, 17797, 17798, 17795
7365, 17342, 17343, 17366, 17365, 17753, 17799, 17800, 17797
7366, 17343, 17344, 17367, 17366, 17755, 17801, 17802, 17799
7367, 17344, 17345, 17368, 17367, 17757, 17803, 17804, 17801
7368, 17345, 17346, 17369, 17368, 17759, 17805, 17806, 17803
7369, 17346, 17347, 17370, 17369, 17761, 17807, 17808, 17805
7370, 17347, 17348, 17371, 17370, 17763, 17809, 17810, 17807
7371, 17348, 17349, 17372, 17371, 17765, 17811, 17812, 17809
7372, 17349, 17350, 17373, 17372, 17767, 17813, 17814, 17811
7373, 17350, 17351, 17374, 17373, 17769, 17815, 17816, 17813
7374, 17351, 17352, 17375, 17374, 17771, 17817, 17818, 17815
7375, 17352, 17353, 17376, 17375, 17773, 17819, 17820, 17817
7376, 17353, 1636, 1637, 17376, 17774, 1648, 17821, 17819
7377, 1614, 17354, 17377, 1615, 17776, 17822, 17823, 1626
7378, 17354, 17355, 17378, 17377, 17778, 17824, 17825, 17822
7379, 17355, 17356, 17379, 17378, 17780, 17826, 17827, 17824
7380, 17356, 17357, 17380, 17379, 17782, 17828, 17829, 17826
7381, 17357, 17358, 17381, 17380, 17784, 17830, 17831, 17828
7382, 17358, 17359, 17382, 17381, 17786, 17832, 17833, 17830
7383, 17359, 17360, 17383, 17382, 17788, 17834, 17835, 17832
7384, 17360, 17361, 17384, 17383, 17790, 17836, 17837, 17834
7385, 17361, 17362, 17385, 17384, 17792, 17838, 17839, 17836
7386, 17362, 17363, 17386, 17385, 17794, 17840, 17841, 17838
7387, 17363, 17364, 17387, 17386, 17796, 17842, 17843, 17840
7388, 17364, 17365, 17388, 17387, 17798, 17844, 17845, 17842
7389, 17365, 17366, 17389, 17388, 17800, 17846, 17847, 17844
7390, 17366, 17367, 17390, 17389, 17802, 17848, 17849, 17846
7391, 17367, 17368, 17391, 17390, 17804, 17850, 17851, 17848
7392, 17368, 17369, 17392, 17391, 17806, 17852, 17853, 17850
7393, 17369, 17370, 17393, 17392, 17808, 17854, 17855, 17852
7394, 17370, 17371, 17394, 17393, 17810, 17856, 17857, 17854
7395, 17371, 17372, 17395, 17394, 17812, 17858, 17859, 17856
7396, 17372, 17373, 17396, 17395, 17814, 17860, 17861, 17858
7397, 17373, 17374, 17397, 17396, 17816, 17862, 17863, 17860
7398, 17374, 17375, 17398, 17397, 17818, 17864, 17865, 17862
7399, 17375, 17376, 17399, 17398, 17820, 17866, 17867, 17864
7400, 17376, 1637, 1638, 17399, 17821, 1649, 17868, 17866
7401, 1615, 17377, 17400, 1616, 17823, 17869, 17870, 1627
7402, 17377, 17378, 17401, 17400, 17825, 17871, 17872, 17869
7403, 17378, 17379, 17402, 17401, 17827, 17873, 17874, 17871
7404, 17379, 17380, 17403, 17402, 17829, 17875, 17876, 17873
7405, 17380, 17381, 17404, 17403, 17831, 17877, 17878, 17875
7406, 17381, 17382, 17405, 17404, 17833, 17879, 17880, 17877
7407, 17382, 17383, 17406, 17405, 17835, 17881, 17882, 17879
7408, 17383, 17384, 17407, 17406, 17837, 17883, 17884, 17881
7409, 17384, 17385, 17408, 17407, 17839, 17885, 17886, 17883
7410, 17385, 17386, 17409, 17408, 17841, 17887, 17888, 17885
7411, 17386, 17387, 17410, 17409, 17843, 17889, 17890, 17887
7412, 17387, 17388, 17411, 17410, 17845, 17891, 17892, 17889
7413, 17388, 17389, 17412, 17411, 17847, 17893, 17894, 17891
7414, 17389, 17390, 17413, 17412, 17849, 17895, 17896, 17893
7415, 17390, 17391, 17414, 17413, 17851, 17897, 17898, 17895
7416, 17391, 17392, 17415, 17414, 17853, 17899, 17900, 17897
7417, 17392, 17393, 17416, 17415, 17855, 17901, 17902, 17899
7418, 17393, 17394, 17417, 17416, 17857, 17903, 17904, 17901
7419, 17394, 17395, 17418, 17417, 17859, 17905, 17906, 17903
7420, 17395, 17396, 17419, 17418, 17861, 17907, 17908, 17905
7421, 17396, 17397, 17420, 17419, 17863, 17909, 17910, 17907
7422, 17397, 17398, 17421, 17420, 17865, 17911, 17912, 17909
7423, 17398, 17399, 17422, 17421, 17867, 17913, 17914, 17911
7424, 17399, 1638, 1639, 17422, 17868, 1650, 17915, 17913
7425, 1616, 17400, 17423, 1617, 17870, 17916, 17917, 1628
7426, 17400, 17401, 17424, 17423, 17872, 17918, 17919, 17916
7427, 17401, 17402, 17425, 17424, 17874, 17920, 17921, 17918
7428, 17402, 17403, 17426, 17425, 17876, 17922, 17923, 17920
7429, 17403, 17404, 17427, 17426, 17878, 17924, 17925, 17922
7430, 17404, 17405, 17428, 17427, 17880, 17926, 17927, 17924
7431, 17405, 17406, 17429, 17428, 17882, 17928, 17929, 17926
7432, 17406, 17407, 17430, 17429, 17884, 17930, 17931, 17928
7433, 17407, 17408, 17431, 17430, 17886, 17932, 17933, 17930
7434, 17408, 17409, 17432, 17431, 17888, 17934, 17935, 17932
7435, 17409, 17410, 17433, 17432, 17890, 17936, 17937, 17934
7436, 17410, 17411, 17434, 17433, 17892, 17938, 17939, 17936
7437, 17411, 17412, 17435, 17434, 17894, 17940, 17941, 17938
7438, 17412, 17413, 17436, 17435, 17896, 17942, 17943, 17940
7439, 17413, 17414, 17437, 17436, 17898, 17944, 17945, 17942
7440, 17414, 17415, 17438, 17437, 17900, 17946, 17947, 17944
7441, 17415, 17416, 17439, 17438, 17902, 17948, 17949, 17946
7442, 17416, 17417, 17440, 17439, 17904, 17950, 17951, 17948
7443, 17417, 17418, 17441, 17440, 17906, 17952, 17953, 17950
7444, 17418, 17419, 17442, 17441, 17908, 17954, 17955, 17952
7445, 17419, 17420, 17443, 17442, 17910, 17956, 17957, 17954
7446, 17420, 17421, 17444, 17443, 17912, 17958, 17959, 17956
7447, 17421, 17422, 17445, 17444, 17914, 17960, 17961, 17958
7448, 17422, 1639, 1640, 17445, 17915, 1651, 17962, 17960
7449, 1617, 17423, 1511, 33, 17917, 17963, 1534, 1629
7450, 17423, 17424, 1512, 1511, 17919, 17964, 1535, 17963
7451, 17424, 17425, 1513, 1512, 17921, 17965, 1536, 17964
7452, 17425, 17426, 1514, 1513, 17923, 17966, 1537, 17965
7453, 17426, 17427, 1515, 1514, 17925, 17967, 1538, 17966
7454, 17427, 17428, 1516, 1515, 17927, 17968, 1539, 17967
7455, 17428, 17429, 1517, 1516, 17929, 17969, 1540, 17968
7456, 17429, 17430, 1518, 1517, 17931, 17970, 1541, 17969
7457, 17430, 17431, 1519, 1518, 17933, 17971, 1542, 17970
7458, 17431, 17432, 1520, 1519, 17935, 17972, 1543, 17971
7459, 17432, 17433, 1521, 1520, 17937, 17973, 1544, 17972
7460, 17433, 17434, 1522, 1521, 17939, 17974, 1545, 17973
7461, 17434, 17435, 1523, 1522, 17941, 17975, 1546, 17974
7462, 17435, 17436, 1524, 1523, 17943, 17976, 1547, 17975
7463, 17436, 17437, 1525, 1524, 17945, 17977, 1548, 17976
7464, 17437, 17438, 1526, 1525, 17947, 17978, 1549, 17977
7465, 17438, 17439, 1527, 1526, 17949, 17979, 1550, 17978
7466, 17439, 17440, 1528, 1527, 17951, 17980, 1551, 17979
7467, 17440, 17441, 1529, 1528, 17953, 17981, 1552, 17980
7468, 17441, 17442, 1530, 1529, 17955, 17982, 1553, 17981
7469, 17442, 17443, 1531, 1530, 17957, 17983, 1554, 17982
7470, 17443, 17444, 1532, 1531, 17959, 17984, 1555, 17983
7471, 17444, 17445, 1533, 1532, 17961, 17985, 1556, 17984
7472, 17445, 1640, 34, 1533, 17962, 1652, 1557, 17985
*ELEMENT, type=CPS8, ELSET=Surface42
7473, 33, 1653, 17986, 1511, 1676, 18515, 18516, 1534
7474, 1653, 1654, 17987, 17986, 1677, 18517, 18518, 18515
7475, 1654, 1655, 17988, 17987, 1678, 18519, 18520, 18517
7476, 1655, 1656, 17989, 17988, 1679, 18521, 18522, 18519
7477, 1656, 1657, 17990, 17989, 1680, 18523, 18524, 18521
7478, 1657, 1658, 17991, 17990, 1681, 18525, 18526, 18523
7479, 1658, 1659, 17992, 17991, 1682, 18527, 18528, 18525
7480, 1659, 1660, 17993, 17992, 1683, 18529, 18530, 18527
7481, 1660, 1661, 17994, 17993, 1684, 18531, 18532, 18529
7482, 1661, 1662, 17995, 17994, 1685, 18533, 18534, 18531
7483, 1662, 1663, 17996, 17995, 1686, 18535, 18536, 18533
7484, 1663, 1664, 17997, 17996, 1687, 18537, 18538, 18535
7485, 1664, 1665, 17998, 17997, 1688, 18539, 18540, 18537
7486, 1665, 1666, 17999, 17998, 1689, 18541, 18542, 18539
7487, 1666, 1667, 18000, 17999, 1690, 18543, 18544, 18541
7488, 1667, 1668, 18001, 18000, 1691, 18545, 18546, 18543
7489, 1668, 1669, 18002, 18001, 1692, 18547, 18548, 18545
7490, 1669, 1670, 18003, 18002, 1693, 18549, 18550, 18547
7491, 1670, 1671, 18004, 18003, 1694, 18551, 18552, 18549
7492, 1671, 1672, 18005, 18004, 1695, 18553, 18554, 18551
7493, 1672, 1673, 18006, 18005, 1696, 18555, 18556, 18553
7494, 1673, 1674, 18007, 18006, 1697, 18557, 18558, 18555
7495, 1674, 1675, 18008, 18007, 1698, 18559, 18560, 18557
7496, 1675, 37, 1747, 18008, 1699, 1770, 18561, 18559
7497, 1511, 17986, 18009, 1512, 18516, 18562, 18563, 1535
7498, 17986, 17987, 18010, 18009, 18518, 18564, 18565, 18562
7499, 17987, 17988, 18011, 18010, 18520, 18566, 18567, 18564
7500, 17988, 17989, 18012, 18011, 18522, 18568, 18569, 18566
7501, 17989, 17990, 18013, 18012, 18524, 18570, 18571, 18568
7502, 17990, 17991, 18014, 18013, 18526, 18572, 18573, 18570
7503, 17991, 17992, 18015, 18014, 18528, 18574, 18575, 18572
7504, 17992, 17993, 18016, 18015, 18530, 18576, 18577, 18574
7505, 17993, 17994, 18017, 18016, 18532, 18578, 18579, 18576
7506, 17994, 17995, 18018, 18017, 18534, 18580, 18581, 18578
7507, 17995, 17996, 18019, 18018, 18536, 18582, 18583, 18580
7508, 17996, 17997, 18020, 18019, 18538, 18584, 18585, 18582
7509, 17997, 17998, 18021, 18020, 18540, 18586, 18587, 18584
7510, 17998, 17999, 18022, 18021, 18542, 18588, 18589, 18586
7511, 17999, 18000, 18023, 18022, 18544, 18590, 18591, 18588
7512, 18000, 18001, 18024, 18023, 18546, 18592, 18593, 18590
7513, 18001, 18002, 18025, 18024, 18548, 18594, 18595, 18592
7514, 18002, 18003, 18026, 18025, 18550, 18596, 18597, 18594
7515, 18003, 18004, 18027, 18026, 18552, 18598, 18599, 18596
7516, 18004, 18005, 18028, 18027, 18554, 18600, 18601, 18598
7517, 18005, 18006, 18029, 18028, 18556, 18602, 18603, 18600
7518, 18006, 18007, 18030, 18029, 18558, 18604, 18605, 18602
7519, 18007, 18008, 18031, 18030, 18560, 18606, 18607, 18604
7520, 18008, 1747, 1748, 18031, 18561, 1771, 18608, 18606
7521, 1512, 18009, 18032, 1513, 18563, 18609, 18610, 1536
7522, 18009, 18010, 18033, 18032, 18565, 18611, 18612, 18609
7523, 18010, 18011, 18034, 18033, 18567, 18613, 18614, 18611
7524, 18011, 18012, 18035, 18034, 18569, 18615, 18616, 18613
7525, 18012, 18013, 18036, 18035, 18571, 18617, 18618, 18615
7526, 18013, 18014, 18037, 18036, 18573, 18619, 18620, 18617
7527, 18014, 18015, 18038, 18037, 18575, 18621, 18622, 18619
7528, 18015, 18016, 18039, 18038, 18577, 18623, 18624, 18621
7529, 18016, 18017, 18040, 18039, 18579, 18625, 18626, 18623
7530, 18017, 18018, 18041, 18040, 18581, 18627, 18628, 18625
7531, 18018, 18019, 18042, 18041, 18583, 18629, 18630, 18627
7532, 18019, 18020, 18043, 18042, 18585, 18631, 18632, 18629
7533, 18020, 18021, 18044, 18043, 18587, 18633, 18634, 18631
7534, 18021, 18022, 18045, 18044, 18589, 18635, 18636, 18633
7535, 18022, 18023, 18046, 18045, 18591, 18637, 18638, 18635
7536, 18023, 18024, 18047, 18046, 18593, 18639, 18640, 18637
7537, 18024, 18025, 18048, 18047, 18595, 18641, 18642, 18639
7538, 18025, 18026, 18049, 18048, 18597, 18643, 18644, 18641
7539, 18026, 18027, 18050, 18049, 18599, 18645, 18646, 18643
7540, 18027, 18028, 18051, 18050, 18601, 18647, 18648, 18645
7541, 18028, 18029, 18052, 18051, 18603, 18649, 18650, 18647
7542, 18029, 18030, 18053, 18052, 18605, 18651, 18652, 18649
7543, 18030, 18031, 18054, 18053, 18607, 18653, 18654, 18651
7544, 18031, 1748, 1749, 18054, 18608, 1772, 18655, 18653
7545, 1513, 18032, 18055, 1514, 18610, 18656, 18657, 1537
7546, 18032, 18033, 18056, 18055, 18612, 18658, 18659, 18656
7547, 18033, 18034, 18057, 18056, 18614, 18660, 18661, 18658
7548, 18034, 18035, 18058, 18057, 18616, 18662, 18663, 18660
7549, 18035, 18036, 18059, 18058, 18618, 18664, 18665, 18662
7550, 18036, 18037, 18060, 18059, 18620, 18666, 18667, 18664
7551, 18037, 18038, 18061, 18060, 18622, 18668, 18669, 18666
7552, 18038, 18039, 18062, 18061, 18624, 18670, 18671, 18668
7553, 18039, 18040, 18063, 18062, 18626, 18672, 18673, 18670
7554, 18040, 18041, 18064, 18063, 18628, 18674, 18675, 18672
7555, 18041, 18042, 18065, 18064, 18630, 18676, 18677, 18674
7556, 18042, 18043, 18066, 18065, 18632, 18678, 18679, 18676
7557, 18043, 18044, 18067, 18066, 18634, 18680, 18681, 18678
7558, 18044, 18045, 18068, 18067, 18636, 18682, 18683, 18680
7559, 18045, 18046, 18069, 18068, 18638, 18684, 18685, 18682
7560, 18046, 18047, 18070, 18069, 18640, 18686, 18687, 18684
7561, 18047, 18048, 18071, 18070, 18642, 18688, 18689, 18686
7562, 18048, 18049, 18072, 18071, 18644, 18690, 18691, 18688
7563, 18049, 18050, 18073, 18072, 18646, 18692, 18693, 18690
7564, 18050, 18051, 18074, 18073, 18648, 18694, 18695, 18692
7565, 18051, 18052, 18075, 18074, 18650, 18696, 18697, 18694
7566, 18052, 18053, 18076, 18075, 18652, 18698, 18699, 18696
7567, 18053, 18054, 18077, 18076, 18654, 18700, 18701, 18698
7568, 18054, 1749, 1750, 18077, 18655, 1773, 18702, 18700
7569, 1514, 18055, 18078, 1515, 18657, 18703, 18704, 1538
7570, 18055, 18056, 18079, 18078, 18659, 18705, 18706, 18703
7571, 18056, 18057, 18080, 18079, 18661, 18707, 18708, 18705
7572, 18057, 18058, 18081, 18080, 18663, 18709, 18710, 18707
7573, 18058, 18059, 18082, 18081, 18665, 18711, 18712, 18709
7574, 18059, 18060, 18083, 18082, 18667, 18713, 18714, 18711
7575, 18060, 18061, 18084, 18083, 18669, 18715, 18716, 18713
7576, 18061, 18062, 18085, 18084, 18671, 18717, 18718, 18715
7577, 18062, 18063, 18086, 18085, 18673, 18719, 18720, 18717
7578, 18063, 18064, 18087, 18086, 18675, 18721, 18722, 18719
7579, 18064, 18065, 18088, 18087, 18677, 18723, 18724, 18721
7580, 18065, 18066, 18089, 18088, 18679, 18725, 18726, 18723
7581, 18066, 18067, 18090, 18089, 18681, 18727, 18728, 18725
7582, 18067, 18068, 18091, 18090, 18683, 18729, 18730, 18727
7583, 18068, 18069, 18092, 18091, 18685, 18731, 18732, 18729
7584, 18069, 18070, 18093, 18092, 18687, 18733, 18734, 18731
7585, 18070, 18071, 18094, 18093, 18689, 18735, 18736, 18733
7586, 18071, 18072, 18095, 18094, 18691, 18737, 18738, 18735
7587, 18072, 18073, 18096, 18095, 18693, 18739, 18740, 18737
7588, 18073, 18074, 18097, 18096, 18695, 18741, 18742, 18739
7589, 18074, 18075, 18098, 18097, 18697, 18743, 18744, 18741
7590, 18075, 18076, 18099, 18098, 18699, 18745, 18746, 18743
7591, 18076, 18077, 18100, 18099, 18701, 18747, 18748, 18745
7592, 18077, 1750, 1751, 18100, 18702, 1774, 18749, 18747
7593, 1515, 18078, 18101, 1516, 18704, 18750, 18751, 1539
7594, 18078, 18079, 18102, 18101, 18706, 18752, 18753, 18750
7595, 18079, 18080, 18103, 18102, 18708, 18754, 18755, 18752
7596, 18080, 18081, 18104, 18103, 18710, 18756, 18757, 18754
7597, 18081, 18082, 18105, 18104, 18712, 18758, 18759, 18756
7598, 18082, 18083, 18106, 18105, 18714, 18760, 18761, 18758
7599, 18083, 18084, 18107, 18106, 18716, 18762, 18763, 18760
7600, 18084, 18085, 18108, 18107, 18718, 18764, 18765, 18762
7601, 18085, 18086, 18109, 18108, 18720, 18766, 18767, 18764
7602, 18086, 18087, 18110, 18109, 18722, 18768, 18769, 18766
7603, 18087, 18088, 18111, 18110, 18724, 18770, 18771, 18768
7604, 18088, 18089, 18112, 18111, 18726, 18772, 18773, 18770
7605, 18089, 18090, 18113, 18112, 18728, 18774, 18775, 18772
7606, 18090, 18091, 18114, 18113, 18730, 18776, 18777, 18774
7607, 18091, 18092, 18115, 18114, 18732, 18778, 18779, 18776
7608, 18092, 18093, 18116, 18115, 18734, 18780, 18781, 18778
7609, 18093, 18094, 18117, 18116, 18736, 18782, 18783, 18780
7610, 18094, 18095, 18118, 18117, 18738, 18784, 18785, 18782
7611, 18095, 18096, 18119, 18118, 18740, 18786, 18787, 18784
7612, 18096, 18097, 18120, 18119, 18742, 18788, 18789, 18786
7613, 18097, 18098, 18121, 18120, 18744, 18790, 18791, 18788
7614, 18098, 18099, 18122, 18121, 18746, 18792, 18793, 18790
7615, 18099, 18100, 18123, 18122, 18748, 18794, 18795, 18792
7616, 18100, 1751, 1752, 18123, 18749, 1775, 18796, 18794
7617, 1516, 18101, 18124, 1517, 18751, 18797, 18798, 1540
7618, 18101, 18102, 18125, 18124, 18753, 18799, 18800, 18797
7619, 18102, 18103, 18126, 18125, 18755, 18801, 18802, 18799
7620, 18103, 18104, 18127, 18126, 18757, 18803, 18804, 18801
7621, 18104, 18105, 18128, 18127, 18759, 18805, 18806, 18803
7622, 18105, 18106, 18129, 18128, 18761, 18807, 18808, 18805
7623, 18106, 18107, 18130, 18129, 18763, 18809, 18810, 18807
7624, 18107, 18108, 18131, 18130, 18765, 18811, 18812, 18809
7625, 18108, 18109, 18132, 18131, 18767, 18813, 18814, 18811
7626, 18109, 18110, 18133, 18132, 18769, 18815, 18816, 18813
7627, 18110, 18111, 18134, 18133, 18771, 18817, 18818, 18815
7628, 18111, 18112, 18135, 18134, 18773, 18819, 18820, 18817
7629, 18112, 18113, 18136, 18135, 18775, 18821, 18822, 18819
7630, 18113, 18114, 18137, 18136, 18777, 18823, 18824, 18821
7631, 18114, 18115, 18138, 18137, 18779, 18825, 18826, 18823
7632, 18115, 18116, 18139, 18138, 18781, 18827, 18828, 18825
7633, 18116, 18117, 18140, 18139, 18783, 18829, 18830, 18827
7634, 18117, 18118, 18141, 18140, 18785, 18831, 18832, 18829
7635, 18118, 18119, 18142, 18141, 18787, 18833, 18834, 18831
7636, 18119, 18120, 18143, 18142, 18789, 18835, 18836, 18833
7637, 18120, 18121, 18144, 18143, 18791, 18837, 18838, 18835
7638, 18121, 18122, 18145, 18144, 18793, 18839, 18840, 18837
7639, 18122, 18123, 18146, 18145, 18795, 18841, 18842, 18839
7640, 18123, 1752, 1753, 18146, 18796, 1776, 18843, 18841
7641, 1517, 18124, 18147, 1518, 18798, 18844, 18845, 1541
7642, 18124, 18125, 18148, 18147, 18800, 18846, 18847, 18844
7643, 18125, 18126, 18149, 18148, 18802, 18848, 18849, 18846
7644, 18126, 18127, 18150, 18149, 18804, 18850, 18851, 18848
7645, 18127, 18128, 18151, 18150, 18806, 18852, 18853, 18850
7646, 18128, 18129, 18152, 18151, 18808, 18854, 18855, 18852
7647, 18129, 18130, 18153, 18152, 18810, 18856, 18857, 18854
7648, 18130, 18131, 18154, 18153, 18812, 18858, 18859, 18856
7649, 18131, 18132, 18155, 18154, 18814, 18860, 18861, 18858
7650, 18132, 18133, 18156, 18155, 18816, 18862, 18863, 18860
7651, 18133, 18134, 18157, 18156, 18818, 18864, 18865, 18862
7652, 18134, 18135, 18158, 18157, 18820, 18866, 18867, 18864
7653, 18135, 18136, 18159, 18158, 18822, 18868, 18869, 18866
7654, 18136, 18137, 18160, 18159, 18824, 18870, 18871, 18868
7655, 18137, 18138, 18161, 18160, 18826, 18872, 18873, 18870
7656, 18138, 18139, 18162, 18161, 18828, 18874, 18875, 18872
7657, 18139, 18140, 18163, 18162, 18830, 18876, 18877, 18874
7658, 18140, 18141, 18164, 18163, 18832, 18878, 18879, 18876
7659, 18141, 18142, 18165, 18164, 18834, 18880, 18881, 18878
7660, 18142, 18143, 18166, 18165, 18836, 18882, 18883, 18880
7661, 18143, 18144, 18167, 18166, 18838, 18884, 18885, 18882
7662, 18144, 18145, 18168, 18167, 18840, 18886, 18887, 18884
7663, 18145, 18146, 18169, 18168, 18842, 18888, 18889, 18886
7664, 18146, 1753, 1754, 18169, 18843, 1777, 18890, 18888
7665, 1518, 18147, 18170, 1519, 18845, 18891, 18892, 1542
7666, 18147, 18148, 18171, 18170, 18847, 18893, 18894, 18891
7667, 18148, 18149, 18172, 18171, 18849, 18895, 18896, 18893
7668, 18149, 18150, 18173, 18172, 18851, 18897, 18898, 18895
7669, 18150, 18151, 18174, 18173, 18853, 18899, 18900, 18897
7670, 18151, 18152, 18175, 18174, 18855, 18901, 18902, 18899
7671, 18152, 18153, 18176, 18175, 18857, 18903, 18904, 18901
7672, 18153, 18154, 18177, 18176, 18859, 18905, 18906, 18903
7673, 18154, 18155, 18178, 18177, 18861, 18907, 18908, 18905
7674, 18155, 18156, 18179, 18178, 18863, 18909, 18910, 18907
7675, 18156, 18157, 18180, 18179, 18865, 18911, 18912, 18909
7676, 18157, 18158, 18181, 18180, 18867, 18913, 18914, 18911
7677, 18158, 18159, 18182, 18181, 18869, 18915, 18916, 18913
7678, 18159, 18160, 18183, 18182, 18871, 18917, 18918, 18915
7679, 18160, 18161, 18184, 18183, 18873, 18919, 18920, 18917
7680, 18161, 18162, 18185, 18184, 18875, 18921, 18922, 18919
7681, 18162, 18163, 18186, 18185, 18877, 18923, 18924, 18921
7682, 18163, 18164, 18187, 18186, 18879, 18925, 18926, 18923
7683, 18164, 18165, 18188, 18187, 18881, 18927, 18928, 18925
7684, 18165, 18166, 18189, 18188, 18883, 18929, 18930, 18927
7685, 18166, 18167, 18190, 18189, 18885, 18931, 18932, 18929
7686, 18167, 18168, 18191, 18190, 18887, 18933, 18934, 18931
7687, 18168, 18169, 18192, 18191, 18889, 18935, 18936, 18933
7688, 18169, 1754, 1755, 18192, 18890, 1778, 18937, 18935
7689, 1519, 18170, 18193, 1520, 18892, 18938, 18939, 1543
7690, 18170, 18171, 18194, 18193, 18894, 18940, 18941, 18938
7691, 18171, 18172, 18195, 18194, 18896, 18942, 18943, 18940
7692, 18172, 18173, 18196, 18195, 18898, 18944, 18945, 18942
7693, 18173, 18174, 18197, 18196, 18900, 18946, 18947, 18944
7694, 18174, 18175, 18198, 18197, 18902, 18948, 18949, 18946
7695, 18175, 18176, 18199, 18198, 18904, 18950, 18951, 18948
7696, 18176, 18177, 18200, 18199, 18906, 18952, 18953, 18950
7697, 18177, 18178, 18201, 18200, 18908, 18954, 18955, 18952
7698, 18178, 18179, 18202, 18201, 18910, 18956, 18957, 18954
7699, 18179, 18180, 18203, 18202, 18912, 18958, 18959, 18956
7700, 18180, 18181, 18204, 18203, 18914, 18960, 18961, 18958
7701, 18181, 18182, 18205, 18204, 18916, 18962, 18963, 18960
7702, 18182, 18183, 18206, 18205, 18918, 18964, 18965, 18962
7703, 18183, 18184, 18207, 18206, 18920, 18966, 18967, 18964
7704, 18184, 18185, 18208, 18207, 18922, 18968, 18969, 18966
7705, 18185, 18186, 18209, 18208, 18924, 18970, 18971, 18968
7706, 18186, 18187, 18210, 18209, 18926, 18972, 18973, 18970
7707, 18187, 18188, 18211, 18210, 18928, 18974, 18975, 18972
7708, 18188, 18189, 18212, 18211, 18930, 18976, 18977, 18974
7709, 18189, 18190, 18213, 18212, 18932, 18978, 18979, 18976
7710, 18190, 18191, 18214, 18213, 18934, 18980, 18981, 18978
7711, 18191, 18192, 18215, 18214, 18936, 18982, 18983, 18980
7712, 18192, 1755, 1756, 18215, 18937, 1779, 18984, 18982
7713, 1520, 18193, 18216, 1521, 18939, 18985, 18986, 1544
7714, 18193, 18194, 18217, 18216, 18941, 18987, 18988, 18985
7715, 18194, 18195, 18218, 18217, 18943, 18989, 18990, 18987
7716, 18195, 18196, 18219, 18218, 18945, 18991, 18992, 18989
7717, 18196, 18197, 18220, 18219, 18947, 18993, 18994, 18991
7718, 18197, 18198, 18221, 18220, 18949, 18995, 18996, 18993
7719, 18198, 18199, 18222, 18221, 18951, 18997, 18998, 18995
7720, 18199, 18200, 18223, 18222, 18953, 18999, 19000, 18997
7721, 18200, 18201, 18224, 18223, 18955, 19001, 19002, 18999
7722, 18201, 18202, 18225, 18224, 18957, 19003, 19004, 19001
7723, 18202, 18203, 18226, 18225, 18959, 19005, 19006, 19003
7724, 18203, 18204, 18227, 18226, 18961, 19007, 19008, 19005
7725, 18204, 18205, 18228, 18227, 18963, 19009, 19010, 19007
7726, 18205, 18206, 18229, 18228, 18965, 19011, 19012, 19009
7727, 18206, 18207, 18230, 18229, 18967, 19013, 19014, 19011
7728, 18207, 18208, 18231, 18230, 18969, 19015, 19016, 19013
7729, 18208, 18209, 18232, 18231, 18971, 19017, 19018, 19015
7730, 18209, 18210, 18233, 18232, 18973, 19019, 19020, 19017
7731, 18210, 18211, 18234, 18233, 18975, 19021, 19022, 19019
7732, 18211, 18212, 18235, 18234, 18977, 19023, 19024, 19021
7733, 18212, 18213, 18236, 18235, 18979, 19025, 19026, 19023
7734, 18213, 18214, 18237, 18236, 18981, 19027, 19028, 19025
7735, 18214, 18215, 18238, 18237, 18983, 19029, 19030, 19027
7736, 18215, 1756, 1757, 18238, 18984, 1780, 19031, 19029
7737, 1521, 18216, 18239, 1522, 18986, 19032, 19033, 1545
7738, 18216, 18217, 18240, 18239, 18988, 19034, 19035, 19032
7739, 18217, 18218, 18241, 18240, 18990, 19036, 19037, 19034
7740, 18218, 18219, 18242, 18241, 18992, 19038, 19039, 19036
7741, 18219, 18220, 18243, 18242, 18994, 19040, 19041, 19038
7742, 18220, 18221, 18244, 18243, 18996, 19042, 19043, 19040
7743, 18221, 18222, 18245, 18244, 18998, 19044, 19045, 19042
7744, 18222, 18223, 18246, 18245, 19000, 19046, 19047, 19044
7745, 18223, 18224, 18247, 18246, 19002, 19048, 19049, 19046
7746, 18224, 18225, 18248, 18247, 19004, 19050, 19051, 19048
7747, 18225, 18226, 18249, 18248, 19006, 19052, 19053, 19050
7748, 18226, 18227, 18250, 18249, 19008, 19054, 19055, 19052
7749, 18227, 18228, 18251, 18250, 19010, 19056, 19057, 19054
7750, 18228, 18229, 18252, 18251, 19012, 19058, 19059, 19056
7751, 18229, 18230, 18253, 18252, 19014, 19060, 19061, 19058
7752, 18230, 18231, 18254, 18253, 19016, 19062, 19063, 19060
7753, 18231, 18232, 18255, 18254, 19018, 19064, 19065, 19062
7754, 18232, 18233, 18256, 18255, 19020, 19066, 19067, 19064
7755, 18233, 18234, 18257, 18256, 19022, 19068, 19069, 19066
7756, 18234, 18235, 18258, 18257, 19024, 19070, 19071, 19068
7757, 18235, 18236, 18259, 18258, 19026, 19072, 19073, 19070
7758, 18236, 18237, 18260, 18259, 19028, 19074, 19075, 19072
7759, 18237, 18238, 18261, 18260, 19030, 19076, 19077, 19074
7760, 18238, 1757, 1758, 18261, 19031, 1781, 19078, 19076
7761, 1522, 18239, 18262, 1523, 19033, 19079, 19080, 1546
7762, 18239, 18240, 18263, 18262, 19035, 19081, 19082, 19079
7763, 18240, 18241, 18264, 18263, 19037, 19083, 19084, 19081
7764, 18241, 18242, 18265, 18264, 19039, 19085, 19086, 19083
7765, 18242, 18243, 18266, 18265, 19041, 19087, 19088, 19085
7766, 18243, 18244, 18267, 18266, 19043, 19089, 19090, 19087
7767, 18244, 18245, 18268, 18267, 19045, 19091, 19092, 19089
7768, 18245, 18246, 18269, 18268, 19047, 19093, 19094, 19091
7769, 18246, 18247, 18270, 18269, 19049, 19095, 19096, 19093
7770, 18247, 18248, 18271, 18270, 19051, 19097, 19098, 19095
7771, 18248, 18249, 18272, 18271, 19053, 19099, 19100, 19097
7772, 18249, 18250, 18273, 18272, 19055, 19101, 19102, 19099
7773, 18250, 18251, 18274, 18273, 19057, 19103, 19104, 19101
7774, 18251, 18252, 18275, 18274, 19059, 19105, 19106, 19103
7775, 18252, 18253, 18276, 18275, 19061, 19107, 19108, 19105
7776, 18253, 18254, 18277, 18276, 19063, 19109, 19110, 19107
7777, 18254, 18255, 18278, 18277, 19065, 19111, 19112, 19109
7778, 18255, 18256, 18279, 18278, 19067, 19113, 19114, 19111
7779, 18256, 18257, 18280, 18279, 19069, 19115, 19116, 19113
7780, 18257, 18258, 18281, 18280, 19071, 19117, 19118, 19115
7781, 18258, 18259, 18282, 18281, 19073, 19119, 19120, 19117
7782, 18259, 18260, 18283, 18282, 19075, 19121, 19122, 19119
7783, 18260, 18261, 18284, 18283, 19077, 19123, 19124, 19121
7784, 18261, 1758, 1759, 18284, 19078, 1782, 19125, 19123
7785, 1523, 18262, 18285, 1524, 19080, 19126, 19127, 1547
7786, 18262, 18263, 18286, 18285, 19082, 19128, 19129, 19126
7787, 18263, 18264, 18287, 18286, 19084, 19130, 19131, 19128
7788, 18264, 18265, 18288, 18287, 19086, 19132, 19133, 19130
7789, 18265, 18266, 18289, 18288, 19088, 19134, 19135, 19132
7790, 18266, 18267, 18290, 18289, 19090, 19136, 19137, 19134
7791, 18267, 18268, 18291, 18290, 19092, 19138, 19139, 19136
7792, 18268, 18269, 18292, 18291, 19094, 19140, 19141, 19138
7793, 18269, 18270, 18293, 18292, 19096, 19142, 19143, 19140
7794, 18270, 18271, 18294, 18293, 19098, 19144, 19145, 19142
7795, 18271, 18272, 18295, 18294, 19100, 19146, 19147, 19144
7796, 18272, 18273, 18296, 18295, 19102, 19148, 19149, 19146
7797, 18273, 18274, 18297, 18296, 19104, 19150, 19151, 19148
7798, 18274, 18275, 18298, 18297, 19106, 19152, 19153, 19150
7799, 18275, 18276, 18299, 18298, 19108, 19154, 19155, 19152
7800, 18276, 18277, 18300, 18299, 19110, 19156, 19157, 19154
7801, 18277, 18278, 18301, 18300, 19112, 19158, 19159, 19156
7802, 18278, 18279, 18302, 18301, 19114, 19160, 19161, 19158
7803, 18279, 18280, 18303, 18302, 19116, 19162, 19163, 19160
7804, 18280, 18281, 18304, 18303, 19118, 19164, 19165, 19162
7805, 18281, 18282, 18305, 18304, 19120, 19166, 19167, 19164
7806, 18282, 18283, 18306, 18305, 19122, 19168, 19169, 19166
7807, 18283, 18284, 18307, 18306, 19124, 19170, 19171, 19168
7808, 18284, 1759, 1760, 18307, 19125, 1783, 19172, 19170
7809, 1524, 18285, 18308, 1525, 19127, 19173, 19174, 1548
7810, 18285, 18286, 18309, 18308, 19129, 19175, 19176, 19173
7811, 18286, 18287, 18310, 18309, 19131, 19177, 19178, 19175
7812, 18287, 18288, 18311, 18310, 19133, 19179, 19180, 19177
7813, 18288, 18289, 18312, 18311, 19135, 19181, 19182, 19179
7814, 18289, 18290, 18313, 18312, 19137, 19183, 19184, 19181
7815, 18290, 18291, 18314, 18313, 19139, 19185, 19186, 19183
7816, 18291, 18292, 18315, 18314, 19141, 19187, 19188, 19185
7817, 18292, 18293, 18316, 18315, 19143, 19189, 19190, 19187
7818, 18293, 18294, 18317, 18316, 19145, 19191, 19192, 19189
7819, 18294, 18295, 18318, 18317, 19147, 19193, 19194, 19191
7820, 18295, 18296, 18319, 18318, 19149, 19195, 19196, 19193
7821, 18296, 18297, 18320, 18319, 19151, 19197, 19198, 19195
7822, 18297, 18298, 18321, 18320, 19153, 19199, 19200, 19197
7823, 18298, 18299, 18322, 18321, 19155, 19201, 19202, 19199
7824, 18299, 18300, 18323, 18322, 19157, 19203, 19204, 19201
7825, 18300, 18301, 18324, 18323, 19159, 19205, 19206, 19203
7826, 18301, 18302, 18325, 18324, 19161, 19207, 19208, 19205
7827, 18302, 18303, 18326, 18325, 19163, 19209, 19210, 19207
7828, 18303, 18304, 18327, 18326, 19165, 19211, 19212, 19209
7829, 18304, 18305, 18328, 18327, 19167, 19213, 19214, 19211
7830, 18305, 18306, 18329, 18328, 19169, 19215, 19216, 19213
7831, 18306, 18307, 18330, 18329, 19171, 19217, 19218, 19215
7832, 18307, 1760, 1761, 18330, 19172, 1784, 19219, 19217
7833, 1525, 18308, 18331, 1526, 19174, 19220, 19221, 1549
7834, 18308, 18309, 18332, 18331, 19176, 19222, 19223, 19220
7835, 18309, 18310, 18333, 18332, 19178, 19224, 19225, 19222
7836, 18310, 18311, 18334, 18333, 19180, 19226, 19227, 19224
7837, 18311, 18312, 18335, 18334, 19182, 19228, 19229, 19226
7838, 18312, 18313, 18336, 18335, 19184, 19230, 19231, 19228
7839, 18313, 18314, 18337, 18336, 19186, 19232, 19233, 19230
7840, 18314, 18315, 18338, 18337, 19188, 19234, 19235, 19232
7841, 18315, 18316, 18339, 18338, 19190, 19236, 19237, 19234
7842, 18316, 18317, 18340, 18339, 19192, 19238, 19239, 19236
7843, 18317, 18318, 18341, 18340, 19194, 19240, 19241, 19238
7844, 18318, 18319, 18342, 18341, 19196, 19242, 19243, 19240
7845, 18319, 18320, 18343, 18342, 19198, 19244, 19245, 19242
7846, 18320, 18321, 18344, 18343, 19200, 19246, 19247, 19244
7847, 18321, 18322, 18345, 18344, 19202, 19248, 19249, 19246
7848, 18322, 18323, 18346, 18345, 19204, 19250, 19251, 19248
7849, 18323, 18324, 18347, 18346, 19206, 19252, 19253, 19250
7850, 18324, 18325, 18348, 18347, 19208, 19254, 19255, 19252
7851, 18325, 18326, 18349, 18348, 19210, 19256, 19257, 19254
7852, 18326, 18327, 18350, 18349, 19212, 19258, 19259, 19256
7853, 18327, 18328, 18351, 18350, 19214, 19260, 19261, 19258
7854, 18328, 18329, 18352, 18351, 19216, 19262, 19263, 19260
7855, 18329, 18330, 18353, 18352, 19218, 19264, 19265, 19262
7856, 18330, 1761, 1762, 18353, 19219, 1785, 19266, 19264
7857, 1526, 18331, 18354, 1527, 19221, 19267, 19268, 1550
7858, 18331, 18332, 18355, 18354, 19223, 19269, 19270, 19267
7859, 18332, 18333, 18356, 18355, 19225, 19271, 19272, 19269
7860, 18333, 18334, 18357, 18356, 19227, 19273, 19274, 19271
7861, 18334, 18335, 18358, 18357, 19229, 19275, 19276, 19273
7862, 18335, 18336, 18359, 18358, 19231, 19277, 19278, 19275
7863, 18336, 18337, 18360, 18359, 19233, 19279, 19280, 19277
7864, 18337, 18338, 18361, 18360, 19235, 19281, 19282, 19279
7865, 18338, 18339, 18362, 18361, 19237, 19283, 19284, 19281
7866, 18339, 18340, 18363, 18362, 19239, 19285, 19286, 19283
7867, 18340, 18341, 18364, 18363, 19241, 19287, 19288, 19285
7868, 18341, 18342, 18365, 18364, 19243, 19289, 19290, 19287
7869, 18342, 18343, 18366, 18365, 19245, 19291, 19292, 19289
7870, 18343, 18344, 18367, 18366, 19247, 19293, 19294, 19291
7871, 18344, 18345, 18368, 18367, 19249, 19295, 19296, 19293
7872, 18345, 18346, 18369, 18368, 19251, 19297, 19298, 19295
7873, 18346, 18347, 18370, 18369, 19253, 19299, 19300, 19297
7874, 18347, 18348, 18371, 18370, 19255, 19301, 19302, 19299
7875, 18348, 18349, 18372, 18371, 19257, 19303, 19304, 19301
7876, 18349, 18350, 18373, 18372, 19259, 19305, 19306, 19303
7877, 18350, 18351, 18374, 18373, 19261, 19307, 19308, 19305
7878, 18351, 18352, 18375, 18374, 19263, 19309, 19310, 19307
7879, 18352, 18353, 18376, 18375, 19265, 19311, 19312, 19309
7880, 18353, 1762, 1763, 18376, 19266, 1786, 19313, 19311
7881, 1527, 18354, 18377, 1528, 19268, 19314, 19315, 1551
7882, 18354, 18355, 18378, 18377, 19270, 19316, 19317, 19314
7883, 18355, 18356, 18379, 18378, 19272, 19318, 19319, 19316
7884, 18356, 18357, 18380, 18379, 19274, 19320, 19321, 19318
7885, 18357, 18358, 18381, 18380, 19276, 19322, 19323, 19320
7886, 18358, 18359, 18382, 18381, 19278, 19324, 19325, 19322
7887, 18359, 18360, 18383, 18382, 19280, 19326, 19327, 19324
7888, 18360, 18361, 18384, 18383, 19282, 19328, 19329, 19326
7889, 18361, 18362, 18385, 18384, 19284, 19330, 19331, 19328
7890, 18362, 18363, 18386, 18385, 19286, 19332, 19333, 19330
7891, 18363, 18364, 18387, 18386, 19288, 19334, 19335, 19332
7892, 18364, 18365, 18388, 18387, 19290, 19336, 19337, 19334
7893, 18365, 18366, 18389, 18388, 19292, 19338, 19339, 19336
7894, 18366, 18367, 18390, 18389, 19294, 19340, 19341, 19338
7895, 18367, 18368, 18391, 18390, 19296, 19342, 19343, 19340
7896, 18368, 18369, 18392, 18391, 19298, 19344, 19345, 19342
7897, 18369, 18370, 18393, 18392, 19300, 19346, 19347, 19344
7898, 18370, 18371, 18394, 18393, 19302, 19348, 19349, 19346
7899, 18371, 18372, 18395, 18394, 19304, 19350, 19351, 19348
7900, 18372, 18373, 18396, 18395, 19306, 19352, 19353, 19350
7901, 18373, 18374, 18397, 18396, 19308, 19354, 19355, 19352
7902, 18374, 18375, 18398, 18397, 19310, 19356, 19357, 19354
7903, 18375, 18376, 18399, 18398, 19312, 19358, 19359, 19356
7904, 18376, 1763, 1764, 18399, 19313, 1787, 19360, 19358
7905, 1528, 18377, 18400, 1529, 19315, 19361, 19362, 1552
7906, 18377, 18378, 18401, 18400, 19317, 19363, 19364, 19361
7907, 18378, 18379, 18402, 18401, 19319, 19365, 19366, 19363
7908, 18379, 18380, 18403, 18402, 19321, 19367, 19368, 19365
7909, 18380, 18381, 18404, 18403, 19323, 19369, 19370, 19367
7910, 18381, 18382, 18405, 18404, 19325, 19371, 19372, 19369
7911, 18382, 18383, 18406, 18405, 19327, 19373, 19374, 19371
7912, 18383, 18384, 18407, 18406, 19329, 19375, 19376, 19373
7913, 18384, 18385, 18408, 18407, 19331, 19377, 19378, 19375
7914, 18385, 18386, 18409, 18408, 19333, 19379, 19380, 19377
7915, 18386, 18387, 18410, 18409, 19335, 19381, 19382, 19379
7916, 18387, 18388, 18411, 18410, 19337, 19383, 19384, 19381
7917, 18388, 18389, 18412, 18411, 19339, 19385, 19386, 19383
7918, 18389, 18390, 18413, 18412, 19341, 19387, 19388, 19385
7919, 18390, 18391, 18414, 18413, 19343, 19389, 19390, 19387
7920, 18391, 18392, 18415, 18414, 19345, 19391, 19392, 19389
7921, 18392, 18393, 18416, 18415, 19347, 19393, 19394, 19391
7922, 18393, 18394, 18417, 18416, 19349, 19395, 19396, 19393
7923, 18394, 18395, 18418, 18417, 19351, 19397, 19398, 19395
7924, 18395, 18396, 18419, 18418, 19353, 19399, 19400, 19397
7925, 18396, 18397, 18420, 18419, 19355, 19401, 19402, 19399
7926, 18397, 18398, 18421, 18420, 19357, 19403, 19404, 19401
7927, 18398, 18399, 18422, 18421, 19359, 19405, 19406, 19403
7928, 18399, 1764, 1765, 18422, 19360, 1788, 19407, 19405
7929, 1529, 18400, 18423, 1530, 19362, 19408, 19409, 1553
7930, 18400, 18401, 18424, 18423, 19364, 19410, 19411, 19408
7931, 18401, 18402, 18425, 18424, 19366, 19412, 19413, 19410
7932, 18402, 18403, 18426, 18425, 19368, 19414, 19415, 19412
7933, 18403, 18404, 18427, 18426, 19370, 19416, 19417, 19414
7934, 18404, 18405, 18428, 18427, 19372, 19418, 19419, 19416
7935, 18405, 18406, 18429, 18428, 19374, 19420, 19421, 19418
7936, 18406, 18407, 18430, 18429, 19376, 19422, 19423, 19420
7937, 18407, 18408, 18431, 18430, 19378, 19424, 19425, 19422
7938, 18408, 18409, 18432, 18431, 19380, 19426, 19427, 19424
7939, 18409, 18410, 18433, 18432, 19382, 19428, 19429, 19426
7940, 18410, 18411, 18434, 18433, 19384, 19430, 19431, 19428
7941, 18411, 18412, 18435, 18434, 19386, 19432, 19433, 19430
7942, 18412, 18413, 18436, 18435, 19388, 19434, 19435, 19432
7943, 18413, 18414, 18437, 18436, 19390, 19436, 19437, 19434
7944, 18414, 18415, 18438, 18437, 19392, 19438, 19439, 19436
7945, 18415, 18416, 18439, 18438, 19394, 19440, 19441, 19438
7946, 18416, 18417, 18440, 18439, 19396, 19442, 19443, 19440
7947, 18417, 18418, 18441, 18440, 19398, 19444, 19445, 19442
7948, 18418, 18419, 18442, 18441, 19400, 19446, 19447, 19444
7949, 18419, 18420, 18443, 18442, 19402, 19448, 19449, 19446
7950, 18420, 18421, 18444, 18443, 19404, 19450, 19451, 19448
7951, 18421, 18422, 18445, 18444, 19406, 19452, 19453, 19450
7952, 18422, 1765, 1766, 18445, 19407, 1789, 19454, 19452
7953, 1530, 18423, 18446, 1531, 19409, 19455, 19456, 1554
7954, 18423, 18424, 18447, 18446, 19411, 19457, 19458, 19455
7955, 18424, 18425, 18448, 18447, 19413, 19459, 19460, 19457
7956, 18425, 18426, 18449, 18448, 19415, 19461, 19462, 19459
7957, 18426, 18427, 18450, 18449, 19417, 19463, 19464, 19461
7958, 18427, 18428, 18451, 18450, 19419, 19465, 19466, 19463
7959, 18428, 18429, 18452, 18451, 19421, 19467, 19468, 19465
7960, 18429, 18430, 18453, 18452, 19423, 19469, 19470, 19467
7961, 18430, 18431, 18454, 18453, 19425, 19471, 19472, 19469
7962, 18431, 18432, 18455, 18454, 19427, 19473, 19474, 19471
7963, 18432, 18433, 18456, 18455, 19429, 19475, 19476, 19473
7964, 18433, 18434, 18457, 18456, 19431, 19477, 19478, 19475
7965, 18434, 18435, 18458, 18457, 19433, 19479, 19480, 19477
7966, 18435, 18436, 18459, 18458, 19435, 19481, 19482, 19479
7967, 18436, 18437, 18460, 18459, 19437, 19483, 19484, 19481
7968, 18437, 18438, 18461, 18460, 19439, 19485, 19486, 19483
7969, 18438, 18439, 18462, 18461, 19441, 19487, 19488, 19485
7970, 18439, 18440, 18463, 18462, 19443, 19489, 19490, 19487
7971, 18440, 18441, 18464, 18463, 19445, 19491, 19492, 19489
7972, 18441, 18442, 18465, 18464, 19447, 19493, 19494, 19491
7973, 18442, 18443, 18466, 18465, 19449, 19495, 19496, 19493
7974, 18443, 18444, 18467, 18466, 19451, 19497, 19498, 19495
7975, 18444, 18445, 18468, 18467, 19453, 19499, 19500, 19497
7976, 18445, 1766, 1767, 18468, 19454, 1790, 19501, 19499
7977, 1531, 18446, 18469, 1532, 19456, 19502, 19503, 1555
7978, 18446, 18447, 18470, 18469, 19458, 19504, 19505, 19502
7979, 18447, 18448, 18471, 18470, 19460, 19506, 19507, 19504
7980, 18448, 18449, 18472, 18471, 19462, 19508, 19509, 19506
7981, 18449, 18450, 18473, 18472, 19464, 19510, 19511, 19508
7982, 18450, 18451, 18474, 18473, 19466, 19512, 19513, 19510
7983, 18451, 18452, 18475, 18474, 19468, 19514, 19515, 19512
7984, 18452, 18453, 18476, 18475, 19470, 19516, 19517, 19514
7985, 18453, 18454, 18477, 18476, 19472, 19518, 19519, 19516
7986, 18454, 18455, 18478, 18477, 19474, 19520, 19521, 19518
7987, 18455, 18456, 18479, 18478, 19476, 19522, 19523, 19520
7988, 18456, 18457, 18480, 18479, 19478, 19524, 19525, 19522
7989, 18457, 18458, 18481, 18480, 19480, 19526, 19527, 19524
7990, 18458, 18459, 18482, 18481, 19482, 19528, 19529, 19526
7991, 18459, 18460, 18483, 18482, 19484, 19530, 19531, 19528
7992, 18460, 18461, 18484, 18483, 19486, 19532, 19533, 19530
7993, 18461, 18462, 18485, 18484, 19488, 19534, 19535, 19532
7994, 18462, 18463, 18486, 18485, 19490, 19536, 19537, 19534
7995, 18463, 18464, 18487, 18486, 19492, 19538, 19539, 19536
7996, 18464, 18465, 18488, 18487, 19494, 19540, 19541, 19538
7997, 18465, 18466, 18489, 18488, 19496, 19542, 19543, 19540
7998, 18466, 18467, 18490, 18489, 19498, 19544, 19545, 19542
7999, 18467, 18468, 18491, 18490, 19500, 19546, 19547, 19544
8000, 18468, 1767, 1768, 18491, 19501, 1791, 19548, 19546
8001, 1532, 18469, 18492, 1533, 19503, 19549, 19550, 1556
8002, 18469, 18470, 18493, 18492, 19505, 19551, 19552, 19549
8003, 18470, 18471, 18494, 18493, 19507, 19553, 19554, 19551
8004, 18471, 18472, 18495, 18494, 19509, 19555, 19556, 19553
8005, 18472, 18473, 18496, 18495, 19511, 19557, 19558, 19555
8006, 18473, 18474, 18497, 18496, 19513, 19559, 19560, 19557
8007, 18474, 18475, 18498, 18497, 19515, 19561, 19562, 19559
8008, 18475, 18476, 18499, 18498, 19517, 19563, 19564, 19561
8009, 18476, 18477, 18500, 18499, 19519, 19565, 19566, 19563
8010, 18477, 18478, 18501, 18500, 19521, 19567, 19568, 19565
8011, 18478, 18479, 18502, 18501, 19523, 19569, 19570, 19567
8012, 18479, 18480, 18503, 18502, 19525, 19571, 19572, 19569
8013, 18480, 18481, 18504, 18503, 19527, 19573, 19574, 19571
8014, 18481, 18482, 18505, 18504, 19529, 19575, 19576, 19573
8015, 18482, 18483, 18506, 18505, 19531, 19577, 19578, 19575
8016, 18483, 18484, 18507, 18506, 19533, 19579, 19580, 19577
8017, 18484, 18485, 18508, 18507, 19535, 19581, 19582, 19579
8018, 18485, 18486, 18509, 18508, 19537, 19583, 19584, 19581
8019, 18486, 18487, 18510, 18509, 19539, 19585, 19586, 19583
8020, 18487, 18488, 18511, 18510, 19541, 19587, 19588, 19585
8021, 18488, 18489, 18512, 18511, 19543, 19589, 19590, 19587
8022, 18489, 18490, 18513, 18512, 19545, 19591, 19592, 19589
8023, 18490, 18491, 18514, 18513, 19547, 19593, 19594, 19591
8024, 18491, 1768, 1769, 18514, 19548, 1792, 19595, 19593
8025, 1533, 18492, 1700, 34, 19550, 19596, 1723, 1557
8026, 18492, 18493, 1701, 1700, 19552, 19597, 1724, 19596
8027, 18493, 18494, 1702, 1701, 19554, 19598, 1725, 19597
8028, 18494, 18495, 1703, 1702, 19556, 19599, 1726, 19598
8029, 18495, 18496, 1704, 1703, 19558, 19600, 1727, 19599
8030, 18496, 18497, 1705, 1704, 19560, 19601, 1728, 19600
8031, 18497, 18498, 1706, 1705, 19562, 19602, 1729, 19601
8032, 18498, 18499, 1707, 1706, 19564, 19603, 1730, 19602
8033, 18499, 18500, 1708, 1707, 19566, 19604, 1731, 19603
8034, 18500, 18501, 1709, 1708, 19568, 19605, 1732, 19604
8035, 18501, 18502, 1710, 1709, 19570, 19606, 1733, 19605
8036, 18502, 18503, 1711, 1710, 19572, 19607, 1734, 19606
8037, 18503, 18504, 1712, 1711, 19574, 19608, 1735, 19607
8038, 18504, 18505, 1713, 1712, 19576, 19609, 1736, 19608
8039, 18505, 18506, 1714, 1713, 19578, 19610, 1737, 19609
8040, 18506, 18507, 1715, 1714, 19580, 19611, 1738, 19610
8041, 18507, 18508, 1716, 1715, 19582, 19612, 1739, 19611
8042, 18508, 18509, 1717, 1716, 19584, 19613, 1740, 19612
8043, 18509, 18510, 1718, 1717, 19586, 19614, 1741, 19613
8044, 18510, 18511, 1719, 1718, 19588, 19615, 1742, 19614
8045, 18511, 18512, 1720, 1719, 19590, 19616, 1743, 19615
8046, 18512, 18513, 1721, 1720, 19592, 19617, 1744, 19616
8047, 18513, 18514, 1722, 1721, 19594, 19618, 1745, 19617
8048, 18514, 1769, 38, 1722, 19595, 1793, 1746, 19618
*ELEMENT, type=CPS8, ELSET=Surface43
8049, 35, 1560, 19619, 1794, 1583, 20148, 20149, 1817
8050, 1794, 19619, 19620, 1795, 20149, 20150, 20151, 1818
8051, 1795, 19620, 19621, 1796, 20151, 20152, 20153, 1819
8052, 1796, 19621, 19622, 1797, 20153, 20154, 20155, 1820
8053, 1797, 19622, 19623, 1798, 20155, 20156, 20157, 1821
8054, 1798, 19623, 19624, 1799, 20157, 20158, 20159, 1822
8055, 1799, 19624, 19625, 1800, 20159, 20160, 20161, 1823
8056, 1800, 19625, 19626, 1801, 20161, 20162, 20163, 1824
8057, 1801, 19626, 19627, 1802, 20163, 20164, 20165, 1825
8058, 1802, 19627, 19628, 1803, 20165, 20166, 20167, 1826
8059, 1803, 19628, 19629, 1804, 20167, 20168, 20169, 1827
8060, 1804, 19629, 19630, 1805, 20169, 20170, 20171, 1828
8061, 1805, 19630, 19631, 1806, 20171, 20172, 20173, 1829
8062, 1806, 19631, 19632, 1807, 20173, 20174, 20175, 1830
8063, 1807, 19632, 19633, 1808, 20175, 20176, 20177, 1831
8064, 1808, 19633, 19634, 1809, 20177, 20178, 20179, 1832
8065, 1809, 19634, 19635, 1810, 20179, 20180, 20181, 1833
8066, 1810, 19635, 19636, 1811, 20181, 20182, 20183, 1834
8067, 1811, 19636, 19637, 1812, 20183, 20184, 20185, 1835
8068, 1812, 19637, 19638, 1813, 20185, 20186, 20187, 1836
8069, 1813, 19638, 19639, 1814, 20187, 20188, 20189, 1837
8070, 1814, 19639, 19640, 1815, 20189, 20190, 20191, 1838
8071, 1815, 19640, 19641, 1816, 20191, 20192, 20193, 1839
8072, 1816, 19641, 1888, 39, 20193, 20194, 1911, 1840
8073, 1560, 1561, 19642, 19619, 1584, 20195, 20196, 20148
8074, 19619, 19642, 19643, 19620, 20196, 20197, 20198, 20150
8075, 19620, 19643, 19644, 19621, 20198, 20199, 20200, 20152
8076, 19621, 19644, 19645, 19622, 20200, 20201, 20202, 20154
8077, 19622, 19645, 19646, 19623, 20202, 20203, 20204, 20156
8078, 19623, 19646, 19647, 19624, 20204, 20205, 20206, 20158
8079, 19624, 19647, 19648, 19625, 20206, 20207, 20208, 20160
8080, 19625, 19648, 19649, 19626, 20208, 20209, 20210, 20162
8081, 19626, 19649, 19650, 19627, 20210, 20211, 20212, 20164
8082, 19627, 19650, 19651, 19628, 20212, 20213, 20214, 20166
8083, 19628, 19651, 19652, 19629, 20214, 20215, 20216, 20168
8084, 19629, 19652, 19653, 19630, 20216, 20217, 20218, 20170
8085, 19630, 19653, 19654, 19631, 20218, 20219, 20220, 20172
8086, 19631, 19654, 19655, 19632, 20220, 20221, 20222, 20174
8087, 19632, 19655, 19656, 19633, 20222, 20223, 20224, 20176
8088, 19633, 19656, 19657, 19634, 20224, 20225, 20226, 20178
8089, 19634, 19657, 19658, 19635, 20226, 20227, 20228, 20180
8090, 19635, 19658, 19659, 19636, 20228, 20229, 20230, 20182
8091, 19636, 19659, 19660, 19637, 20230, 20231, 20232, 20184
8092, 19637, 19660, 19661, 19638, 20232, 20233, 20234, 20186
8093, 19638, 19661, 19662, 19639, 20234, 20235, 20236, 20188
8094, 19639, 19662, 19663, 19640, 20236, 20237, 20238, 20190
8095, 19640, 19663, 19664, 19641, 20238, 20239, 20240, 20192
8096, 19641, 19664, 1889, 1888, 20240, 20241, 1912, 20194
8097, 1561, 1562, 19665, 19642, 1585, 20242, 20243, 20195
8098, 19642, 19665, 19666, 19643, 20243, 20244, 20245, 20197
8099, 19643, 19666, 19667, 19644, 20245, 20246, 20247, 20199
8100, 19644, 19667, 19668, 19645, 20247, 20248, 20249, 20201
8101, 19645, 19668, 19669, 19646, 20249, 20250, 20251, 20203
8102, 19646, 19669, 19670, 19647, 20251, 20252, 20253, 20205
8103, 19647, 19670, 19671, 19648, 20253, 20254, 20255, 20207
8104, 19648, 19671, 19672, 19649, 20255, 20256, 20257, 20209
8105, 19649, 19672, 19673, 19650, 20257, 20258, 20259, 20211
8106, 19650, 19673, 19674, 19651, 20259, 20260, 20261, 20213
8107, 19651, 19674, 19675, 19652, 20261, 20262, 20263, 20215
8108, 19652, 19675, 19676, 19653, 20263, 20264, 20265, 20217
8109, 19653, 19676, 19677, 19654, 20265, 20266, 20267, 20219
8110, 19654, 19677, 19678, 19655, 20267, 20268, 20269, 20221
8111, 19655, 19678, 19679, 19656, 20269, 20270, 20271, 20223
8112, 19656, 19679, 19680, 19657, 20271, 20272, 20273, 20225
8113, 19657, 19680, 19681, 19658, 20273, 20274, 20275, 20227
8114, 19658, 19681, 19682, 19659, 20275, 20276, 20277, 20229
8115, 19659, 19682, 19683, 19660, 20277, 20278, 20279, 20231
8116, 19660, 19683, 19684, 19661, 20279, 20280, 20281, 20233
8117, 19661, 19684, 19685, 19662, 20281, 20282, 20283, 20235
8118, 19662, 19685, 19686, 19663, 20283, 20284, 20285, 20237
8119, 19663, 19686, 19687, 19664, 20285, 20286, 20287, 20239
8120, 19664, 19687, 1890, 1889, 20287, 20288, 1913, 20241
8121, 1562, 1563, 19688, 19665, 1586, 20289, 20290, 20242
8122, 19665, 19688, 19689, 19666, 20290, 20291, 20292, 20244
8123, 19666, 19689, 19690, 19667, 20292, 20293, 20294, 20246
8124, 19667, 19690, 19691, 19668, 20294, 20295, 20296, 20248
8125, 19668, 19691, 19692, 19669, 20296, 20297, 20298, 20250
8126, 19669, 19692, 19693, 19670, 20298, 20299, 20300, 20252
8127, 19670, 19693, 19694, 19671, 20300, 20301, 20302, 20254
8128, 19671, 19694, 19695, 19672, 20302, 20303, 20304, 20256
8129, 19672, 19695, 19696, 19673, 20304, 20305, 20306, 20258
8130, 19673, 19696, 19697, 19674, 20306, 20307, 20308, 20260
8131, 19674, 19697, 19698, 19675, 20308, 20309, 20310, 20262
8132, 19675, 19698, 19699, 19676, 20310, 20311, 20312, 20264
8133, 19676, 19699, 19700, 19677, 20312, 20313, 20314, 20266
8134, 19677, 19700, 19701, 19678, 20314, 20315, 20316, 20268
8135, 19678, 19701, 19702, 19679, 20316, 20317, 20318, 20270
8136, 19679, 19702, 19703, 19680, 20318, 20319, 20320, 20272
8137, 19680, 19703, 19704, 19681, 20320, 20321, 20322, 20274
8138, 19681, 19704, 19705, 19682, 20322, 20323, 20324, 20276
8139, 19682, 19705, 19706, 19683, 20324, 20325, 20326, 20278
8140, 19683, 19706, 19707, 19684, 20326, 20327, 20328, 20280
8141, 19684, 19707, 19708, 19685, 20328, 20329, 20330, 20282
8142, 19685, 19708, 19709, 19686, 20330, 20331, 20332, 20284
8143, 19686, 19709, 19710, 19687, 20332, 20333, 20334, 20286
8144, 19687, 19710, 1891, 1890, 20334, 20335, 1914, 20288
8145, 1563, 1564, 19711, 19688, 1587, 20336, 20337, 20289
8146, 19688, 19711, 19712, 19689, 20337, 20338, 20339, 20291
8147, 19689, 19712, 19713, 19690, 20339, 20340, 20341, 20293
8148, 19690, 19713, 19714, 19691, 20341, 20342, 20343, 20295
8149, 19691, 19714, 19715, 19692, 20343, 20344, 20345, 20297
8150, 19692, 19715, 19716, 19693, 20345, 20346, 20347, 20299
8151, 19693, 19716, 19717, 19694, 20347, 20348, 20349, 20301
8152, 19694, 19717, 19718, 19695, 20349, 20350, 20351, 20303
8153, 19695, 19718, 19719, 19696, 20351, 20352, 20353, 20305
8154, 19696, 19719, 19720, 19697, 20353, 20354, 20355, 20307
8155, 19697, 19720, 19721, 19698, 20355, 20356, 20357, 20309
8156, 19698, 19721, 19722, 19699, 20357, 20358, 20359, 20311
8157, 19699, 19722, 19723, 19700, 20359, 20360, 20361, 20313
8158, 19700, 19723, 19724, 19701, 20361, 20362, 20363, 20315
8159, 19701, 19724, 19725, 19702, 20363, 20364, 20365, 20317
8160, 19702, 19725, 19726, 19703, 20365, 20366, 20367, 20319
8161, 19703, 19726, 19727, 19704, 20367, 20368, 20369, 20321
8162, 19704, 19727, 19728, 19705, 20369, 20370, 20371, 20323
8163, 19705, 19728, 19729, 19706, 20371, 20372, 20373, 20325
8164, 19706, 19729, 19730, 19707, 20373, 20374, 20375, 20327
8165, 19707, 19730, 19731, 19708, 20375, 20376, 20377, 20329
8166, 19708, 19731, 19732, 19709, 20377, 20378, 20379, 20331
8167, 19709, 19732, 19733, 19710, 20379, 20380, 20381, 20333
8168, 19710, 19733, 1892, 1891, 20381, 20382, 1915, 20335
8169, 1564, 1565, 19734, 19711, 1588, 20383, 20384, 20336
8170, 19711, 19734, 19735, 19712, 20384, 20385, 20386, 20338
8171, 19712, 19735, 19736, 19713, 20386, 20387, 20388, 20340
8172, 19713, 19736, 19737, 19714, 20388, 20389, 20390, 20342
8173, 19714, 19737, 19738, 19715, 20390, 20391, 20392, 20344
8174, 19715, 19738, 19739, 19716, 20392, 20393, 20394, 20346
8175, 19716, 19739, 19740, 19717, 20394, 20395, 20396, 20348
8176, 19717, 19740, 19741, 19718, 20396, 20397, 20398, 20350
8177, 19718, 19741, 19742, 19719, 20398, 20399, 20400, 20352
8178, 19719, 19742, 19743, 19720, 20400, 20401, 20402, 20354
8179, 19720, 19743, 19744, 19721, 20402, 20403, 20404, 20356
8180, 19721, 19744, 19745, 19722, 20404, 20405, 20406, 20358
8181, 19722, 19745, 19746, 19723, 20406, 20407, 20408, 20360
8182, 19723, 19746, 19747, 19724, 20408, 20409, 20410, 20362
8183, 19724, 19747, 19748, 19725, 20410, 20411, 20412, 20364
8184, 19725, 19748, 19749, 19726, 20412, 20413, 20414, 20366
8185, 19726, 19749, 19750, 19727, 20414, 20415, 20416, 20368
8186, 19727, 19750, 19751, 19728, 20416, 20417, 20418, 20370
8187, 19728, 19751, 19752, 19729, 20418, 20419, 20420, 20372
8188, 19729, 19752, 19753, 19730, 20420, 20421, 20422, 20374
8189, 19730, 19753, 19754, 19731, 20422, 20423, 20424, 20376
8190, 19731, 19754, 19755, 19732, 20424, 20425, 20426, 20378
8191, 19732, 19755, 19756, 19733, 20426, 20427, 20428, 20380
8192, 19733, 19756, 1893, 1892, 20428, 20429, 1916, 20382
8193, 1565, 1566, 19757, 19734, 1589, 20430, 20431, 20383
8194, 19734, 19757, 19758, 19735, 20431, 20432, 20433, 20385
8195, 19735, 19758, 19759, 19736, 20433, 20434, 20435, 20387
8196, 19736, 19759, 19760, 19737, 20435, 20436, 20437, 20389
8197, 19737, 19760, 19761, 19738, 20437, 20438, 20439, 20391
8198, 19738, 19761, 19762, 19739, 20439, 20440, 20441, 20393
8199, 19739, 19762, 19763, 19740, 20441, 20442, 20443, 20395
8200, 19740, 19763, 19764, 19741, 20443, 20444, 20445, 20397
8201, 19741, 19764, 19765, 19742, 20445, 20446, 20447, 20399
8202, 19742, 19765, 19766, 19743, 20447, 20448, 20449, 20401
8203, 19743, 19766, 19767, 19744, 20449, 20450, 20451, 20403
8204, 19744, 19767, 19768, 19745, 20451, 20452, 20453, 20405
8205, 19745, 19768, 19769, 19746, 20453, 20454, 20455, 20407
8206, 19746, 19769, 19770, 19747, 20455, 20456, 20457, 20409
8207, 19747, 19770, 19771, 19748, 20457, 20458, 20459, 20411
8208, 19748, 19771, 19772, 19749, 20459, 20460, 20461, 20413
8209, 19749, 19772, 19773, 19750, 20461, 20462, 20463, 20415
8210, 19750, 19773, 19774, 19751, 20463, 20464, 20465, 20417
8211, 19751, 19774, 19775, 19752, 20465, 20466, 20467, 20419
8212, 19752, 19775, 19776, 19753, 20467, 20468, 20469, 20421
8213, 19753, 19776, 19777, 19754, 20469, 20470, 20471, 20423
8214, 19754, 19777, 19778, 19755, 20471, 20472, 20473, 20425
8215, 19755, 19778, 19779, 19756, 20473, 20474, 20475, 20427
8216, 19756, 19779, 1894, 1893, 20475, 20476, 1917, 20429
8217, 1566, 1567, 19780, 19757, 1590, 20477, 20478, 20430
8218, 19757, 19780, 19781, 19758, 20478, 20479, 20480, 20432
8219, 19758, 19781, 19782, 19759, 20480, 20481, 20482, 20434
8220, 19759, 19782, 19783, 19760, 20482, 20483, 20484, 20436
8221, 19760, 19783, 19784, 19761, 20484, 20485, 20486, 20438
8222, 19761, 19784, 19785, 19762, 20486, 20487, 20488, 20440
8223, 19762, 19785, 19786, 19763, 20488, 20489, 20490, 20442
8224, 19763, 19786, 19787, 19764, 20490, 20491, 20492, 20444
8225, 19764, 19787, 19788, 19765, 20492, 20493, 20494, 20446
8226, 19765, 19788, 19789, 19766, 20494, 20495, 20496, 20448
8227, 19766, 19789, 19790, 19767, 20496, 20497, 20498, 20450
8228, 19767, 19790, 19791, 19768, 20498, 20499, 20500, 20452
8229, 19768, 19791, 19792, 19769, 20500, 20501, 20502, 20454
8230, 19769, 19792, 19793, 19770, 20502, 20503, 20504, 20456
8231, 19770, 19793, 19794, 19771, 20504, 20505, 20506, 20458
8232, 19771, 19794, 19795, 19772, 20506, 20507, 20508, 20460
8233, 19772, 19795, 19796, 19773, 20508, 20509, 20510, 20462
8234, 19773, 19796, 19797, 19774, 20510, 20511, 20512, 20464
8235, 19774, 19797, 19798, 19775, 20512, 20513, 20514, 20466
8236, 19775, 19798, 19799, 19776, 20514, 20515, 20516, 20468
8237, 19776, 19799, 19800, 19777, 20516, 20517, 20518, 20470
8238, 19777, 19800, 19801, 19778, 20518, 20519, 20520, 20472
8239, 19778, 19801, 19802, 19779, 20520, 20521, 20522, 20474
8240, 19779, 19802, 1895, 1894, 20522, 20523, 1918, 20476
8241, 1567, 1568, 19803, 19780, 1591, 20524, 20525, 20477
8242, 19780, 19803, 19804, 19781, 20525, 20526, 20527, 20479
8243, 19781, 19804, 19805, 19782, 20527, 20528, 20529, 20481
8244, 19782, 19805, 19806, 19783, 20529, 20530, 20531, 20483
8245, 19783, 19806, 19807, 19784, 20531, 20532, 20533, 20485
8246, 19784, 19807, 19808, 19785, 20533, 20534, 20535, 20487
8247, 19785, 19808, 19809, 19786, 20535, 20536, 20537, 20489
8248, 19786, 19809, 19810, 19787, 20537, 20538, 20539, 20491
8249, 19787, 19810, 19811, 19788, 20539, 20540, 20541, 20493
8250, 19788, 19811, 19812, 19789, 20541, 20542, 20543, 20495
8251, 19789, 19812, 19813, 19790, 20543, 20544, 20545, 20497
8252, 19790, 19813, 19814, 19791, 20545, 20546, 20547, 20499
8253, 19791, 19814, 19815, 19792, 20547, 20548, 20549, 20501
8254, 19792, 19815, 19816, 19793, 20549, 20550, 20551, 20503
8255, 19793, 19816, 19817, 19794, 20551, 20552, 20553, 20505
8256, 19794, 19817, 19818, 19795, 20553, 20554, 20555, 20507
8257, 19795, 19818, 19819, 19796, 20555, 20556, 20557, 20509
8258, 19796, 19819, 19820, 19797, 20557, 20558, 20559, 20511
8259, 19797, 19820, 19821, 19798, 20559, 20560, 20561, 20513
8260, 19798, 19821, 19822, 19799, 20561, 20562, 20563, 20515
8261, 19799, 19822, 19823, 19800, 20563, 20564, 20565, 20517
8262, 19800, 19823, 19824, 19801, 20565, 20566, 20567, 20519
8263, 19801, 19824, 19825, 19802, 20567, 20568, 20569, 20521
8264, 19802, 19825, 1896, 1895, 20569, 20570, 1919, 20523
8265, 1568, 1569, 19826, 19803, 1592, 20571, 20572, 20524
