9472, 9473, 9474, 9475, 9476, 9477, 9478, 9479, 9480, 9481, 
9482, 9483, 9484, 9485, 9486, 9487, 9488, 9489, 9490, 9491, 
9492, 9493, 9494, 9495, 9496, 9497, 9498, 9499, 9500, 9501, 
9502, 9503, 9504, 9505, 9506, 9507, 9508, 9509, 9510, 9511, 
9512, 9513, 9514, 9515, 9516, 9517, 9518, 9519, 9520, 9521, 
9522, 9523, 9524, 9525, 9526, 9527, 9528, 9529, 9530, 9531, 
9532, 9533, 9534, 9535, 9536, 9537, 9538, 9539, 9540, 9541, 
9542, 9543, 9544, 9545, 9546, 9547, 9548, 9549, 9550, 9551, 
9552, 9553, 9554, 9555, 9556, 9557, 9558, 9559, 9560, 9561, 
9562, 9563, 9564, 9565, 9566, 9567, 9568, 9569, 9570, 9571, 
9572, 9573, 9574, 9575, 9576, 9577, 9578, 9579, 9580, 9581, 
9582, 9583, 9584, 9585, 9586, 9587, 9588, 9589, 9590, 9591, 
9592, 9593, 9594, 9595, 9596, 9597, 9598, 9599, 9600, 9601, 
9602, 9603, 9604, 9605, 9606, 9607, 9608, 9609, 9610, 9611, 
9612, 9613, 9614, 9615, 9616, 9617, 9618, 9619, 9620, 9621, 
9622, 9623, 9624, 9625, 9626, 9627, 9628, 9629, 9630, 9631, 
9632, 9633, 9634, 9635, 9636, 9637, 9638, 9639, 9640, 9641, 
9642, 9643, 9644, 9645, 9646, 9647, 9648, 9649, 9650, 9651, 
9652, 9653, 9654, 9655, 9656, 9657, 9658, 9659, 9660, 9661, 
9662, 9663, 9664, 9665, 9666, 9667, 9668, 9669, 9670, 9671, 
9672, 9673, 9674, 9675, 9676, 9677, 9678, 9679, 9680, 9681, 
9682, 9683, 9684, 9685, 9686, 9687, 9688, 9689, 9690, 9691, 
9692, 9693, 9694, 9695, 9696, 9697, 9698, 9699, 9700, 9701, 
9702, 9703, 9704, 9705, 9706, 9707, 9708, 9709, 9710, 9711, 
9712, 9713, 9714, 9715, 9716, 9717, 9718, 9719, 9720, 9721, 
9722, 9723, 9724, 9725, 9726, 9727, 9728, 9729, 9730, 9731, 
9732, 9733, 9734, 9735, 9736, 9737, 9738, 9739, 9740, 9741, 
9742, 9743, 9744, 9745, 9746, 9747, 9748, 9749, 9750, 9751, 
9752, 9753, 9754, 9755, 9756, 9757, 9758, 9759, 9760, 9761, 
9762, 9763, 9764, 9765, 9766, 9767, 9768, 9769, 9770, 9771, 
9772, 9773, 9774, 9775, 9776, 9777, 9778, 9779, 9780, 9781, 
9782, 9783, 9784, 9785, 9786, 9787, 9788, 9789, 9790, 9791, 
9792, 9793, 9794, 9795, 9796, 9797, 9798, 9799, 9800, 9801, 
9802, 9803, 9804, 9805, 9806, 9807, 9808, 9809, 9810, 9811, 
9812, 9813, 9814, 9815, 9816, 9817, 9818, 9819, 9820, 9821, 
9822, 9823, 9824, 9825, 9826, 9827, 9828, 9829, 9830, 9831, 
9832, 9833, 9834, 9835, 9836, 9837, 9838, 9839, 9840, 9841, 
9842, 9843, 9844, 9845, 9846, 9847, 9848, 9849, 9850, 9851, 
9852, 9853, 9854, 9855, 9856, 9857, 9858, 9859, 9860, 9861, 
9862, 9863, 9864, 9865, 9866, 9867, 9868, 9869, 9870, 9871, 
9872, 9873, 9874, 9875, 9876, 9877, 9878, 9879, 9880, 9881, 
9882, 9883, 9884, 9885, 9886, 9887, 9888, 9889, 9890, 9891, 
9892, 9893, 9894, 9895, 9896, 9897, 9898, 9899, 9900, 9901, 
9902, 9903, 9904, 9905, 9906, 9907, 9908, 9909, 9910, 9911, 
9912, 9913, 9914, 9915, 9916, 9917, 9918, 9919, 9920, 9921, 
9922, 9923, 9924, 9925, 9926, 9927, 9928, 9929, 9930, 9931, 
9932, 9933, 9934, 9935, 9936, 9937, 9938, 9939, 9940, 9941, 
9942, 9943, 9944, 9945, 9946, 9947, 9948, 9949, 9950, 9951, 
9952, 9953, 9954, 9955, 9956, 9957, 9958, 9959, 9960, 9961, 
9962, 9963, 9964, 9965, 9966, 9967, 9968, 9969, 9970, 9971, 
9972, 9973, 9974, 9975, 9976, 9977, 9978, 9979, 9980, 9981, 
9982, 9983, 9984, 9985, 9986, 9987, 9988, 9989, 9990, 9991, 
9992, 9993, 9994, 9995, 9996, 9997, 9998, 9999, 10000, 10001, 
10002, 10003, 10004, 10005, 10006, 10007, 10008, 10009, 10010, 10011, 
10012, 10013, 10014, 10015, 10016, 10017, 10018, 10019, 10020, 10021, 
10022, 10023, 10024, 10025, 10026, 10027, 10028, 10029, 10030, 10031, 
10032, 10033, 10034, 10035, 10036, 10037, 10038, 10039, 10040, 10041, 
10042, 10043, 10044, 10045, 10046, 10047, 10048, 10049, 10050, 10051, 
10052, 10053, 10054, 10055, 10056, 10057, 10058, 10059, 10060, 10061, 
10062, 10063, 10064, 10065, 10066, 10067, 10068, 10069, 10070, 10071, 
10072, 10073, 10074, 10075, 10076, 10077, 10078, 10079, 10080, 10081, 
10082, 10083, 10084, 10085, 10086, 10087, 10088, 10089, 10090, 10091, 
10092, 10093, 10094, 10095, 10096, 10097, 10098, 10099, 10100, 10101, 
10102, 10103, 10104, 10105, 10106, 10107, 10108, 10109, 10110, 10111, 
10112, 10113, 10114, 10115, 10116, 10117, 10118, 10119, 10120, 10121, 
10122, 10123, 10124, 10125, 10126, 10127, 10128, 10129, 10130, 10131, 
10132, 10133, 10134, 10135, 10136, 10137, 10138, 10139, 10140, 10141, 
10142, 10143, 10144, 10145, 10146, 10147, 10148, 10149, 10150, 10151, 
10152, 10153, 10154, 10155, 10156, 10157, 10158, 10159, 10160, 10161, 
10162, 10163, 10164, 10165, 10166, 10167, 10168, 10169, 10170, 10171, 
10172, 10173, 10174, 10175, 10176, 10177, 10178, 10179, 10180, 10181, 
10182, 10183, 10184, 10185, 10186, 10187, 10188, 10189, 10190, 10191, 
10192, 10193, 10194, 10195, 10196, 10197, 10198, 10199, 10200, 10201, 
10202, 10203, 10204, 10205, 10206, 10207, 10208, 10209, 10210, 10211, 
10212, 10213, 10214, 10215, 10216, 10217, 10218, 10219, 10220, 10221, 
10222, 10223, 10224, 10225, 10226, 10227, 10228, 10229, 10230, 10231, 
10232, 10233, 10234, 10235, 10236, 10237, 10238, 10239, 10240, 10241, 
10242, 10243, 10244, 10245, 10246, 10247, 10248, 10249, 10250, 10251, 
10252, 10253, 10254, 10255, 10256, 10257, 10258, 10259, 10260, 10261, 
10262, 10263, 10264, 10265, 10266, 10267, 10268, 10269, 10270, 10271, 
10272, 10273, 10274, 10275, 10276, 10277, 10278, 10279, 10280, 10281, 
10282, 10283, 10284, 10285, 10286, 10287, 10288, 10289, 10290, 10291, 
10292, 10293, 10294, 10295, 10296, 10297, 10298, 10299, 10300, 10301, 
10302, 10303, 10304, 10305, 10306, 10307, 10308, 10309, 10310, 10311, 
10312, 10313, 10314, 10315, 10316, 10317, 10318, 10319, 10320, 10321, 
10322, 10323, 10324, 10325, 10326, 10327, 10328, 10329, 10330, 10331, 
10332, 10333, 10334, 10335, 10336, 10337, 10338, 10339, 10340, 10341, 
10342, 10343, 10344, 10345, 10346, 10347, 10348, 10349, 10350, 10351, 
10352, 10353, 10354, 10355, 10356, 10357, 10358, 10359, 10360, 10361, 
10362, 10363, 10364, 10365, 10366, 10367, 10368, 10369, 10370, 10371, 
10372, 10373, 10374, 10375, 10376, 10377, 10378, 10379, 10380, 10381, 
10382, 10383, 10384, 10385, 10386, 10387, 10388, 10389, 10390, 10391, 
10392, 10393, 10394, 10395, 10396, 10397, 10398, 10399, 10400, 10401, 
10402, 10403, 10404, 10405, 10406, 10407, 10408, 10409, 10410, 10411, 
10412, 10413, 10414, 10415, 10416, 10417, 10418, 10419, 10420, 10421, 
10422, 10423, 10424, 10425, 10426, 10427, 10428, 10429, 10430, 10431, 
10432, 10433, 10434, 10435, 10436, 10437, 10438, 10439, 10440, 10441, 
10442, 10443, 10444, 10445, 10446, 10447, 10448, 10449, 10450, 10451, 
10452, 10453, 10454, 10455, 10456, 10457, 10458, 10459, 10460, 10461, 
10462, 10463, 10464, 10465, 10466, 10467, 10468, 10469, 10470, 10471, 
10472, 10473, 10474, 10475, 10476, 10477, 10478, 10479, 10480, 10481, 
10482, 10483, 10484, 10485, 10486, 10487, 10488, 10489, 10490, 10491, 
10492, 10493, 10494, 10495, 10496, 10497, 10498, 10499, 10500, 10501, 
10502, 10503, 10504, 10505, 10506, 10507, 10508, 10509, 10510, 10511, 
10512, 10513, 10514, 10515, 10516, 10517, 10518, 10519, 10520, 10521, 
10522, 10523, 10524, 10525, 10526, 10527, 10528, 10529, 10530, 10531, 
10532, 10533, 10534, 10535, 10536, 10537, 10538, 10539, 10540, 10541, 
10542, 10543, 10544, 10545, 10546, 10547, 10548, 10549, 10550, 10551, 
10552, 10553, 10554, 10555, 10556, 10557, 10558, 10559, 10560, 10561, 
10562, 10563, 10564, 10565, 10566, 10567, 10568, 10569, 10570, 10571, 
10572, 10573, 10574, 10575, 10576, 10577, 10578, 10579, 10580, 10581, 
10582, 10583, 10584, 10585, 10586, 10587, 10588, 10589, 10590, 10591, 
10592, 10593, 10594, 10595, 10596, 10597, 10598, 10599, 10600, 10601, 
10602, 10603, 10604, 10605, 10606, 10607, 10608, 10609, 10610, 10611, 
10612, 10613, 10614, 10615, 10616, 10617, 10618, 10619, 10620, 10621, 
10622, 10623, 10624, 10625, 10626, 10627, 10628, 10629, 10630, 10631, 
10632, 10633, 10634, 10635, 10636, 10637, 10638, 10639, 10640, 10641, 
10642, 10643, 10644, 10645, 10646, 10647, 10648, 10649, 10650, 10651, 
10652, 10653, 10654, 10655, 10656, 10657, 10658, 10659, 10660, 10661, 
10662, 10663, 10664, 10665, 10666, 10667, 10668, 10669, 10670, 10671, 
10672, 10673, 10674, 10675, 10676, 10677, 10678, 10679, 10680, 10681, 
10682, 10683, 10684, 10685, 10686, 10687, 10688, 10689, 10690, 10691, 
10692, 10693, 10694, 10695, 10696, 10697, 10698, 10699, 10700, 10701, 
10702, 10703, 10704, 10705, 10706, 10707, 10708, 10709, 10710, 10711, 
10712, 10713, 10714, 10715, 10716, 10717, 10718, 10719, 10720, 10721, 
10722, 10723, 10724, 10725, 10726, 10727, 10728, 10729, 10730, 10731, 
10732, 10733, 10734, 10735, 10736, 10737, 10738, 10739, 10740, 10741, 
10742, 10743, 10744, 10745, 10746, 10747, 10748, 10749, 10750, 10751, 
10752, 10753, 10754, 10755, 10756, 10757, 10758, 10759, 10760, 10761, 
10762, 10763, 10764, 10765, 10766, 10767, 10768, 10769, 10770, 10771, 
10772, 10773, 10774, 10775, 10776, 10777, 10778, 10779, 10780, 10781, 
10782, 10783, 10784, 10785, 10786, 10787, 10788, 10789, 10790, 10791, 
10792, 10793, 10794, 10795, 10796, 10797, 10798, 10799, 10800, 10801, 
10802, 10803, 10804, 10805, 10806, 10807, 10808, 10809, 10810, 10811, 
10812, 10813, 10814, 10815, 10816, 10817, 10818, 10819, 10820, 10821, 
10822, 10823, 10824, 10825, 10826, 10827, 10828, 10829, 10830, 10831, 
10832, 10833, 10834, 10835, 10836, 10837, 10838, 10839, 10840, 10841, 
10842, 10843, 10844, 10845, 10846, 10847, 10848, 10849, 10850, 10851, 
10852, 10853, 10854, 10855, 10856, 10857, 10858, 10859, 10860, 10861, 
10862, 10863, 10864, 10865, 10866, 10867, 10868, 10869, 10870, 10871, 
10872, 10873, 10874, 10875, 10876, 10877, 10878, 10879, 10880, 10881, 
10882, 10883, 10884, 10885, 10886, 10887, 10888, 10889, 10890, 10891, 
10892, 10893, 10894, 10895, 10896, 10897, 10898, 10899, 10900, 10901, 
10902, 10903, 10904, 10905, 10906, 10907, 10908, 10909, 10910, 10911, 
10912, 10913, 10914, 10915, 10916, 10917, 10918, 10919, 10920, 10921, 
10922, 10923, 10924, 10925, 10926, 10927, 10928, 10929, 10930, 10931, 
10932, 10933, 10934, 10935, 10936, 10937, 10938, 10939, 10940, 10941, 
10942, 10943, 10944, 10945, 10946, 10947, 10948, 10949, 10950, 10951, 
10952, 10953, 10954, 10955, 10956, 10957, 10958, 10959, 10960, 10961, 
10962, 10963, 10964, 10965, 10966, 10967, 10968, 10969, 10970, 10971, 
10972, 10973, 10974, 10975, 10976, 
*NSET,NSET=SemiconductorR_2D
33, 34, 37, 38, 1511, 1512, 1513, 1514, 1515, 1516, 
1517, 1518, 1519, 1520, 1521, 1522, 1523, 1524, 1525, 1526, 
1527, 1528, 1529, 1530, 1531, 1532, 1533, 1534, 1535, 1536, 
1537, 1538, 1539, 1540, 1541, 1542, 1543, 1544, 1545, 1546, 
1547, 1548, 1549, 1550, 1551, 1552, 1553, 1554, 1555, 1556, 
1557, 1653, 1654, 1655, 1656, 1657, 1658, 1659, 1660, 1661, 
1662, 1663, 1664, 1665, 1666, 1667, 1668, 1669, 1670, 1671, 
1672, 1673, 1674, 1675, 1676, 1677, 1678, 1679, 1680, 1681, 
1682, 1683, 1684, 1685, 1686, 1687, 1688, 1689, 1690, 1691, 
1692, 1693, 1694, 1695, 1696, 1697, 1698, 1699, 1700, 1701, 
1702, 1703, 1704, 1705, 1706, 1707, 1708, 1709, 1710, 1711, 
1712, 1713, 1714, 1715, 1716, 1717, 1718, 1719, 1720, 1721, 
1722, 1723, 1724, 1725, 1726, 1727, 1728, 1729, 1730, 1731, 
1732, 1733, 1734, 1735, 1736, 1737, 1738, 1739, 1740, 1741, 
1742, 1743, 1744, 1745, 1746, 1747, 1748, 1749, 1750, 1751, 
1752, 1753, 1754, 1755, 1756, 1757, 1758, 1759, 1760, 1761, 
1762, 1763, 1764, 1765, 1766, 1767, 1768, 1769, 1770, 1771, 
1772, 1773, 1774, 1775, 1776, 1777, 1778, 1779, 1780, 1781, 
1782, 1783, 1784, 1785, 1786, 1787, 1788, 1789, 1790, 1791, 
1792, 1793, 17986, 17987, 17988, 17989, 17990, 17991, 17992, 17993, 
17994, 17995, 17996, 17997, 17998, 17999, 18000, 18001, 18002, 18003, 
18004, 18005, 18006, 18007, 18008, 18009, 18010, 18011, 18012, 18013, 
18014, 18015, 18016, 18017, 18018, 18019, 18020, 18021, 18022, 18023, 
18024, 18025, 18026, 18027, 18028, 18029, 18030, 18031, 18032, 18033, 
18034, 18035, 18036, 18037, 18038, 18039, 18040, 18041, 18042, 18043, 
18044, 18045, 18046, 18047, 18048, 18049, 18050, 18051, 18052, 18053, 
18054, 18055, 18056, 18057, 18058, 18059, 18060, 18061, 18062, 18063, 
18064, 18065, 18066, 18067, 18068, 18069, 18070, 18071, 18072, 18073, 
18074, 18075, 18076, 18077, 18078, 18079, 18080, 18081, 18082, 18083, 
18084, 18085, 18086, 18087, 18088, 18089, 18090, 18091, 18092, 18093, 
18094, 18095, 18096, 18097, 18098, 18099, 18100, 18101, 18102, 18103, 
18104, 18105, 18106, 18107, 18108, 18109, 18110, 18111, 18112, 18113, 
18114, 18115, 18116, 18117, 18118, 18119, 18120, 18121, 18122, 18123, 
18124, 18125, 18126, 18127, 18128, 18129, 18130, 18131, 18132, 18133, 
18134, 18135, 18136, 18137, 18138, 18139, 18140, 18141, 18142, 18143, 
18144, 18145, 18146, 18147, 18148, 18149, 18150, 18151, 18152, 18153, 
18154, 18155, 18156, 18157, 18158, 18159, 18160, 18161, 18162, 18163, 
18164, 18165, 18166, 18167, 18168, 18169, 18170, 18171, 18172, 18173, 
18174, 18175, 18176, 18177, 18178, 18179, 18180, 18181, 18182, 18183, 
18184, 18185, 18186, 18187, 18188, 18189, 18190, 18191, 18192, 18193, 
18194, 18195, 18196, 18197, 18198, 18199, 18200, 18201, 18202, 18203, 
18204, 18205, 18206, 18207, 18208, 18209, 18210, 18211, 18212, 18213, 
18214, 18215, 18216, 18217, 18218, 18219, 18220, 18221, 18222, 18223, 
18224, 18225, 18226, 18227, 18228, 18229, 18230, 18231, 18232, 18233, 
18234, 18235, 18236, 18237, 18238, 18239, 18240, 18241, 18242, 18243, 
18244, 18245, 18246, 18247, 18248, 18249, 18250, 18251, 18252, 18253, 
18254, 18255, 18256, 18257, 18258, 18259, 18260, 18261, 18262, 18263, 
18264, 18265, 18266, 18267, 18268, 18269, 18270, 18271, 18272, 18273, 
18274, 18275, 18276, 18277, 18278, 18279, 18280, 18281, 18282, 18283, 
18284, 18285, 18286, 18287, 18288, 18289, 18290, 18291, 18292, 18293, 
18294, 18295, 18296, 18297, 18298, 18299, 18300, 18301, 18302, 18303, 
18304, 18305, 18306, 18307, 18308, 18309, 18310, 18311, 18312, 18313, 
18314, 18315, 18316, 18317, 18318, 18319, 18320, 18321, 18322, 18323, 
18324, 18325, 18326, 18327, 18328, 18329, 18330, 18331, 18332, 18333, 
18334, 18335, 18336, 18337, 18338, 18339, 18340, 18341, 18342, 18343, 
18344, 18345, 18346, 18347, 18348, 18349, 18350, 18351, 18352, 18353, 
18354, 18355, 18356, 18357, 18358, 18359, 18360, 18361, 18362, 18363, 
18364, 18365, 18366, 18367, 18368, 18369, 18370, 18371, 18372, 18373, 
18374, 18375, 18376, 18377, 18378, 18379, 18380, 18381, 18382, 18383, 
18384, 18385, 18386, 18387, 18388, 18389, 18390, 18391, 18392, 18393, 
18394, 18395, 18396, 18397, 18398, 18399, 18400, 18401, 18402, 18403, 
18404, 18405, 18406, 18407, 18408, 18409, 18410, 18411, 18412, 18413, 
18414, 18415, 18416, 18417, 18418, 18419, 18420, 18421, 18422, 18423, 
18424, 18425, 18426, 18427, 18428, 18429, 18430, 18431, 18432, 18433, 
18434, 18435, 18436, 18437, 18438, 18439, 18440, 18441, 18442, 18443, 
18444, 18445, 18446, 18447, 18448, 18449, 18450, 18451, 18452, 18453, 
18454, 18455, 18456, 18457, 18458, 18459, 18460, 18461, 18462, 18463, 
18464, 18465, 18466, 18467, 18468, 18469, 18470, 18471, 18472, 18473, 
18474, 18475, 18476, 18477, 18478, 18479, 18480, 18481, 18482, 18483, 
18484, 18485, 18486, 18487, 18488, 18489, 18490, 18491, 18492, 18493, 
18494, 18495, 18496, 18497, 18498, 18499, 18500, 18501, 18502, 18503, 
18504, 18505, 18506, 18507, 18508, 18509, 18510, 18511, 18512, 18513, 
18514, 18515, 18516, 18517, 18518, 18519, 18520, 18521, 18522, 18523, 
18524, 18525, 18526, 18527, 18528, 18529, 18530, 18531, 18532, 18533, 
18534, 18535, 18536, 18537, 18538, 18539, 18540, 18541, 18542, 18543, 
18544, 18545, 18546, 18547, 18548, 18549, 18550, 18551, 18552, 18553, 
18554, 18555, 18556, 18557, 18558, 18559, 18560, 18561, 18562, 18563, 
18564, 18565, 18566, 18567, 18568, 18569, 18570, 18571, 18572, 18573, 
18574, 18575, 18576, 18577, 18578, 18579, 18580, 18581, 18582, 18583, 
18584, 18585, 18586, 18587, 18588, 18589, 18590, 18591, 18592, 18593, 
18594, 18595, 18596, 18597, 18598, 18599, 18600, 18601, 18602, 18603, 
18604, 18605, 18606, 18607, 18608, 18609, 18610, 18611, 18612, 18613, 
18614, 18615, 18616, 18617, 18618, 18619, 18620, 18621, 18622, 18623, 
18624, 18625, 18626, 18627, 18628, 18629, 18630, 18631, 18632, 18633, 
18634, 18635, 18636, 18637, 18638, 18639, 18640, 18641, 18642, 18643, 
18644, 18645, 18646, 18647, 18648, 18649, 18650, 18651, 18652, 18653, 
18654, 18655, 18656, 18657, 18658, 18659, 18660, 18661, 18662, 18663, 
18664, 18665, 18666, 18667, 18668, 18669, 18670, 18671, 18672, 18673, 
18674, 18675, 18676, 18677, 18678, 18679, 18680, 18681, 18682, 18683, 
18684, 18685, 18686, 18687, 18688, 18689, 18690, 18691, 18692, 18693, 
18694, 18695, 18696, 18697, 18698, 18699, 18700, 18701, 18702, 18703, 
18704, 18705, 18706, 18707, 18708, 18709, 18710, 18711, 18712, 18713, 
18714, 18715, 18716, 18717, 18718, 18719, 18720, 18721, 18722, 18723, 
18724, 18725, 18726, 18727, 18728, 18729, 18730, 18731, 18732, 18733, 
18734, 18735, 18736, 18737, 18738, 18739, 18740, 18741, 18742, 18743, 
18744, 18745, 18746, 18747, 18748, 18749, 18750, 18751, 18752, 18753, 
18754, 18755, 18756, 18757, 18758, 18759, 18760, 18761, 18762, 18763, 
18764, 18765, 18766, 18767, 18768, 18769, 18770, 18771, 18772, 18773, 
18774, 18775, 18776, 18777, 18778, 18779, 18780, 18781, 18782, 18783, 
18784, 18785, 18786, 18787, 18788, 18789, 18790, 18791, 18792, 18793, 
18794, 18795, 18796, 18797, 18798, 18799, 18800, 18801, 18802, 18803, 
18804, 18805, 18806, 18807, 18808, 18809, 18810, 18811, 18812, 18813, 
18814, 18815, 18816, 18817, 18818, 18819, 18820, 18821, 18822, 18823, 
18824, 18825, 18826, 18827, 18828, 18829, 18830, 18831, 18832, 18833, 
18834, 18835, 18836, 18837, 18838, 18839, 18840, 18841, 18842, 18843, 
18844, 18845, 18846, 18847, 18848, 18849, 18850, 18851, 18852, 18853, 
18854, 18855, 18856, 18857, 18858, 18859, 18860, 18861, 18862, 18863, 
18864, 18865, 18866, 18867, 18868, 18869, 18870, 18871, 18872, 18873, 
18874, 18875, 18876, 18877, 18878, 18879, 18880, 18881, 18882, 18883, 
18884, 18885, 18886, 18887, 18888, 18889, 18890, 18891, 18892, 18893, 
18894, 18895, 18896, 18897, 18898, 18899, 18900, 18901, 18902, 18903, 
18904, 18905, 18906, 18907, 18908, 18909, 18910, 18911, 18912, 18913, 
18914, 18915, 18916, 18917, 18918, 18919, 18920, 18921, 18922, 18923, 
18924, 18925, 18926, 18927, 18928, 18929, 18930, 18931, 18932, 18933, 
18934, 18935, 18936, 18937, 18938, 18939, 18940, 18941, 18942, 18943, 
18944, 18945, 18946, 18947, 18948, 18949, 18950, 18951, 18952, 18953, 
18954, 18955, 18956, 18957, 18958, 18959, 18960, 18961, 18962, 18963, 
18964, 18965, 18966, 18967, 18968, 18969, 18970, 18971, 18972, 18973, 
18974, 18975, 18976, 18977, 18978, 18979, 18980, 18981, 18982, 18983, 
18984, 18985, 18986, 18987, 18988, 18989, 18990, 18991, 18992, 18993, 
18994, 18995, 18996, 18997, 18998, 18999, 19000, 19001, 19002, 19003, 
19004, 19005, 19006, 19007, 19008, 19009, 19010, 19011, 19012, 19013, 
19014, 19015, 19016, 19017, 19018, 19019, 19020, 19021, 19022, 19023, 
19024, 19025, 19026, 19027, 19028, 19029, 19030, 19031, 19032, 19033, 
19034, 19035, 19036, 19037, 19038, 19039, 19040, 19041, 19042, 19043, 
19044, 19045, 19046, 19047, 19048, 19049, 19050, 19051, 19052, 19053, 
19054, 19055, 19056, 19057, 19058, 19059, 19060, 19061, 19062, 19063, 
19064, 19065, 19066, 19067, 19068, 19069, 19070, 19071, 19072, 19073, 
19074, 19075, 19076, 19077, 19078, 19079, 19080, 19081, 19082, 19083, 
19084, 19085, 19086, 19087, 19088, 19089, 19090, 19091, 19092, 19093, 
19094, 19095, 19096, 19097, 19098, 19099, 19100, 19101, 19102, 19103, 
19104, 19105, 19106, 19107, 19108, 19109, 19110, 19111, 19112, 19113, 
19114, 19115, 19116, 19117, 19118, 19119, 19120, 19121, 19122, 19123, 
19124, 19125, 19126, 19127, 19128, 19129, 19130, 19131, 19132, 19133, 
19134, 19135, 19136, 19137, 19138, 19139, 19140, 19141, 19142, 19143, 
19144, 19145, 19146, 19147, 19148, 19149, 19150, 19151, 19152, 19153, 
19154, 19155, 19156, 19157, 19158, 19159, 19160, 19161, 19162, 19163, 
19164, 19165, 19166, 19167, 19168, 19169, 19170, 19171, 19172, 19173, 
19174, 19175, 19176, 19177, 19178, 19179, 19180, 19181, 19182, 19183, 
19184, 19185, 19186, 19187, 19188, 19189, 19190, 19191, 19192, 19193, 
19194, 19195, 19196, 19197, 19198, 19199, 19200, 19201, 19202, 19203, 
19204, 19205, 19206, 19207, 19208, 19209, 19210, 19211, 19212, 19213, 
19214, 19215, 19216, 19217, 19218, 19219, 19220, 19221, 19222, 19223, 
19224, 19225, 19226, 19227, 19228, 19229, 19230, 19231, 19232, 19233, 
19234, 19235, 19236, 19237, 19238, 19239, 19240, 19241, 19242, 19243, 
19244, 19245, 19246, 19247, 19248, 19249, 19250, 19251, 19252, 19253, 
19254, 19255, 19256, 19257, 19258, 19259, 19260, 19261, 19262, 19263, 
19264, 19265, 19266, 19267, 19268, 19269, 19270, 19271, 19272, 19273, 
19274, 19275, 19276, 19277, 19278, 19279, 19280, 19281, 19282, 19283, 
19284, 19285, 19286, 19287, 19288, 19289, 19290, 19291, 19292, 19293, 
19294, 19295, 19296, 19297, 19298, 19299, 19300, 19301, 19302, 19303, 
19304, 19305, 19306, 19307, 19308, 19309, 19310, 19311, 19312, 19313, 
19314, 19315, 19316, 19317, 19318, 19319, 19320, 19321, 19322, 19323, 
19324, 19325, 19326, 19327, 19328, 19329, 19330, 19331, 19332, 19333, 
19334, 19335, 19336, 19337, 19338, 19339, 19340, 19341, 19342, 19343, 
19344, 19345, 19346, 19347, 19348, 19349, 19350, 19351, 19352, 19353, 
19354, 19355, 19356, 19357, 19358, 19359, 19360, 19361, 19362, 19363, 
19364, 19365, 19366, 19367, 19368, 19369, 19370, 19371, 19372, 19373, 
19374, 19375, 19376, 19377, 19378, 19379, 19380, 19381, 19382, 19383, 
19384, 19385, 19386, 19387, 19388, 19389, 19390, 19391, 19392, 19393, 
19394, 19395, 19396, 19397, 19398, 19399, 19400, 19401, 19402, 19403, 
19404, 19405, 19406, 19407, 19408, 19409, 19410, 19411, 19412, 19413, 
19414, 19415, 19416, 19417, 19418, 19419, 19420, 19421, 19422, 19423, 
19424, 19425, 19426, 19427, 19428, 19429, 19430, 19431, 19432, 19433, 
19434, 19435, 19436, 19437, 19438, 19439, 19440, 19441, 19442, 19443, 
19444, 19445, 19446, 19447, 19448, 19449, 19450, 19451, 19452, 19453, 
19454, 19455, 19456, 19457, 19458, 19459, 19460, 19461, 19462, 19463, 
19464, 19465, 19466, 19467, 19468, 19469, 19470, 19471, 19472, 19473, 
19474, 19475, 19476, 19477, 19478, 19479, 19480, 19481, 19482, 19483, 
19484, 19485, 19486, 19487, 19488, 19489, 19490, 19491, 19492, 19493, 
19494, 19495, 19496, 19497, 19498, 19499, 19500, 19501, 19502, 19503, 
19504, 19505, 19506, 19507, 19508, 19509, 19510, 19511, 19512, 19513, 
19514, 19515, 19516, 19517, 19518, 19519, 19520, 19521, 19522, 19523, 
19524, 19525, 19526, 19527, 19528, 19529, 19530, 19531, 19532, 19533, 
19534, 19535, 19536, 19537, 19538, 19539, 19540, 19541, 19542, 19543, 
19544, 19545, 19546, 19547, 19548, 19549, 19550, 19551, 19552, 19553, 
19554, 19555, 19556, 19557, 19558, 19559, 19560, 19561, 19562, 19563, 
19564, 19565, 19566, 19567, 19568, 19569, 19570, 19571, 19572, 19573, 
19574, 19575, 19576, 19577, 19578, 19579, 19580, 19581, 19582, 19583, 
19584, 19585, 19586, 19587, 19588, 19589, 19590, 19591, 19592, 19593, 
19594, 19595, 19596, 19597, 19598, 19599, 19600, 19601, 19602, 19603, 
19604, 19605, 19606, 19607, 19608, 19609, 19610, 19611, 19612, 19613, 
19614, 19615, 19616, 19617, 19618, 
*NSET,NSET=Symmetry
1, 3, 5, 7, 11, 12, 15, 16, 19, 20, 
23, 24, 25, 26, 29, 30, 33, 34, 37, 38, 
41, 42, 45, 46, 49, 50, 53, 55, 57, 58, 
61, 62, 79, 80, 81, 83, 87, 88, 89, 91, 
92, 95, 120, 121, 122, 123, 124, 176, 177, 178, 
179, 180, 256, 257, 258, 259, 260, 261, 262, 263, 
264, 265, 266, 267, 268, 269, 270, 271, 272, 273, 
274, 275, 276, 277, 278, 279, 280, 281, 282, 283, 
284, 285, 286, 287, 288, 289, 290, 291, 292, 293, 
294, 295, 296, 297, 298, 299, 300, 301, 302, 350, 
351, 352, 353, 354, 355, 356, 357, 358, 359, 360, 
361, 362, 363, 364, 365, 366, 367, 368, 369, 370, 
371, 372, 373, 374, 375, 376, 377, 378, 379, 380, 
381, 382, 383, 384, 385, 386, 387, 388, 389, 390, 
391, 392, 393, 394, 395, 396, 446, 470, 471, 472, 
473, 474, 475, 476, 477, 478, 479, 480, 481, 482, 
483, 484, 485, 486, 487, 488, 489, 490, 491, 492, 
493, 494, 495, 496, 497, 498, 499, 500, 501, 502, 
503, 504, 505, 506, 507, 508, 509, 510, 511, 512, 
513, 514, 515, 516, 517, 682, 683, 684, 685, 686, 
687, 688, 689, 690, 691, 692, 693, 694, 695, 696, 
697, 698, 699, 700, 701, 702, 703, 704, 705, 706, 
707, 708, 709, 710, 711, 712, 713, 714, 715, 716, 
717, 718, 719, 720, 721, 722, 723, 724, 725, 726, 
727, 728, 752, 753, 754, 755, 756, 757, 758, 759, 
760, 761, 762, 763, 764, 765, 766, 767, 768, 769, 
770, 771, 772, 773, 774, 775, 776, 777, 778, 779, 
780, 781, 782, 783, 784, 785, 786, 787, 788, 789, 
790, 791, 792, 793, 794, 795, 796, 797, 798, 799, 
800, 801, 802, 803, 804, 805, 806, 807, 808, 809, 
810, 811, 812, 813, 814, 815, 816, 817, 818, 819, 
820, 821, 822, 823, 824, 825, 826, 827, 828, 829, 
830, 831, 832, 833, 834, 835, 836, 837, 838, 839, 
840, 841, 842, 843, 844, 845, 918, 942, 943, 944, 
945, 946, 947, 948, 949, 950, 951, 952, 953, 954, 
955, 956, 957, 958, 959, 960, 961, 962, 963, 964, 
965, 966, 967, 968, 969, 970, 971, 972, 973, 974, 
975, 976, 977, 978, 979, 980, 981, 982, 983, 984, 
985, 986, 987, 988, 989, 1070, 1071, 1072, 1073, 1074, 
1098, 1099, 1100, 1101, 1102, 1103, 1104, 1105, 1106, 1107, 
1108, 1109, 1110, 1111, 1112, 1113, 1114, 1115, 1116, 1117, 
1118, 1119, 1120, 1121, 1122, 1123, 1124, 1125, 1126, 1127, 
1128, 1129, 1130, 1131, 1132, 1133, 1134, 1135, 1136, 1137, 
1138, 1139, 1140, 1141, 1142, 1143, 1144, 1145, 1146, 1147, 
1148, 1149, 1173, 1174, 1175, 1176, 1177, 1178, 1179, 1180, 
1181, 1182, 1183, 1184, 1185, 1186, 1187, 1188, 1189, 1190, 
1191, 1192, 1193, 1194, 1195, 1265, 1266, 1267, 1268, 1269, 
1270, 1271, 1272, 1273, 1274, 1275, 1276, 1277, 1278, 1279, 
1280, 1281, 1282, 1283, 1284, 1285, 1286, 1287, 1288, 1289, 
1290, 1291, 1292, 1293, 1294, 1295, 1296, 1297, 1298, 1299, 
1300, 1301, 1302, 1303, 1304, 1305, 1306, 1307, 1308, 1309, 
1310, 1311, 1312, 1313, 1314, 1315, 1316, 1317, 1318, 1319, 
1320, 1321, 1322, 1323, 1324, 1325, 1326, 1327, 1328, 1329, 
1330, 1331, 1332, 1333, 1334, 1335, 1336, 1337, 1338, 1339, 
1340, 1341, 1342, 1343, 1344, 1345, 1346, 1347, 1348, 1349, 
1350, 1351, 1352, 1353, 1354, 1355, 1356, 1357, 1358, 1359, 
1360, 1361, 1362, 1363, 1509, 1510, 1511, 1512, 1513, 1514, 
1515, 1516, 1517, 1518, 1519, 1520, 1521, 1522, 1523, 1524, 
1525, 1526, 1527, 1528, 1529, 1530, 1531, 1532, 1533, 1534, 
1535, 1536, 1537, 1538, 1539, 1540, 1541, 1542, 1543, 1544, 
1545, 1546, 1547, 1548, 1549, 1550, 1551, 1552, 1553, 1554, 
1555, 1556, 1557, 1653, 1654, 1655, 1656, 1657, 1658, 1659, 
1660, 1661, 1662, 1663, 1664, 1665, 1666, 1667, 1668, 1669, 
1670, 1671, 1672, 1673, 1674, 1675, 1676, 1677, 1678, 1679, 
1680, 1681, 1682, 1683, 1684, 1685, 1686, 1687, 1688, 1689, 
1690, 1691, 1692, 1693, 1694, 1695, 1696, 1697, 1698, 1699, 
1700, 1701, 1702, 1703, 1704, 1705, 1706, 1707, 1708, 1709, 
1710, 1711, 1712, 1713, 1714, 1715, 1716, 1717, 1718, 1719, 
1720, 1721, 1722, 1723, 1724, 1725, 1726, 1727, 1728, 1729, 
1730, 1731, 1732, 1733, 1734, 1735, 1736, 1737, 1738, 1739, 
1740, 1741, 1742, 1743, 1744, 1745, 1746, 1747, 1748, 1749, 
1750, 1751, 1752, 1753, 1754, 1755, 1756, 1757, 1758, 1759, 
1760, 1761, 1762, 1763, 1764, 1765, 1766, 1767, 1768, 1769, 
1770, 1771, 1772, 1773, 1774, 1775, 1776, 1777, 1778, 1779, 
1780, 1781, 1782, 1783, 1784, 1785, 1786, 1787, 1788, 1789, 
1790, 1791, 1792, 1793, 1981, 1982, 1983, 1984, 1985, 1986, 
1987, 1988, 1989, 1990, 1991, 1992, 1993, 1994, 1995, 1996, 
1997, 1998, 1999, 2000, 2001, 2002, 2003, 2004, 2005, 2006, 
2007, 2008, 2009, 2010, 2011, 2012, 2013, 2014, 2015, 2016, 
2017, 2018, 2019, 2020, 2021, 2022, 2023, 2024, 2025, 2026, 
2027, 2028, 2029, 2125, 2126, 2127, 2128, 2129, 2130, 2131, 
2132, 2133, 2134, 2135, 2136, 2137, 2138, 2139, 2140, 2141, 
2142, 2143, 2144, 2145, 2146, 2147, 2148, 2149, 2150, 2151, 
2152, 2153, 2154, 2155, 2156, 2157, 2158, 2159, 2160, 2161, 
2162, 2163, 2164, 2165, 2166, 2167, 2168, 2169, 2170, 2171, 
2172, 2173, 2174, 2175, 2176, 2177, 2178, 2179, 2180, 2181, 
2285, 2286, 2287, 2288, 2289, 2290, 2291, 2345, 2370, 2371, 
2372, 2373, 2374, 2375, 2405, 2406, 2407, 2408, 2409, 2410, 
2411, 2412, 2413, 2414, 2415, 2416, 2417, 2418, 2419, 2420, 
2421, 2422, 2423, 2424, 2425, 2426, 2427, 2428, 2429, 2430, 
2431, 2432, 2433, 2434, 2435, 2436, 2437, 2438, 2439, 2440, 
2441, 2442, 2443, 2444, 2445, 2446, 2447, 2448, 2449, 2450, 
2451, 2452, 2453, 2549, 2550, 2551, 2552, 2553, 2554, 2555, 
2556, 2557, 2558, 2559, 2560, 2561, 2562, 2563, 2564, 2565, 
2566, 2567, 2568, 2569, 2570, 2571, 2572, 2573, 2574, 2575, 
2576, 2577, 2578, 2579, 2580, 2581, 2582, 2583, 2584, 2585, 
2586, 2587, 2588, 2589, 2590, 2591, 2592, 2593, 2594, 2595, 
2596, 2597, 3244, 3245, 3246, 3247, 3248, 3249, 3250, 3251, 
3252, 3276, 3277, 3278, 3279, 3280, 3281, 3282, 3283, 3284, 
3285, 3286, 3287, 3288, 3289, 3290, 3291, 3292, 3293, 3294, 
3295, 3296, 3297, 3298, 3299, 3300, 3301, 3302, 3303, 3304, 
3305, 3306, 3307, 3308, 3309, 3310, 3311, 3312, 3313, 3314, 
3315, 3316, 3317, 3318, 3319, 3320, 3321, 3322, 3323, 3324, 
3325, 3326, 3327, 3328, 3329, 3330, 3331, 3355, 3356, 3357, 
3358, 3359, 3360, 3361, 3362, 3363, 3364, 3365, 3366, 3367, 
3368, 3369, 3370, 3371, 3372, 3414, 3415, 3416, 3417, 3418, 
3419, 3420, 3421, 3422, 3423, 3424, 3425, 3426, 3427, 3428, 
3429, 3430, 3431, 3432, 3433, 3434, 3435, 3436, 3437, 3438, 
3439, 3440, 3441, 3442, 3443, 3444, 3445, 3446, 3447, 3448, 
3449, 3450, 3451, 3452, 3453, 3454, 3455, 3456, 3457, 3458, 
3459, 3460, 3461, 3462, 3463, 3464, 3465, 3466, 3467, 3468, 
3469, 3614, 3615, 3616, 3617, 3618, 3619, 3620, 3621, 3622, 
3646, 3647, 3648, 3649, 3650, 3651, 3652, 3653, 3654, 3655, 
3656, 3657, 3658, 3659, 3660, 3661, 3662, 3663, 3664, 3665, 
3666, 3667, 3668, 3669, 3670, 3671, 3672, 3673, 3674, 3675, 
3676, 3677, 3678, 3679, 3680, 3681, 3682, 3683, 3684, 3685, 
3686, 3687, 3688, 3689, 3690, 3691, 3692, 3693, 3694, 3695, 
3696, 3697, 3698, 3699, 3700, 3701, 3725, 3726, 3727, 3728, 
3729, 3730, 3731, 3732, 3733, 3734, 3768, 3769, 3770, 3771, 
3772, 3773, 3774, 3775, 3776, 3777, 3778, 3779, 3780, 3781, 
3782, 3783, 3784, 3785, 3786, 3787, 3788, 3789, 3790, 3791, 
3792, 3793, 3794, 3795, 3796, 3797, 3798, 3799, 3800, 3801, 
3802, 3803, 3804, 3805, 3806, 3807, 3808, 3809, 3810, 3811, 
3812, 3813, 3814, 3815, 3816, 3817, 3818, 3819, 3820, 3821, 
3822, 3823, 3824, 3825, 3826, 3827, 3828, 3829, 3830, 3831, 
3832, 3944, 3945, 3946, 3947, 3948, 3949, 3950, 3951, 3952, 
3953, 5894, 5895, 5896, 5897, 5898, 5899, 5900, 5901, 5902, 
5903, 5904, 5905, 5906, 5907, 5908, 5909, 5910, 5911, 5912, 
5913, 5914, 5915, 5916, 5917, 5918, 5919, 5920, 5921, 5922, 
5923, 5924, 5925, 5926, 5927, 5928, 5929, 5930, 5931, 5932, 
5933, 5934, 5935, 5936, 5937, 5938, 5939, 5940, 5941, 5942, 
5943, 5944, 5945, 5946, 5947, 5948, 5949, 5950, 5951, 5952, 
5953, 5954, 5955, 5956, 5957, 5958, 5959, 5960, 5961, 5962, 
5963, 5964, 5965, 5966, 5967, 5968, 5969, 5970, 5971, 5972, 
5973, 5974, 5975, 5976, 5977, 5978, 5979, 5980, 5981, 5982, 
5983, 5984, 5985, 5986, 5987, 5988, 5989, 5990, 5991, 5992, 
5993, 5994, 5995, 5996, 5997, 5998, 5999, 6000, 6001, 6002, 
6003, 6004, 6005, 6006, 6007, 6008, 6009, 6010, 6011, 6012, 
6013, 6014, 6015, 6016, 6017, 6018, 6019, 6020, 6021, 6022, 
6023, 6024, 6025, 6026, 6027, 6028, 6029, 6030, 6031, 6032, 
6033, 6034, 6035, 6036, 6037, 6038, 6039, 6040, 6041, 6042, 
6043, 6044, 6045, 6046, 6047, 6048, 6049, 6050, 6051, 6052, 
6053, 6054, 6055, 6056, 6091, 6092, 6093, 6094, 6095, 6096, 
6097, 6098, 6099, 6100, 6101, 6102, 6103, 6104, 6105, 6106, 
6107, 6108, 6109, 6110, 6111, 6112, 6113, 9344, 9345, 9346, 
9347, 9348, 9349, 9350, 9351, 9352, 9353, 9354, 9355, 9356, 
9357, 9358, 9359, 9360, 9361, 9362, 9363, 9364, 9365, 9366, 
9367, 9368, 9369, 9370, 9371, 9372, 9373, 9374, 9375, 9376, 
9377, 9378, 9379, 9380, 9381, 9382, 9383, 9384, 9385, 9386, 
9387, 9388, 9389, 9390, 9391, 9392, 9393, 9394, 9395, 9396, 
9397, 9398, 9399, 9400, 9401, 9402, 9403, 9404, 9405, 9406, 
9407, 9408, 9409, 9410, 9411, 9412, 9413, 9414, 9415, 9416, 
9417, 9418, 9419, 9420, 9421, 9422, 9423, 9424, 9425, 9426, 
9427, 9428, 9429, 9430, 9431, 9432, 9433, 9434, 9435, 9436, 
9437, 9438, 9439, 9440, 9441, 9442, 9443, 9444, 9445, 9446, 
9447, 9448, 9449, 9450, 9451, 9452, 9453, 9454, 9455, 9456, 
9457, 9458, 9459, 9460, 9461, 9462, 9463, 9464, 9465, 9466, 
9467, 9468, 9469, 9470, 9471, 9472, 9473, 9474, 9475, 9476, 
9477, 9478, 9479, 9480, 9481, 9482, 9483, 9484, 9485, 9486, 
9487, 9488, 9489, 9490, 9491, 9492, 9493, 9494, 9495, 9496, 
9497, 9498, 9499, 9500, 9501, 9502, 9503, 9504, 9505, 9506, 
9507, 9508, 9509, 9510, 9511, 9512, 9513, 9514, 9515, 9516, 
9517, 9518, 9519, 9520, 9521, 9522, 9523, 9524, 9525, 9526, 
9527, 9528, 9529, 9530, 9531, 9532, 9533, 9534, 9535, 9536, 
9537, 9538, 9539, 9540, 9541, 9542, 9543, 9544, 9545, 9546, 
9547, 9548, 9549, 9550, 9551, 9552, 9553, 9554, 9555, 9556, 
9557, 9558, 9559, 9560, 9561, 9562, 9563, 9564, 9565, 9566, 
9567, 9568, 9569, 9570, 9571, 9572, 9573, 9574, 9575, 9576, 
9577, 9578, 9579, 9580, 9581, 9582, 9583, 9584, 9585, 9586, 
9587, 9588, 9589, 9590, 9591, 9592, 9593, 9594, 9595, 9596, 
9597, 9598, 9599, 9600, 9601, 9602, 9603, 9604, 9605, 9606, 
9607, 9608, 9609, 9610, 9611, 9612, 9613, 9614, 9615, 9616, 
9617, 9618, 9619, 9620, 9621, 9622, 9623, 9624, 9625, 9626, 
9627, 9628, 9629, 9630, 9631, 9632, 9633, 9634, 9635, 9636, 
9637, 9638, 9639, 9640, 9641, 9642, 9643, 9644, 9645, 9646, 
9647, 9648, 9649, 9650, 9651, 9652, 9653, 9654, 9655, 9656, 
9657, 9658, 9659, 9660, 9661, 9662, 9663, 9664, 9665, 9666, 
9667, 9668, 9669, 9670, 9671, 9672, 9673, 9674, 9675, 9676, 
9677, 9678, 9679, 9680, 9681, 9682, 9683, 9684, 9685, 9686, 
9687, 9688, 9689, 9690, 9691, 9692, 9693, 9694, 9695, 9696, 
9697, 9698, 9699, 9700, 9701, 9702, 9703, 9704, 9705, 9706, 
9707, 9708, 9709, 9710, 9711, 9712, 9713, 9714, 9715, 9716, 
9717, 9718, 9719, 9720, 9721, 9722, 9723, 9724, 9725, 9726, 
9727, 9728, 9729, 9730, 9731, 9732, 9733, 9734, 9735, 9736, 
9737, 9738, 9739, 9740, 9741, 9742, 9743, 9744, 9745, 9746, 
9747, 9748, 9749, 9750, 9751, 9752, 9753, 9754, 9755, 9756, 
9757, 9758, 9759, 9760, 9761, 9762, 9763, 9764, 9765, 9766, 
9767, 9768, 9769, 9770, 9771, 9772, 9773, 9774, 9775, 9776, 
9777, 9778, 9779, 9780, 9781, 9782, 9783, 9784, 9785, 9786, 
9787, 9788, 9789, 9790, 9791, 9792, 9793, 9794, 9795, 9796, 
9797, 9798, 9799, 9800, 9801, 9802, 9803, 9804, 9805, 9806, 
9807, 9808, 9809, 9810, 9811, 9812, 9813, 9814, 9815, 9816, 
9817, 9818, 9819, 9820, 9821, 9822, 9823, 9824, 9825, 9826, 
9827, 9828, 9829, 9830, 9831, 9832, 9833, 9834, 9835, 9836, 
9837, 9838, 9839, 9840, 9841, 9842, 9843, 9844, 9845, 9846, 
9847, 9848, 9849, 9850, 9851, 9852, 9853, 9854, 9855, 9856, 
9857, 9858, 9859, 9860, 9861, 9862, 9863, 9864, 9865, 9866, 
9867, 9868, 9869, 9870, 9871, 9872, 9873, 9874, 9875, 9876, 
9877, 9878, 9879, 9880, 9881, 9882, 9883, 9884, 9885, 9886, 
9887, 9888, 9889, 9890, 9891, 9892, 9893, 9894, 9895, 9896, 
9897, 9898, 9899, 9900, 9901, 9902, 9903, 9904, 9905, 9906, 
9907, 9908, 9909, 9910, 9911, 9912, 9913, 9914, 9915, 9916, 
9917, 9918, 9919, 9920, 9921, 9922, 9923, 9924, 9925, 9926, 
9927, 9928, 9929, 9930, 9931, 9932, 9933, 9934, 9935, 9936, 
9937, 9938, 9939, 9940, 9941, 9942, 9943, 9944, 9945, 9946, 
9947, 9948, 9949, 9950, 9951, 9952, 9953, 9954, 9955, 9956, 
9957, 9958, 9959, 9960, 9961, 9962, 9963, 9964, 9965, 9966, 
9967, 9968, 9969, 9970, 9971, 9972, 9973, 9974, 9975, 9976, 
9977, 9978, 9979, 9980, 9981, 9982, 9983, 9984, 9985, 9986, 
9987, 9988, 9989, 9990, 9991, 9992, 9993, 9994, 9995, 9996, 
9997, 9998, 9999, 10000, 10001, 10002, 10003, 10004, 10005, 10006, 
10007, 10008, 10009, 10010, 10011, 10012, 10013, 10014, 10015, 10016, 
10017, 10018, 10019, 10020, 10021, 10022, 10023, 10024, 10025, 10026, 
10027, 10028, 10029, 10030, 10031, 10032, 10033, 10034, 10035, 10036, 
10037, 10038, 10039, 10040, 10041, 10042, 10043, 10044, 10045, 10046, 
10047, 10048, 10049, 10050, 10051, 10052, 10053, 10054, 10055, 10056, 
10057, 10058, 10059, 10060, 10061, 10062, 10063, 10064, 10065, 10066, 
10067, 10068, 10069, 10070, 10071, 10072, 10073, 10074, 10075, 10076, 
10077, 10078, 10079, 10080, 10081, 10082, 10083, 10084, 10085, 10086, 
10087, 10088, 10089, 10090, 10091, 10092, 10093, 10094, 10095, 10096, 
10097, 10098, 10099, 10100, 10101, 10102, 10103, 10104, 10105, 10106, 
10107, 10108, 10109, 10110, 10111, 10112, 10113, 10114, 10115, 10116, 
10117, 10118, 10119, 10120, 10121, 10122, 10123, 10124, 10125, 10126, 
10127, 10128, 10129, 10130, 10131, 10132, 10133, 10134, 10135, 10136, 
10137, 10138, 10139, 10140, 10141, 10142, 10143, 10144, 10145, 10146, 
10147, 10148, 10149, 10150, 10151, 10152, 10153, 10154, 10155, 10156, 
10157, 10158, 10159, 10160, 10161, 10162, 10163, 10164, 10165, 10166, 
10167, 10168, 10169, 10170, 10171, 10172, 10173, 10174, 10175, 10176, 
10177, 10178, 10179, 10180, 10181, 10182, 10183, 10184, 10185, 10186, 
10187, 10188, 10189, 10190, 10191, 10192, 10193, 10194, 10195, 10196, 
10197, 10198, 10199, 10200, 10201, 10202, 10203, 10204, 10205, 10206, 
10207, 10208, 10209, 10210, 10211, 10212, 10213, 10214, 10215, 10216, 
10217, 10218, 10219, 10220, 10221, 10222, 10223, 10224, 10225, 10226, 
10227, 10228, 10229, 10230, 10231, 10232, 10233, 10234, 10235, 10236, 
10237, 10238, 10239, 10240, 10241, 10242, 10243, 10244, 10245, 10246, 
10247, 10248, 10249, 10250, 10251, 10252, 10253, 10254, 10255, 10256, 
10257, 10258, 10259, 10260, 10261, 10262, 10263, 10264, 10265, 10266, 
10267, 10268, 10269, 10270, 10271, 10272, 10273, 10274, 10275, 10276, 
10277, 10278, 10279, 10280, 10281, 10282, 10283, 10284, 10285, 10286, 
10287, 10288, 10289, 10290, 10291, 10292, 10293, 10294, 10295, 10296, 
10297, 10298, 10299, 10300, 10301, 10302, 10303, 10304, 10305, 10306, 
10307, 10308, 10309, 10310, 10311, 10312, 10313, 10314, 10315, 10316, 
10317, 10318, 10319, 10320, 10321, 10322, 10323, 10324, 10325, 10326, 
10327, 10328, 10329, 10330, 10331, 10332, 10333, 10334, 10335, 10336, 
10337, 10338, 10339, 10340, 10341, 10342, 10343, 10344, 10345, 10346, 
10347, 10348, 10349, 10350, 10351, 10352, 10353, 10354, 10355, 10356, 
10357, 10358, 10359, 10360, 10361, 10362, 10363, 10364, 10365, 10366, 
10367, 10368, 10369, 10370, 10371, 10372, 10373, 10374, 10375, 10376, 
10377, 10378, 10379, 10380, 10381, 10382, 10383, 10384, 10385, 10386, 
10387, 10388, 10389, 10390, 10391, 10392, 10393, 10394, 10395, 10396, 
10397, 10398, 10399, 10400, 10401, 10402, 10403, 10404, 10405, 10406, 
10407, 10408, 10409, 10410, 10411, 10412, 10413, 10414, 10415, 10416, 
10417, 10418, 10419, 10420, 10421, 10422, 10423, 10424, 10425, 10426, 
10427, 10428, 10429, 10430, 10431, 10432, 10433, 10434, 10435, 10436, 
10437, 10438, 10439, 10440, 10441, 10442, 10443, 10444, 10445, 10446, 
10447, 10448, 10449, 10450, 10451, 10452, 10453, 10454, 10455, 10456, 
10457, 10458, 10459, 10460, 10461, 10462, 10463, 10464, 10465, 10466, 
10467, 10468, 10469, 10470, 10471, 10472, 10473, 10474, 10475, 10476, 
10477, 10478, 10479, 10480, 10481, 10482, 10483, 10484, 10485, 10486, 
10487, 10488, 10489, 10490, 10491, 10492, 10493, 10494, 10495, 10496, 
10497, 10498, 10499, 10500, 10501, 10502, 10503, 10504, 10505, 10506, 
10507, 10508, 10509, 10510, 10511, 10512, 10513, 10514, 10515, 10516, 
10517, 10518, 10519, 10520, 10521, 10522, 10523, 10524, 10525, 10526, 
10527, 10528, 10529, 10530, 10531, 10532, 10533, 10534, 10535, 10536, 
10537, 10538, 10539, 10540, 10541, 10542, 10543, 10544, 10545, 10546, 
10547, 10548, 10549, 10550, 10551, 10552, 10553, 10554, 10555, 10556, 
10557, 10558, 10559, 10560, 10561, 10562, 10563, 10564, 10565, 10566, 
10567, 10568, 10569, 10570, 10571, 10572, 10573, 10574, 10575, 10576, 
10577, 10578, 10579, 10580, 10581, 10582, 10583, 10584, 10585, 10586, 
10587, 10588, 10589, 10590, 10591, 10592, 10593, 10594, 10595, 10596, 
10597, 10598, 10599, 10600, 10601, 10602, 10603, 10604, 10605, 10606, 
10607, 10608, 10609, 10610, 10611, 10612, 10613, 10614, 10615, 10616, 
10617, 10618, 10619, 10620, 10621, 10622, 10623, 10624, 10625, 10626, 
10627, 10628, 10629, 10630, 10631, 10632, 10633, 10634, 10635, 10636, 
10637, 10638, 10639, 10640, 10641, 10642, 10643, 10644, 10645, 10646, 
10647, 10648, 10649, 10650, 10651, 10652, 10653, 10654, 10655, 10656, 
10657, 10658, 10659, 10660, 10661, 10662, 10663, 10664, 10665, 10666, 
10667, 10668, 10669, 10670, 10671, 10672, 10673, 10674, 10675, 10676, 
10677, 10678, 10679, 10680, 10681, 10682, 10683, 10684, 10685, 10686, 
10687, 10688, 10689, 10690, 10691, 10692, 10693, 10694, 10695, 10696, 
10697, 10698, 10699, 10700, 10701, 10702, 10703, 10704, 10705, 10706, 
10707, 10708, 10709, 10710, 10711, 10712, 10713, 10714, 10715, 10716, 
10717, 10718, 10719, 10720, 10721, 10722, 10723, 10724, 10725, 10726, 
10727, 10728, 10729, 10730, 10731, 10732, 10733, 10734, 10735, 10736, 
10737, 10738, 10739, 10740, 10741, 10742, 10743, 10744, 10745, 10746, 
10747, 10748, 10749, 10750, 10751, 10752, 10753, 10754, 10755, 10756, 
10757, 10758, 10759, 10760, 10761, 10762, 10763, 10764, 10765, 10766, 
10767, 10768, 10769, 10770, 10771, 10772, 10773, 10774, 10775, 10776, 
10777, 10778, 10779, 10780, 10781, 10782, 10783, 10784, 10785, 10786, 
10787, 10788, 10789, 10790, 10791, 10792, 10793, 10794, 10795, 10796, 
10797, 10798, 10799, 10800, 10801, 10802, 10803, 10804, 10805, 10806, 
10807, 10808, 10809, 10810, 10811, 10812, 10813, 10814, 10815, 10816, 
10817, 10818, 10819, 10820, 10821, 10822, 10823, 10824, 10825, 10826, 
10827, 10828, 10829, 10830, 10831, 10832, 10833, 10834, 10835, 10836, 
10837, 10838, 10839, 10840, 10841, 10842, 10843, 10844, 10845, 10846, 
10847, 10848, 10849, 10850, 10851, 10852, 10853, 10854, 10855, 10856, 
10857, 10858, 10859, 10860, 10861, 10862, 10863, 10864, 10865, 10866, 
10867, 10868, 10869, 10870, 10871, 10872, 10873, 10874, 10875, 10876, 
10877, 10878, 10879, 10880, 10881, 10882, 10883, 10884, 10885, 10886, 
10887, 10888, 10889, 10890, 10891, 10892, 10893, 10894, 10895, 10896, 
10897, 10898, 10899, 10900, 10901, 10902, 10903, 10904, 10905, 10906, 
10907, 10908, 10909, 10910, 10911, 10912, 10913, 10914, 10915, 10916, 
10917, 10918, 10919, 10920, 10921, 10922, 10923, 10924, 10925, 10926, 
10927, 10928, 10929, 10930, 10931, 10932, 10933, 10934, 10935, 10936, 
10937, 10938, 10939, 10940, 10941, 10942, 10943, 10944, 10945, 10946, 
10947, 10948, 10949, 10950, 10951, 10952, 10953, 10954, 10955, 10956, 
10957, 10958, 10959, 10960, 10961, 10962, 10963, 10964, 10965, 10966, 
10967, 10968, 10969, 10970, 10971, 10972, 10973, 10974, 10975, 10976, 
12597, 12598, 12599, 12600, 12601, 12602, 12603, 12604, 12605, 12606, 
12607, 12608, 12609, 12610, 12611, 12612, 12613, 12614, 12615, 12616, 
12617, 12618, 12619, 13666, 13667, 13668, 13669, 13670, 13671, 13672, 
13673, 13674, 13675, 13676, 13677, 13678, 13679, 13680, 13681, 13682, 
13683, 13684, 13685, 13686, 13687, 13688, 13689, 13690, 13691, 13692, 
13693, 13694, 13695, 13696, 13697, 13698, 13699, 13700, 13701, 13702, 
13703, 13704, 13705, 13706, 13707, 13708, 13709, 13710, 13711, 13712, 
13713, 13714, 13715, 13716, 13717, 13718, 13719, 13720, 13721, 13722, 
13723, 13724, 13725, 13726, 13727, 13728, 13729, 13730, 13731, 13732, 
13733, 13734, 13735, 13736, 13737, 13738, 13739, 13740, 13741, 13742, 
13743, 13744, 13745, 13746, 13747, 13748, 13749, 13750, 13751, 13752, 
13753, 13754, 13755, 13756, 13757, 13758, 13759, 13760, 13761, 13762, 
13763, 13764, 13765, 13766, 13767, 13768, 13769, 13770, 13771, 13772, 
13773, 13774, 13775, 13776, 13777, 13778, 13779, 13780, 13781, 13782, 
13783, 13784, 13785, 13786, 13787, 13788, 13789, 13790, 13791, 13792, 
13793, 13794, 13795, 13796, 13797, 13798, 13799, 13800, 13801, 13802, 
13803, 13804, 13805, 13806, 13807, 13808, 13809, 13810, 13811, 13812, 
13813, 13814, 13815, 13816, 13817, 13818, 13819, 13820, 13821, 13822, 
13823, 13824, 13825, 13826, 13827, 13828, 14701, 14702, 14703, 14704, 
14705, 14706, 14707, 14708, 14709, 14710, 14711, 14712, 14713, 14714, 
14715, 14716, 14717, 14718, 14719, 14720, 14721, 14722, 14723, 14724, 
14725, 14726, 14727, 14728, 14729, 14730, 15134, 15135, 15136, 15137, 
15138, 15139, 15140, 15141, 15142, 15143, 15144, 15145, 15146, 15147, 
15148, 15149, 15150, 15151, 15152, 15153, 15154, 15155, 15156, 15157, 
15158, 15159, 15160, 15161, 15162, 15163, 15164, 15165, 15166, 15167, 
15168, 15169, 15170, 15171, 15172, 15173, 15174, 15175, 15176, 15177, 
15178, 15179, 15180, 15181, 15182, 15183, 15184, 15185, 15186, 15187, 
15188, 15189, 15190, 15191, 15192, 15193, 15194, 15195, 15196, 15197, 
15198, 15199, 15200, 15201, 15202, 15203, 15204, 15205, 15206, 15207, 
15208, 15209, 15210, 15211, 15212, 15213, 15214, 15215, 15216, 15217, 
15218, 15219, 15220, 15221, 15222, 15223, 15224, 15225, 15226, 15227, 
15228, 15229, 15230, 15231, 15232, 15233, 15234, 15235, 15236, 15237, 
15238, 15239, 15240, 15241, 15242, 15243, 15244, 15245, 15246, 15247, 
15248, 15249, 15250, 15251, 15252, 15253, 15254, 15255, 15256, 15257, 
15258, 15259, 15260, 15261, 15262, 15263, 15264, 15265, 15266, 15267, 
15268, 15269, 15270, 15271, 15272, 15273, 15274, 15275, 15276, 15277, 
15278, 15279, 15280, 15281, 15282, 15283, 15284, 15285, 15286, 15287, 
15288, 15289, 15290, 15291, 15292, 15293, 15294, 15295, 15296, 17125, 
17126, 17127, 17128, 17129, 17130, 17131, 17132, 17133, 17134, 17135, 
17136, 17137, 17138, 17139, 17140, 17141, 17142, 17143, 17144, 17145, 
17146, 17147, 17986, 17987, 17988, 17989, 17990, 17991, 17992, 17993, 
17994, 17995, 17996, 17997, 17998, 17999, 18000, 18001, 18002, 18003, 
18004, 18005, 18006, 18007, 18008, 18009, 18010, 18011, 18012, 18013, 
18014, 18015, 18016, 18017, 18018, 18019, 18020, 18021, 18022, 18023, 
18024, 18025, 18026, 18027, 18028, 18029, 18030, 18031, 18032, 18033, 
18034, 18035, 18036, 18037, 18038, 18039, 18040, 18041, 18042, 18043, 
18044, 18045, 18046, 18047, 18048, 18049, 18050, 18051, 18052, 18053, 
18054, 18055, 18056, 18057, 18058, 18059, 18060, 18061, 18062, 18063, 
18064, 18065, 18066, 18067, 18068, 18069, 18070, 18071, 18072, 18073, 
18074, 18075, 18076, 18077, 18078, 18079, 18080, 18081, 18082, 18083, 
18084, 18085, 18086, 18087, 18088, 18089, 18090, 18091, 18092, 18093, 
18094, 18095, 18096, 18097, 18098, 18099, 18100, 18101, 18102, 18103, 
18104, 18105, 18106, 18107, 18108, 18109, 18110, 18111, 18112, 18113, 
18114, 18115, 18116, 18117, 18118, 18119, 18120, 18121, 18122, 18123, 
18124, 18125, 18126, 18127, 18128, 18129, 18130, 18131, 18132, 18133, 
18134, 18135, 18136, 18137, 18138, 18139, 18140, 18141, 18142, 18143, 
18144, 18145, 18146, 18147, 18148, 18149, 18150, 18151, 18152, 18153, 
18154, 18155, 18156, 18157, 18158, 18159, 18160, 18161, 18162, 18163, 
18164, 18165, 18166, 18167, 18168, 18169, 18170, 18171, 18172, 18173, 
18174, 18175, 18176, 18177, 18178, 18179, 18180, 18181, 18182, 18183, 
18184, 18185, 18186, 18187, 18188, 18189, 18190, 18191, 18192, 18193, 
18194, 18195, 18196, 18197, 18198, 18199, 18200, 18201, 18202, 18203, 
18204, 18205, 18206, 18207, 18208, 18209, 18210, 18211, 18212, 18213, 
18214, 18215, 18216, 18217, 18218, 18219, 18220, 18221, 18222, 18223, 
18224, 18225, 18226, 18227, 18228, 18229, 18230, 18231, 18232, 18233, 
18234, 18235, 18236, 18237, 18238, 18239, 18240, 18241, 18242, 18243, 
18244, 18245, 18246, 18247, 18248, 18249, 18250, 18251, 18252, 18253, 
18254, 18255, 18256, 18257, 18258, 18259, 18260, 18261, 18262, 18263, 
18264, 18265, 18266, 18267, 18268, 18269, 18270, 18271, 18272, 18273, 
18274, 18275, 18276, 18277, 18278, 18279, 18280, 18281, 18282, 18283, 
18284, 18285, 18286, 18287, 18288, 18289, 18290, 18291, 18292, 18293, 
18294, 18295, 18296, 18297, 18298, 18299, 18300, 18301, 18302, 18303, 
18304, 18305, 18306, 18307, 18308, 18309, 18310, 18311, 18312, 18313, 
18314, 18315, 18316, 18317, 18318, 18319, 18320, 18321, 18322, 18323, 
18324, 18325, 18326, 18327, 18328, 18329, 18330, 18331, 18332, 18333, 
18334, 18335, 18336, 18337, 18338, 18339, 18340, 18341, 18342, 18343, 
18344, 18345, 18346, 18347, 18348, 18349, 18350, 18351, 18352, 18353, 
18354, 18355, 18356, 18357, 18358, 18359, 18360, 18361, 18362, 18363, 
18364, 18365, 18366, 18367, 18368, 18369, 18370, 18371, 18372, 18373, 
18374, 18375, 18376, 18377, 18378, 18379, 18380, 18381, 18382, 18383, 
18384, 18385, 18386, 18387, 18388, 18389, 18390, 18391, 18392, 18393, 
18394, 18395, 18396, 18397, 18398, 18399, 18400, 18401, 18402, 18403, 
18404, 18405, 18406, 18407, 18408, 18409, 18410, 18411, 18412, 18413, 
18414, 18415, 18416, 18417, 18418, 18419, 18420, 18421, 18422, 18423, 
18424, 18425, 18426, 18427, 18428, 18429, 18430, 18431, 18432, 18433, 
18434, 18435, 18436, 18437, 18438, 18439, 18440, 18441, 18442, 18443, 
18444, 18445, 18446, 18447, 18448, 18449, 18450, 18451, 18452, 18453, 
18454, 18455, 18456, 18457, 18458, 18459, 18460, 18461, 18462, 18463, 
18464, 18465, 18466, 18467, 18468, 18469, 18470, 18471, 18472, 18473, 
18474, 18475, 18476, 18477, 18478, 18479, 18480, 18481, 18482, 18483, 
18484, 18485, 18486, 18487, 18488, 18489, 18490, 18491, 18492, 18493, 
18494, 18495, 18496, 18497, 18498, 18499, 18500, 18501, 18502, 18503, 
18504, 18505, 18506, 18507, 18508, 18509, 18510, 18511, 18512, 18513, 
18514, 18515, 18516, 18517, 18518, 18519, 18520, 18521, 18522, 18523, 
18524, 18525, 18526, 18527, 18528, 18529, 18530, 18531, 18532, 18533, 
18534, 18535, 18536, 18537, 18538, 18539, 18540, 18541, 18542, 18543, 
18544, 18545, 18546, 18547, 18548, 18549, 18550, 18551, 18552, 18553, 
18554, 18555, 18556, 18557, 18558, 18559, 18560, 18561, 18562, 18563, 
18564, 18565, 18566, 18567, 18568, 18569, 18570, 18571, 18572, 18573, 
18574, 18575, 18576, 18577, 18578, 18579, 18580, 18581, 18582, 18583, 
18584, 18585, 18586, 18587, 18588, 18589, 18590, 18591, 18592, 18593, 
18594, 18595, 18596, 18597, 18598, 18599, 18600, 18601, 18602, 18603, 
18604, 18605, 18606, 18607, 18608, 18609, 18610, 18611, 18612, 18613, 
18614, 18615, 18616, 18617, 18618, 18619, 18620, 18621, 18622, 18623, 
18624, 18625, 18626, 18627, 18628, 18629, 18630, 18631, 18632, 18633, 
18634, 18635, 18636, 18637, 18638, 18639, 18640, 18641, 18642, 18643, 
18644, 18645, 18646, 18647, 18648, 18649, 18650, 18651, 18652, 18653, 
18654, 18655, 18656, 18657, 18658, 18659, 18660, 18661, 18662, 18663, 
18664, 18665, 18666, 18667, 18668, 18669, 18670, 18671, 18672, 18673, 
18674, 18675, 18676, 18677, 18678, 18679, 18680, 18681, 18682, 18683, 
18684, 18685, 18686, 18687, 18688, 18689, 18690, 18691, 18692, 18693, 
18694, 18695, 18696, 18697, 18698, 18699, 18700, 18701, 18702, 18703, 
18704, 18705, 18706, 18707, 18708, 18709, 18710, 18711, 18712, 18713, 
18714, 18715, 18716, 18717, 18718, 18719, 18720, 18721, 18722, 18723, 
18724, 18725, 18726, 18727, 18728, 18729, 18730, 18731, 18732, 18733, 
18734, 18735, 18736, 18737, 18738, 18739, 18740, 18741, 18742, 18743, 
18744, 18745, 18746, 18747, 18748, 18749, 18750, 18751, 18752, 18753, 
18754, 18755, 18756, 18757, 18758, 18759, 18760, 18761, 18762, 18763, 
18764, 18765, 18766, 18767, 18768, 18769, 18770, 18771, 18772, 18773, 
18774, 18775, 18776, 18777, 18778, 18779, 18780, 18781, 18782, 18783, 
18784, 18785, 18786, 18787, 18788, 18789, 18790, 18791, 18792, 18793, 
18794, 18795, 18796, 18797, 18798, 18799, 18800, 18801, 18802, 18803, 
18804, 18805, 18806, 18807, 18808, 18809, 18810, 18811, 18812, 18813, 
18814, 18815, 18816, 18817, 18818, 18819, 18820, 18821, 18822, 18823, 
18824, 18825, 18826, 18827, 18828, 18829, 18830, 18831, 18832, 18833, 
18834, 18835, 18836, 18837, 18838, 18839, 18840, 18841, 18842, 18843, 
18844, 18845, 18846, 18847, 18848, 18849, 18850, 18851, 18852, 18853, 
18854, 18855, 18856, 18857, 18858, 18859, 18860, 18861, 18862, 18863, 
18864, 18865, 18866, 18867, 18868, 18869, 18870, 18871, 18872, 18873, 
18874, 18875, 18876, 18877, 18878, 18879, 18880, 18881, 18882, 18883, 
18884, 18885, 18886, 18887, 18888, 18889, 18890, 18891, 18892, 18893, 
18894, 18895, 18896, 18897, 18898, 18899, 18900, 18901, 18902, 18903, 
18904, 18905, 18906, 18907, 18908, 18909, 18910, 18911, 18912, 18913, 
18914, 18915, 18916, 18917, 18918, 18919, 18920, 18921, 18922, 18923, 
18924, 18925, 18926, 18927, 18928, 18929, 18930, 18931, 18932, 18933, 
18934, 18935, 18936, 18937, 18938, 18939, 18940, 18941, 18942, 18943, 
18944, 18945, 18946, 18947, 18948, 18949, 18950, 18951, 18952, 18953, 
18954, 18955, 18956, 18957, 18958, 18959, 18960, 18961, 18962, 18963, 
18964, 18965, 18966, 18967, 18968, 18969, 18970, 18971, 18972, 18973, 
18974, 18975, 18976, 18977, 18978, 18979, 18980, 18981, 18982, 18983, 
18984, 18985, 18986, 18987, 18988, 18989, 18990, 18991, 18992, 18993, 
18994, 18995, 18996, 18997, 18998, 18999, 19000, 19001, 19002, 19003, 
19004, 19005, 19006, 19007, 19008, 19009, 19010, 19011, 19012, 19013, 
19014, 19015, 19016, 19017, 19018, 19019, 19020, 19021, 19022, 19023, 
19024, 19025, 19026, 19027, 19028, 19029, 19030, 19031, 19032, 19033, 
19034, 19035, 19036, 19037, 19038, 19039, 19040, 19041, 19042, 19043, 
19044, 19045, 19046, 19047, 19048, 19049, 19050, 19051, 19052, 19053, 
19054, 19055, 19056, 19057, 19058, 19059, 19060, 19061, 19062, 19063, 
19064, 19065, 19066, 19067, 19068, 19069, 19070, 19071, 19072, 19073, 
19074, 19075, 19076, 19077, 19078, 19079, 19080, 19081, 19082, 19083, 
19084, 19085, 19086, 19087, 19088, 19089, 19090, 19091, 19092, 19093, 
19094, 19095, 19096, 19097, 19098, 19099, 19100, 19101, 19102, 19103, 
19104, 19105, 19106, 19107, 19108, 19109, 19110, 19111, 19112, 19113, 
19114, 19115, 19116, 19117, 19118, 19119, 19120, 19121, 19122, 19123, 
19124, 19125, 19126, 19127, 19128, 19129, 19130, 19131, 19132, 19133, 
19134, 19135, 19136, 19137, 19138, 19139, 19140, 19141, 19142, 19143, 
19144, 19145, 19146, 19147, 19148, 19149, 19150, 19151, 19152, 19153, 
19154, 19155, 19156, 19157, 19158, 19159, 19160, 19161, 19162, 19163, 
19164, 19165, 19166, 19167, 19168, 19169, 19170, 19171, 19172, 19173, 
19174, 19175, 19176, 19177, 19178, 19179, 19180, 19181, 19182, 19183, 
19184, 19185, 19186, 19187, 19188, 19189, 19190, 19191, 19192, 19193, 
19194, 19195, 19196, 19197, 19198, 19199, 19200, 19201, 19202, 19203, 
19204, 19205, 19206, 19207, 19208, 19209, 19210, 19211, 19212, 19213, 
19214, 19215, 19216, 19217, 19218, 19219, 19220, 19221, 19222, 19223, 
19224, 19225, 19226, 19227, 19228, 19229, 19230, 19231, 19232, 19233, 
19234, 19235, 19236, 19237, 19238, 19239, 19240, 19241, 19242, 19243, 
19244, 19245, 19246, 19247, 19248, 19249, 19250, 19251, 19252, 19253, 
19254, 19255, 19256, 19257, 19258, 19259, 19260, 19261, 19262, 19263, 
19264, 19265, 19266, 19267, 19268, 19269, 19270, 19271, 19272, 19273, 
19274, 19275, 19276, 19277, 19278, 19279, 19280, 19281, 19282, 19283, 
19284, 19285, 19286, 19287, 19288, 19289, 19290, 19291, 19292, 19293, 
19294, 19295, 19296, 19297, 19298, 19299, 19300, 19301, 19302, 19303, 
19304, 19305, 19306, 19307, 19308, 19309, 19310, 19311, 19312, 19313, 
19314, 19315, 19316, 19317, 19318, 19319, 19320, 19321, 19322, 19323, 
19324, 19325, 19326, 19327, 19328, 19329, 19330, 19331, 19332, 19333, 
19334, 19335, 19336, 19337, 19338, 19339, 19340, 19341, 19342, 19343, 
19344, 19345, 19346, 19347, 19348, 19349, 19350, 19351, 19352, 19353, 
19354, 19355, 19356, 19357, 19358, 19359, 19360, 19361, 19362, 19363, 
19364, 19365, 19366, 19367, 19368, 19369, 19370, 19371, 19372, 19373, 
19374, 19375, 19376, 19377, 19378, 19379, 19380, 19381, 19382, 19383, 
19384, 19385, 19386, 19387, 19388, 19389, 19390, 19391, 19392, 19393, 
19394, 19395, 19396, 19397, 19398, 19399, 19400, 19401, 19402, 19403, 
19404, 19405, 19406, 19407, 19408, 19409, 19410, 19411, 19412, 19413, 
19414, 19415, 19416, 19417, 19418, 19419, 19420, 19421, 19422, 19423, 
19424, 19425, 19426, 19427, 19428, 19429, 19430, 19431, 19432, 19433, 
19434, 19435, 19436, 19437, 19438, 19439, 19440, 19441, 19442, 19443, 
19444, 19445, 19446, 19447, 19448, 19449, 19450, 19451, 19452, 19453, 
19454, 19455, 19456, 19457, 19458, 19459, 19460, 19461, 19462, 19463, 
19464, 19465, 19466, 19467, 19468, 19469, 19470, 19471, 19472, 19473, 
19474, 19475, 19476, 19477, 19478, 19479, 19480, 19481, 19482, 19483, 
19484, 19485, 19486, 19487, 19488, 19489, 19490, 19491, 19492, 19493, 
19494, 19495, 19496, 19497, 19498, 19499, 19500, 19501, 19502, 19503, 
19504, 19505, 19506, 19507, 19508, 19509, 19510, 19511, 19512, 19513, 
19514, 19515, 19516, 19517, 19518, 19519, 19520, 19521, 19522, 19523, 
19524, 19525, 19526, 19527, 19528, 19529, 19530, 19531, 19532, 19533, 
19534, 19535, 19536, 19537, 19538, 19539, 19540, 19541, 19542, 19543, 
19544, 19545, 19546, 19547, 19548, 19549, 19550, 19551, 19552, 19553, 
19554, 19555, 19556, 19557, 19558, 19559, 19560, 19561, 19562, 19563, 
19564, 19565, 19566, 19567, 19568, 19569, 19570, 19571, 19572, 19573, 
19574, 19575, 19576, 19577, 19578, 19579, 19580, 19581, 19582, 19583, 
19584, 19585, 19586, 19587, 19588, 19589, 19590, 19591, 19592, 19593, 
19594, 19595, 19596, 19597, 19598, 19599, 19600, 19601, 19602, 19603, 
19604, 19605, 19606, 19607, 19608, 19609, 19610, 19611, 19612, 19613, 
19614, 19615, 19616, 19617, 19618, 23631, 23632, 23633, 23634, 23635, 
23636, 23637, 23638, 23639, 23640, 23641, 23642, 23643, 23644, 23645, 
23646, 23647, 23648, 23649, 23650, 23651, 23652, 23653, 24492, 24493, 
24494, 24495, 24496, 24497, 24498, 24499, 24500, 24501, 24502, 24503, 
24504, 24505, 24506, 24507, 24508, 24509, 24510, 24511, 24512, 24513, 
24514, 24515, 24516, 24517, 24518, 24519, 24520, 24521, 24522, 24523, 
24524, 24525, 24526, 24527, 24528, 24529, 24530, 24531, 24532, 24533, 
24534, 24535, 24536, 24537, 24538, 24539, 24540, 24541, 24542, 24543, 
24544, 24545, 24546, 24547, 24548, 24549, 24550, 24551, 24552, 24553, 
24554, 24555, 24556, 24557, 24558, 24559, 24560, 24561, 24562, 24563, 
24564, 24565, 24566, 24567, 24568, 24569, 24570, 24571, 24572, 24573, 
24574, 24575, 24576, 24577, 24578, 24579, 24580, 24581, 24582, 24583, 
24584, 24585, 24586, 24587, 24588, 24589, 24590, 24591, 24592, 24593, 
24594, 24595, 24596, 24597, 24598, 24599, 24600, 24601, 24602, 24603, 
24604, 24605, 24606, 24607, 24608, 24609, 24610, 24611, 24612, 24613, 
24614, 24615, 24616, 24617, 24618, 24619, 24620, 24621, 24622, 24623, 
24624, 24625, 24626, 24627, 24628, 24629, 24630, 24631, 24632, 24633, 
24634, 24635, 24636, 24637, 24638, 24639, 24640, 24641, 24642, 24643, 
24644, 24645, 24646, 24647, 24648, 24649, 24650, 24651, 24652, 24653, 
24654, 25769, 25770, 25885, 25886, 25979, 25980, 25981, 25982, 25983, 
25984, 25985, 25986, 25987, 25988, 25989, 25990, 25991, 25992, 25993, 
25994, 25995, 25996, 25997, 25998, 25999, 26000, 26001, 26840, 26841, 
26842, 26843, 26844, 26845, 26846, 26847, 26848, 26849, 26850, 26851, 
26852, 26853, 26854, 26855, 26856, 26857, 26858, 26859, 26860, 26861, 
26862, 31693, 31694, 31695, 31696, 31697, 31698, 31699, 31700, 31701, 
31702, 31703, 31704, 31705, 31706, 31707, 31708, 31709, 31710, 31711, 
31712, 31713, 31714, 31715, 31716, 31717, 31718, 31719, 31720, 31721, 
31722, 31723, 31724, 31725, 31726, 31727, 31728, 31729, 31730, 31731, 
31732, 31733, 31734, 31735, 31736, 31737, 31738, 31739, 31740, 31741, 
31742, 31743, 31744, 31745, 31746, 31747, 31748, 31749, 31750, 31751, 
31752, 31753, 31754, 31755, 31756, 31757, 31758, 31759, 31760, 31761, 
31762, 31763, 31764, 31765, 31766, 31767, 31768, 31769, 31770, 31771, 
31772, 31773, 31774, 31775, 31776, 31777, 31778, 31779, 31780, 31781, 
31782, 31783, 31784, 31785, 31786, 31787, 31788, 31789, 31790, 31791, 
31792, 31793, 31794, 31795, 31796, 31797, 31798, 31799, 31800, 31801, 
31802, 31803, 31804, 31805, 31806, 31807, 31808, 31809, 31810, 31811, 
31812, 31813, 31814, 31815, 31816, 31817, 31818, 31819, 31820, 31821, 
31822, 31823, 31824, 31825, 31826, 31827, 31828, 31829, 31830, 31831, 
31832, 31833, 31834, 31835, 31836, 31837, 31838, 31839, 31840, 31841, 
31842, 31843, 31844, 31845, 31846, 31847, 31848, 31849, 31850, 31851, 
31852, 31853, 31854, 31855, 31856, 31857, 31858, 31859, 31860, 31861, 
31862, 31863, 31864, 31865, 31866, 31867, 31868, 31869, 31870, 31871, 
31872, 31873, 31874, 31875, 31876, 31877, 31878, 31879, 31880, 31881, 
31882, 31883, 31884, 31885, 31886, 31887, 31888, 31889, 31890, 31891, 
31892, 31893, 31894, 31895, 31896, 31897, 31898, 31899, 31900, 31901, 
31902, 31903, 31904, 31905, 31906, 31907, 31908, 31909, 31910, 31911, 
31912, 31913, 31914, 31915, 31916, 31917, 31918, 31919, 31920, 31921, 
31922, 31923, 31924, 31925, 31926, 31927, 31928, 31929, 31930, 31931, 
31932, 31933, 31934, 31935, 31936, 31937, 31938, 31939, 31940, 31941, 
31942, 31943, 31944, 31945, 31946, 31947, 31948, 31949, 31950, 31951, 
31952, 31953, 31954, 31955, 31956, 31957, 31958, 31959, 31960, 31961, 
31962, 31963, 31964, 31965, 31966, 31967, 31968, 31969, 31970, 31971, 
31972, 31973, 31974, 31975, 31976, 31977, 31978, 31979, 31980, 31981, 
31982, 31983, 31984, 31985, 31986, 31987, 31988, 31989, 31990, 31991, 
31992, 31993, 31994, 31995, 32936, 32937, 32938, 32939, 32940, 32941, 
32942, 32943, 32944, 32945, 32946, 32947, 32948, 32949, 32950, 32951, 
32952, 32953, 32954, 32955, 32956, 32957, 32958, 32959, 32960, 32961, 
32962, 32963, 32964, 32965, 32966, 32967, 32968, 32969, 32970, 32971, 
32972, 32973, 32974, 32975, 32976, 32977, 32978, 32979, 32980, 32981, 
32982, 32983, 32984, 32985, 32986, 32987, 32988, 32989, 32990, 32991, 
33342, 33343, 33344, 33345, 33346, 33347, 33348, 33349, 33350, 33351, 
33352, 33353, 33354, 33355, 33356, 33357, 33358, 33359, 33360, 33361, 
33362, 33363, 33364, 33365, 33366, 33367, 33368, 33369, 33370, 33371, 
33372, 33373, 33374, 33375, 33376, 33377, 33378, 33379, 33380, 33381, 
33382, 33383, 33384, 33385, 33386, 33387, 33388, 33389, 33390, 33391, 
33392, 33393, 33394, 33395, 33396, 33397, 33398, 33399, 33400, 33401, 
33402, 33403, 33404, 33405, 33406, 33407, 33408, 33409, 33410, 33411, 
33412, 33413, 33414, 33415, 33416, 33417, 33418, 33419, 33420, 33421, 
33422, 33423, 33424, 33425, 33426, 33427, 33428, 33429, 33430, 33431, 
33432, 33433, 33434, 33435, 33436, 33437, 33438, 33439, 33440, 33441, 
33442, 33443, 33444, 33445, 33446, 33447, 33448, 33449, 33450, 33451, 
33452, 33453, 33454, 33455, 33456, 33457, 33458, 33459, 33460, 33461, 
33462, 33463, 33464, 33465, 33466, 33467, 33468, 33469, 33470, 33471, 
33472, 33473, 33474, 33475, 33476, 33477, 33478, 33479, 33480, 33481, 
33482, 33483, 33484, 33485, 33486, 33487, 33488, 33489, 33490, 33491, 
33492, 33493, 33494, 33495, 33496, 33497, 33498, 33499, 33500, 33501, 
33502, 33503, 33504, 33505, 33506, 33507, 33508, 33509, 33510, 33511, 
33512, 33513, 33514, 33515, 33516, 33517, 33518, 33519, 33520, 33521, 
33522, 33523, 33524, 33525, 33526, 33527, 33528, 33529, 33530, 33531, 
33532, 33533, 33534, 33535, 33536, 33537, 33538, 33539, 33540, 33541, 
33542, 33543, 33544, 33545, 33546, 33547, 33548, 33549, 33550, 33551, 
33552, 33553, 33554, 33555, 33556, 33557, 33558, 33559, 33560, 33561, 
33562, 33563, 33564, 33565, 33566, 33567, 33568, 33569, 33570, 33571, 
33572, 33573, 33574, 33575, 33576, 33577, 33578, 33579, 33580, 33581, 
33582, 33583, 33584, 33585, 33586, 33587, 33588, 33589, 33590, 33591, 
33592, 33593, 33594, 33595, 33596, 33597, 33598, 33599, 33600, 33601, 
33602, 33603, 33604, 33605, 33606, 33607, 33608, 33609, 33610, 33611, 
33612, 33613, 33614, 33615, 33616, 33617, 33618, 33619, 33620, 33621, 
33622, 33623, 33624, 33625, 33626, 33627, 33628, 33629, 33630, 33631, 
33632, 33633, 33634, 33635, 33636, 33637, 33638, 33639, 33640, 33641, 
33642, 33643, 33644, 35338, 35339, 35340, 35341, 35342, 35343, 35344, 
35345, 35346, 35347, 35348, 35349, 35350, 35351, 35352, 35353, 35354, 
35355, 35356, 35357, 35358, 35359, 35360, 35361, 35362, 35363, 35364, 
35365, 35366, 35367, 35368, 35369, 35370, 35371, 35372, 35373, 35374, 
35375, 35376, 35377, 35378, 35379, 35380, 35381, 35382, 35383, 35384, 
35385, 35386, 35387, 35388, 35389, 35390, 35391, 35392, 35393, 35394, 
35395, 35396, 35397, 35398, 35399, 35400, 35401, 35402, 35403, 35404, 
35405, 35406, 35407, 35408, 35409, 35410, 35411, 35412, 35413, 35414, 
35415, 35416, 35417, 35418, 35419, 35420, 35421, 35422, 35423, 35424, 
35425, 35426, 35427, 35428, 35429, 35430, 35431, 35432, 35433, 35434, 
35435, 35436, 35437, 35438, 35439, 35440, 35441, 35442, 35443, 35444, 
35445, 35446, 35447, 35448, 35449, 35450, 35451, 35452, 35453, 35454, 
35455, 35456, 35457, 35458, 35459, 35460, 35461, 35462, 35463, 35464, 
35465, 35466, 35467, 35468, 35469, 35470, 35471, 35472, 35473, 35474, 
35475, 35476, 35477, 35478, 35479, 35480, 35481, 35482, 35483, 35484, 
35485, 35486, 35487, 35488, 35489, 35490, 35491, 35492, 35493, 35494, 
35495, 35496, 35497, 35498, 35499, 35500, 35501, 35502, 35503, 35504, 
35505, 35506, 35507, 35508, 35509, 35510, 35511, 35512, 35513, 35514, 
35515, 35516, 35517, 35518, 35519, 35520, 35521, 35522, 35523, 35524, 
35525, 35526, 35527, 35528, 35529, 35530, 35531, 35532, 35533, 35534, 
35535, 35536, 35537, 35538, 35539, 35540, 35541, 35542, 35543, 35544, 
35545, 35546, 35547, 35548, 35549, 35550, 35551, 35552, 35553, 35554, 
35555, 35556, 35557, 35558, 35559, 35560, 35561, 35562, 35563, 35564, 
35565, 35566, 35567, 35568, 35569, 35570, 35571, 35572, 35573, 35574, 
35575, 35576, 35577, 35578, 35579, 35580, 35581, 35582, 35583, 35584, 
35585, 35586, 35587, 35588, 35589, 35590, 35591, 35592, 35593, 35594, 
35595, 35596, 35597, 35598, 35599, 35600, 35601, 35602, 35603, 35604, 
35605, 35606, 35607, 35608, 35609, 35610, 35611, 35612, 35613, 35614, 
35615, 35616, 35617, 35618, 35619, 35620, 35621, 35622, 35623, 35624, 
35625, 35626, 35627, 35628, 35629, 35630, 35631, 35632, 35633, 35634, 
35635, 35636, 35637, 35638, 35639, 35640, 36581, 36582, 36583, 36584, 
36747, 36748, 36749, 36750, 36751, 36752, 36753, 36754, 36755, 36756, 
36757, 36758, 36759, 36760, 36761, 36762, 36763, 36764, 36765, 36766, 
36767, 36768, 36769, 36770, 36771, 36772, 36773, 36774, 36775, 36776, 
36777, 36778, 36779, 36780, 36781, 36782, 36783, 36784, 36785, 36786, 
36787, 36788, 36789, 36790, 36791, 36792, 36793, 36794, 36795, 36796, 
36797, 36798, 36799, 36800, 36801, 36802, 36803, 36804, 36805, 36806, 
36807, 36808, 36809, 36810, 36811, 36812, 36813, 36814, 36815, 36816, 
36817, 36818, 36819, 36820, 36821, 36822, 36823, 36824, 36825, 36826, 
36827, 36828, 36829, 36830, 36831, 36832, 36833, 36834, 36835, 36836, 
36837, 36838, 36839, 36840, 36841, 36842, 36843, 36844, 36845, 36846, 
36847, 36848, 36849, 36850, 36851, 36852, 36853, 36854, 36855, 36856, 
36857, 36858, 36859, 36860, 36861, 36862, 36863, 36864, 36865, 36866, 
36867, 36868, 36869, 36870, 36871, 36872, 36873, 36874, 36875, 36876, 
36877, 36878, 36879, 36880, 36881, 36882, 36883, 36884, 36885, 36886, 
36887, 36888, 36889, 36890, 36891, 36892, 36893, 36894, 36895, 36896, 
36897, 36898, 36899, 36900, 36901, 36902, 36903, 36904, 36905, 36906, 
36907, 36908, 36909, 36910, 36911, 36912, 36913, 36914, 36915, 36916, 
36917, 36918, 36919, 36920, 36921, 36922, 36923, 36924, 36925, 36926, 
36927, 36928, 36929, 36930, 36931, 36932, 36933, 36934, 36935, 36936, 
36937, 36938, 36939, 36940, 36941, 36942, 36943, 36944, 36945, 36946, 
36947, 36948, 36949, 36950, 36951, 36952, 36953, 36954, 36955, 36956, 
36957, 36958, 36959, 36960, 36961, 36962, 36963, 36964, 36965, 36966, 
36967, 36968, 36969, 36970, 36971, 36972, 36973, 36974, 36975, 36976, 
36977, 36978, 36979, 36980, 36981, 36982, 36983, 36984, 36985, 36986, 
36987, 36988, 36989, 36990, 36991, 36992, 36993, 36994, 36995, 36996, 
36997, 36998, 36999, 37000, 37001, 37002, 37003, 37004, 37005, 37006, 
37007, 37008, 37009, 37010, 37011, 37012, 37013, 37014, 37015, 37016, 
37017, 37018, 37019, 37020, 37021, 37022, 37023, 37024, 37025, 37026, 
37027, 37028, 37029, 37030, 37031, 37032, 37033, 37034, 37035, 37036, 
37037, 37038, 37039, 37040, 37041, 37042, 37043, 37044, 37045, 37046, 
37047, 37048, 37049, 38440, 38441, 38442, 38443, 
*NSET,NSET=Copper
1, 2, 3, 4, 5, 6, 7, 8, 17, 18, 
19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 
29, 30, 31, 32, 41, 42, 43, 44, 45, 46, 
47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 
97, 98, 99, 100, 101, 102, 103, 104, 105, 106, 
107, 108, 109, 110, 111, 112, 113, 114, 115, 116, 
117, 118, 119, 120, 121, 122, 123, 124, 125, 126, 
127, 128, 129, 130, 131, 132, 133, 134, 135, 136, 
137, 138, 139, 140, 141, 142, 143, 144, 145, 146, 
147, 148, 149, 150, 151, 152, 153, 154, 155, 156, 
157, 158, 159, 160, 161, 162, 163, 164, 165, 166, 
167, 168, 169, 170, 171, 172, 173, 174, 175, 176, 
177, 178, 179, 180, 181, 182, 183, 184, 185, 186, 
187, 188, 189, 190, 191, 192, 193, 194, 195, 196, 
197, 198, 199, 200, 201, 202, 203, 204, 205, 206, 
207, 208, 209, 210, 211, 212, 213, 214, 215, 216, 
217, 218, 219, 220, 221, 222, 223, 224, 225, 226, 
227, 228, 229, 230, 231, 232, 233, 234, 235, 236, 
237, 238, 239, 240, 241, 242, 243, 244, 245, 246, 
247, 248, 249, 250, 251, 252, 253, 254, 255, 256, 
257, 258, 259, 260, 261, 262, 263, 264, 265, 266, 
267, 268, 269, 270, 271, 272, 273, 274, 275, 276, 
277, 278, 279, 280, 281, 282, 283, 284, 285, 286, 
287, 288, 289, 290, 291, 292, 293, 294, 295, 296, 
297, 298, 299, 300, 301, 302, 303, 304, 305, 306, 
307, 308, 309, 310, 311, 312, 313, 314, 315, 316, 
317, 318, 319, 320, 321, 322, 323, 324, 325, 326, 
327, 328, 329, 330, 331, 332, 333, 334, 335, 336, 
337, 338, 339, 340, 341, 342, 343, 344, 345, 346, 
347, 348, 349, 350, 351, 352, 353, 354, 355, 356, 
357, 358, 359, 360, 361, 362, 363, 364, 365, 366, 
367, 368, 369, 370, 371, 372, 373, 374, 375, 376, 
377, 378, 379, 380, 381, 382, 383, 384, 385, 386, 
387, 388, 389, 390, 391, 392, 393, 394, 395, 396, 
871, 872, 873, 874, 875, 876, 877, 878, 879, 880, 
881, 882, 883, 884, 885, 886, 887, 888, 889, 890, 
891, 892, 893, 894, 895, 896, 897, 898, 899, 900, 
901, 902, 903, 904, 905, 906, 907, 908, 909, 910, 
911, 912, 913, 914, 915, 916, 917, 919, 920, 921, 
922, 923, 924, 925, 926, 927, 928, 929, 930, 931, 
932, 933, 934, 935, 936, 937, 938, 939, 940, 941, 
943, 944, 945, 946, 947, 948, 949, 950, 951, 952, 
953, 954, 955, 956, 957, 958, 959, 960, 961, 962, 
963, 964, 965, 966, 967, 968, 969, 970, 971, 972, 
973, 974, 975, 976, 977, 978, 979, 980, 981, 982, 
983, 984, 985, 986, 987, 988, 989, 990, 991, 992, 
993, 994, 995, 996, 997, 998, 999, 1000, 1001, 1002, 
1003, 1004, 1005, 1006, 1007, 1008, 1009, 1010, 1011, 1012, 
1013, 1014, 1015, 1016, 1017, 1018, 1019, 1020, 1021, 1022, 
1023, 1024, 1025, 1026, 1027, 1028, 1029, 1030, 1031, 1032, 
1033, 1034, 1035, 1036, 1037, 1038, 1039, 1040, 1041, 1042, 
1043, 1044, 1045, 1046, 1047, 1048, 1049, 1050, 1051, 1052, 
1053, 1054, 1055, 1056, 1057, 1058, 1059, 1060, 1061, 1062, 
1063, 1064, 1065, 1066, 1067, 1068, 1069, 1070, 1071, 1072, 
1073, 1074, 1075, 1076, 1077, 1078, 1079, 1080, 1081, 1082, 
1083, 1084, 1085, 1086, 1087, 1088, 1089, 1090, 1091, 1092, 
1093, 1094, 1095, 1096, 1097, 1098, 1099, 1100, 1101, 1102, 
1103, 1104, 1105, 1106, 1107, 1108, 1109, 1110, 1111, 1112, 
1113, 1114, 1115, 1116, 1117, 1118, 1119, 1120, 1121, 1122, 
1123, 1124, 1125, 1126, 1127, 1128, 1129, 1130, 1131, 1132, 
1133, 1134, 1135, 1136, 1137, 1138, 1139, 1140, 1141, 1142, 
1143, 1144, 1145, 1146, 1147, 1148, 1149, 1150, 1151, 1152, 
1153, 1154, 1155, 1156, 1157, 1158, 1159, 1160, 1161, 1162, 
1163, 1164, 1165, 1166, 1167, 1168, 1169, 1170, 1171, 1172, 
1173, 1174, 1175, 1176, 1177, 1178, 1179, 1180, 1181, 1182, 
1183, 1184, 1185, 1186, 1187, 1188, 1189, 1190, 1191, 1192, 
1193, 1194, 1195, 1196, 1197, 1198, 1199, 1200, 1201, 1202, 
1203, 1204, 1205, 1206, 1207, 1208, 1209, 1210, 1211, 1212, 
1213, 1214, 1215, 1216, 1217, 1218, 1219, 1220, 1221, 1222, 
1223, 1224, 1225, 1226, 1227, 1228, 1229, 1230, 1231, 1232, 
1233, 1234, 1235, 1236, 1237, 1238, 1239, 1240, 1241, 1242, 
1243, 1244, 1245, 1246, 1247, 1248, 1249, 1250, 1251, 1252, 
1253, 1254, 1255, 1256, 1257, 1258, 1259, 1260, 1261, 1262, 
1263, 1264, 1265, 1266, 1267, 1268, 1269, 1270, 1271, 1272, 
1273, 1274, 1275, 1276, 1277, 1278, 1279, 1280, 1281, 1282, 
1283, 1284, 1285, 1286, 1287, 1288, 1289, 1290, 1291, 1292, 
1293, 1294, 1295, 1296, 1297, 1298, 1299, 1300, 1301, 1302, 
1303, 1304, 1305, 1306, 1307, 1308, 1309, 1310, 1311, 1312, 
1313, 1314, 1315, 1316, 1317, 1318, 1319, 1320, 1321, 1322, 
1323, 1324, 1325, 1326, 1327, 1328, 1329, 1330, 1331, 1332, 
1333, 1334, 1335, 1336, 1337, 1338, 1339, 1340, 1341, 1342, 
1343, 1344, 1345, 1346, 1347, 1348, 1349, 1350, 1351, 1352, 
1353, 1354, 1355, 1356, 1357, 1358, 1359, 1360, 1361, 1362, 
1363, 1364, 1365, 1366, 1367, 1368, 1369, 1370, 1371, 1372, 
1373, 1374, 1375, 1376, 1377, 1378, 1379, 1380, 1381, 1382, 
1383, 1384, 1385, 1386, 1387, 1388, 1389, 1390, 1391, 1392, 
1393, 1394, 1395, 1396, 1397, 1398, 1399, 1400, 1401, 1402, 
1403, 1404, 1405, 1406, 1407, 1408, 1409, 1410, 1411, 1412, 
1413, 1414, 1415, 1416, 1417, 1418, 1419, 1420, 1421, 1422, 
1423, 1424, 1425, 1426, 1427, 1428, 1429, 1430, 1431, 1432, 
1433, 1434, 1435, 1436, 1437, 1438, 1439, 1440, 1441, 1442, 
1443, 1444, 1445, 1446, 1447, 1448, 1449, 1450, 1451, 1452, 
1453, 1454, 1455, 1456, 1457, 1458, 1459, 1460, 1461, 1462, 
1463, 1464, 1465, 1466, 1467, 1468, 1469, 1470, 1471, 1472, 
1473, 1474, 1475, 1476, 1477, 1478, 1479, 1480, 1481, 1482, 
1483, 1484, 1485, 1486, 1487, 1488, 1489, 1490, 1491, 1492, 
1493, 1494, 1495, 1496, 1497, 1498, 1499, 1500, 1501, 1502, 
1503, 1504, 1505, 1506, 1507, 1508, 1983, 1984, 1985, 1986, 
1987, 1988, 1989, 1990, 1991, 1992, 1993, 1994, 1995, 1996, 
1997, 1998, 1999, 2000, 2001, 2002, 2003, 2004, 2005, 2006, 
2007, 2008, 2009, 2010, 2011, 2012, 2013, 2014, 2015, 2016, 
2017, 2018, 2019, 2020, 2021, 2022, 2023, 2024, 2025, 2026, 
2027, 2028, 2029, 2032, 2033, 2034, 2035, 2036, 2037, 2038, 
2039, 2040, 2041, 2042, 2043, 2044, 2045, 2046, 2047, 2048, 
2049, 2050, 2051, 2052, 2053, 2054, 2055, 2056, 2057, 2058, 
2059, 2060, 2061, 2062, 2063, 2064, 2065, 2066, 2067, 2068, 
2069, 2070, 2071, 2072, 2073, 2074, 2075, 2076, 2077, 2078, 
2079, 2080, 2081, 2082, 2083, 2084, 2085, 2086, 2087, 2088, 
2089, 2090, 2091, 2092, 2093, 2094, 2095, 2096, 2097, 2098, 
2099, 2100, 2101, 2102, 2103, 2104, 2105, 2106, 2107, 2108, 
2109, 2110, 2111, 2112, 2113, 2114, 2115, 2116, 2117, 2118, 
2119, 2120, 2121, 2122, 2123, 2124, 2125, 2126, 2127, 2128, 
2129, 2130, 2131, 2132, 2133, 2134, 2135, 2136, 2137, 2138, 
2139, 2140, 2141, 2142, 2143, 2144, 2145, 2146, 2147, 2148, 
2149, 2150, 2151, 2152, 2153, 2154, 2155, 2156, 2157, 2158, 
2159, 2160, 2161, 2162, 2163, 2164, 2165, 2166, 2167, 2168, 
2169, 2170, 2171, 2172, 2173, 2174, 2175, 2176, 2177, 2178, 
2179, 2180, 2181, 2182, 2183, 2184, 2185, 2186, 2187, 2188, 
2189, 2190, 2191, 2192, 2193, 2194, 2195, 2196, 2197, 2198, 
2199, 2200, 2201, 2202, 2203, 2204, 2205, 2206, 2207, 2208, 
2209, 2210, 2211, 2212, 2213, 2214, 2215, 2216, 2217, 2218, 
2219, 2220, 2221, 2222, 2223, 2224, 2225, 2226, 2227, 2228, 
2229, 2230, 2231, 2232, 2233, 2234, 2235, 2236, 2237, 2238, 
2239, 2240, 2241, 2242, 2243, 2244, 2245, 2246, 2247, 2248, 
2249, 2250, 2251, 2252, 2253, 2254, 2255, 2256, 2257, 2258, 
2259, 2260, 2261, 2262, 2263, 2264, 2265, 2266, 2267, 2268, 
2269, 2270, 2271, 2272, 2273, 2274, 2275, 2276, 2277, 2278, 
2279, 2280, 2281, 2282, 2283, 2284, 2285, 2286, 2287, 2288, 
2289, 2290, 2291, 2292, 2293, 2294, 2295, 2296, 2297, 2298, 
2299, 2300, 2301, 2302, 2303, 2304, 2305, 2306, 2307, 2308, 
2309, 2310, 2311, 2312, 2313, 2314, 2315, 2316, 2317, 2318, 
2319, 2320, 2321, 2322, 2323, 2324, 2325, 2326, 2327, 2328, 
2329, 2330, 2331, 2332, 2333, 2334, 2335, 2336, 2337, 2338, 
2339, 2340, 2341, 2342, 2343, 2344, 2345, 2346, 2347, 2348, 
2349, 2350, 2351, 2352, 2353, 2354, 2355, 2356, 2357, 2358, 
2359, 2360, 2361, 2362, 2363, 2364, 2365, 2366, 2367, 2368, 
2369, 2370, 2371, 2372, 2373, 2374, 2375, 2376, 2377, 2378, 
2379, 2380, 2381, 2382, 2383, 2384, 2385, 2386, 2387, 2388, 
2389, 2390, 2391, 2392, 2393, 2394, 2395, 2396, 2397, 2398, 
2399, 2400, 2401, 2402, 2403, 2404, 3987, 3988, 3989, 3990, 
3991, 3992, 3993, 3994, 3995, 3996, 3997, 3998, 3999, 4000, 
4001, 4002, 4003, 4004, 4005, 4006, 4007, 4008, 4009, 4010, 
4011, 4012, 4013, 4014, 4015, 4016, 4017, 4018, 4019, 4020, 
4021, 4022, 4023, 4024, 4025, 4026, 4027, 4028, 4029, 4030, 
4031, 4032, 4033, 4034, 4035, 4036, 4037, 4038, 4039, 4040, 
4041, 4042, 4043, 4044, 4045, 4046, 4047, 4048, 4049, 4050, 
4051, 4052, 4053, 4054, 4055, 4056, 4057, 4058, 4059, 4060, 
4061, 4062, 4063, 4064, 4065, 4066, 4067, 4068, 4069, 4070, 
4071, 4072, 4073, 4074, 4075, 4076, 4077, 4078, 4079, 4080, 
4081, 4082, 4083, 4084, 4085, 4086, 4087, 4088, 4089, 4090, 
4091, 4092, 4093, 4094, 4095, 4096, 4097, 4098, 4099, 4100, 
4101, 4102, 4103, 4104, 4105, 4106, 4107, 4108, 4109, 4110, 
4111, 4112, 4113, 4114, 4115, 4116, 4117, 4118, 4119, 4120, 
4121, 4122, 4123, 4124, 4125, 4126, 4127, 4128, 4129, 4130, 
4131, 4132, 4133, 4134, 4135, 4136, 4137, 4138, 4139, 4140, 
4141, 4142, 4143, 4144, 4145, 4146, 4147, 4148, 4149, 4150, 
4151, 4152, 4153, 4154, 4155, 4156, 4157, 4158, 4159, 4160, 
4161, 4162, 4163, 4164, 4165, 4166, 4167, 4168, 4169, 4170, 
4171, 4172, 4173, 4174, 4175, 4176, 4177, 4178, 4179, 4180, 
4181, 4182, 4183, 4184, 4185, 4186, 4187, 4188, 4189, 4190, 
4191, 4192, 4193, 4194, 4195, 4196, 4197, 4198, 4199, 4200, 
4201, 4202, 4203, 4204, 4205, 4206, 4207, 4208, 4209, 4210, 
4211, 4212, 4213, 4214, 4215, 4216, 4217, 4218, 4219, 4220, 
4221, 4222, 4223, 4224, 4225, 4226, 4227, 4228, 4229, 4230, 
4231, 4232, 4233, 4234, 4235, 4236, 4237, 4238, 4239, 4240, 
4241, 4242, 4243, 4244, 4245, 4246, 4247, 4248, 4249, 4250, 
4251, 4252, 4253, 4254, 4255, 4256, 4257, 4258, 4259, 4260, 
4261, 4262, 4263, 4264, 4265, 4266, 4267, 4268, 4269, 4270, 
4271, 4272, 4273, 4274, 4275, 4276, 4277, 4278, 4279, 4280, 
4281, 4282, 4283, 4284, 4285, 4286, 4287, 4288, 4289, 4290, 
4291, 4292, 4293, 4294, 4295, 4296, 4297, 4298, 4299, 4300, 
4301, 4302, 4303, 4304, 4305, 4306, 4307, 4308, 4309, 4310, 
4311, 4312, 4313, 4314, 4315, 4316, 4317, 4318, 4319, 4320, 
4321, 4322, 4323, 4324, 4325, 4326, 4327, 4328, 4329, 4330, 
4331, 4332, 4333, 4334, 4335, 4336, 4337, 4338, 4339, 4340, 
4341, 4342, 4343, 4344, 4345, 4346, 4347, 4348, 4349, 4350, 
4351, 4352, 4353, 4354, 4355, 4356, 4357, 4358, 4359, 4360, 
4361, 4362, 4363, 4364, 4365, 4366, 4367, 4368, 4369, 4370, 
4371, 4372, 4373, 4374, 4375, 4376, 4377, 4378, 4379, 4380, 
4381, 4382, 4383, 4384, 4385, 4386, 4387, 4388, 4389, 4390, 
4391, 4392, 4393, 4394, 4395, 4396, 4397, 4398, 4399, 4400, 
4401, 4402, 4403, 4404, 4405, 4406, 4407, 4408, 4409, 4410, 
4411, 4412, 4413, 4414, 4415, 4416, 4417, 4418, 4419, 4420, 
4421, 4422, 4423, 4424, 4425, 4426, 4427, 4428, 4429, 4430, 
4431, 4432, 4433, 4434, 4435, 4436, 4437, 4438, 4439, 4440, 
4441, 4442, 4443, 4444, 4445, 4446, 4447, 4448, 4449, 4450, 
4451, 4452, 4453, 4454, 4455, 4456, 4457, 4458, 4459, 4460, 
4461, 4462, 4463, 4464, 4465, 4466, 4467, 4468, 4469, 4470, 
4471, 4472, 4473, 4474, 4475, 4476, 4477, 4478, 4479, 4480, 
4481, 4482, 4483, 4484, 4485, 4486, 4487, 4488, 4489, 4490, 
4491, 4492, 4493, 4494, 4495, 4496, 4497, 4498, 4499, 4500, 
4501, 4502, 4503, 4504, 4505, 4506, 4507, 4508, 4509, 4510, 
4511, 4512, 4513, 4514, 4515, 4516, 4517, 4518, 4519, 4520, 
4521, 4522, 4523, 4524, 4525, 4526, 4527, 4528, 4529, 4530, 
4531, 4532, 4533, 4534, 4535, 4536, 4537, 4538, 4539, 4540, 
4541, 4542, 4543, 4544, 4545, 4546, 4547, 4548, 4549, 4550, 
4551, 4552, 4553, 4554, 4555, 4556, 4557, 4558, 4559, 4560, 
4561, 4562, 4563, 4564, 4565, 4566, 4567, 4568, 4569, 4570, 
4571, 4572, 4573, 4574, 4575, 4576, 4577, 4578, 4579, 4580, 
4581, 4582, 4583, 4584, 4585, 4586, 4587, 4588, 4589, 4590, 
4591, 4592, 4593, 4594, 4595, 4596, 4597, 4598, 4599, 4600, 
4601, 4602, 4603, 4604, 4605, 4606, 4607, 4608, 4609, 4610, 
4611, 4612, 4613, 4614, 4615, 4616, 4617, 4618, 4619, 4620, 
4621, 4622, 4623, 4624, 4625, 4626, 4627, 4628, 4629, 4630, 
4631, 4632, 4633, 4634, 4635, 4636, 4637, 4638, 4639, 4640, 
4641, 4642, 4643, 4644, 4645, 4646, 4647, 4648, 4649, 4650, 
4651, 4652, 4653, 4654, 4655, 4656, 4657, 4658, 4659, 4660, 
4661, 4662, 4663, 4664, 4665, 4666, 4667, 4668, 4669, 4670, 
4671, 4672, 4673, 4674, 4675, 4676, 4677, 4678, 4679, 4680, 
4681, 4682, 4683, 4684, 4685, 4686, 4687, 4688, 4689, 4690, 
4691, 4692, 4693, 4694, 4695, 4696, 4697, 4698, 4699, 4700, 
4701, 4702, 4703, 4704, 4705, 4706, 4707, 4708, 4709, 4710, 
4711, 4712, 4713, 4714, 4715, 4716, 4717, 4718, 4719, 4720, 
4721, 4722, 4723, 4724, 4725, 4726, 4727, 4728, 4729, 4730, 
4731, 4732, 4733, 4734, 4735, 4736, 4737, 4738, 4739, 4740, 
4741, 4742, 4743, 4744, 4745, 4746, 4747, 4748, 4749, 4750, 
4751, 4752, 4753, 4754, 4755, 4756, 4757, 4758, 4759, 4760, 
4761, 4762, 4763, 4764, 4765, 4766, 4767, 4768, 4769, 4770, 
4771, 4772, 4773, 4774, 4775, 4776, 4777, 4778, 4779, 4780, 
4781, 4782, 4783, 4784, 4785, 4786, 4787, 4788, 4789, 4790, 
4791, 4792, 4793, 4794, 4795, 4796, 4797, 4798, 4799, 4800, 
4801, 4802, 4803, 4804, 4805, 4806, 4807, 4808, 4809, 4810, 
4811, 4812, 4813, 4814, 4815, 4816, 4817, 4818, 4819, 4820, 
4821, 4822, 4823, 4824, 4825, 4826, 4827, 4828, 4829, 4830, 
4831, 4832, 4833, 4834, 4835, 4836, 4837, 4838, 4839, 4840, 
4841, 4842, 4843, 4844, 4845, 4846, 4847, 4848, 4849, 4850, 
4851, 4852, 4853, 4854, 4855, 4856, 4857, 4858, 4859, 4860, 
4861, 4862, 4863, 4864, 4865, 4866, 4867, 4868, 4869, 4870, 
4871, 4872, 4873, 4874, 4875, 4876, 4877, 4878, 4879, 4880, 
4881, 4882, 4883, 4884, 4885, 4886, 4887, 4888, 4889, 4890, 
4891, 4892, 4893, 4894, 4895, 4896, 4897, 4898, 4899, 4900, 
4901, 4902, 4903, 4904, 4905, 4906, 4907, 4908, 4909, 4910, 
4911, 4912, 4913, 4914, 4915, 4916, 4917, 4918, 4919, 4920, 
4921, 4922, 4923, 4924, 4925, 4926, 4927, 4928, 4929, 4930, 
4931, 4932, 4933, 4934, 4935, 4936, 4937, 4938, 4939, 4940, 
4941, 4942, 4943, 4944, 4945, 4946, 4947, 4948, 4949, 4950, 
4951, 4952, 4953, 4954, 4955, 4956, 4957, 4958, 4959, 4960, 
4961, 4962, 4963, 4964, 4965, 4966, 4967, 4968, 4969, 4970, 
4971, 4972, 4973, 4974, 4975, 4976, 4977, 4978, 4979, 4980, 
4981, 4982, 4983, 4984, 4985, 4986, 4987, 4988, 4989, 4990, 
4991, 4992, 4993, 4994, 4995, 4996, 4997, 4998, 4999, 5000, 
5001, 5002, 5003, 5004, 5005, 5006, 5007, 5008, 5009, 5010, 
5011, 5012, 5013, 5014, 5015, 5016, 5017, 5018, 5019, 5020, 
5021, 5022, 5023, 5024, 5025, 5026, 5027, 5028, 5029, 5030, 
5031, 5032, 5033, 5034, 5035, 5036, 5037, 5038, 5039, 5040, 
5041, 5042, 5043, 5044, 5045, 5046, 5047, 5048, 5049, 5050, 
5051, 5052, 5053, 5054, 5055, 5056, 5057, 5058, 5059, 5060, 
5061, 5062, 5063, 5064, 5065, 5066, 5067, 5068, 5069, 5070, 
5071, 5072, 5073, 5074, 5075, 5076, 5077, 5078, 5079, 5080, 
5081, 5082, 5083, 5084, 5085, 5086, 5087, 5088, 5089, 5090, 
5091, 5092, 5093, 5094, 5095, 5096, 5097, 5098, 5099, 5100, 
5101, 5102, 5103, 5104, 5105, 5106, 5107, 5108, 5109, 5110, 
5111, 5112, 5113, 5114, 5115, 5116, 5117, 5118, 5119, 5120, 
5121, 5122, 5123, 5124, 5125, 5126, 5127, 5128, 5129, 5130, 
5131, 5132, 5133, 5134, 5135, 5136, 5137, 5138, 5139, 5140, 
5141, 5142, 5143, 5144, 5145, 5146, 5147, 5148, 5149, 5150, 
5151, 5152, 5153, 5154, 5155, 5156, 5157, 5158, 5159, 5160, 
5161, 5162, 5163, 5164, 5165, 5166, 5167, 5168, 5169, 5170, 
5171, 5172, 5173, 5174, 5175, 5176, 5177, 5178, 5179, 5180, 
5181, 5182, 5183, 5184, 5185, 5186, 5187, 5188, 5189, 5190, 
5191, 5192, 5193, 5194, 5195, 5196, 5197, 5198, 5199, 5200, 
5201, 5202, 5203, 5204, 5205, 5206, 5207, 5208, 5209, 5210, 
5211, 5212, 5213, 5214, 5215, 5216, 5217, 5218, 5219, 5220, 
5221, 5222, 5223, 5224, 5225, 5226, 5227, 5228, 5229, 5230, 
5231, 5232, 5233, 5234, 5235, 5236, 5237, 5238, 5239, 5240, 
5241, 5242, 5243, 5244, 5245, 5246, 5247, 5248, 5249, 5250, 
5251, 5252, 5253, 5254, 5255, 5256, 5257, 5258, 5259, 5260, 
5261, 5262, 5263, 5264, 5265, 5266, 5267, 5268, 5269, 5270, 
5271, 5272, 5273, 5274, 5275, 5276, 5277, 5278, 5279, 5280, 
5281, 5282, 5283, 5284, 5285, 5286, 5287, 5288, 5289, 5290, 
5291, 5292, 5293, 5294, 5295, 5296, 5297, 5298, 5299, 5300, 
5301, 5302, 5303, 5304, 5305, 5306, 5307, 5308, 5309, 5310, 
5311, 5312, 5313, 5314, 5315, 5316, 5317, 5318, 5319, 5320, 
5321, 5322, 5323, 5324, 5325, 5326, 5327, 5328, 5329, 5330, 
5331, 5332, 5333, 5334, 5335, 5336, 5337, 5338, 5339, 5340, 
5341, 5342, 5343, 5344, 5345, 5346, 5347, 5348, 5349, 5350, 
5351, 5352, 5353, 5354, 5355, 5356, 5357, 5358, 5359, 5360, 
5361, 5362, 5363, 5364, 5365, 5366, 5367, 5368, 5369, 5370, 
5371, 5372, 5373, 5374, 5375, 5376, 5377, 5378, 5379, 5380, 
5381, 5382, 5383, 5384, 5385, 5386, 5387, 5388, 5389, 5390, 
5391, 5392, 5393, 5394, 5395, 5396, 5397, 5398, 5399, 5400, 
5401, 5402, 5403, 5404, 5405, 5406, 5407, 5408, 5409, 5410, 
5411, 5412, 5413, 5414, 5415, 5416, 5417, 5418, 5419, 5420, 
5421, 5422, 5423, 5424, 5425, 5426, 5427, 5428, 5429, 5430, 
5431, 5432, 5433, 5434, 5435, 5436, 5437, 5438, 5439, 5440, 
5441, 5442, 5443, 5444, 5445, 5446, 5447, 5448, 5449, 5450, 
5451, 5452, 5453, 5454, 5455, 5456, 5457, 5458, 5459, 5460, 
5461, 5462, 5463, 5464, 5465, 5466, 5467, 5468, 5469, 5470, 
5471, 5472, 5473, 5474, 5475, 5476, 5477, 5478, 5479, 5480, 
5481, 5482, 5483, 5484, 5485, 5486, 5487, 5488, 5489, 5490, 
5491, 5492, 5493, 5494, 5495, 5496, 5497, 5498, 5499, 5500, 
5501, 5502, 5503, 5504, 5505, 5506, 5507, 5508, 5509, 5510, 
5511, 5512, 5513, 5514, 5515, 5516, 5517, 5518, 5519, 5520, 
5521, 5522, 5523, 5524, 5525, 5526, 5527, 5528, 5529, 5530, 
5531, 5532, 5533, 5534, 5535, 5536, 5537, 5538, 5539, 5540, 
5541, 5542, 5543, 5544, 5545, 5546, 5547, 5548, 5549, 5550, 
5551, 5552, 5553, 5554, 5555, 5556, 5557, 5558, 5559, 5560, 
5561, 5562, 5563, 5564, 5565, 5566, 5567, 5568, 5569, 5570, 
5571, 5572, 5573, 5574, 5575, 5576, 5577, 5578, 5579, 5580, 
5581, 5582, 5583, 5584, 5585, 5586, 5587, 5588, 5589, 5590, 
5591, 5592, 5593, 5594, 5595, 5596, 5597, 5598, 5599, 5600, 
5601, 5602, 5603, 5604, 5605, 5606, 5607, 5608, 5609, 5610, 
5611, 5612, 5613, 5614, 5615, 5616, 5617, 5618, 5619, 5620, 
5621, 5622, 5623, 5624, 5625, 5626, 5627, 5628, 5629, 5630, 
5631, 5632, 5633, 5634, 5635, 5636, 5637, 5638, 5639, 5640, 
5641, 5642, 5643, 5644, 5645, 5646, 5647, 5648, 5649, 5650, 
5651, 5652, 5653, 5654, 5655, 5656, 5657, 5658, 5659, 5660, 
5661, 5662, 5663, 5664, 5665, 5666, 5667, 5668, 5669, 5670, 
5671, 5672, 5673, 5674, 5675, 5676, 5677, 5678, 5679, 5680, 
5681, 5682, 5683, 5684, 5685, 5686, 5687, 5688, 5689, 5690, 
5691, 5692, 5693, 5694, 5695, 5696, 5697, 5698, 5699, 5700, 
5701, 5702, 5703, 5704, 5705, 5706, 5707, 5708, 5709, 5710, 
5711, 5712, 5713, 5714, 5715, 5716, 5717, 5718, 5719, 5720, 
5721, 5722, 5723, 5724, 5725, 5726, 5727, 5728, 5729, 5730, 
5731, 5732, 5733, 5734, 5735, 5736, 5737, 5738, 5739, 5740, 
5741, 5742, 5743, 5744, 5745, 5746, 5747, 5748, 5749, 5750, 
5751, 5752, 5753, 5754, 5755, 5756, 5757, 5758, 5759, 5760, 
5761, 5762, 5763, 5764, 5765, 5766, 5767, 5768, 5769, 5770, 
5771, 5772, 5773, 5774, 5775, 5776, 5777, 5778, 5779, 5780, 
5781, 5782, 5783, 5784, 5785, 5786, 5787, 5788, 5789, 5790, 
5791, 5792, 5793, 5794, 5795, 5796, 5797, 5798, 5799, 5800, 
5801, 5802, 5803, 5804, 5805, 5806, 5807, 5808, 5809, 5810, 
5811, 5812, 5813, 5814, 5815, 5816, 5817, 5818, 5819, 5820, 
5821, 5822, 5823, 5824, 5825, 5826, 5827, 5828, 5829, 5830, 
5831, 5832, 5833, 5834, 5835, 5836, 5837, 5838, 5839, 5840, 
5841, 5842, 5843, 5844, 5845, 5846, 5847, 5848, 5849, 5850, 
5851, 5852, 5853, 5854, 5855, 5856, 5857, 5858, 5859, 5860, 
5861, 5862, 5863, 5864, 5865, 5866, 5867, 5868, 5869, 5870, 
5871, 5872, 5873, 5874, 5875, 5876, 5877, 5878, 5879, 5880, 
5881, 5882, 5883, 5884, 5885, 5886, 5887, 5888, 5889, 5890, 
5891, 5892, 5893, 5894, 5895, 5896, 5897, 5898, 5899, 5900, 
5901, 5902, 5903, 5904, 5905, 5906, 5907, 5908, 5909, 5910, 
5911, 5912, 5913, 5914, 5915, 5916, 5917, 5918, 5919, 5920, 
5921, 5922, 5923, 5924, 5925, 5926, 5927, 5928, 5929, 5930, 
5931, 5932, 5933, 5934, 5935, 5936, 5937, 5938, 5939, 5940, 
5941, 5942, 5943, 5944, 5945, 5946, 5947, 5948, 5949, 5950, 
5951, 5952, 5953, 5954, 5955, 5956, 5957, 5958, 5959, 5960, 
5961, 5962, 5963, 5964, 5965, 5966, 5967, 5968, 5969, 5970, 
5971, 5972, 5973, 5974, 5975, 5976, 5977, 5978, 5979, 5980, 
5981, 5982, 5983, 5984, 5985, 5986, 5987, 5988, 5989, 5990, 
5991, 5992, 5993, 5994, 5995, 5996, 5997, 5998, 5999, 6000, 
6001, 6002, 6003, 6004, 6005, 6006, 6007, 6008, 6009, 6010, 
6011, 6012, 6013, 6014, 6015, 6016, 6017, 6018, 6019, 6020, 
6021, 6022, 6023, 6024, 6025, 6026, 6027, 6028, 6029, 6030, 
6031, 6032, 6033, 6034, 6035, 6036, 6037, 6038, 6039, 6040, 
6041, 6042, 6043, 6044, 6045, 6046, 6047, 6048, 6049, 6050, 
6051, 6052, 6053, 6054, 6055, 6056, 12631, 12632, 12633, 12634, 
12635, 12636, 12637, 12638, 12639, 12640, 12641, 12642, 12643, 12644, 
12645, 12646, 12647, 12648, 12649, 12650, 12651, 12652, 12653, 12654, 
12655, 12656, 12657, 12658, 12659, 12660, 12661, 12662, 12663, 12664, 
12665, 12666, 12667, 12668, 12669, 12670, 12671, 12672, 12673, 12674, 
12675, 12676, 12677, 12678, 12679, 12680, 12681, 12682, 12683, 12684, 
12685, 12686, 12687, 12688, 12689, 12690, 12691, 12692, 12693, 12694, 
12695, 12696, 12697, 12698, 12699, 12700, 12701, 12702, 12703, 12704, 
12705, 12706, 12707, 12708, 12709, 12710, 12711, 12712, 12713, 12714, 
12715, 12716, 12717, 12718, 12719, 12720, 12721, 12722, 12723, 12724, 
12725, 12726, 12727, 12728, 12729, 12730, 12731, 12732, 12733, 12734, 
12735, 12736, 12737, 12738, 12739, 12740, 12741, 12742, 12743, 12744, 
12745, 12746, 12747, 12748, 12749, 12750, 12751, 12752, 12753, 12754, 
12755, 12756, 12757, 12758, 12759, 12760, 12761, 12762, 12763, 12764, 
12765, 12766, 12767, 12768, 12769, 12770, 12771, 12772, 12773, 12774, 
12775, 12776, 12777, 12778, 12779, 12780, 12781, 12782, 12783, 12784, 
12785, 12786, 12787, 12788, 12789, 12790, 12791, 12792, 12793, 12794, 
12795, 12796, 12797, 12798, 12799, 12800, 12801, 12802, 12803, 12804, 
12805, 12806, 12807, 12808, 12809, 12810, 12811, 12812, 12813, 12814, 
12815, 12816, 12817, 12818, 12819, 12820, 12821, 12822, 12823, 12824, 
12825, 12826, 12827, 12828, 12829, 12830, 12831, 12832, 12833, 12834, 
12835, 12836, 12837, 12838, 12839, 12840, 12841, 12842, 12843, 12844, 
12845, 12846, 12847, 12848, 12849, 12850, 12851, 12852, 12853, 12854, 
12855, 12856, 12857, 12858, 12859, 12860, 12861, 12862, 12863, 12864, 
12865, 12866, 12867, 12868, 12869, 12870, 12871, 12872, 12873, 12874, 
12875, 12876, 12877, 12878, 12879, 12880, 12881, 12882, 12883, 12884, 
12885, 12886, 12887, 12888, 12889, 12890, 12891, 12892, 12893, 12894, 
12895, 12896, 12897, 12898, 12899, 12900, 12901, 12902, 12903, 12904, 
12905, 12906, 12907, 12908, 12909, 12910, 12911, 12912, 12913, 12914, 
12915, 12916, 12917, 12918, 12919, 12920, 12921, 12922, 12923, 12924, 
12925, 12926, 12927, 12928, 12929, 12930, 12931, 12932, 12933, 12934, 
12935, 12936, 12937, 12938, 12939, 12940, 12941, 12942, 12943, 12944, 
12945, 12946, 12947, 12948, 12949, 12950, 12951, 12952, 12953, 12954, 
12955, 12956, 12957, 12958, 12959, 12960, 12961, 12962, 12963, 12964, 
12965, 12966, 12967, 12968, 12969, 12970, 12971, 12972, 12973, 12974, 
12975, 12976, 12977, 12978, 12979, 12980, 12981, 12982, 12983, 12984, 
12985, 12986, 12987, 12988, 12989, 12990, 12991, 12992, 12993, 12994, 
12995, 12996, 12997, 12998, 12999, 13000, 13001, 13002, 13003, 13004, 
13005, 13006, 13007, 13008, 13009, 13010, 13011, 13012, 13013, 13014, 
13015, 13016, 13017, 13018, 13019, 13020, 13021, 13022, 13023, 13024, 
13025, 13026, 13027, 13028, 13029, 13030, 13031, 13032, 13033, 13034, 
13035, 13036, 13037, 13038, 13039, 13040, 13041, 13042, 13043, 13044, 
13045, 13046, 13047, 13048, 13049, 13050, 13051, 13052, 13053, 13054, 
13055, 13056, 13057, 13058, 13059, 13060, 13061, 13062, 13063, 13064, 
13065, 13066, 13067, 13068, 13069, 13070, 13071, 13072, 13073, 13074, 
13075, 13076, 13077, 13078, 13079, 13080, 13081, 13082, 13083, 13084, 
13085, 13086, 13087, 13088, 13089, 13090, 13091, 13092, 13093, 13094, 
13095, 13096, 13097, 13098, 13099, 13100, 13101, 13102, 13103, 13104, 
13105, 13106, 13107, 13108, 13109, 13110, 13111, 13112, 13113, 13114, 
13115, 13116, 13117, 13118, 13119, 13120, 13121, 13122, 13123, 13124, 
13125, 13126, 13127, 13128, 13129, 13130, 13131, 13132, 13133, 13134, 
13135, 13136, 13137, 13138, 13139, 13140, 13141, 13142, 13143, 13144, 
13145, 13146, 13147, 13148, 13149, 13150, 13151, 13152, 13153, 13154, 
13155, 13156, 13157, 13158, 13159, 13160, 13161, 13162, 13163, 13164, 
13165, 13166, 13167, 13168, 13169, 13170, 13171, 13172, 13173, 13174, 
13175, 13176, 13177, 13178, 13179, 13180, 13181, 13182, 13183, 13184, 
13185, 13186, 13187, 13188, 13189, 13190, 13191, 13192, 13193, 13194, 
13195, 13196, 13197, 13198, 13199, 13200, 13201, 13202, 13203, 13204, 
13205, 13206, 13207, 13208, 13209, 13210, 13211, 13212, 13213, 13214, 
13215, 13216, 13217, 13218, 13219, 13220, 13221, 13222, 13223, 13224, 
13225, 13226, 13227, 13228, 13229, 13230, 13231, 13232, 13233, 13234, 
13235, 13236, 13237, 13238, 13239, 13240, 13241, 13242, 13243, 13244, 
13245, 13246, 13247, 13248, 13249, 13250, 13251, 13252, 13253, 13254, 
13255, 13256, 13257, 13258, 13259, 13260, 13261, 13262, 13263, 13264, 
13265, 13266, 13267, 13268, 13269, 13270, 13271, 13272, 13273, 13274, 
13275, 13276, 13277, 13278, 13279, 13280, 13281, 13282, 13283, 13284, 
13285, 13286, 13287, 13288, 13289, 13290, 13291, 13292, 13293, 13294, 
13295, 13296, 13297, 13298, 13299, 13300, 13301, 13302, 13303, 13304, 
13305, 13306, 13307, 13308, 13309, 13310, 13311, 13312, 13313, 13314, 
13315, 13316, 13317, 13318, 13319, 13320, 13321, 13322, 13323, 13324, 
13325, 13326, 13327, 13328, 13329, 13330, 13331, 13332, 13333, 13334, 
13335, 13336, 13337, 13338, 13339, 13340, 13341, 13342, 13343, 13344, 
13345, 13346, 13347, 13348, 13349, 13350, 13351, 13352, 13353, 13354, 
13355, 13356, 13357, 13358, 13359, 13360, 13361, 13362, 13363, 13364, 
13365, 13366, 13367, 13368, 13369, 13370, 13371, 13372, 13373, 13374, 
13375, 13376, 13377, 13378, 13379, 13380, 13381, 13382, 13383, 13384, 
13385, 13386, 13387, 13388, 13389, 13390, 13391, 13392, 13393, 13394, 
13395, 13396, 13397, 13398, 13399, 13400, 13401, 13402, 13403, 13404, 
13405, 13406, 13407, 13408, 13409, 13410, 13411, 13412, 13413, 13414, 
13415, 13416, 13417, 13418, 13419, 13420, 13421, 13422, 13423, 13424, 
13425, 13426, 13427, 13428, 13429, 13430, 13431, 13432, 13433, 13434, 
13435, 13436, 13437, 13438, 13439, 13440, 13441, 13442, 13443, 13444, 
13445, 13446, 13447, 13448, 13449, 13450, 13451, 13452, 13453, 13454, 
13455, 13456, 13457, 13458, 13459, 13460, 13461, 13462, 13463, 13464, 
13465, 13466, 13467, 13468, 13469, 13470, 13471, 13472, 13473, 13474, 
13475, 13476, 13477, 13478, 13479, 13480, 13481, 13482, 13483, 13484, 
13485, 13486, 13487, 13488, 13489, 13490, 13491, 13492, 13493, 13494, 
13495, 13496, 13497, 13498, 13499, 13500, 13501, 13502, 13503, 13504, 
13505, 13506, 13507, 13508, 13509, 13510, 13511, 13512, 13513, 13514, 
13515, 13516, 13517, 13518, 13519, 13520, 13521, 13522, 13523, 13524, 
13525, 13526, 13527, 13528, 13529, 13530, 13531, 13532, 13533, 13534, 
13535, 13536, 13537, 13538, 13539, 13540, 13541, 13542, 13543, 13544, 
13545, 13546, 13547, 13548, 13549, 13550, 13551, 13552, 13553, 13554, 
13555, 13556, 13557, 13558, 13559, 13560, 13561, 13562, 13563, 13564, 
13565, 13566, 13567, 13568, 13569, 13570, 13571, 13572, 13573, 13574, 
13575, 13576, 13577, 13578, 13579, 13580, 13581, 13582, 13583, 13584, 
13585, 13586, 13587, 13588, 13589, 13590, 13591, 13592, 13593, 13594, 
13595, 13596, 13597, 13598, 13599, 13600, 13601, 13602, 13603, 13604, 
13605, 13606, 13607, 13608, 13609, 13610, 13611, 13612, 13613, 13614, 
13615, 13616, 13617, 13618, 13619, 13620, 13621, 13622, 13623, 13624, 
13625, 13626, 13627, 13628, 13629, 13630, 13631, 13632, 13633, 13634, 
13635, 13636, 13637, 13638, 13639, 13640, 13641, 13642, 13643, 13644, 
13645, 13646, 13647, 13648, 13649, 13650, 13651, 13652, 13653, 13654, 
13655, 13656, 13657, 13658, 13659, 13660, 13661, 13662, 13663, 13664, 
13665, 13666, 13667, 13668, 13669, 13670, 13671, 13672, 13673, 13674, 
13675, 13676, 13677, 13678, 13679, 13680, 13681, 13682, 13683, 13684, 
13685, 13686, 13687, 13688, 13689, 13690, 13691, 13692, 13693, 13694, 
13695, 13696, 13697, 13698, 13699, 13700, 13701, 13702, 13703, 13704, 
13705, 13706, 13707, 13708, 13709, 13710, 13711, 13712, 13713, 13714, 
13715, 13716, 13717, 13718, 13719, 13720, 13721, 13722, 13723, 13724, 
13725, 13726, 13727, 13728, 13729, 13730, 13731, 13732, 13733, 13734, 
13735, 13736, 13737, 13738, 13739, 13740, 13741, 13742, 13743, 13744, 
13745, 13746, 13747, 13748, 13749, 13750, 13751, 13752, 13753, 13754, 
13755, 13756, 13757, 13758, 13759, 13760, 13761, 13762, 13763, 13764, 
13765, 13766, 13767, 13768, 13769, 13770, 13771, 13772, 13773, 13774, 
13775, 13776, 13777, 13778, 13779, 13780, 13781, 13782, 13783, 13784, 
13785, 13786, 13787, 13788, 13789, 13790, 13791, 13792, 13793, 13794, 
13795, 13796, 13797, 13798, 13799, 13800, 13801, 13802, 13803, 13804, 
13805, 13806, 13807, 13808, 13809, 13810, 13811, 13812, 13813, 13814, 
13815, 13816, 13817, 13818, 13819, 13820, 13821, 13822, 13823, 13824, 
13825, 13826, 13827, 13828, 13829, 13830, 13831, 13832, 13833, 13834, 
13835, 13836, 13837, 13838, 13839, 13840, 13841, 13842, 13843, 13844, 
13845, 13846, 13847, 13848, 13849, 13850, 13851, 13852, 13853, 13854, 
13855, 13856, 13857, 13858, 13859, 13860, 13861, 13862, 13863, 13864, 
13865, 13866, 13867, 13868, 13869, 13870, 13871, 13872, 13873, 13874, 
13875, 13876, 13877, 13878, 13879, 13880, 13881, 13882, 13883, 13884, 
13885, 13886, 13887, 13888, 13889, 13890, 13891, 13892, 13893, 13894, 
13895, 13896, 13897, 13898, 13899, 13900, 13901, 13902, 13903, 13904, 
13905, 13906, 13907, 13908, 13909, 13910, 13911, 13912, 13913, 13914, 
13915, 13916, 13917, 13918, 13919, 13920, 13921, 13922, 13923, 13924, 
13925, 13926, 13927, 13928, 13929, 13930, 13931, 13932, 13933, 13934, 
13935, 13936, 13937, 13938, 13939, 13940, 13941, 13942, 13943, 13944, 
13945, 13946, 13947, 13948, 13949, 13950, 13951, 13952, 13953, 13954, 
13955, 13956, 13957, 13958, 13959, 13960, 13961, 13962, 13963, 13964, 
13965, 13966, 13967, 13968, 13969, 13970, 13971, 13972, 13973, 13974, 
13975, 13976, 13977, 13978, 13979, 13980, 13981, 13982, 13983, 13984, 
13985, 13986, 13987, 13988, 13989, 13990, 13991, 13992, 13993, 13994, 
13995, 13996, 13997, 13998, 13999, 14000, 14001, 14002, 14003, 14004, 
14005, 14006, 14007, 14008, 14009, 14010, 14011, 14012, 14013, 14014, 
14015, 14016, 14017, 14018, 14019, 14020, 14021, 14022, 14023, 14024, 
14025, 14026, 14027, 14028, 14029, 14030, 14031, 14032, 14033, 14034, 
14035, 14036, 14037, 14038, 14039, 14040, 14041, 14042, 14043, 14044, 
14045, 14046, 14047, 14048, 14049, 14050, 14051, 14052, 14053, 14054, 
14055, 14056, 14057, 14058, 14059, 14060, 14061, 14062, 14063, 14064, 
14065, 14066, 14067, 14068, 14069, 14070, 14071, 14072, 14073, 14074, 
14075, 14076, 14077, 14078, 14079, 14080, 14081, 14082, 14083, 14084, 
14085, 14086, 14087, 14088, 14089, 14090, 14091, 14092, 14093, 14094, 
14095, 14096, 14097, 14098, 14099, 14100, 14101, 14102, 14103, 14104, 
14105, 14106, 14107, 14108, 14109, 14110, 14111, 14112, 14113, 14114, 
14115, 14116, 14117, 14118, 14119, 14120, 14121, 14122, 14123, 14124, 
14125, 14126, 14127, 14128, 14129, 14130, 14131, 14132, 14133, 14134, 
14135, 14136, 14137, 14138, 14139, 14140, 14141, 14142, 14143, 14144, 
14145, 14146, 14147, 14148, 14149, 14150, 14151, 14152, 14153, 14154, 
14155, 14156, 14157, 14158, 14159, 14160, 14161, 14162, 14163, 14164, 
14165, 14166, 14167, 14168, 14169, 14170, 14171, 14172, 14173, 14174, 
14175, 14176, 14177, 14178, 14179, 14180, 14181, 14182, 14183, 14184, 
14185, 14186, 14187, 14188, 14189, 14190, 14191, 14192, 14193, 14194, 
14195, 14196, 14197, 14198, 14199, 14200, 14201, 14202, 14203, 14204, 
14205, 14206, 14207, 14208, 14209, 14210, 14211, 14212, 14213, 14214, 
14215, 14216, 14217, 14218, 14219, 14220, 14221, 14222, 14223, 14224, 
14225, 14226, 14227, 14228, 14229, 14230, 14231, 14232, 14233, 14234, 
14235, 14236, 14237, 14238, 14239, 14240, 14241, 14242, 14243, 14244, 
14245, 14246, 14247, 14248, 14249, 14250, 14251, 14252, 14253, 14254, 
14255, 14256, 14257, 14258, 14259, 14260, 14261, 14262, 14263, 14264, 
14265, 14266, 14267, 14268, 14269, 14270, 14271, 14272, 14273, 14274, 
14275, 14276, 14277, 14278, 14279, 14280, 14281, 14282, 14283, 14284, 
14285, 14286, 14287, 14288, 14289, 14290, 14291, 14292, 14293, 14294, 
