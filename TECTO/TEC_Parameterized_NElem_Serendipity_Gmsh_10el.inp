*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_Serendipity_Gmsh_10el.inp
*NODE
1, 0, 0, 0.5
2, 0, 0, 0
3, 0, 0.1, 0.5
4, 0, 0.1, 0
5, 1, 0, 0.5
6, 1, 0, 0
7, 1, 0.1, 0.5
8, 1, 0.1, 0
9, 1, 0.15, 0
10, 0, 0.15, 0
11, 1, 0.15, 0.5
12, 0, 0.15, 0.5
13, 1, 1.35, 0
14, 0, 1.35, 0
15, 1, 1.35, 0.5
16, 0, 1.35, 0.5
17, 1, 1.4, 0
18, 0, 1.4, 0
19, 1, 1.4, 0.5
20, 0, 1.4, 0.5
21, 1, 1.5, 0
22, 0, 1.5, 0
23, 1, 1.5, 0.5
24, 0, 1.5, 0.5
25, 1.2, 1.4, 0.5
26, 1.2, 1.5, 0.5
27, 1.2, 1.4, 0
28, 1.2, 1.5, 0
29, 2.2, 1.4, 0.5
30, 2.2, 1.5, 0.5
31, 2.2, 1.4, 0
32, 2.2, 1.5, 0
33, 1.2, 1.35, 0.5
34, 2.2, 1.35, 0.5
35, 1.2, 1.35, 0
36, 2.2, 1.35, 0
37, 1.2, 0.15, 0.5
38, 2.2, 0.15, 0.5
39, 1.2, 0.15, 0
40, 2.2, 0.15, 0
41, 1.2, 0.1, 0.5
42, 2.2, 0.1, 0.5
43, 1.2, 0.1, 0
44, 2.2, 0.1, 0
45, 1.2, -1.2490009027033e-16, 0.5
46, 2.2, -1.2490009027033e-16, 0.5
47, 1.2, -1.2490009027033e-16, 0
48, 2.2, -1.2490009027033e-16, 0
49, 2.3, 0.1, 0.5
50, 2.3, -1.2490009027033e-16, 0.5
51, 2.3, 0.1, 0
52, 2.3, -1.2490009027033e-16, 0
53, -0.1, 0, 0.5
54, -0.1, 0, 0
55, -0.1, 0.1, 0.5
56, -0.1, 0.1, 0
57, 1.05, 0.15, 0.5
58, 1.05, 1.35, 0.5
59, 1.05, 0.15, 0
60, 1.05, 1.35, 0
61, 1.15, 1.35, 0.5
62, 1.15, 0.15, 0.5
63, 1.15, 1.35, 0
64, 1.15, 0.15, 0
65, 1, 0.15, -0.1
66, 1, 1.35, -0.1
67, 0, 0.15, -0.1
68, 0, 1.35, -0.1
69, 1.2, 1.35, -0.1
70, 1.2, 0.15, -0.1
71, 2.2, 1.35, -0.1
72, 2.2, 0.15, -0.1
73, 1.15, 1.35, -0.1
74, 1.15, 0.15, -0.1
75, 1.05, 0.15, -0.1
76, 1.05, 1.35, -0.1
77, 1, 1.7, 0
78, 0, 1.7, 0
79, 1, 1.7, 0.5
80, 0, 1.7, 0.5
81, 1.2, 1.7, 0.5
82, 1.2, 1.7, 0
83, 2.2, 1.7, 0.5
84, 2.2, 1.7, 0
85, 1, -0.2, 0
86, 0, -0.2, 0
87, 1, -0.2, 0.5
88, 0, -0.2, 0.5
89, -0.1, -0.2, 0.5
90, -0.1, -0.2, 0
91, 1.2, -0.2, 0.5
92, 2.2, -0.2, 0.5
93, 1.2, -0.2, 0
94, 2.2, -0.2, 0
95, 2.3, -0.2, 0.5
96, 2.3, -0.2, 0
97, 0, 0, 0.041666666666667
98, 0, 0, 0.083333333333333
99, 0, 0, 0.125
100, 0, 0, 0.16666666666667
101, 0, 0, 0.20833333333333
102, 0, 0, 0.25
103, 0, 0, 0.29166666666667
104, 0, 0, 0.33333333333333
105, 0, 0, 0.375
106, 0, 0, 0.41666666666667
107, 0, 0, 0.45833333333333
108, 0, 0, 0.020833333333333
109, 0, 0, 0.0625
110, 0, 0, 0.10416666666667
111, 0, 0, 0.14583333333333
112, 0, 0, 0.1875
113, 0, 0, 0.22916666666667
114, 0, 0, 0.27083333333333
115, 0, 0, 0.3125
116, 0, 0, 0.35416666666667
117, 0, 0, 0.39583333333333
118, 0, 0, 0.4375
119, 0, 0, 0.47916666666667
120, 0, 0.033333333333333, 0.5
121, 0, 0.066666666666667, 0.5
122, 0, 0.016666666666667, 0.5
123, 0, 0.05, 0.5
124, 0, 0.083333333333333, 0.5
125, 0, 0.1, 0.041666666666667
126, 0, 0.1, 0.083333333333333
127, 0, 0.1, 0.125
128, 0, 0.1, 0.16666666666667
129, 0, 0.1, 0.20833333333333
130, 0, 0.1, 0.25
131, 0, 0.1, 0.29166666666667
132, 0, 0.1, 0.33333333333333
133, 0, 0.1, 0.375
134, 0, 0.1, 0.41666666666667
135, 0, 0.1, 0.45833333333333
136, 0, 0.1, 0.020833333333333
137, 0, 0.1, 0.0625
138, 0, 0.1, 0.10416666666667
139, 0, 0.1, 0.14583333333333
140, 0, 0.1, 0.1875
141, 0, 0.1, 0.22916666666667
142, 0, 0.1, 0.27083333333333
143, 0, 0.1, 0.3125
144, 0, 0.1, 0.35416666666667
145, 0, 0.1, 0.39583333333333
146, 0, 0.1, 0.4375
147, 0, 0.1, 0.47916666666667
148, 0, 0.033333333333333, 0
149, 0, 0.066666666666667, 0
150, 0, 0.016666666666667, 0
151, 0, 0.05, 0
152, 0, 0.083333333333333, 0
153, 1, 0, 0.041666666666667
154, 1, 0, 0.083333333333333
155, 1, 0, 0.125
156, 1, 0, 0.16666666666667
157, 1, 0, 0.20833333333333
158, 1, 0, 0.25
159, 1, 0, 0.29166666666667
160, 1, 0, 0.33333333333333
161, 1, 0, 0.375
162, 1, 0, 0.41666666666667
163, 1, 0, 0.45833333333333
164, 1, 0, 0.020833333333333
165, 1, 0, 0.0625
166, 1, 0, 0.10416666666667
167, 1, 0, 0.14583333333333
168, 1, 0, 0.1875
169, 1, 0, 0.22916666666667
170, 1, 0, 0.27083333333333
171, 1, 0, 0.3125
172, 1, 0, 0.35416666666667
173, 1, 0, 0.39583333333333
174, 1, 0, 0.4375
175, 1, 0, 0.47916666666667
176, 1, 0.033333333333333, 0.5
177, 1, 0.066666666666667, 0.5
178, 1, 0.016666666666667, 0.5
179, 1, 0.05, 0.5
180, 1, 0.083333333333333, 0.5
181, 1, 0.1, 0.041666666666667
182, 1, 0.1, 0.083333333333333
183, 1, 0.1, 0.125
184, 1, 0.1, 0.16666666666667
185, 1, 0.1, 0.20833333333333
186, 1, 0.1, 0.25
187, 1, 0.1, 0.29166666666667
188, 1, 0.1, 0.33333333333333
189, 1, 0.1, 0.375
190, 1, 0.1, 0.41666666666667
191, 1, 0.1, 0.45833333333333
192, 1, 0.1, 0.020833333333333
193, 1, 0.1, 0.0625
194, 1, 0.1, 0.10416666666667
195, 1, 0.1, 0.14583333333333
196, 1, 0.1, 0.1875
197, 1, 0.1, 0.22916666666667
198, 1, 0.1, 0.27083333333333
199, 1, 0.1, 0.3125
200, 1, 0.1, 0.35416666666667
201, 1, 0.1, 0.39583333333333
202, 1, 0.1, 0.4375
203, 1, 0.1, 0.47916666666667
204, 1, 0.033333333333333, 0
205, 1, 0.066666666666667, 0
206, 1, 0.016666666666667, 0
207, 1, 0.05, 0
208, 1, 0.083333333333333, 0
209, 0.041666666666667, 0, 0
210, 0.083333333333333, 0, 0
211, 0.125, 0, 0
212, 0.16666666666667, 0, 0
213, 0.20833333333333, 0, 0
214, 0.25, 0, 0
215, 0.29166666666667, 0, 0
216, 0.33333333333333, 0, 0
217, 0.375, 0, 0
218, 0.41666666666667, 0, 0
219, 0.45833333333333, 0, 0
220, 0.5, 0, 0
221, 0.54166666666667, 0, 0
222, 0.58333333333333, 0, 0
223, 0.625, 0, 0
224, 0.66666666666667, 0, 0
225, 0.70833333333333, 0, 0
226, 0.75, 0, 0
227, 0.79166666666667, 0, 0
228, 0.83333333333333, 0, 0
229, 0.875, 0, 0
230, 0.91666666666667, 0, 0
231, 0.95833333333333, 0, 0
232, 0.020833333333333, 0, 0
233, 0.0625, 0, 0
234, 0.10416666666667, 0, 0
235, 0.14583333333333, 0, 0
236, 0.1875, 0, 0
237, 0.22916666666667, 0, 0
238, 0.27083333333333, 0, 0
239, 0.3125, 0, 0
240, 0.35416666666667, 0, 0
241, 0.39583333333333, 0, 0
242, 0.4375, 0, 0
243, 0.47916666666667, 0, 0
244, 0.52083333333333, 0, 0
245, 0.5625, 0, 0
246, 0.60416666666667, 0, 0
247, 0.64583333333333, 0, 0
248, 0.6875, 0, 0
249, 0.72916666666667, 0, 0
250, 0.77083333333333, 0, 0
251, 0.8125, 0, 0
252, 0.85416666666667, 0, 0
253, 0.89583333333333, 0, 0
254, 0.9375, 0, 0
255, 0.97916666666667, 0, 0
256, 0.041666666666667, 0, 0.5
257, 0.083333333333333, 0, 0.5
258, 0.125, 0, 0.5
259, 0.16666666666667, 0, 0.5
260, 0.20833333333333, 0, 0.5
261, 0.25, 0, 0.5
262, 0.29166666666667, 0, 0.5
263, 0.33333333333333, 0, 0.5
264, 0.375, 0, 0.5
265, 0.41666666666667, 0, 0.5
266, 0.45833333333333, 0, 0.5
267, 0.5, 0, 0.5
268, 0.54166666666667, 0, 0.5
269, 0.58333333333333, 0, 0.5
270, 0.625, 0, 0.5
271, 0.66666666666667, 0, 0.5
272, 0.70833333333333, 0, 0.5
273, 0.75, 0, 0.5
274, 0.79166666666667, 0, 0.5
275, 0.83333333333333, 0, 0.5
276, 0.875, 0, 0.5
277, 0.91666666666667, 0, 0.5
278, 0.95833333333333, 0, 0.5
279, 0.020833333333333, 0, 0.5
280, 0.0625, 0, 0.5
281, 0.10416666666667, 0, 0.5
282, 0.14583333333333, 0, 0.5
283, 0.1875, 0, 0.5
284, 0.22916666666667, 0, 0.5
285, 0.27083333333333, 0, 0.5
286, 0.3125, 0, 0.5
287, 0.35416666666667, 0, 0.5
288, 0.39583333333333, 0, 0.5
289, 0.4375, 0, 0.5
290, 0.47916666666667, 0, 0.5
291, 0.52083333333333, 0, 0.5
292, 0.5625, 0, 0.5
293, 0.60416666666667, 0, 0.5
294, 0.64583333333333, 0, 0.5
295, 0.6875, 0, 0.5
296, 0.72916666666667, 0, 0.5
297, 0.77083333333333, 0, 0.5
298, 0.8125, 0, 0.5
299, 0.85416666666667, 0, 0.5
300, 0.89583333333333, 0, 0.5
301, 0.9375, 0, 0.5
302, 0.97916666666667, 0, 0.5
303, 0.041666666666667, 0.1, 0
304, 0.083333333333333, 0.1, 0
305, 0.125, 0.1, 0
306, 0.16666666666667, 0.1, 0
307, 0.20833333333333, 0.1, 0
308, 0.25, 0.1, 0
309, 0.29166666666667, 0.1, 0
310, 0.33333333333333, 0.1, 0
311, 0.375, 0.1, 0
312, 0.41666666666667, 0.1, 0
313, 0.45833333333333, 0.1, 0
314, 0.5, 0.1, 0
315, 0.54166666666667, 0.1, 0
316, 0.58333333333333, 0.1, 0
317, 0.625, 0.1, 0
318, 0.66666666666667, 0.1, 0
319, 0.70833333333333, 0.1, 0
320, 0.75, 0.1, 0
321, 0.79166666666667, 0.1, 0
322, 0.83333333333333, 0.1, 0
323, 0.875, 0.1, 0
324, 0.91666666666667, 0.1, 0
325, 0.95833333333333, 0.1, 0
326, 0.020833333333333, 0.1, 0
327, 0.0625, 0.1, 0
328, 0.10416666666667, 0.1, 0
329, 0.14583333333333, 0.1, 0
330, 0.1875, 0.1, 0
331, 0.22916666666667, 0.1, 0
332, 0.27083333333333, 0.1, 0
333, 0.3125, 0.1, 0
334, 0.35416666666667, 0.1, 0
335, 0.39583333333333, 0.1, 0
336, 0.4375, 0.1, 0
337, 0.47916666666667, 0.1, 0
338, 0.52083333333333, 0.1, 0
339, 0.5625, 0.1, 0
340, 0.60416666666667, 0.1, 0
341, 0.64583333333333, 0.1, 0
342, 0.6875, 0.1, 0
343, 0.72916666666667, 0.1, 0
344, 0.77083333333333, 0.1, 0
345, 0.8125, 0.1, 0
346, 0.85416666666667, 0.1, 0
347, 0.89583333333333, 0.1, 0
348, 0.9375, 0.1, 0
349, 0.97916666666667, 0.1, 0
350, 0.041666666666667, 0.1, 0.5
351, 0.083333333333333, 0.1, 0.5
352, 0.125, 0.1, 0.5
353, 0.16666666666667, 0.1, 0.5
354, 0.20833333333333, 0.1, 0.5
355, 0.25, 0.1, 0.5
356, 0.29166666666667, 0.1, 0.5
357, 0.33333333333333, 0.1, 0.5
358, 0.375, 0.1, 0.5
359, 0.41666666666667, 0.1, 0.5
360, 0.45833333333333, 0.1, 0.5
361, 0.5, 0.1, 0.5
362, 0.54166666666667, 0.1, 0.5
363, 0.58333333333333, 0.1, 0.5
364, 0.625, 0.1, 0.5
365, 0.66666666666667, 0.1, 0.5
366, 0.70833333333333, 0.1, 0.5
367, 0.75, 0.1, 0.5
368, 0.79166666666667, 0.1, 0.5
369, 0.83333333333333, 0.1, 0.5
370, 0.875, 0.1, 0.5
371, 0.91666666666667, 0.1, 0.5
372, 0.95833333333333, 0.1, 0.5
373, 0.020833333333333, 0.1, 0.5
374, 0.0625, 0.1, 0.5
375, 0.10416666666667, 0.1, 0.5
376, 0.14583333333333, 0.1, 0.5
377, 0.1875, 0.1, 0.5
378, 0.22916666666667, 0.1, 0.5
379, 0.27083333333333, 0.1, 0.5
380, 0.3125, 0.1, 0.5
381, 0.35416666666667, 0.1, 0.5
382, 0.39583333333333, 0.1, 0.5
383, 0.4375, 0.1, 0.5
384, 0.47916666666667, 0.1, 0.5
385, 0.52083333333333, 0.1, 0.5
386, 0.5625, 0.1, 0.5
387, 0.60416666666667, 0.1, 0.5
388, 0.64583333333333, 0.1, 0.5
389, 0.6875, 0.1, 0.5
390, 0.72916666666667, 0.1, 0.5
391, 0.77083333333333, 0.1, 0.5
392, 0.8125, 0.1, 0.5
393, 0.85416666666667, 0.1, 0.5
394, 0.89583333333333, 0.1, 0.5
395, 0.9375, 0.1, 0.5
396, 0.97916666666667, 0.1, 0.5
397, 1, 0.125, 0
398, 0, 0.125, 0
399, 0.041666666666667, 0.15, 0
400, 0.083333333333333, 0.15, 0
401, 0.125, 0.15, 0
402, 0.16666666666667, 0.15, 0
403, 0.20833333333333, 0.15, 0
404, 0.25, 0.15, 0
405, 0.29166666666667, 0.15, 0
406, 0.33333333333333, 0.15, 0
407, 0.375, 0.15, 0
408, 0.41666666666667, 0.15, 0
409, 0.45833333333333, 0.15, 0
410, 0.5, 0.15, 0
411, 0.54166666666667, 0.15, 0
412, 0.58333333333333, 0.15, 0
413, 0.625, 0.15, 0
414, 0.66666666666667, 0.15, 0
415, 0.70833333333333, 0.15, 0
416, 0.75, 0.15, 0
417, 0.79166666666667, 0.15, 0
418, 0.83333333333333, 0.15, 0
419, 0.875, 0.15, 0
420, 0.91666666666667, 0.15, 0
421, 0.95833333333333, 0.15, 0
422, 0.020833333333333, 0.15, 0
423, 0.0625, 0.15, 0
424, 0.10416666666667, 0.15, 0
425, 0.14583333333333, 0.15, 0
426, 0.1875, 0.15, 0
427, 0.22916666666667, 0.15, 0
428, 0.27083333333333, 0.15, 0
429, 0.3125, 0.15, 0
430, 0.35416666666667, 0.15, 0
431, 0.39583333333333, 0.15, 0
432, 0.4375, 0.15, 0
433, 0.47916666666667, 0.15, 0
434, 0.52083333333333, 0.15, 0
435, 0.5625, 0.15, 0
436, 0.60416666666667, 0.15, 0
437, 0.64583333333333, 0.15, 0
438, 0.6875, 0.15, 0
439, 0.72916666666667, 0.15, 0
440, 0.77083333333333, 0.15, 0
441, 0.8125, 0.15, 0
442, 0.85416666666667, 0.15, 0
443, 0.89583333333333, 0.15, 0
444, 0.9375, 0.15, 0
445, 0.97916666666667, 0.15, 0
446, 1, 0.125, 0.5
447, 1, 0.15, 0.041666666666667
448, 1, 0.15, 0.083333333333333
449, 1, 0.15, 0.125
450, 1, 0.15, 0.16666666666667
451, 1, 0.15, 0.20833333333333
452, 1, 0.15, 0.25
453, 1, 0.15, 0.29166666666667
454, 1, 0.15, 0.33333333333333
455, 1, 0.15, 0.375
456, 1, 0.15, 0.41666666666667
457, 1, 0.15, 0.45833333333333
458, 1, 0.15, 0.020833333333333
459, 1, 0.15, 0.0625
460, 1, 0.15, 0.10416666666667
461, 1, 0.15, 0.14583333333333
462, 1, 0.15, 0.1875
463, 1, 0.15, 0.22916666666667
464, 1, 0.15, 0.27083333333333
465, 1, 0.15, 0.3125
466, 1, 0.15, 0.35416666666667
467, 1, 0.15, 0.39583333333333
468, 1, 0.15, 0.4375
469, 1, 0.15, 0.47916666666667
470, 0, 0.125, 0.5
471, 0.041666666666667, 0.15, 0.5
472, 0.083333333333333, 0.15, 0.5
473, 0.125, 0.15, 0.5
474, 0.16666666666667, 0.15, 0.5
475, 0.20833333333333, 0.15, 0.5
476, 0.25, 0.15, 0.5
477, 0.29166666666667, 0.15, 0.5
478, 0.33333333333333, 0.15, 0.5
479, 0.375, 0.15, 0.5
480, 0.41666666666667, 0.15, 0.5
481, 0.45833333333333, 0.15, 0.5
482, 0.5, 0.15, 0.5
483, 0.54166666666667, 0.15, 0.5
484, 0.58333333333333, 0.15, 0.5
485, 0.625, 0.15, 0.5
486, 0.66666666666667, 0.15, 0.5
487, 0.70833333333333, 0.15, 0.5
488, 0.75, 0.15, 0.5
489, 0.79166666666667, 0.15, 0.5
490, 0.83333333333333, 0.15, 0.5
491, 0.875, 0.15, 0.5
492, 0.91666666666667, 0.15, 0.5
493, 0.95833333333333, 0.15, 0.5
494, 0.020833333333333, 0.15, 0.5
495, 0.0625, 0.15, 0.5
496, 0.10416666666667, 0.15, 0.5
497, 0.14583333333333, 0.15, 0.5
498, 0.1875, 0.15, 0.5
499, 0.22916666666667, 0.15, 0.5
500, 0.27083333333333, 0.15, 0.5
501, 0.3125, 0.15, 0.5
502, 0.35416666666667, 0.15, 0.5
503, 0.39583333333333, 0.15, 0.5
504, 0.4375, 0.15, 0.5
505, 0.47916666666667, 0.15, 0.5
506, 0.52083333333333, 0.15, 0.5
507, 0.5625, 0.15, 0.5
508, 0.60416666666667, 0.15, 0.5
509, 0.64583333333333, 0.15, 0.5
510, 0.6875, 0.15, 0.5
511, 0.72916666666667, 0.15, 0.5
512, 0.77083333333333, 0.15, 0.5
513, 0.8125, 0.15, 0.5
514, 0.85416666666667, 0.15, 0.5
515, 0.89583333333333, 0.15, 0.5
516, 0.9375, 0.15, 0.5
517, 0.97916666666667, 0.15, 0.5
518, 0, 0.15, 0.041666666666667
519, 0, 0.15, 0.083333333333333
520, 0, 0.15, 0.125
521, 0, 0.15, 0.16666666666667
522, 0, 0.15, 0.20833333333333
523, 0, 0.15, 0.25
524, 0, 0.15, 0.29166666666667
525, 0, 0.15, 0.33333333333333
526, 0, 0.15, 0.375
527, 0, 0.15, 0.41666666666667
528, 0, 0.15, 0.45833333333333
529, 0, 0.15, 0.020833333333333
530, 0, 0.15, 0.0625
531, 0, 0.15, 0.10416666666667
532, 0, 0.15, 0.14583333333333
533, 0, 0.15, 0.1875
534, 0, 0.15, 0.22916666666667
535, 0, 0.15, 0.27083333333333
536, 0, 0.15, 0.3125
537, 0, 0.15, 0.35416666666667
538, 0, 0.15, 0.39583333333333
539, 0, 0.15, 0.4375
540, 0, 0.15, 0.47916666666667
541, 1, 0.2, 0
542, 1, 0.25, 0
543, 1, 0.3, 0
544, 1, 0.35, 0
545, 1, 0.4, 0
546, 1, 0.45, 0
547, 1, 0.5, 0
548, 1, 0.55, 0
549, 1, 0.6, 0
550, 1, 0.65, 0
551, 1, 0.7, 0
552, 1, 0.75, 0
553, 1, 0.8, 0
554, 1, 0.85, 0
555, 1, 0.9, 0
556, 1, 0.95, 0
557, 1, 1, 0
558, 1, 1.05, 0
559, 1, 1.1, 0
560, 1, 1.15, 0
561, 1, 1.2, 0
562, 1, 1.25, 0
563, 1, 1.3, 0
564, 1, 0.175, 0
565, 1, 0.225, 0
566, 1, 0.275, 0
567, 1, 0.325, 0
568, 1, 0.375, 0
569, 1, 0.425, 0
570, 1, 0.475, 0
571, 1, 0.525, 0
572, 1, 0.575, 0
573, 1, 0.625, 0
574, 1, 0.675, 0
575, 1, 0.725, 0
576, 1, 0.775, 0
577, 1, 0.825, 0
578, 1, 0.875, 0
579, 1, 0.925, 0
580, 1, 0.975, 0
581, 1, 1.025, 0
582, 1, 1.075, 0
583, 1, 1.125, 0
584, 1, 1.175, 0
585, 1, 1.225, 0
586, 1, 1.275, 0
587, 1, 1.325, 0
588, 0, 0.2, 0
589, 0, 0.25, 0
590, 0, 0.3, 0
591, 0, 0.35, 0
592, 0, 0.4, 0
593, 0, 0.45, 0
594, 0, 0.5, 0
595, 0, 0.55, 0
596, 0, 0.6, 0
597, 0, 0.65, 0
598, 0, 0.7, 0
599, 0, 0.75, 0
600, 0, 0.8, 0
601, 0, 0.85, 0
602, 0, 0.9, 0
603, 0, 0.95, 0
604, 0, 1, 0
605, 0, 1.05, 0
606, 0, 1.1, 0
607, 0, 1.15, 0
608, 0, 1.2, 0
609, 0, 1.25, 0
610, 0, 1.3, 0
611, 0, 0.175, 0
612, 0, 0.225, 0
613, 0, 0.275, 0
614, 0, 0.325, 0
615, 0, 0.375, 0
616, 0, 0.425, 0
617, 0, 0.475, 0
618, 0, 0.525, 0
619, 0, 0.575, 0
620, 0, 0.625, 0
621, 0, 0.675, 0
622, 0, 0.725, 0
623, 0, 0.775, 0
624, 0, 0.825, 0
625, 0, 0.875, 0
626, 0, 0.925, 0
627, 0, 0.975, 0
628, 0, 1.025, 0
629, 0, 1.075, 0
630, 0, 1.125, 0
631, 0, 1.175, 0
632, 0, 1.225, 0
633, 0, 1.275, 0
634, 0, 1.325, 0
635, 0.041666666666667, 1.35, 0
636, 0.083333333333333, 1.35, 0
637, 0.125, 1.35, 0
638, 0.16666666666667, 1.35, 0
639, 0.20833333333333, 1.35, 0
640, 0.25, 1.35, 0
641, 0.29166666666667, 1.35, 0
642, 0.33333333333333, 1.35, 0
643, 0.375, 1.35, 0
644, 0.41666666666667, 1.35, 0
645, 0.45833333333333, 1.35, 0
646, 0.5, 1.35, 0
647, 0.54166666666667, 1.35, 0
648, 0.58333333333333, 1.35, 0
649, 0.625, 1.35, 0
650, 0.66666666666667, 1.35, 0
651, 0.70833333333333, 1.35, 0
652, 0.75, 1.35, 0
653, 0.79166666666667, 1.35, 0
654, 0.83333333333333, 1.35, 0
655, 0.875, 1.35, 0
656, 0.91666666666667, 1.35, 0
657, 0.95833333333333, 1.35, 0
658, 0.020833333333333, 1.35, 0
659, 0.0625, 1.35, 0
660, 0.10416666666667, 1.35, 0
661, 0.14583333333333, 1.35, 0
662, 0.1875, 1.35, 0
663, 0.22916666666667, 1.35, 0
664, 0.27083333333333, 1.35, 0
665, 0.3125, 1.35, 0
666, 0.35416666666667, 1.35, 0
667, 0.39583333333333, 1.35, 0
668, 0.4375, 1.35, 0
669, 0.47916666666667, 1.35, 0
670, 0.52083333333333, 1.35, 0
671, 0.5625, 1.35, 0
672, 0.60416666666667, 1.35, 0
673, 0.64583333333333, 1.35, 0
674, 0.6875, 1.35, 0
675, 0.72916666666667, 1.35, 0
676, 0.77083333333333, 1.35, 0
677, 0.8125, 1.35, 0
678, 0.85416666666667, 1.35, 0
679, 0.89583333333333, 1.35, 0
680, 0.9375, 1.35, 0
681, 0.97916666666667, 1.35, 0
682, 1, 0.2, 0.5
683, 1, 0.25, 0.5
684, 1, 0.3, 0.5
685, 1, 0.35, 0.5
686, 1, 0.4, 0.5
687, 1, 0.45, 0.5
688, 1, 0.5, 0.5
689, 1, 0.55, 0.5
690, 1, 0.6, 0.5
691, 1, 0.65, 0.5
692, 1, 0.7, 0.5
693, 1, 0.75, 0.5
694, 1, 0.8, 0.5
695, 1, 0.85, 0.5
696, 1, 0.9, 0.5
697, 1, 0.95, 0.5
698, 1, 1, 0.5
699, 1, 1.05, 0.5
700, 1, 1.1, 0.5
701, 1, 1.15, 0.5
702, 1, 1.2, 0.5
703, 1, 1.25, 0.5
704, 1, 1.3, 0.5
705, 1, 0.175, 0.5
706, 1, 0.225, 0.5
707, 1, 0.275, 0.5
708, 1, 0.325, 0.5
709, 1, 0.375, 0.5
710, 1, 0.425, 0.5
711, 1, 0.475, 0.5
712, 1, 0.525, 0.5
713, 1, 0.575, 0.5
714, 1, 0.625, 0.5
715, 1, 0.675, 0.5
716, 1, 0.725, 0.5
717, 1, 0.775, 0.5
718, 1, 0.825, 0.5
719, 1, 0.875, 0.5
720, 1, 0.925, 0.5
721, 1, 0.975, 0.5
722, 1, 1.025, 0.5
723, 1, 1.075, 0.5
724, 1, 1.125, 0.5
725, 1, 1.175, 0.5
726, 1, 1.225, 0.5
727, 1, 1.275, 0.5
728, 1, 1.325, 0.5
729, 1, 1.35, 0.041666666666667
730, 1, 1.35, 0.083333333333333
731, 1, 1.35, 0.125
732, 1, 1.35, 0.16666666666667
733, 1, 1.35, 0.20833333333333
734, 1, 1.35, 0.25
735, 1, 1.35, 0.29166666666667
736, 1, 1.35, 0.33333333333333
737, 1, 1.35, 0.375
738, 1, 1.35, 0.41666666666667
739, 1, 1.35, 0.45833333333333
740, 1, 1.35, 0.020833333333333
741, 1, 1.35, 0.0625
742, 1, 1.35, 0.10416666666667
743, 1, 1.35, 0.14583333333333
744, 1, 1.35, 0.1875
745, 1, 1.35, 0.22916666666667
746, 1, 1.35, 0.27083333333333
747, 1, 1.35, 0.3125
748, 1, 1.35, 0.35416666666667
749, 1, 1.35, 0.39583333333333
750, 1, 1.35, 0.4375
751, 1, 1.35, 0.47916666666667
752, 0, 0.2, 0.5
753, 0, 0.25, 0.5
754, 0, 0.3, 0.5
755, 0, 0.35, 0.5
756, 0, 0.4, 0.5
757, 0, 0.45, 0.5
758, 0, 0.5, 0.5
759, 0, 0.55, 0.5
760, 0, 0.6, 0.5
761, 0, 0.65, 0.5
762, 0, 0.7, 0.5
763, 0, 0.75, 0.5
764, 0, 0.8, 0.5
765, 0, 0.85, 0.5
766, 0, 0.9, 0.5
767, 0, 0.95, 0.5
768, 0, 1, 0.5
769, 0, 1.05, 0.5
770, 0, 1.1, 0.5
771, 0, 1.15, 0.5
772, 0, 1.2, 0.5
773, 0, 1.25, 0.5
774, 0, 1.3, 0.5
775, 0, 0.175, 0.5
776, 0, 0.225, 0.5
777, 0, 0.275, 0.5
778, 0, 0.325, 0.5
779, 0, 0.375, 0.5
780, 0, 0.425, 0.5
781, 0, 0.475, 0.5
782, 0, 0.525, 0.5
783, 0, 0.575, 0.5
784, 0, 0.625, 0.5
785, 0, 0.675, 0.5
786, 0, 0.725, 0.5
787, 0, 0.775, 0.5
788, 0, 0.825, 0.5
789, 0, 0.875, 0.5
790, 0, 0.925, 0.5
791, 0, 0.975, 0.5
792, 0, 1.025, 0.5
793, 0, 1.075, 0.5
794, 0, 1.125, 0.5
795, 0, 1.175, 0.5
796, 0, 1.225, 0.5
797, 0, 1.275, 0.5
798, 0, 1.325, 0.5
799, 0.041666666666667, 1.35, 0.5
800, 0.083333333333333, 1.35, 0.5
801, 0.125, 1.35, 0.5
802, 0.16666666666667, 1.35, 0.5
803, 0.20833333333333, 1.35, 0.5
804, 0.25, 1.35, 0.5
805, 0.29166666666667, 1.35, 0.5
806, 0.33333333333333, 1.35, 0.5
807, 0.375, 1.35, 0.5
808, 0.41666666666667, 1.35, 0.5
809, 0.45833333333333, 1.35, 0.5
810, 0.5, 1.35, 0.5
811, 0.54166666666667, 1.35, 0.5
812, 0.58333333333333, 1.35, 0.5
813, 0.625, 1.35, 0.5
814, 0.66666666666667, 1.35, 0.5
815, 0.70833333333333, 1.35, 0.5
816, 0.75, 1.35, 0.5
817, 0.79166666666667, 1.35, 0.5
818, 0.83333333333333, 1.35, 0.5
819, 0.875, 1.35, 0.5
820, 0.91666666666667, 1.35, 0.5
821, 0.95833333333333, 1.35, 0.5
822, 0.020833333333333, 1.35, 0.5
823, 0.0625, 1.35, 0.5
824, 0.10416666666667, 1.35, 0.5
825, 0.14583333333333, 1.35, 0.5
826, 0.1875, 1.35, 0.5
827, 0.22916666666667, 1.35, 0.5
828, 0.27083333333333, 1.35, 0.5
829, 0.3125, 1.35, 0.5
830, 0.35416666666667, 1.35, 0.5
831, 0.39583333333333, 1.35, 0.5
832, 0.4375, 1.35, 0.5
833, 0.47916666666667, 1.35, 0.5
834, 0.52083333333333, 1.35, 0.5
835, 0.5625, 1.35, 0.5
836, 0.60416666666667, 1.35, 0.5
837, 0.64583333333333, 1.35, 0.5
838, 0.6875, 1.35, 0.5
839, 0.72916666666667, 1.35, 0.5
840, 0.77083333333333, 1.35, 0.5
841, 0.8125, 1.35, 0.5
842, 0.85416666666667, 1.35, 0.5
843, 0.89583333333333, 1.35, 0.5
844, 0.9375, 1.35, 0.5
845, 0.97916666666667, 1.35, 0.5
846, 0, 1.35, 0.041666666666667
847, 0, 1.35, 0.083333333333333
848, 0, 1.35, 0.125
849, 0, 1.35, 0.16666666666667
850, 0, 1.35, 0.20833333333333
851, 0, 1.35, 0.25
852, 0, 1.35, 0.29166666666667
853, 0, 1.35, 0.33333333333333
854, 0, 1.35, 0.375
855, 0, 1.35, 0.41666666666667
856, 0, 1.35, 0.45833333333333
857, 0, 1.35, 0.020833333333333
858, 0, 1.35, 0.0625
859, 0, 1.35, 0.10416666666667
860, 0, 1.35, 0.14583333333333
861, 0, 1.35, 0.1875
862, 0, 1.35, 0.22916666666667
863, 0, 1.35, 0.27083333333333
864, 0, 1.35, 0.3125
865, 0, 1.35, 0.35416666666667
866, 0, 1.35, 0.39583333333333
867, 0, 1.35, 0.4375
868, 0, 1.35, 0.47916666666667
869, 1, 1.375, 0
870, 0, 1.375, 0
871, 0.041666666666667, 1.4, 0
872, 0.083333333333333, 1.4, 0
873, 0.125, 1.4, 0
874, 0.16666666666667, 1.4, 0
875, 0.20833333333333, 1.4, 0
876, 0.25, 1.4, 0
877, 0.29166666666667, 1.4, 0
878, 0.33333333333333, 1.4, 0
879, 0.375, 1.4, 0
880, 0.41666666666667, 1.4, 0
881, 0.45833333333333, 1.4, 0
882, 0.5, 1.4, 0
883, 0.54166666666667, 1.4, 0
884, 0.58333333333333, 1.4, 0
885, 0.625, 1.4, 0
886, 0.66666666666667, 1.4, 0
887, 0.70833333333333, 1.4, 0
888, 0.75, 1.4, 0
889, 0.79166666666667, 1.4, 0
890, 0.83333333333333, 1.4, 0
891, 0.875, 1.4, 0
892, 0.91666666666667, 1.4, 0
893, 0.95833333333333, 1.4, 0
894, 0.020833333333333, 1.4, 0
895, 0.0625, 1.4, 0
896, 0.10416666666667, 1.4, 0
897, 0.14583333333333, 1.4, 0
898, 0.1875, 1.4, 0
899, 0.22916666666667, 1.4, 0
900, 0.27083333333333, 1.4, 0
901, 0.3125, 1.4, 0
902, 0.35416666666667, 1.4, 0
903, 0.39583333333333, 1.4, 0
904, 0.4375, 1.4, 0
905, 0.47916666666667, 1.4, 0
906, 0.52083333333333, 1.4, 0
907, 0.5625, 1.4, 0
908, 0.60416666666667, 1.4, 0
909, 0.64583333333333, 1.4, 0
910, 0.6875, 1.4, 0
911, 0.72916666666667, 1.4, 0
912, 0.77083333333333, 1.4, 0
913, 0.8125, 1.4, 0
914, 0.85416666666667, 1.4, 0
915, 0.89583333333333, 1.4, 0
916, 0.9375, 1.4, 0
917, 0.97916666666667, 1.4, 0
918, 1, 1.375, 0.5
919, 1, 1.4, 0.041666666666667
920, 1, 1.4, 0.083333333333333
921, 1, 1.4, 0.125
922, 1, 1.4, 0.16666666666667
923, 1, 1.4, 0.20833333333333
924, 1, 1.4, 0.25
925, 1, 1.4, 0.29166666666667
926, 1, 1.4, 0.33333333333333
927, 1, 1.4, 0.375
928, 1, 1.4, 0.41666666666667
929, 1, 1.4, 0.45833333333333
930, 1, 1.4, 0.020833333333333
931, 1, 1.4, 0.0625
932, 1, 1.4, 0.10416666666667
933, 1, 1.4, 0.14583333333333
934, 1, 1.4, 0.1875
935, 1, 1.4, 0.22916666666667
936, 1, 1.4, 0.27083333333333
937, 1, 1.4, 0.3125
938, 1, 1.4, 0.35416666666667
939, 1, 1.4, 0.39583333333333
940, 1, 1.4, 0.4375
941, 1, 1.4, 0.47916666666667
942, 0, 1.375, 0.5
943, 0.041666666666667, 1.4, 0.5
944, 0.083333333333333, 1.4, 0.5
945, 0.125, 1.4, 0.5
946, 0.16666666666667, 1.4, 0.5
947, 0.20833333333333, 1.4, 0.5
948, 0.25, 1.4, 0.5
949, 0.29166666666667, 1.4, 0.5
950, 0.33333333333333, 1.4, 0.5
951, 0.375, 1.4, 0.5
952, 0.41666666666667, 1.4, 0.5
953, 0.45833333333333, 1.4, 0.5
954, 0.5, 1.4, 0.5
955, 0.54166666666667, 1.4, 0.5
956, 0.58333333333333, 1.4, 0.5
957, 0.625, 1.4, 0.5
958, 0.66666666666667, 1.4, 0.5
959, 0.70833333333333, 1.4, 0.5
960, 0.75, 1.4, 0.5
961, 0.79166666666667, 1.4, 0.5
962, 0.83333333333333, 1.4, 0.5
963, 0.875, 1.4, 0.5
964, 0.91666666666667, 1.4, 0.5
965, 0.95833333333333, 1.4, 0.5
966, 0.020833333333333, 1.4, 0.5
967, 0.0625, 1.4, 0.5
968, 0.10416666666667, 1.4, 0.5
969, 0.14583333333333, 1.4, 0.5
970, 0.1875, 1.4, 0.5
971, 0.22916666666667, 1.4, 0.5
972, 0.27083333333333, 1.4, 0.5
973, 0.3125, 1.4, 0.5
974, 0.35416666666667, 1.4, 0.5
975, 0.39583333333333, 1.4, 0.5
976, 0.4375, 1.4, 0.5
977, 0.47916666666667, 1.4, 0.5
978, 0.52083333333333, 1.4, 0.5
979, 0.5625, 1.4, 0.5
980, 0.60416666666667, 1.4, 0.5
981, 0.64583333333333, 1.4, 0.5
982, 0.6875, 1.4, 0.5
983, 0.72916666666667, 1.4, 0.5
984, 0.77083333333333, 1.4, 0.5
985, 0.8125, 1.4, 0.5
986, 0.85416666666667, 1.4, 0.5
987, 0.89583333333333, 1.4, 0.5
988, 0.9375, 1.4, 0.5
989, 0.97916666666667, 1.4, 0.5
990, 0, 1.4, 0.041666666666667
991, 0, 1.4, 0.083333333333333
992, 0, 1.4, 0.125
993, 0, 1.4, 0.16666666666667
994, 0, 1.4, 0.20833333333333
995, 0, 1.4, 0.25
996, 0, 1.4, 0.29166666666667
997, 0, 1.4, 0.33333333333333
998, 0, 1.4, 0.375
999, 0, 1.4, 0.41666666666667
1000, 0, 1.4, 0.45833333333333
1001, 0, 1.4, 0.020833333333333
1002, 0, 1.4, 0.0625
1003, 0, 1.4, 0.10416666666667
1004, 0, 1.4, 0.14583333333333
1005, 0, 1.4, 0.1875
1006, 0, 1.4, 0.22916666666667
1007, 0, 1.4, 0.27083333333333
1008, 0, 1.4, 0.3125
1009, 0, 1.4, 0.35416666666667
1010, 0, 1.4, 0.39583333333333
1011, 0, 1.4, 0.4375
1012, 0, 1.4, 0.47916666666667
1013, 1, 1.4333333333333, 0
1014, 1, 1.4666666666667, 0
1015, 1, 1.4166666666667, 0
1016, 1, 1.45, 0
1017, 1, 1.4833333333333, 0
1018, 0, 1.4333333333333, 0
1019, 0, 1.4666666666667, 0
1020, 0, 1.4166666666667, 0
1021, 0, 1.45, 0
1022, 0, 1.4833333333333, 0
1023, 0.041666666666667, 1.5, 0
1024, 0.083333333333333, 1.5, 0
1025, 0.125, 1.5, 0
1026, 0.16666666666667, 1.5, 0
1027, 0.20833333333333, 1.5, 0
1028, 0.25, 1.5, 0
1029, 0.29166666666667, 1.5, 0
1030, 0.33333333333333, 1.5, 0
1031, 0.375, 1.5, 0
1032, 0.41666666666667, 1.5, 0
1033, 0.45833333333333, 1.5, 0
1034, 0.5, 1.5, 0
1035, 0.54166666666667, 1.5, 0
1036, 0.58333333333333, 1.5, 0
1037, 0.625, 1.5, 0
1038, 0.66666666666667, 1.5, 0
1039, 0.70833333333333, 1.5, 0
1040, 0.75, 1.5, 0
1041, 0.79166666666667, 1.5, 0
1042, 0.83333333333333, 1.5, 0
1043, 0.875, 1.5, 0
1044, 0.91666666666667, 1.5, 0
1045, 0.95833333333333, 1.5, 0
1046, 0.020833333333333, 1.5, 0
1047, 0.0625, 1.5, 0
1048, 0.10416666666667, 1.5, 0
1049, 0.14583333333333, 1.5, 0
1050, 0.1875, 1.5, 0
1051, 0.22916666666667, 1.5, 0
1052, 0.27083333333333, 1.5, 0
1053, 0.3125, 1.5, 0
1054, 0.35416666666667, 1.5, 0
1055, 0.39583333333333, 1.5, 0
1056, 0.4375, 1.5, 0
1057, 0.47916666666667, 1.5, 0
1058, 0.52083333333333, 1.5, 0
1059, 0.5625, 1.5, 0
1060, 0.60416666666667, 1.5, 0
1061, 0.64583333333333, 1.5, 0
1062, 0.6875, 1.5, 0
1063, 0.72916666666667, 1.5, 0
1064, 0.77083333333333, 1.5, 0
1065, 0.8125, 1.5, 0
1066, 0.85416666666667, 1.5, 0
1067, 0.89583333333333, 1.5, 0
1068, 0.9375, 1.5, 0
1069, 0.97916666666667, 1.5, 0
1070, 1, 1.4333333333333, 0.5
1071, 1, 1.4666666666667, 0.5
1072, 1, 1.4166666666667, 0.5
1073, 1, 1.45, 0.5
1074, 1, 1.4833333333333, 0.5
1075, 1, 1.5, 0.041666666666667
1076, 1, 1.5, 0.083333333333333
1077, 1, 1.5, 0.125
1078, 1, 1.5, 0.16666666666667
1079, 1, 1.5, 0.20833333333333
1080, 1, 1.5, 0.25
1081, 1, 1.5, 0.29166666666667
1082, 1, 1.5, 0.33333333333333
1083, 1, 1.5, 0.375
1084, 1, 1.5, 0.41666666666667
1085, 1, 1.5, 0.45833333333333
1086, 1, 1.5, 0.020833333333333
1087, 1, 1.5, 0.0625
1088, 1, 1.5, 0.10416666666667
1089, 1, 1.5, 0.14583333333333
1090, 1, 1.5, 0.1875
1091, 1, 1.5, 0.22916666666667
1092, 1, 1.5, 0.27083333333333
1093, 1, 1.5, 0.3125
1094, 1, 1.5, 0.35416666666667
1095, 1, 1.5, 0.39583333333333
1096, 1, 1.5, 0.4375
1097, 1, 1.5, 0.47916666666667
1098, 0, 1.4333333333333, 0.5
1099, 0, 1.4666666666667, 0.5
1100, 0, 1.4166666666667, 0.5
1101, 0, 1.45, 0.5
1102, 0, 1.4833333333333, 0.5
1103, 0.041666666666667, 1.5, 0.5
1104, 0.083333333333333, 1.5, 0.5
1105, 0.125, 1.5, 0.5
1106, 0.16666666666667, 1.5, 0.5
1107, 0.20833333333333, 1.5, 0.5
1108, 0.25, 1.5, 0.5
1109, 0.29166666666667, 1.5, 0.5
1110, 0.33333333333333, 1.5, 0.5
1111, 0.375, 1.5, 0.5
1112, 0.41666666666667, 1.5, 0.5
1113, 0.45833333333333, 1.5, 0.5
1114, 0.5, 1.5, 0.5
1115, 0.54166666666667, 1.5, 0.5
1116, 0.58333333333333, 1.5, 0.5
1117, 0.625, 1.5, 0.5
1118, 0.66666666666667, 1.5, 0.5
1119, 0.70833333333333, 1.5, 0.5
1120, 0.75, 1.5, 0.5
1121, 0.79166666666667, 1.5, 0.5
1122, 0.83333333333333, 1.5, 0.5
1123, 0.875, 1.5, 0.5
1124, 0.91666666666667, 1.5, 0.5
1125, 0.95833333333333, 1.5, 0.5
1126, 0.020833333333333, 1.5, 0.5
1127, 0.0625, 1.5, 0.5
1128, 0.10416666666667, 1.5, 0.5
1129, 0.14583333333333, 1.5, 0.5
1130, 0.1875, 1.5, 0.5
1131, 0.22916666666667, 1.5, 0.5
1132, 0.27083333333333, 1.5, 0.5
1133, 0.3125, 1.5, 0.5
1134, 0.35416666666667, 1.5, 0.5
1135, 0.39583333333333, 1.5, 0.5
1136, 0.4375, 1.5, 0.5
1137, 0.47916666666667, 1.5, 0.5
1138, 0.52083333333333, 1.5, 0.5
1139, 0.5625, 1.5, 0.5
1140, 0.60416666666667, 1.5, 0.5
1141, 0.64583333333333, 1.5, 0.5
1142, 0.6875, 1.5, 0.5
1143, 0.72916666666667, 1.5, 0.5
1144, 0.77083333333333, 1.5, 0.5
1145, 0.8125, 1.5, 0.5
1146, 0.85416666666667, 1.5, 0.5
1147, 0.89583333333333, 1.5, 0.5
1148, 0.9375, 1.5, 0.5
1149, 0.97916666666667, 1.5, 0.5
1150, 0, 1.5, 0.041666666666667
1151, 0, 1.5, 0.083333333333333
1152, 0, 1.5, 0.125
1153, 0, 1.5, 0.16666666666667
1154, 0, 1.5, 0.20833333333333
1155, 0, 1.5, 0.25
1156, 0, 1.5, 0.29166666666667
1157, 0, 1.5, 0.33333333333333
1158, 0, 1.5, 0.375
1159, 0, 1.5, 0.41666666666667
1160, 0, 1.5, 0.45833333333333
1161, 0, 1.5, 0.020833333333333
1162, 0, 1.5, 0.0625
1163, 0, 1.5, 0.10416666666667
1164, 0, 1.5, 0.14583333333333
1165, 0, 1.5, 0.1875
1166, 0, 1.5, 0.22916666666667
1167, 0, 1.5, 0.27083333333333
1168, 0, 1.5, 0.3125
1169, 0, 1.5, 0.35416666666667
1170, 0, 1.5, 0.39583333333333
1171, 0, 1.5, 0.4375
1172, 0, 1.5, 0.47916666666667
1173, 1.04, 1.4, 0.5
1174, 1.08, 1.4, 0.5
1175, 1.12, 1.4, 0.5
1176, 1.16, 1.4, 0.5
1177, 1.02, 1.4, 0.5
1178, 1.06, 1.4, 0.5
1179, 1.1, 1.4, 0.5
1180, 1.14, 1.4, 0.5
1181, 1.18, 1.4, 0.5
1182, 1.04, 1.5, 0.5
1183, 1.08, 1.5, 0.5
1184, 1.12, 1.5, 0.5
1185, 1.16, 1.5, 0.5
1186, 1.02, 1.5, 0.5
1187, 1.06, 1.5, 0.5
1188, 1.1, 1.5, 0.5
1189, 1.14, 1.5, 0.5
1190, 1.18, 1.5, 0.5
1191, 1.2, 1.4333333333333, 0.5
1192, 1.2, 1.4666666666667, 0.5
1193, 1.2, 1.4166666666667, 0.5
1194, 1.2, 1.45, 0.5
1195, 1.2, 1.4833333333333, 0.5
1196, 1.04, 1.4, 0
1197, 1.08, 1.4, 0
1198, 1.12, 1.4, 0
1199, 1.16, 1.4, 0
1200, 1.02, 1.4, 0
1201, 1.06, 1.4, 0
1202, 1.1, 1.4, 0
1203, 1.14, 1.4, 0
1204, 1.18, 1.4, 0
1205, 1.04, 1.5, 0
1206, 1.08, 1.5, 0
1207, 1.12, 1.5, 0
1208, 1.16, 1.5, 0
1209, 1.02, 1.5, 0
1210, 1.06, 1.5, 0
1211, 1.1, 1.5, 0
1212, 1.14, 1.5, 0
1213, 1.18, 1.5, 0
1214, 1.2, 1.4333333333333, 0
1215, 1.2, 1.4666666666667, 0
1216, 1.2, 1.4166666666667, 0
1217, 1.2, 1.45, 0
1218, 1.2, 1.4833333333333, 0
1219, 1.2, 1.4, 0.041666666666667
1220, 1.2, 1.4, 0.083333333333333
1221, 1.2, 1.4, 0.125
1222, 1.2, 1.4, 0.16666666666667
1223, 1.2, 1.4, 0.20833333333333
1224, 1.2, 1.4, 0.25
1225, 1.2, 1.4, 0.29166666666667
1226, 1.2, 1.4, 0.33333333333333
1227, 1.2, 1.4, 0.375
1228, 1.2, 1.4, 0.41666666666667
1229, 1.2, 1.4, 0.45833333333333
1230, 1.2, 1.4, 0.020833333333333
1231, 1.2, 1.4, 0.0625
1232, 1.2, 1.4, 0.10416666666667
1233, 1.2, 1.4, 0.14583333333333
1234, 1.2, 1.4, 0.1875
1235, 1.2, 1.4, 0.22916666666667
1236, 1.2, 1.4, 0.27083333333333
1237, 1.2, 1.4, 0.3125
1238, 1.2, 1.4, 0.35416666666667
1239, 1.2, 1.4, 0.39583333333333
1240, 1.2, 1.4, 0.4375
1241, 1.2, 1.4, 0.47916666666667
1242, 1.2, 1.5, 0.041666666666667
1243, 1.2, 1.5, 0.083333333333333
1244, 1.2, 1.5, 0.125
1245, 1.2, 1.5, 0.16666666666667
1246, 1.2, 1.5, 0.20833333333333
1247, 1.2, 1.5, 0.25
1248, 1.2, 1.5, 0.29166666666667
1249, 1.2, 1.5, 0.33333333333333
1250, 1.2, 1.5, 0.375
1251, 1.2, 1.5, 0.41666666666667
1252, 1.2, 1.5, 0.45833333333333
1253, 1.2, 1.5, 0.020833333333333
1254, 1.2, 1.5, 0.0625
1255, 1.2, 1.5, 0.10416666666667
1256, 1.2, 1.5, 0.14583333333333
1257, 1.2, 1.5, 0.1875
1258, 1.2, 1.5, 0.22916666666667
1259, 1.2, 1.5, 0.27083333333333
1260, 1.2, 1.5, 0.3125
1261, 1.2, 1.5, 0.35416666666667
1262, 1.2, 1.5, 0.39583333333333
1263, 1.2, 1.5, 0.4375
1264, 1.2, 1.5, 0.47916666666667
1265, 1.2416666666667, 1.4, 0.5
1266, 1.2833333333333, 1.4, 0.5
1267, 1.325, 1.4, 0.5
1268, 1.3666666666667, 1.4, 0.5
1269, 1.4083333333333, 1.4, 0.5
1270, 1.45, 1.4, 0.5
1271, 1.4916666666667, 1.4, 0.5
1272, 1.5333333333333, 1.4, 0.5
1273, 1.575, 1.4, 0.5
1274, 1.6166666666667, 1.4, 0.5
1275, 1.6583333333333, 1.4, 0.5
1276, 1.7, 1.4, 0.5
1277, 1.7416666666667, 1.4, 0.5
1278, 1.7833333333333, 1.4, 0.5
1279, 1.825, 1.4, 0.5
1280, 1.8666666666667, 1.4, 0.5
1281, 1.9083333333333, 1.4, 0.5
1282, 1.95, 1.4, 0.5
1283, 1.9916666666667, 1.4, 0.5
1284, 2.0333333333333, 1.4, 0.5
1285, 2.075, 1.4, 0.5
1286, 2.1166666666667, 1.4, 0.5
1287, 2.1583333333333, 1.4, 0.5
1288, 1.2208333333333, 1.4, 0.5
1289, 1.2625, 1.4, 0.5
1290, 1.3041666666667, 1.4, 0.5
1291, 1.3458333333333, 1.4, 0.5
1292, 1.3875, 1.4, 0.5
1293, 1.4291666666667, 1.4, 0.5
1294, 1.4708333333333, 1.4, 0.5
1295, 1.5125, 1.4, 0.5
1296, 1.5541666666667, 1.4, 0.5
1297, 1.5958333333333, 1.4, 0.5
1298, 1.6375, 1.4, 0.5
1299, 1.6791666666667, 1.4, 0.5
1300, 1.7208333333333, 1.4, 0.5
1301, 1.7625, 1.4, 0.5
1302, 1.8041666666667, 1.4, 0.5
1303, 1.8458333333333, 1.4, 0.5
1304, 1.8875, 1.4, 0.5
1305, 1.9291666666667, 1.4, 0.5
1306, 1.9708333333333, 1.4, 0.5
1307, 2.0125, 1.4, 0.5
1308, 2.0541666666667, 1.4, 0.5
1309, 2.0958333333333, 1.4, 0.5
1310, 2.1375, 1.4, 0.5
1311, 2.1791666666667, 1.4, 0.5
1312, 1.2416666666667, 1.5, 0.5
1313, 1.2833333333333, 1.5, 0.5
1314, 1.325, 1.5, 0.5
1315, 1.3666666666667, 1.5, 0.5
1316, 1.4083333333333, 1.5, 0.5
1317, 1.45, 1.5, 0.5
1318, 1.4916666666667, 1.5, 0.5
1319, 1.5333333333333, 1.5, 0.5
1320, 1.575, 1.5, 0.5
1321, 1.6166666666667, 1.5, 0.5
1322, 1.6583333333333, 1.5, 0.5
1323, 1.7, 1.5, 0.5
1324, 1.7416666666667, 1.5, 0.5
1325, 1.7833333333333, 1.5, 0.5
1326, 1.825, 1.5, 0.5
1327, 1.8666666666667, 1.5, 0.5
1328, 1.9083333333333, 1.5, 0.5
1329, 1.95, 1.5, 0.5
1330, 1.9916666666667, 1.5, 0.5
1331, 2.0333333333333, 1.5, 0.5
1332, 2.075, 1.5, 0.5
1333, 2.1166666666667, 1.5, 0.5
1334, 2.1583333333333, 1.5, 0.5
1335, 1.2208333333333, 1.5, 0.5
1336, 1.2625, 1.5, 0.5
1337, 1.3041666666667, 1.5, 0.5
1338, 1.3458333333333, 1.5, 0.5
1339, 1.3875, 1.5, 0.5
1340, 1.4291666666667, 1.5, 0.5
1341, 1.4708333333333, 1.5, 0.5
1342, 1.5125, 1.5, 0.5
1343, 1.5541666666667, 1.5, 0.5
1344, 1.5958333333333, 1.5, 0.5
1345, 1.6375, 1.5, 0.5
1346, 1.6791666666667, 1.5, 0.5
1347, 1.7208333333333, 1.5, 0.5
1348, 1.7625, 1.5, 0.5
1349, 1.8041666666667, 1.5, 0.5
1350, 1.8458333333333, 1.5, 0.5
1351, 1.8875, 1.5, 0.5
1352, 1.9291666666667, 1.5, 0.5
1353, 1.9708333333333, 1.5, 0.5
1354, 2.0125, 1.5, 0.5
1355, 2.0541666666667, 1.5, 0.5
1356, 2.0958333333333, 1.5, 0.5
1357, 2.1375, 1.5, 0.5
1358, 2.1791666666667, 1.5, 0.5
1359, 2.2, 1.4333333333333, 0.5
1360, 2.2, 1.4666666666667, 0.5
1361, 2.2, 1.4166666666667, 0.5
1362, 2.2, 1.45, 0.5
1363, 2.2, 1.4833333333333, 0.5
1364, 1.2416666666667, 1.4, 0
1365, 1.2833333333333, 1.4, 0
1366, 1.325, 1.4, 0
1367, 1.3666666666667, 1.4, 0
1368, 1.4083333333333, 1.4, 0
1369, 1.45, 1.4, 0
1370, 1.4916666666667, 1.4, 0
1371, 1.5333333333333, 1.4, 0
1372, 1.575, 1.4, 0
1373, 1.6166666666667, 1.4, 0
1374, 1.6583333333333, 1.4, 0
1375, 1.7, 1.4, 0
1376, 1.7416666666667, 1.4, 0
1377, 1.7833333333333, 1.4, 0
1378, 1.825, 1.4, 0
1379, 1.8666666666667, 1.4, 0
1380, 1.9083333333333, 1.4, 0
1381, 1.95, 1.4, 0
1382, 1.9916666666667, 1.4, 0
1383, 2.0333333333333, 1.4, 0
1384, 2.075, 1.4, 0
1385, 2.1166666666667, 1.4, 0
1386, 2.1583333333333, 1.4, 0
1387, 1.2208333333333, 1.4, 0
1388, 1.2625, 1.4, 0
1389, 1.3041666666667, 1.4, 0
1390, 1.3458333333333, 1.4, 0
1391, 1.3875, 1.4, 0
1392, 1.4291666666667, 1.4, 0
1393, 1.4708333333333, 1.4, 0
1394, 1.5125, 1.4, 0
1395, 1.5541666666667, 1.4, 0
1396, 1.5958333333333, 1.4, 0
1397, 1.6375, 1.4, 0
1398, 1.6791666666667, 1.4, 0
1399, 1.7208333333333, 1.4, 0
1400, 1.7625, 1.4, 0
1401, 1.8041666666667, 1.4, 0
1402, 1.8458333333333, 1.4, 0
1403, 1.8875, 1.4, 0
1404, 1.9291666666667, 1.4, 0
1405, 1.9708333333333, 1.4, 0
1406, 2.0125, 1.4, 0
1407, 2.0541666666667, 1.4, 0
1408, 2.0958333333333, 1.4, 0
1409, 2.1375, 1.4, 0
1410, 2.1791666666667, 1.4, 0
1411, 1.2416666666667, 1.5, 0
1412, 1.2833333333333, 1.5, 0
1413, 1.325, 1.5, 0
1414, 1.3666666666667, 1.5, 0
1415, 1.4083333333333, 1.5, 0
1416, 1.45, 1.5, 0
1417, 1.4916666666667, 1.5, 0
1418, 1.5333333333333, 1.5, 0
1419, 1.575, 1.5, 0
1420, 1.6166666666667, 1.5, 0
1421, 1.6583333333333, 1.5, 0
1422, 1.7, 1.5, 0
1423, 1.7416666666667, 1.5, 0
1424, 1.7833333333333, 1.5, 0
1425, 1.825, 1.5, 0
1426, 1.8666666666667, 1.5, 0
1427, 1.9083333333333, 1.5, 0
1428, 1.95, 1.5, 0
1429, 1.9916666666667, 1.5, 0
1430, 2.0333333333333, 1.5, 0
1431, 2.075, 1.5, 0
1432, 2.1166666666667, 1.5, 0
1433, 2.1583333333333, 1.5, 0
1434, 1.2208333333333, 1.5, 0
1435, 1.2625, 1.5, 0
1436, 1.3041666666667, 1.5, 0
1437, 1.3458333333333, 1.5, 0
1438, 1.3875, 1.5, 0
1439, 1.4291666666667, 1.5, 0
1440, 1.4708333333333, 1.5, 0
1441, 1.5125, 1.5, 0
1442, 1.5541666666667, 1.5, 0
1443, 1.5958333333333, 1.5, 0
1444, 1.6375, 1.5, 0
1445, 1.6791666666667, 1.5, 0
1446, 1.7208333333333, 1.5, 0
1447, 1.7625, 1.5, 0
1448, 1.8041666666667, 1.5, 0
1449, 1.8458333333333, 1.5, 0
1450, 1.8875, 1.5, 0
1451, 1.9291666666667, 1.5, 0
1452, 1.9708333333333, 1.5, 0
1453, 2.0125, 1.5, 0
1454, 2.0541666666667, 1.5, 0
1455, 2.0958333333333, 1.5, 0
1456, 2.1375, 1.5, 0
1457, 2.1791666666667, 1.5, 0
1458, 2.2, 1.4333333333333, 0
1459, 2.2, 1.4666666666667, 0
1460, 2.2, 1.4166666666667, 0
1461, 2.2, 1.45, 0
1462, 2.2, 1.4833333333333, 0
1463, 2.2, 1.4, 0.041666666666667
1464, 2.2, 1.4, 0.083333333333333
1465, 2.2, 1.4, 0.125
1466, 2.2, 1.4, 0.16666666666667
1467, 2.2, 1.4, 0.20833333333333
1468, 2.2, 1.4, 0.25
1469, 2.2, 1.4, 0.29166666666667
1470, 2.2, 1.4, 0.33333333333333
1471, 2.2, 1.4, 0.375
1472, 2.2, 1.4, 0.41666666666667
1473, 2.2, 1.4, 0.45833333333333
1474, 2.2, 1.4, 0.020833333333333
1475, 2.2, 1.4, 0.0625
1476, 2.2, 1.4, 0.10416666666667
1477, 2.2, 1.4, 0.14583333333333
1478, 2.2, 1.4, 0.1875
1479, 2.2, 1.4, 0.22916666666667
1480, 2.2, 1.4, 0.27083333333333
1481, 2.2, 1.4, 0.3125
1482, 2.2, 1.4, 0.35416666666667
1483, 2.2, 1.4, 0.39583333333333
1484, 2.2, 1.4, 0.4375
1485, 2.2, 1.4, 0.47916666666667
1486, 2.2, 1.5, 0.041666666666667
1487, 2.2, 1.5, 0.083333333333333
1488, 2.2, 1.5, 0.125
1489, 2.2, 1.5, 0.16666666666667
1490, 2.2, 1.5, 0.20833333333333
1491, 2.2, 1.5, 0.25
1492, 2.2, 1.5, 0.29166666666667
1493, 2.2, 1.5, 0.33333333333333
1494, 2.2, 1.5, 0.375
1495, 2.2, 1.5, 0.41666666666667
1496, 2.2, 1.5, 0.45833333333333
1497, 2.2, 1.5, 0.020833333333333
1498, 2.2, 1.5, 0.0625
1499, 2.2, 1.5, 0.10416666666667
1500, 2.2, 1.5, 0.14583333333333
1501, 2.2, 1.5, 0.1875
1502, 2.2, 1.5, 0.22916666666667
1503, 2.2, 1.5, 0.27083333333333
1504, 2.2, 1.5, 0.3125
1505, 2.2, 1.5, 0.35416666666667
1506, 2.2, 1.5, 0.39583333333333
1507, 2.2, 1.5, 0.4375
1508, 2.2, 1.5, 0.47916666666667
1509, 1.2, 1.375, 0.5
1510, 2.2, 1.375, 0.5
1511, 1.2416666666667, 1.35, 0.5
1512, 1.2833333333333, 1.35, 0.5
1513, 1.325, 1.35, 0.5
1514, 1.3666666666667, 1.35, 0.5
1515, 1.4083333333333, 1.35, 0.5
1516, 1.45, 1.35, 0.5
1517, 1.4916666666667, 1.35, 0.5
1518, 1.5333333333333, 1.35, 0.5
1519, 1.575, 1.35, 0.5
1520, 1.6166666666667, 1.35, 0.5
1521, 1.6583333333333, 1.35, 0.5
1522, 1.7, 1.35, 0.5
1523, 1.7416666666667, 1.35, 0.5
1524, 1.7833333333333, 1.35, 0.5
1525, 1.825, 1.35, 0.5
1526, 1.8666666666667, 1.35, 0.5
1527, 1.9083333333333, 1.35, 0.5
1528, 1.95, 1.35, 0.5
1529, 1.9916666666667, 1.35, 0.5
1530, 2.0333333333333, 1.35, 0.5
1531, 2.075, 1.35, 0.5
1532, 2.1166666666667, 1.35, 0.5
1533, 2.1583333333333, 1.35, 0.5
1534, 1.2208333333333, 1.35, 0.5
1535, 1.2625, 1.35, 0.5
1536, 1.3041666666667, 1.35, 0.5
1537, 1.3458333333333, 1.35, 0.5
1538, 1.3875, 1.35, 0.5
1539, 1.4291666666667, 1.35, 0.5
1540, 1.4708333333333, 1.35, 0.5
1541, 1.5125, 1.35, 0.5
1542, 1.5541666666667, 1.35, 0.5
1543, 1.5958333333333, 1.35, 0.5
1544, 1.6375, 1.35, 0.5
1545, 1.6791666666667, 1.35, 0.5
1546, 1.7208333333333, 1.35, 0.5
1547, 1.7625, 1.35, 0.5
1548, 1.8041666666667, 1.35, 0.5
1549, 1.8458333333333, 1.35, 0.5
1550, 1.8875, 1.35, 0.5
1551, 1.9291666666667, 1.35, 0.5
1552, 1.9708333333333, 1.35, 0.5
1553, 2.0125, 1.35, 0.5
1554, 2.0541666666667, 1.35, 0.5
1555, 2.0958333333333, 1.35, 0.5
1556, 2.1375, 1.35, 0.5
1557, 2.1791666666667, 1.35, 0.5
1558, 1.2, 1.375, 0
1559, 2.2, 1.375, 0
1560, 1.2416666666667, 1.35, 0
1561, 1.2833333333333, 1.35, 0
1562, 1.325, 1.35, 0
1563, 1.3666666666667, 1.35, 0
1564, 1.4083333333333, 1.35, 0
1565, 1.45, 1.35, 0
1566, 1.4916666666667, 1.35, 0
1567, 1.5333333333333, 1.35, 0
1568, 1.575, 1.35, 0
1569, 1.6166666666667, 1.35, 0
1570, 1.6583333333333, 1.35, 0
1571, 1.7, 1.35, 0
1572, 1.7416666666667, 1.35, 0
1573, 1.7833333333333, 1.35, 0
1574, 1.825, 1.35, 0
1575, 1.8666666666667, 1.35, 0
1576, 1.9083333333333, 1.35, 0
1577, 1.95, 1.35, 0
1578, 1.9916666666667, 1.35, 0
1579, 2.0333333333333, 1.35, 0
1580, 2.075, 1.35, 0
1581, 2.1166666666667, 1.35, 0
1582, 2.1583333333333, 1.35, 0
1583, 1.2208333333333, 1.35, 0
1584, 1.2625, 1.35, 0
1585, 1.3041666666667, 1.35, 0
1586, 1.3458333333333, 1.35, 0
1587, 1.3875, 1.35, 0
1588, 1.4291666666667, 1.35, 0
1589, 1.4708333333333, 1.35, 0
1590, 1.5125, 1.35, 0
1591, 1.5541666666667, 1.35, 0
1592, 1.5958333333333, 1.35, 0
1593, 1.6375, 1.35, 0
1594, 1.6791666666667, 1.35, 0
1595, 1.7208333333333, 1.35, 0
1596, 1.7625, 1.35, 0
1597, 1.8041666666667, 1.35, 0
1598, 1.8458333333333, 1.35, 0
1599, 1.8875, 1.35, 0
1600, 1.9291666666667, 1.35, 0
1601, 1.9708333333333, 1.35, 0
1602, 2.0125, 1.35, 0
1603, 2.0541666666667, 1.35, 0
1604, 2.0958333333333, 1.35, 0
1605, 2.1375, 1.35, 0
1606, 2.1791666666667, 1.35, 0
1607, 1.2, 1.35, 0.041666666666667
1608, 1.2, 1.35, 0.083333333333333
1609, 1.2, 1.35, 0.125
1610, 1.2, 1.35, 0.16666666666667
1611, 1.2, 1.35, 0.20833333333333
1612, 1.2, 1.35, 0.25
1613, 1.2, 1.35, 0.29166666666667
1614, 1.2, 1.35, 0.33333333333333
1615, 1.2, 1.35, 0.375
1616, 1.2, 1.35, 0.41666666666667
1617, 1.2, 1.35, 0.45833333333333
1618, 1.2, 1.35, 0.020833333333333
1619, 1.2, 1.35, 0.0625
1620, 1.2, 1.35, 0.10416666666667
1621, 1.2, 1.35, 0.14583333333333
1622, 1.2, 1.35, 0.1875
1623, 1.2, 1.35, 0.22916666666667
1624, 1.2, 1.35, 0.27083333333333
1625, 1.2, 1.35, 0.3125
1626, 1.2, 1.35, 0.35416666666667
1627, 1.2, 1.35, 0.39583333333333
1628, 1.2, 1.35, 0.4375
1629, 1.2, 1.35, 0.47916666666667
1630, 2.2, 1.35, 0.041666666666667
1631, 2.2, 1.35, 0.083333333333333
1632, 2.2, 1.35, 0.125
1633, 2.2, 1.35, 0.16666666666667
1634, 2.2, 1.35, 0.20833333333333
1635, 2.2, 1.35, 0.25
1636, 2.2, 1.35, 0.29166666666667
1637, 2.2, 1.35, 0.33333333333333
1638, 2.2, 1.35, 0.375
1639, 2.2, 1.35, 0.41666666666667
1640, 2.2, 1.35, 0.45833333333333
1641, 2.2, 1.35, 0.020833333333333
1642, 2.2, 1.35, 0.0625
1643, 2.2, 1.35, 0.10416666666667
1644, 2.2, 1.35, 0.14583333333333
1645, 2.2, 1.35, 0.1875
1646, 2.2, 1.35, 0.22916666666667
1647, 2.2, 1.35, 0.27083333333333
1648, 2.2, 1.35, 0.3125
1649, 2.2, 1.35, 0.35416666666667
1650, 2.2, 1.35, 0.39583333333333
1651, 2.2, 1.35, 0.4375
1652, 2.2, 1.35, 0.47916666666667
1653, 1.2, 1.3, 0.5
1654, 1.2, 1.25, 0.5
1655, 1.2, 1.2, 0.5
1656, 1.2, 1.15, 0.5
1657, 1.2, 1.1, 0.5
1658, 1.2, 1.05, 0.5
1659, 1.2, 1, 0.5
1660, 1.2, 0.95, 0.5
1661, 1.2, 0.9, 0.5
1662, 1.2, 0.85, 0.5
1663, 1.2, 0.8, 0.5
1664, 1.2, 0.75, 0.5
1665, 1.2, 0.7, 0.5
1666, 1.2, 0.65, 0.5
1667, 1.2, 0.6, 0.5
1668, 1.2, 0.55, 0.5
1669, 1.2, 0.5, 0.5
1670, 1.2, 0.45, 0.5
1671, 1.2, 0.4, 0.5
1672, 1.2, 0.35, 0.5
1673, 1.2, 0.3, 0.5
1674, 1.2, 0.25, 0.5
1675, 1.2, 0.2, 0.5
1676, 1.2, 1.325, 0.5
1677, 1.2, 1.275, 0.5
1678, 1.2, 1.225, 0.5
1679, 1.2, 1.175, 0.5
1680, 1.2, 1.125, 0.5
1681, 1.2, 1.075, 0.5
1682, 1.2, 1.025, 0.5
1683, 1.2, 0.975, 0.5
1684, 1.2, 0.925, 0.5
1685, 1.2, 0.875, 0.5
1686, 1.2, 0.825, 0.5
1687, 1.2, 0.775, 0.5
1688, 1.2, 0.725, 0.5
1689, 1.2, 0.675, 0.5
1690, 1.2, 0.625, 0.5
1691, 1.2, 0.575, 0.5
1692, 1.2, 0.525, 0.5
1693, 1.2, 0.475, 0.5
1694, 1.2, 0.425, 0.5
1695, 1.2, 0.375, 0.5
1696, 1.2, 0.325, 0.5
1697, 1.2, 0.275, 0.5
1698, 1.2, 0.225, 0.5
1699, 1.2, 0.175, 0.5
1700, 2.2, 1.3, 0.5
1701, 2.2, 1.25, 0.5
1702, 2.2, 1.2, 0.5
1703, 2.2, 1.15, 0.5
1704, 2.2, 1.1, 0.5
1705, 2.2, 1.05, 0.5
1706, 2.2, 1, 0.5
1707, 2.2, 0.95, 0.5
1708, 2.2, 0.9, 0.5
1709, 2.2, 0.85, 0.5
1710, 2.2, 0.8, 0.5
1711, 2.2, 0.75, 0.5
1712, 2.2, 0.7, 0.5
1713, 2.2, 0.65, 0.5
1714, 2.2, 0.6, 0.5
1715, 2.2, 0.55, 0.5
1716, 2.2, 0.5, 0.5
1717, 2.2, 0.45, 0.5
1718, 2.2, 0.4, 0.5
1719, 2.2, 0.35, 0.5
1720, 2.2, 0.3, 0.5
1721, 2.2, 0.25, 0.5
1722, 2.2, 0.2, 0.5
1723, 2.2, 1.325, 0.5
1724, 2.2, 1.275, 0.5
1725, 2.2, 1.225, 0.5
1726, 2.2, 1.175, 0.5
1727, 2.2, 1.125, 0.5
1728, 2.2, 1.075, 0.5
1729, 2.2, 1.025, 0.5
1730, 2.2, 0.975, 0.5
1731, 2.2, 0.925, 0.5
1732, 2.2, 0.875, 0.5
1733, 2.2, 0.825, 0.5
1734, 2.2, 0.775, 0.5
1735, 2.2, 0.725, 0.5
1736, 2.2, 0.675, 0.5
1737, 2.2, 0.625, 0.5
1738, 2.2, 0.575, 0.5
1739, 2.2, 0.525, 0.5
1740, 2.2, 0.475, 0.5
1741, 2.2, 0.425, 0.5
1742, 2.2, 0.375, 0.5
1743, 2.2, 0.325, 0.5
1744, 2.2, 0.275, 0.5
1745, 2.2, 0.225, 0.5
1746, 2.2, 0.175, 0.5
1747, 1.2416666666667, 0.15, 0.5
1748, 1.2833333333333, 0.15, 0.5
1749, 1.325, 0.15, 0.5
1750, 1.3666666666667, 0.15, 0.5
1751, 1.4083333333333, 0.15, 0.5
1752, 1.45, 0.15, 0.5
1753, 1.4916666666667, 0.15, 0.5
1754, 1.5333333333333, 0.15, 0.5
1755, 1.575, 0.15, 0.5
1756, 1.6166666666667, 0.15, 0.5
1757, 1.6583333333333, 0.15, 0.5
1758, 1.7, 0.15, 0.5
1759, 1.7416666666667, 0.15, 0.5
1760, 1.7833333333333, 0.15, 0.5
1761, 1.825, 0.15, 0.5
1762, 1.8666666666667, 0.15, 0.5
1763, 1.9083333333333, 0.15, 0.5
1764, 1.95, 0.15, 0.5
1765, 1.9916666666667, 0.15, 0.5
1766, 2.0333333333333, 0.15, 0.5
1767, 2.075, 0.15, 0.5
1768, 2.1166666666667, 0.15, 0.5
1769, 2.1583333333333, 0.15, 0.5
1770, 1.2208333333333, 0.15, 0.5
1771, 1.2625, 0.15, 0.5
1772, 1.3041666666667, 0.15, 0.5
1773, 1.3458333333333, 0.15, 0.5
1774, 1.3875, 0.15, 0.5
1775, 1.4291666666667, 0.15, 0.5
1776, 1.4708333333333, 0.15, 0.5
1777, 1.5125, 0.15, 0.5
1778, 1.5541666666667, 0.15, 0.5
1779, 1.5958333333333, 0.15, 0.5
1780, 1.6375, 0.15, 0.5
1781, 1.6791666666667, 0.15, 0.5
1782, 1.7208333333333, 0.15, 0.5
1783, 1.7625, 0.15, 0.5
1784, 1.8041666666667, 0.15, 0.5
1785, 1.8458333333333, 0.15, 0.5
1786, 1.8875, 0.15, 0.5
1787, 1.9291666666667, 0.15, 0.5
1788, 1.9708333333333, 0.15, 0.5
1789, 2.0125, 0.15, 0.5
1790, 2.0541666666667, 0.15, 0.5
1791, 2.0958333333333, 0.15, 0.5
1792, 2.1375, 0.15, 0.5
1793, 2.1791666666667, 0.15, 0.5
1794, 1.2, 1.3, 0
1795, 1.2, 1.25, 0
1796, 1.2, 1.2, 0
1797, 1.2, 1.15, 0
1798, 1.2, 1.1, 0
1799, 1.2, 1.05, 0
1800, 1.2, 1, 0
1801, 1.2, 0.95, 0
1802, 1.2, 0.9, 0
1803, 1.2, 0.85, 0
1804, 1.2, 0.8, 0
1805, 1.2, 0.75, 0
1806, 1.2, 0.7, 0
1807, 1.2, 0.65, 0
1808, 1.2, 0.6, 0
1809, 1.2, 0.55, 0
1810, 1.2, 0.5, 0
1811, 1.2, 0.45, 0
1812, 1.2, 0.4, 0
1813, 1.2, 0.35, 0
1814, 1.2, 0.3, 0
1815, 1.2, 0.25, 0
1816, 1.2, 0.2, 0
1817, 1.2, 1.325, 0
1818, 1.2, 1.275, 0
1819, 1.2, 1.225, 0
1820, 1.2, 1.175, 0
1821, 1.2, 1.125, 0
1822, 1.2, 1.075, 0
1823, 1.2, 1.025, 0
1824, 1.2, 0.975, 0
1825, 1.2, 0.925, 0
1826, 1.2, 0.875, 0
1827, 1.2, 0.825, 0
1828, 1.2, 0.775, 0
1829, 1.2, 0.725, 0
1830, 1.2, 0.675, 0
1831, 1.2, 0.625, 0
1832, 1.2, 0.575, 0
1833, 1.2, 0.525, 0
1834, 1.2, 0.475, 0
1835, 1.2, 0.425, 0
1836, 1.2, 0.375, 0
1837, 1.2, 0.325, 0
1838, 1.2, 0.275, 0
1839, 1.2, 0.225, 0
1840, 1.2, 0.175, 0
1841, 2.2, 1.3, 0
1842, 2.2, 1.25, 0
1843, 2.2, 1.2, 0
1844, 2.2, 1.15, 0
1845, 2.2, 1.1, 0
1846, 2.2, 1.05, 0
1847, 2.2, 1, 0
1848, 2.2, 0.95, 0
1849, 2.2, 0.9, 0
1850, 2.2, 0.85, 0
1851, 2.2, 0.8, 0
1852, 2.2, 0.75, 0
1853, 2.2, 0.7, 0
1854, 2.2, 0.65, 0
1855, 2.2, 0.6, 0
1856, 2.2, 0.55, 0
1857, 2.2, 0.5, 0
1858, 2.2, 0.45, 0
1859, 2.2, 0.4, 0
1860, 2.2, 0.35, 0
1861, 2.2, 0.3, 0
1862, 2.2, 0.25, 0
1863, 2.2, 0.2, 0
1864, 2.2, 1.325, 0
1865, 2.2, 1.275, 0
1866, 2.2, 1.225, 0
1867, 2.2, 1.175, 0
1868, 2.2, 1.125, 0
1869, 2.2, 1.075, 0
1870, 2.2, 1.025, 0
1871, 2.2, 0.975, 0
1872, 2.2, 0.925, 0
1873, 2.2, 0.875, 0
1874, 2.2, 0.825, 0
1875, 2.2, 0.775, 0
1876, 2.2, 0.725, 0
1877, 2.2, 0.675, 0
1878, 2.2, 0.625, 0
1879, 2.2, 0.575, 0
1880, 2.2, 0.525, 0
1881, 2.2, 0.475, 0
1882, 2.2, 0.425, 0
1883, 2.2, 0.375, 0
1884, 2.2, 0.325, 0
1885, 2.2, 0.275, 0
1886, 2.2, 0.225, 0
1887, 2.2, 0.175, 0
1888, 1.2416666666667, 0.15, 0
1889, 1.2833333333333, 0.15, 0
1890, 1.325, 0.15, 0
1891, 1.3666666666667, 0.15, 0
1892, 1.4083333333333, 0.15, 0
1893, 1.45, 0.15, 0
1894, 1.4916666666667, 0.15, 0
1895, 1.5333333333333, 0.15, 0
1896, 1.575, 0.15, 0
1897, 1.6166666666667, 0.15, 0
1898, 1.6583333333333, 0.15, 0
1899, 1.7, 0.15, 0
1900, 1.7416666666667, 0.15, 0
1901, 1.7833333333333, 0.15, 0
1902, 1.825, 0.15, 0
1903, 1.8666666666667, 0.15, 0
1904, 1.9083333333333, 0.15, 0
1905, 1.95, 0.15, 0
1906, 1.9916666666667, 0.15, 0
1907, 2.0333333333333, 0.15, 0
1908, 2.075, 0.15, 0
1909, 2.1166666666667, 0.15, 0
1910, 2.1583333333333, 0.15, 0
1911, 1.2208333333333, 0.15, 0
1912, 1.2625, 0.15, 0
1913, 1.3041666666667, 0.15, 0
1914, 1.3458333333333, 0.15, 0
1915, 1.3875, 0.15, 0
1916, 1.4291666666667, 0.15, 0
1917, 1.4708333333333, 0.15, 0
1918, 1.5125, 0.15, 0
1919, 1.5541666666667, 0.15, 0
1920, 1.5958333333333, 0.15, 0
1921, 1.6375, 0.15, 0
1922, 1.6791666666667, 0.15, 0
1923, 1.7208333333333, 0.15, 0
1924, 1.7625, 0.15, 0
1925, 1.8041666666667, 0.15, 0
1926, 1.8458333333333, 0.15, 0
1927, 1.8875, 0.15, 0
1928, 1.9291666666667, 0.15, 0
1929, 1.9708333333333, 0.15, 0
1930, 2.0125, 0.15, 0
1931, 2.0541666666667, 0.15, 0
1932, 2.0958333333333, 0.15, 0
1933, 2.1375, 0.15, 0
1934, 2.1791666666667, 0.15, 0
1935, 1.2, 0.15, 0.041666666666667
1936, 1.2, 0.15, 0.083333333333333
1937, 1.2, 0.15, 0.125
1938, 1.2, 0.15, 0.16666666666667
1939, 1.2, 0.15, 0.20833333333333
1940, 1.2, 0.15, 0.25
1941, 1.2, 0.15, 0.29166666666667
1942, 1.2, 0.15, 0.33333333333333
1943, 1.2, 0.15, 0.375
1944, 1.2, 0.15, 0.41666666666667
1945, 1.2, 0.15, 0.45833333333333
1946, 1.2, 0.15, 0.020833333333333
1947, 1.2, 0.15, 0.0625
1948, 1.2, 0.15, 0.10416666666667
1949, 1.2, 0.15, 0.14583333333333
1950, 1.2, 0.15, 0.1875
1951, 1.2, 0.15, 0.22916666666667
1952, 1.2, 0.15, 0.27083333333333
1953, 1.2, 0.15, 0.3125
1954, 1.2, 0.15, 0.35416666666667
1955, 1.2, 0.15, 0.39583333333333
1956, 1.2, 0.15, 0.4375
1957, 1.2, 0.15, 0.47916666666667
1958, 2.2, 0.15, 0.041666666666667
1959, 2.2, 0.15, 0.083333333333333
1960, 2.2, 0.15, 0.125
1961, 2.2, 0.15, 0.16666666666667
1962, 2.2, 0.15, 0.20833333333333
1963, 2.2, 0.15, 0.25
1964, 2.2, 0.15, 0.29166666666667
1965, 2.2, 0.15, 0.33333333333333
1966, 2.2, 0.15, 0.375
1967, 2.2, 0.15, 0.41666666666667
1968, 2.2, 0.15, 0.45833333333333
1969, 2.2, 0.15, 0.020833333333333
1970, 2.2, 0.15, 0.0625
1971, 2.2, 0.15, 0.10416666666667
1972, 2.2, 0.15, 0.14583333333333
1973, 2.2, 0.15, 0.1875
1974, 2.2, 0.15, 0.22916666666667
1975, 2.2, 0.15, 0.27083333333333
1976, 2.2, 0.15, 0.3125
1977, 2.2, 0.15, 0.35416666666667
1978, 2.2, 0.15, 0.39583333333333
1979, 2.2, 0.15, 0.4375
1980, 2.2, 0.15, 0.47916666666667
1981, 1.2, 0.125, 0.5
1982, 2.2, 0.125, 0.5
1983, 1.2416666666667, 0.1, 0.5
1984, 1.2833333333333, 0.1, 0.5
1985, 1.325, 0.1, 0.5
1986, 1.3666666666667, 0.1, 0.5
1987, 1.4083333333333, 0.1, 0.5
1988, 1.45, 0.1, 0.5
1989, 1.4916666666667, 0.1, 0.5
1990, 1.5333333333333, 0.1, 0.5
1991, 1.575, 0.1, 0.5
1992, 1.6166666666667, 0.1, 0.5
1993, 1.6583333333333, 0.1, 0.5
1994, 1.7, 0.1, 0.5
1995, 1.7416666666667, 0.1, 0.5
1996, 1.7833333333333, 0.1, 0.5
1997, 1.825, 0.1, 0.5
1998, 1.8666666666667, 0.1, 0.5
1999, 1.9083333333333, 0.1, 0.5
2000, 1.95, 0.1, 0.5
2001, 1.9916666666667, 0.1, 0.5
2002, 2.0333333333333, 0.1, 0.5
2003, 2.075, 0.1, 0.5
2004, 2.1166666666667, 0.1, 0.5
2005, 2.1583333333333, 0.1, 0.5
2006, 1.2208333333333, 0.1, 0.5
2007, 1.2625, 0.1, 0.5
2008, 1.3041666666667, 0.1, 0.5
2009, 1.3458333333333, 0.1, 0.5
2010, 1.3875, 0.1, 0.5
2011, 1.4291666666667, 0.1, 0.5
2012, 1.4708333333333, 0.1, 0.5
2013, 1.5125, 0.1, 0.5
2014, 1.5541666666667, 0.1, 0.5
2015, 1.5958333333333, 0.1, 0.5
2016, 1.6375, 0.1, 0.5
2017, 1.6791666666667, 0.1, 0.5
2018, 1.7208333333333, 0.1, 0.5
2019, 1.7625, 0.1, 0.5
2020, 1.8041666666667, 0.1, 0.5
2021, 1.8458333333333, 0.1, 0.5
2022, 1.8875, 0.1, 0.5
2023, 1.9291666666667, 0.1, 0.5
2024, 1.9708333333333, 0.1, 0.5
2025, 2.0125, 0.1, 0.5
2026, 2.0541666666667, 0.1, 0.5
2027, 2.0958333333333, 0.1, 0.5
2028, 2.1375, 0.1, 0.5
2029, 2.1791666666667, 0.1, 0.5
2030, 1.2, 0.125, 0
2031, 2.2, 0.125, 0
2032, 1.2416666666667, 0.1, 0
2033, 1.2833333333333, 0.1, 0
2034, 1.325, 0.1, 0
2035, 1.3666666666667, 0.1, 0
2036, 1.4083333333333, 0.1, 0
2037, 1.45, 0.1, 0
2038, 1.4916666666667, 0.1, 0
2039, 1.5333333333333, 0.1, 0
2040, 1.575, 0.1, 0
2041, 1.6166666666667, 0.1, 0
2042, 1.6583333333333, 0.1, 0
2043, 1.7, 0.1, 0
2044, 1.7416666666667, 0.1, 0
2045, 1.7833333333333, 0.1, 0
2046, 1.825, 0.1, 0
2047, 1.8666666666667, 0.1, 0
2048, 1.9083333333333, 0.1, 0
2049, 1.95, 0.1, 0
2050, 1.9916666666667, 0.1, 0
2051, 2.0333333333333, 0.1, 0
2052, 2.075, 0.1, 0
2053, 2.1166666666667, 0.1, 0
2054, 2.1583333333333, 0.1, 0
2055, 1.2208333333333, 0.1, 0
2056, 1.2625, 0.1, 0
2057, 1.3041666666667, 0.1, 0
2058, 1.3458333333333, 0.1, 0
2059, 1.3875, 0.1, 0
2060, 1.4291666666667, 0.1, 0
2061, 1.4708333333333, 0.1, 0
2062, 1.5125, 0.1, 0
2063, 1.5541666666667, 0.1, 0
2064, 1.5958333333333, 0.1, 0
2065, 1.6375, 0.1, 0
2066, 1.6791666666667, 0.1, 0
2067, 1.7208333333333, 0.1, 0
2068, 1.7625, 0.1, 0
2069, 1.8041666666667, 0.1, 0
2070, 1.8458333333333, 0.1, 0
2071, 1.8875, 0.1, 0
2072, 1.9291666666667, 0.1, 0
2073, 1.9708333333333, 0.1, 0
2074, 2.0125, 0.1, 0
2075, 2.0541666666667, 0.1, 0
2076, 2.0958333333333, 0.1, 0
2077, 2.1375, 0.1, 0
2078, 2.1791666666667, 0.1, 0
2079, 1.2, 0.1, 0.041666666666667
2080, 1.2, 0.1, 0.083333333333333
2081, 1.2, 0.1, 0.125
2082, 1.2, 0.1, 0.16666666666667
2083, 1.2, 0.1, 0.20833333333333
2084, 1.2, 0.1, 0.25
2085, 1.2, 0.1, 0.29166666666667
2086, 1.2, 0.1, 0.33333333333333
2087, 1.2, 0.1, 0.375
2088, 1.2, 0.1, 0.41666666666667
2089, 1.2, 0.1, 0.45833333333333
2090, 1.2, 0.1, 0.020833333333333
2091, 1.2, 0.1, 0.0625
2092, 1.2, 0.1, 0.10416666666667
2093, 1.2, 0.1, 0.14583333333333
2094, 1.2, 0.1, 0.1875
2095, 1.2, 0.1, 0.22916666666667
2096, 1.2, 0.1, 0.27083333333333
2097, 1.2, 0.1, 0.3125
2098, 1.2, 0.1, 0.35416666666667
2099, 1.2, 0.1, 0.39583333333333
2100, 1.2, 0.1, 0.4375
2101, 1.2, 0.1, 0.47916666666667
2102, 2.2, 0.1, 0.041666666666667
2103, 2.2, 0.1, 0.083333333333333
2104, 2.2, 0.1, 0.125
2105, 2.2, 0.1, 0.16666666666667
2106, 2.2, 0.1, 0.20833333333333
2107, 2.2, 0.1, 0.25
2108, 2.2, 0.1, 0.29166666666667
2109, 2.2, 0.1, 0.33333333333333
2110, 2.2, 0.1, 0.375
2111, 2.2, 0.1, 0.41666666666667
2112, 2.2, 0.1, 0.45833333333333
2113, 2.2, 0.1, 0.020833333333333
2114, 2.2, 0.1, 0.0625
2115, 2.2, 0.1, 0.10416666666667
2116, 2.2, 0.1, 0.14583333333333
2117, 2.2, 0.1, 0.1875
2118, 2.2, 0.1, 0.22916666666667
2119, 2.2, 0.1, 0.27083333333333
2120, 2.2, 0.1, 0.3125
2121, 2.2, 0.1, 0.35416666666667
2122, 2.2, 0.1, 0.39583333333333
2123, 2.2, 0.1, 0.4375
2124, 2.2, 0.1, 0.47916666666667
2125, 1.2, 0.066666666666667, 0.5
2126, 1.2, 0.033333333333333, 0.5
2127, 1.2, 0.083333333333333, 0.5
2128, 1.2, 0.05, 0.5
2129, 1.2, 0.016666666666667, 0.5
2130, 2.2, 0.066666666666667, 0.5
2131, 2.2, 0.033333333333333, 0.5
2132, 2.2, 0.083333333333333, 0.5
2133, 2.2, 0.05, 0.5
2134, 2.2, 0.016666666666667, 0.5
2135, 1.2416666666667, 1.2490009027033e-16, 0.5
2136, 1.2833333333333, 1.2490009027033e-16, 0.5
2137, 1.325, 1.2490009027033e-16, 0.5
2138, 1.3666666666667, 1.2490009027033e-16, 0.5
2139, 1.4083333333333, 1.2490009027033e-16, 0.5
2140, 1.45, 1.2490009027033e-16, 0.5
2141, 1.4916666666667, 1.2490009027033e-16, 0.5
2142, 1.5333333333333, 1.2490009027033e-16, 0.5
2143, 1.575, 1.2490009027033e-16, 0.5
2144, 1.6166666666667, 1.2490009027033e-16, 0.5
2145, 1.6583333333333, 1.2490009027033e-16, 0.5
2146, 1.7, 1.2490009027033e-16, 0.5
2147, 1.7416666666667, 1.2490009027033e-16, 0.5
2148, 1.7833333333333, 1.2490009027033e-16, 0.5
2149, 1.825, 1.2490009027033e-16, 0.5
2150, 1.8666666666667, 1.2490009027033e-16, 0.5
2151, 1.9083333333333, 1.2490009027033e-16, 0.5
2152, 1.95, 1.2490009027033e-16, 0.5
2153, 1.9916666666667, 1.2490009027033e-16, 0.5
2154, 2.0333333333333, 1.2490009027033e-16, 0.5
2155, 2.075, 1.2490009027033e-16, 0.5
2156, 2.1166666666667, 1.2490009027033e-16, 0.5
2157, 2.1583333333333, 1.2490009027033e-16, 0.5
2158, 1.2208333333333, 0, 0.5
2159, 1.2625, 0, 0.5
2160, 1.3041666666667, 0, 0.5
2161, 1.3458333333333, 0, 0.5
2162, 1.3875, 0, 0.5
2163, 1.4291666666667, 0, 0.5
2164, 1.4708333333333, 0, 0.5
2165, 1.5125, 0, 0.5
2166, 1.5541666666667, 0, 0.5
2167, 1.5958333333333, 0, 0.5
2168, 1.6375, 0, 0.5
2169, 1.6791666666667, 0, 0.5
2170, 1.7208333333333, 0, 0.5
2171, 1.7625, 0, 0.5
2172, 1.8041666666667, 0, 0.5
2173, 1.8458333333333, 0, 0.5
2174, 1.8875, 0, 0.5
2175, 1.9291666666667, 0, 0.5
2176, 1.9708333333333, 0, 0.5
2177, 2.0125, 0, 0.5
2178, 2.0541666666667, 0, 0.5
2179, 2.0958333333333, 0, 0.5
2180, 2.1375, 0, 0.5
2181, 2.1791666666667, 0, 0.5
2182, 1.2, 0.066666666666667, 0
2183, 1.2, 0.033333333333333, 0
2184, 1.2, 0.083333333333333, 0
2185, 1.2, 0.05, 0
2186, 1.2, 0.016666666666667, 0
2187, 2.2, 0.066666666666667, 0
2188, 2.2, 0.033333333333333, 0
2189, 2.2, 0.083333333333333, 0
2190, 2.2, 0.05, 0
2191, 2.2, 0.016666666666667, 0
2192, 1.2416666666667, 1.2490009027033e-16, 0
2193, 1.2833333333333, 1.2490009027033e-16, 0
2194, 1.325, 1.2490009027033e-16, 0
2195, 1.3666666666667, 1.2490009027033e-16, 0
2196, 1.4083333333333, 1.2490009027033e-16, 0
2197, 1.45, 1.2490009027033e-16, 0
2198, 1.4916666666667, 1.2490009027033e-16, 0
2199, 1.5333333333333, 1.2490009027033e-16, 0
2200, 1.575, 1.2490009027033e-16, 0
2201, 1.6166666666667, 1.2490009027033e-16, 0
2202, 1.6583333333333, 1.2490009027033e-16, 0
2203, 1.7, 1.2490009027033e-16, 0
2204, 1.7416666666667, 1.2490009027033e-16, 0
2205, 1.7833333333333, 1.2490009027033e-16, 0
2206, 1.825, 1.2490009027033e-16, 0
2207, 1.8666666666667, 1.2490009027033e-16, 0
2208, 1.9083333333333, 1.2490009027033e-16, 0
2209, 1.95, 1.2490009027033e-16, 0
2210, 1.9916666666667, 1.2490009027033e-16, 0
2211, 2.0333333333333, 1.2490009027033e-16, 0
2212, 2.075, 1.2490009027033e-16, 0
2213, 2.1166666666667, 1.2490009027033e-16, 0
2214, 2.1583333333333, 1.2490009027033e-16, 0
2215, 1.2208333333333, 0, 0
2216, 1.2625, 0, 0
2217, 1.3041666666667, 0, 0
2218, 1.3458333333333, 0, 0
2219, 1.3875, 0, 0
2220, 1.4291666666667, 0, 0
2221, 1.4708333333333, 0, 0
2222, 1.5125, 0, 0
2223, 1.5541666666667, 0, 0
2224, 1.5958333333333, 0, 0
2225, 1.6375, 0, 0
2226, 1.6791666666667, 0, 0
2227, 1.7208333333333, 0, 0
2228, 1.7625, 0, 0
2229, 1.8041666666667, 0, 0
2230, 1.8458333333333, 0, 0
2231, 1.8875, 0, 0
2232, 1.9291666666667, 0, 0
2233, 1.9708333333333, 0, 0
2234, 2.0125, 0, 0
2235, 2.0541666666667, 0, 0
2236, 2.0958333333333, 0, 0
2237, 2.1375, 0, 0
2238, 2.1791666666667, 0, 0
2239, 1.2, 1.2490009027033e-16, 0.041666666666667
2240, 1.2, 1.2490009027033e-16, 0.083333333333333
2241, 1.2, 1.2490009027033e-16, 0.125
2242, 1.2, 1.2490009027033e-16, 0.16666666666667
2243, 1.2, 1.2490009027033e-16, 0.20833333333333
2244, 1.2, 1.2490009027033e-16, 0.25
2245, 1.2, 1.2490009027033e-16, 0.29166666666667
2246, 1.2, 1.2490009027033e-16, 0.33333333333333
2247, 1.2, 1.2490009027033e-16, 0.375
2248, 1.2, 1.2490009027033e-16, 0.41666666666667
2249, 1.2, 1.2490009027033e-16, 0.45833333333333
2250, 1.2, -1.2490009027033e-16, 0.020833333333333
2251, 1.2, -1.2490009027033e-16, 0.0625
2252, 1.2, -1.2490009027033e-16, 0.10416666666667
2253, 1.2, -1.2490009027033e-16, 0.14583333333333
2254, 1.2, -1.2490009027033e-16, 0.1875
2255, 1.2, -1.2490009027033e-16, 0.22916666666667
2256, 1.2, -1.2490009027033e-16, 0.27083333333333
2257, 1.2, -1.2490009027033e-16, 0.3125
2258, 1.2, -1.2490009027033e-16, 0.35416666666667
2259, 1.2, -1.2490009027033e-16, 0.39583333333333
2260, 1.2, -1.2490009027033e-16, 0.4375
2261, 1.2, -1.2490009027033e-16, 0.47916666666667
2262, 2.2, 1.2490009027033e-16, 0.041666666666667
2263, 2.2, 1.2490009027033e-16, 0.083333333333333
2264, 2.2, 1.2490009027033e-16, 0.125
2265, 2.2, 1.2490009027033e-16, 0.16666666666667
2266, 2.2, 1.2490009027033e-16, 0.20833333333333
2267, 2.2, 1.2490009027033e-16, 0.25
2268, 2.2, 1.2490009027033e-16, 0.29166666666667
2269, 2.2, 1.2490009027033e-16, 0.33333333333333
2270, 2.2, 1.2490009027033e-16, 0.375
2271, 2.2, 1.2490009027033e-16, 0.41666666666667
2272, 2.2, 1.2490009027033e-16, 0.45833333333333
2273, 2.2, -1.2490009027033e-16, 0.020833333333333
2274, 2.2, -1.2490009027033e-16, 0.0625
2275, 2.2, -1.2490009027033e-16, 0.10416666666667
2276, 2.2, -1.2490009027033e-16, 0.14583333333333
2277, 2.2, -1.2490009027033e-16, 0.1875
2278, 2.2, -1.2490009027033e-16, 0.22916666666667
2279, 2.2, -1.2490009027033e-16, 0.27083333333333
2280, 2.2, -1.2490009027033e-16, 0.3125
2281, 2.2, -1.2490009027033e-16, 0.35416666666667
2282, 2.2, -1.2490009027033e-16, 0.39583333333333
2283, 2.2, -1.2490009027033e-16, 0.4375
2284, 2.2, -1.2490009027033e-16, 0.47916666666667
2285, 2.25, 0.1, 0.5
2286, 2.25, -1.2490009027033e-16, 0.5
2287, 2.3, 0.066666666666667, 0.5
2288, 2.3, 0.033333333333333, 0.5
2289, 2.3, 0.083333333333333, 0.5
2290, 2.3, 0.05, 0.5
2291, 2.3, 0.016666666666667, 0.5
2292, 2.25, 0.1, 0
2293, 2.25, -1.2490009027033e-16, 0
2294, 2.3, 0.066666666666667, 0
2295, 2.3, 0.033333333333333, 0
2296, 2.3, 0.083333333333333, 0
2297, 2.3, 0.05, 0
2298, 2.3, 0.016666666666667, 0
2299, 2.3, 0.1, 0.041666666666667
2300, 2.3, 0.1, 0.083333333333333
2301, 2.3, 0.1, 0.125
2302, 2.3, 0.1, 0.16666666666667
2303, 2.3, 0.1, 0.20833333333333
2304, 2.3, 0.1, 0.25
2305, 2.3, 0.1, 0.29166666666667
2306, 2.3, 0.1, 0.33333333333333
2307, 2.3, 0.1, 0.375
2308, 2.3, 0.1, 0.41666666666667
2309, 2.3, 0.1, 0.45833333333333
2310, 2.3, 0.1, 0.020833333333333
2311, 2.3, 0.1, 0.0625
2312, 2.3, 0.1, 0.10416666666667
2313, 2.3, 0.1, 0.14583333333333
2314, 2.3, 0.1, 0.1875
2315, 2.3, 0.1, 0.22916666666667
2316, 2.3, 0.1, 0.27083333333333
2317, 2.3, 0.1, 0.3125
2318, 2.3, 0.1, 0.35416666666667
2319, 2.3, 0.1, 0.39583333333333
2320, 2.3, 0.1, 0.4375
2321, 2.3, 0.1, 0.47916666666667
2322, 2.3, 1.2490009027033e-16, 0.041666666666667
2323, 2.3, 1.2490009027033e-16, 0.083333333333333
2324, 2.3, 1.2490009027033e-16, 0.125
2325, 2.3, 1.2490009027033e-16, 0.16666666666667
2326, 2.3, 1.2490009027033e-16, 0.20833333333333
2327, 2.3, 1.2490009027033e-16, 0.25
2328, 2.3, 1.2490009027033e-16, 0.29166666666667
2329, 2.3, 1.2490009027033e-16, 0.33333333333333
2330, 2.3, 1.2490009027033e-16, 0.375
2331, 2.3, 1.2490009027033e-16, 0.41666666666667
2332, 2.3, 1.2490009027033e-16, 0.45833333333333
2333, 2.3, -1.2490009027033e-16, 0.020833333333333
2334, 2.3, -1.2490009027033e-16, 0.0625
2335, 2.3, -1.2490009027033e-16, 0.10416666666667
2336, 2.3, -1.2490009027033e-16, 0.14583333333333
2337, 2.3, -1.2490009027033e-16, 0.1875
2338, 2.3, -1.2490009027033e-16, 0.22916666666667
2339, 2.3, -1.2490009027033e-16, 0.27083333333333
2340, 2.3, -1.2490009027033e-16, 0.3125
2341, 2.3, -1.2490009027033e-16, 0.35416666666667
2342, 2.3, -1.2490009027033e-16, 0.39583333333333
2343, 2.3, -1.2490009027033e-16, 0.4375
2344, 2.3, -1.2490009027033e-16, 0.47916666666667
2345, -0.05, 0, 0.5
2346, -0.05, 0, 0
2347, -0.1, 0, 0.041666666666667
2348, -0.1, 0, 0.083333333333333
2349, -0.1, 0, 0.125
2350, -0.1, 0, 0.16666666666667
2351, -0.1, 0, 0.20833333333333
2352, -0.1, 0, 0.25
2353, -0.1, 0, 0.29166666666667
2354, -0.1, 0, 0.33333333333333
2355, -0.1, 0, 0.375
2356, -0.1, 0, 0.41666666666667
2357, -0.1, 0, 0.45833333333333
2358, -0.1, 0, 0.020833333333333
2359, -0.1, 0, 0.0625
2360, -0.1, 0, 0.10416666666667
2361, -0.1, 0, 0.14583333333333
2362, -0.1, 0, 0.1875
2363, -0.1, 0, 0.22916666666667
2364, -0.1, 0, 0.27083333333333
2365, -0.1, 0, 0.3125
2366, -0.1, 0, 0.35416666666667
2367, -0.1, 0, 0.39583333333333
2368, -0.1, 0, 0.4375
2369, -0.1, 0, 0.47916666666667
2370, -0.05, 0.1, 0.5
2371, -0.1, 0.033333333333333, 0.5
2372, -0.1, 0.066666666666667, 0.5
2373, -0.1, 0.016666666666667, 0.5
2374, -0.1, 0.05, 0.5
2375, -0.1, 0.083333333333333, 0.5
2376, -0.05, 0.1, 0
2377, -0.1, 0.1, 0.041666666666667
2378, -0.1, 0.1, 0.083333333333333
2379, -0.1, 0.1, 0.125
2380, -0.1, 0.1, 0.16666666666667
2381, -0.1, 0.1, 0.20833333333333
2382, -0.1, 0.1, 0.25
2383, -0.1, 0.1, 0.29166666666667
2384, -0.1, 0.1, 0.33333333333333
2385, -0.1, 0.1, 0.375
2386, -0.1, 0.1, 0.41666666666667
2387, -0.1, 0.1, 0.45833333333333
2388, -0.1, 0.1, 0.020833333333333
2389, -0.1, 0.1, 0.0625
2390, -0.1, 0.1, 0.10416666666667
2391, -0.1, 0.1, 0.14583333333333
2392, -0.1, 0.1, 0.1875
2393, -0.1, 0.1, 0.22916666666667
2394, -0.1, 0.1, 0.27083333333333
2395, -0.1, 0.1, 0.3125
2396, -0.1, 0.1, 0.35416666666667
2397, -0.1, 0.1, 0.39583333333333
2398, -0.1, 0.1, 0.4375
2399, -0.1, 0.1, 0.47916666666667
2400, -0.1, 0.033333333333333, 0
2401, -0.1, 0.066666666666667, 0
2402, -0.1, 0.016666666666667, 0
2403, -0.1, 0.05, 0
2404, -0.1, 0.083333333333333, 0
2405, 1.025, 0.15, 0.5
2406, 1.025, 1.35, 0.5
2407, 1.05, 0.2, 0.5
2408, 1.05, 0.25, 0.5
2409, 1.05, 0.3, 0.5
2410, 1.05, 0.35, 0.5
2411, 1.05, 0.4, 0.5
2412, 1.05, 0.45, 0.5
2413, 1.05, 0.5, 0.5
2414, 1.05, 0.55, 0.5
2415, 1.05, 0.6, 0.5
2416, 1.05, 0.65, 0.5
2417, 1.05, 0.7, 0.5
2418, 1.05, 0.75, 0.5
2419, 1.05, 0.8, 0.5
2420, 1.05, 0.85, 0.5
2421, 1.05, 0.9, 0.5
2422, 1.05, 0.95, 0.5
2423, 1.05, 1, 0.5
2424, 1.05, 1.05, 0.5
2425, 1.05, 1.1, 0.5
2426, 1.05, 1.15, 0.5
2427, 1.05, 1.2, 0.5
2428, 1.05, 1.25, 0.5
2429, 1.05, 1.3, 0.5
2430, 1.05, 0.175, 0.5
2431, 1.05, 0.225, 0.5
2432, 1.05, 0.275, 0.5
2433, 1.05, 0.325, 0.5
2434, 1.05, 0.375, 0.5
2435, 1.05, 0.425, 0.5
2436, 1.05, 0.475, 0.5
2437, 1.05, 0.525, 0.5
2438, 1.05, 0.575, 0.5
2439, 1.05, 0.625, 0.5
2440, 1.05, 0.675, 0.5
2441, 1.05, 0.725, 0.5
2442, 1.05, 0.775, 0.5
2443, 1.05, 0.825, 0.5
2444, 1.05, 0.875, 0.5
2445, 1.05, 0.925, 0.5
2446, 1.05, 0.975, 0.5
2447, 1.05, 1.025, 0.5
2448, 1.05, 1.075, 0.5
2449, 1.05, 1.125, 0.5
2450, 1.05, 1.175, 0.5
2451, 1.05, 1.225, 0.5
2452, 1.05, 1.275, 0.5
2453, 1.05, 1.325, 0.5
2454, 1.025, 0.15, 0
2455, 1.025, 1.35, 0
2456, 1.05, 0.2, 0
2457, 1.05, 0.25, 0
2458, 1.05, 0.3, 0
2459, 1.05, 0.35, 0
2460, 1.05, 0.4, 0
2461, 1.05, 0.45, 0
2462, 1.05, 0.5, 0
2463, 1.05, 0.55, 0
2464, 1.05, 0.6, 0
2465, 1.05, 0.65, 0
2466, 1.05, 0.7, 0
2467, 1.05, 0.75, 0
2468, 1.05, 0.8, 0
2469, 1.05, 0.85, 0
2470, 1.05, 0.9, 0
2471, 1.05, 0.95, 0
2472, 1.05, 1, 0
2473, 1.05, 1.05, 0
2474, 1.05, 1.1, 0
2475, 1.05, 1.15, 0
2476, 1.05, 1.2, 0
2477, 1.05, 1.25, 0
2478, 1.05, 1.3, 0
2479, 1.05, 0.175, 0
2480, 1.05, 0.225, 0
2481, 1.05, 0.275, 0
2482, 1.05, 0.325, 0
2483, 1.05, 0.375, 0
2484, 1.05, 0.425, 0
2485, 1.05, 0.475, 0
2486, 1.05, 0.525, 0
2487, 1.05, 0.575, 0
2488, 1.05, 0.625, 0
2489, 1.05, 0.675, 0
2490, 1.05, 0.725, 0
2491, 1.05, 0.775, 0
2492, 1.05, 0.825, 0
2493, 1.05, 0.875, 0
2494, 1.05, 0.925, 0
2495, 1.05, 0.975, 0
2496, 1.05, 1.025, 0
2497, 1.05, 1.075, 0
2498, 1.05, 1.125, 0
2499, 1.05, 1.175, 0
2500, 1.05, 1.225, 0
2501, 1.05, 1.275, 0
2502, 1.05, 1.325, 0
2503, 1.05, 0.15, 0.041666666666667
2504, 1.05, 0.15, 0.083333333333333
2505, 1.05, 0.15, 0.125
2506, 1.05, 0.15, 0.16666666666667
2507, 1.05, 0.15, 0.20833333333333
2508, 1.05, 0.15, 0.25
2509, 1.05, 0.15, 0.29166666666667
2510, 1.05, 0.15, 0.33333333333333
2511, 1.05, 0.15, 0.375
2512, 1.05, 0.15, 0.41666666666667
2513, 1.05, 0.15, 0.45833333333333
2514, 1.05, 0.15, 0.020833333333333
2515, 1.05, 0.15, 0.0625
2516, 1.05, 0.15, 0.10416666666667
2517, 1.05, 0.15, 0.14583333333333
2518, 1.05, 0.15, 0.1875
2519, 1.05, 0.15, 0.22916666666667
2520, 1.05, 0.15, 0.27083333333333
2521, 1.05, 0.15, 0.3125
2522, 1.05, 0.15, 0.35416666666667
2523, 1.05, 0.15, 0.39583333333333
2524, 1.05, 0.15, 0.4375
2525, 1.05, 0.15, 0.47916666666667
2526, 1.05, 1.35, 0.041666666666667
2527, 1.05, 1.35, 0.083333333333333
2528, 1.05, 1.35, 0.125
2529, 1.05, 1.35, 0.16666666666667
2530, 1.05, 1.35, 0.20833333333333
2531, 1.05, 1.35, 0.25
2532, 1.05, 1.35, 0.29166666666667
2533, 1.05, 1.35, 0.33333333333333
2534, 1.05, 1.35, 0.375
2535, 1.05, 1.35, 0.41666666666667
2536, 1.05, 1.35, 0.45833333333333
2537, 1.05, 1.35, 0.020833333333333
2538, 1.05, 1.35, 0.0625
2539, 1.05, 1.35, 0.10416666666667
2540, 1.05, 1.35, 0.14583333333333
2541, 1.05, 1.35, 0.1875
2542, 1.05, 1.35, 0.22916666666667
2543, 1.05, 1.35, 0.27083333333333
2544, 1.05, 1.35, 0.3125
2545, 1.05, 1.35, 0.35416666666667
2546, 1.05, 1.35, 0.39583333333333
2547, 1.05, 1.35, 0.4375
2548, 1.05, 1.35, 0.47916666666667
2549, 1.175, 1.35, 0.5
2550, 1.175, 0.15, 0.5
2551, 1.15, 1.3, 0.5
2552, 1.15, 1.25, 0.5
2553, 1.15, 1.2, 0.5
2554, 1.15, 1.15, 0.5
2555, 1.15, 1.1, 0.5
2556, 1.15, 1.05, 0.5
2557, 1.15, 1, 0.5
2558, 1.15, 0.95, 0.5
2559, 1.15, 0.9, 0.5
2560, 1.15, 0.85, 0.5
2561, 1.15, 0.8, 0.5
2562, 1.15, 0.75, 0.5
2563, 1.15, 0.7, 0.5
2564, 1.15, 0.65, 0.5
2565, 1.15, 0.6, 0.5
2566, 1.15, 0.55, 0.5
2567, 1.15, 0.5, 0.5
2568, 1.15, 0.45, 0.5
2569, 1.15, 0.4, 0.5
2570, 1.15, 0.35, 0.5
2571, 1.15, 0.3, 0.5
2572, 1.15, 0.25, 0.5
2573, 1.15, 0.2, 0.5
2574, 1.15, 1.325, 0.5
2575, 1.15, 1.275, 0.5
2576, 1.15, 1.225, 0.5
2577, 1.15, 1.175, 0.5
2578, 1.15, 1.125, 0.5
2579, 1.15, 1.075, 0.5
2580, 1.15, 1.025, 0.5
2581, 1.15, 0.975, 0.5
2582, 1.15, 0.925, 0.5
2583, 1.15, 0.875, 0.5
2584, 1.15, 0.825, 0.5
2585, 1.15, 0.775, 0.5
2586, 1.15, 0.725, 0.5
2587, 1.15, 0.675, 0.5
2588, 1.15, 0.625, 0.5
2589, 1.15, 0.575, 0.5
2590, 1.15, 0.525, 0.5
2591, 1.15, 0.475, 0.5
2592, 1.15, 0.425, 0.5
2593, 1.15, 0.375, 0.5
2594, 1.15, 0.325, 0.5
2595, 1.15, 0.275, 0.5
2596, 1.15, 0.225, 0.5
2597, 1.15, 0.175, 0.5
2598, 1.175, 1.35, 0
2599, 1.175, 0.15, 0
2600, 1.15, 1.3, 0
2601, 1.15, 1.25, 0
2602, 1.15, 1.2, 0
2603, 1.15, 1.15, 0
2604, 1.15, 1.1, 0
2605, 1.15, 1.05, 0
2606, 1.15, 1, 0
2607, 1.15, 0.95, 0
2608, 1.15, 0.9, 0
2609, 1.15, 0.85, 0
2610, 1.15, 0.8, 0
2611, 1.15, 0.75, 0
2612, 1.15, 0.7, 0
2613, 1.15, 0.65, 0
2614, 1.15, 0.6, 0
2615, 1.15, 0.55, 0
2616, 1.15, 0.5, 0
2617, 1.15, 0.45, 0
2618, 1.15, 0.4, 0
2619, 1.15, 0.35, 0
2620, 1.15, 0.3, 0
2621, 1.15, 0.25, 0
2622, 1.15, 0.2, 0
2623, 1.15, 1.325, 0
2624, 1.15, 1.275, 0
2625, 1.15, 1.225, 0
2626, 1.15, 1.175, 0
2627, 1.15, 1.125, 0
2628, 1.15, 1.075, 0
2629, 1.15, 1.025, 0
2630, 1.15, 0.975, 0
2631, 1.15, 0.925, 0
2632, 1.15, 0.875, 0
2633, 1.15, 0.825, 0
2634, 1.15, 0.775, 0
2635, 1.15, 0.725, 0
2636, 1.15, 0.675, 0
2637, 1.15, 0.625, 0
2638, 1.15, 0.575, 0
2639, 1.15, 0.525, 0
2640, 1.15, 0.475, 0
2641, 1.15, 0.425, 0
2642, 1.15, 0.375, 0
2643, 1.15, 0.325, 0
2644, 1.15, 0.275, 0
2645, 1.15, 0.225, 0
2646, 1.15, 0.175, 0
2647, 1.15, 1.35, 0.041666666666667
2648, 1.15, 1.35, 0.083333333333333
2649, 1.15, 1.35, 0.125
2650, 1.15, 1.35, 0.16666666666667
2651, 1.15, 1.35, 0.20833333333333
2652, 1.15, 1.35, 0.25
2653, 1.15, 1.35, 0.29166666666667
2654, 1.15, 1.35, 0.33333333333333
2655, 1.15, 1.35, 0.375
2656, 1.15, 1.35, 0.41666666666667
2657, 1.15, 1.35, 0.45833333333333
2658, 1.15, 1.35, 0.020833333333333
2659, 1.15, 1.35, 0.0625
2660, 1.15, 1.35, 0.10416666666667
2661, 1.15, 1.35, 0.14583333333333
2662, 1.15, 1.35, 0.1875
2663, 1.15, 1.35, 0.22916666666667
2664, 1.15, 1.35, 0.27083333333333
2665, 1.15, 1.35, 0.3125
2666, 1.15, 1.35, 0.35416666666667
2667, 1.15, 1.35, 0.39583333333333
2668, 1.15, 1.35, 0.4375
2669, 1.15, 1.35, 0.47916666666667
2670, 1.15, 0.15, 0.041666666666667
2671, 1.15, 0.15, 0.083333333333333
2672, 1.15, 0.15, 0.125
2673, 1.15, 0.15, 0.16666666666667
2674, 1.15, 0.15, 0.20833333333333
2675, 1.15, 0.15, 0.25
2676, 1.15, 0.15, 0.29166666666667
2677, 1.15, 0.15, 0.33333333333333
2678, 1.15, 0.15, 0.375
2679, 1.15, 0.15, 0.41666666666667
2680, 1.15, 0.15, 0.45833333333333
2681, 1.15, 0.15, 0.020833333333333
2682, 1.15, 0.15, 0.0625
2683, 1.15, 0.15, 0.10416666666667
2684, 1.15, 0.15, 0.14583333333333
2685, 1.15, 0.15, 0.1875
2686, 1.15, 0.15, 0.22916666666667
2687, 1.15, 0.15, 0.27083333333333
2688, 1.15, 0.15, 0.3125
2689, 1.15, 0.15, 0.35416666666667
2690, 1.15, 0.15, 0.39583333333333
2691, 1.15, 0.15, 0.4375
2692, 1.15, 0.15, 0.47916666666667
2693, 1, 0.15, -0.05
2694, 1, 1.35, -0.05
2695, 1, 0.2, -0.1
2696, 1, 0.25, -0.1
2697, 1, 0.3, -0.1
2698, 1, 0.35, -0.1
2699, 1, 0.4, -0.1
2700, 1, 0.45, -0.1
2701, 1, 0.5, -0.1
2702, 1, 0.55, -0.1
2703, 1, 0.6, -0.1
2704, 1, 0.65, -0.1
2705, 1, 0.7, -0.1
2706, 1, 0.75, -0.1
2707, 1, 0.8, -0.1
2708, 1, 0.85, -0.1
2709, 1, 0.9, -0.1
2710, 1, 0.95, -0.1
2711, 1, 1, -0.1
2712, 1, 1.05, -0.1
2713, 1, 1.1, -0.1
2714, 1, 1.15, -0.1
2715, 1, 1.2, -0.1
2716, 1, 1.25, -0.1
2717, 1, 1.3, -0.1
2718, 1, 0.175, -0.1
2719, 1, 0.225, -0.1
2720, 1, 0.275, -0.1
2721, 1, 0.325, -0.1
2722, 1, 0.375, -0.1
2723, 1, 0.425, -0.1
2724, 1, 0.475, -0.1
2725, 1, 0.525, -0.1
2726, 1, 0.575, -0.1
2727, 1, 0.625, -0.1
2728, 1, 0.675, -0.1
2729, 1, 0.725, -0.1
2730, 1, 0.775, -0.1
2731, 1, 0.825, -0.1
2732, 1, 0.875, -0.1
2733, 1, 0.925, -0.1
2734, 1, 0.975, -0.1
2735, 1, 1.025, -0.1
2736, 1, 1.075, -0.1
2737, 1, 1.125, -0.1
2738, 1, 1.175, -0.1
2739, 1, 1.225, -0.1
2740, 1, 1.275, -0.1
2741, 1, 1.325, -0.1
2742, 0, 0.15, -0.05
2743, 0, 1.35, -0.05
2744, 0, 0.2, -0.1
2745, 0, 0.25, -0.1
2746, 0, 0.3, -0.1
2747, 0, 0.35, -0.1
2748, 0, 0.4, -0.1
2749, 0, 0.45, -0.1
2750, 0, 0.5, -0.1
2751, 0, 0.55, -0.1
2752, 0, 0.6, -0.1
2753, 0, 0.65, -0.1
2754, 0, 0.7, -0.1
2755, 0, 0.75, -0.1
2756, 0, 0.8, -0.1
2757, 0, 0.85, -0.1
2758, 0, 0.9, -0.1
2759, 0, 0.95, -0.1
2760, 0, 1, -0.1
2761, 0, 1.05, -0.1
2762, 0, 1.1, -0.1
2763, 0, 1.15, -0.1
2764, 0, 1.2, -0.1
2765, 0, 1.25, -0.1
2766, 0, 1.3, -0.1
2767, 0, 0.175, -0.1
2768, 0, 0.225, -0.1
2769, 0, 0.275, -0.1
2770, 0, 0.325, -0.1
2771, 0, 0.375, -0.1
2772, 0, 0.425, -0.1
2773, 0, 0.475, -0.1
2774, 0, 0.525, -0.1
2775, 0, 0.575, -0.1
2776, 0, 0.625, -0.1
2777, 0, 0.675, -0.1
2778, 0, 0.725, -0.1
2779, 0, 0.775, -0.1
2780, 0, 0.825, -0.1
2781, 0, 0.875, -0.1
2782, 0, 0.925, -0.1
2783, 0, 0.975, -0.1
2784, 0, 1.025, -0.1
2785, 0, 1.075, -0.1
2786, 0, 1.125, -0.1
2787, 0, 1.175, -0.1
2788, 0, 1.225, -0.1
2789, 0, 1.275, -0.1
2790, 0, 1.325, -0.1
2791, 0.041666666666667, 0.15, -0.1
2792, 0.083333333333333, 0.15, -0.1
2793, 0.125, 0.15, -0.1
2794, 0.16666666666667, 0.15, -0.1
2795, 0.20833333333333, 0.15, -0.1
2796, 0.25, 0.15, -0.1
2797, 0.29166666666667, 0.15, -0.1
2798, 0.33333333333333, 0.15, -0.1
2799, 0.375, 0.15, -0.1
2800, 0.41666666666667, 0.15, -0.1
2801, 0.45833333333333, 0.15, -0.1
2802, 0.5, 0.15, -0.1
2803, 0.54166666666667, 0.15, -0.1
2804, 0.58333333333333, 0.15, -0.1
2805, 0.625, 0.15, -0.1
2806, 0.66666666666667, 0.15, -0.1
2807, 0.70833333333333, 0.15, -0.1
2808, 0.75, 0.15, -0.1
2809, 0.79166666666667, 0.15, -0.1
2810, 0.83333333333333, 0.15, -0.1
2811, 0.875, 0.15, -0.1
2812, 0.91666666666667, 0.15, -0.1
2813, 0.95833333333333, 0.15, -0.1
2814, 0.020833333333333, 0.15, -0.1
2815, 0.0625, 0.15, -0.1
2816, 0.10416666666667, 0.15, -0.1
2817, 0.14583333333333, 0.15, -0.1
2818, 0.1875, 0.15, -0.1
2819, 0.22916666666667, 0.15, -0.1
2820, 0.27083333333333, 0.15, -0.1
2821, 0.3125, 0.15, -0.1
2822, 0.35416666666667, 0.15, -0.1
2823, 0.39583333333333, 0.15, -0.1
2824, 0.4375, 0.15, -0.1
2825, 0.47916666666667, 0.15, -0.1
2826, 0.52083333333333, 0.15, -0.1
2827, 0.5625, 0.15, -0.1
2828, 0.60416666666667, 0.15, -0.1
2829, 0.64583333333333, 0.15, -0.1
2830, 0.6875, 0.15, -0.1
2831, 0.72916666666667, 0.15, -0.1
2832, 0.77083333333333, 0.15, -0.1
2833, 0.8125, 0.15, -0.1
2834, 0.85416666666667, 0.15, -0.1
2835, 0.89583333333333, 0.15, -0.1
2836, 0.9375, 0.15, -0.1
2837, 0.97916666666667, 0.15, -0.1
2838, 0.041666666666667, 1.35, -0.1
2839, 0.083333333333333, 1.35, -0.1
2840, 0.125, 1.35, -0.1
2841, 0.16666666666667, 1.35, -0.1
2842, 0.20833333333333, 1.35, -0.1
2843, 0.25, 1.35, -0.1
2844, 0.29166666666667, 1.35, -0.1
2845, 0.33333333333333, 1.35, -0.1
2846, 0.375, 1.35, -0.1
2847, 0.41666666666667, 1.35, -0.1
2848, 0.45833333333333, 1.35, -0.1
2849, 0.5, 1.35, -0.1
2850, 0.54166666666667, 1.35, -0.1
2851, 0.58333333333333, 1.35, -0.1
2852, 0.625, 1.35, -0.1
2853, 0.66666666666667, 1.35, -0.1
2854, 0.70833333333333, 1.35, -0.1
2855, 0.75, 1.35, -0.1
2856, 0.79166666666667, 1.35, -0.1
2857, 0.83333333333333, 1.35, -0.1
2858, 0.875, 1.35, -0.1
2859, 0.91666666666667, 1.35, -0.1
2860, 0.95833333333333, 1.35, -0.1
2861, 0.020833333333333, 1.35, -0.1
2862, 0.0625, 1.35, -0.1
2863, 0.10416666666667, 1.35, -0.1
2864, 0.14583333333333, 1.35, -0.1
2865, 0.1875, 1.35, -0.1
2866, 0.22916666666667, 1.35, -0.1
2867, 0.27083333333333, 1.35, -0.1
2868, 0.3125, 1.35, -0.1
2869, 0.35416666666667, 1.35, -0.1
2870, 0.39583333333333, 1.35, -0.1
2871, 0.4375, 1.35, -0.1
2872, 0.47916666666667, 1.35, -0.1
2873, 0.52083333333333, 1.35, -0.1
2874, 0.5625, 1.35, -0.1
2875, 0.60416666666667, 1.35, -0.1
2876, 0.64583333333333, 1.35, -0.1
2877, 0.6875, 1.35, -0.1
2878, 0.72916666666667, 1.35, -0.1
2879, 0.77083333333333, 1.35, -0.1
2880, 0.8125, 1.35, -0.1
2881, 0.85416666666667, 1.35, -0.1
2882, 0.89583333333333, 1.35, -0.1
2883, 0.9375, 1.35, -0.1
2884, 0.97916666666667, 1.35, -0.1
2885, 1.2, 1.35, -0.05
2886, 1.2, 0.15, -0.05
2887, 1.2, 1.3, -0.1
2888, 1.2, 1.25, -0.1
2889, 1.2, 1.2, -0.1
2890, 1.2, 1.15, -0.1
2891, 1.2, 1.1, -0.1
2892, 1.2, 1.05, -0.1
2893, 1.2, 1, -0.1
2894, 1.2, 0.95, -0.1
2895, 1.2, 0.9, -0.1
2896, 1.2, 0.85, -0.1
2897, 1.2, 0.8, -0.1
2898, 1.2, 0.75, -0.1
2899, 1.2, 0.7, -0.1
2900, 1.2, 0.65, -0.1
2901, 1.2, 0.6, -0.1
2902, 1.2, 0.55, -0.1
2903, 1.2, 0.5, -0.1
2904, 1.2, 0.45, -0.1
2905, 1.2, 0.4, -0.1
2906, 1.2, 0.35, -0.1
2907, 1.2, 0.3, -0.1
2908, 1.2, 0.25, -0.1
2909, 1.2, 0.2, -0.1
2910, 1.2, 1.325, -0.1
2911, 1.2, 1.275, -0.1
2912, 1.2, 1.225, -0.1
2913, 1.2, 1.175, -0.1
2914, 1.2, 1.125, -0.1
2915, 1.2, 1.075, -0.1
2916, 1.2, 1.025, -0.1
2917, 1.2, 0.975, -0.1
2918, 1.2, 0.925, -0.1
2919, 1.2, 0.875, -0.1
2920, 1.2, 0.825, -0.1
2921, 1.2, 0.775, -0.1
2922, 1.2, 0.725, -0.1
2923, 1.2, 0.675, -0.1
2924, 1.2, 0.625, -0.1
2925, 1.2, 0.575, -0.1
2926, 1.2, 0.525, -0.1
2927, 1.2, 0.475, -0.1
2928, 1.2, 0.425, -0.1
2929, 1.2, 0.375, -0.1
2930, 1.2, 0.325, -0.1
2931, 1.2, 0.275, -0.1
2932, 1.2, 0.225, -0.1
2933, 1.2, 0.175, -0.1
2934, 2.2, 1.35, -0.05
2935, 2.2, 0.15, -0.05
2936, 2.2, 1.3, -0.1
2937, 2.2, 1.25, -0.1
2938, 2.2, 1.2, -0.1
2939, 2.2, 1.15, -0.1
2940, 2.2, 1.1, -0.1
2941, 2.2, 1.05, -0.1
2942, 2.2, 1, -0.1
2943, 2.2, 0.95, -0.1
2944, 2.2, 0.9, -0.1
2945, 2.2, 0.85, -0.1
2946, 2.2, 0.8, -0.1
2947, 2.2, 0.75, -0.1
2948, 2.2, 0.7, -0.1
2949, 2.2, 0.65, -0.1
2950, 2.2, 0.6, -0.1
2951, 2.2, 0.55, -0.1
2952, 2.2, 0.5, -0.1
2953, 2.2, 0.45, -0.1
2954, 2.2, 0.4, -0.1
2955, 2.2, 0.35, -0.1
2956, 2.2, 0.3, -0.1
2957, 2.2, 0.25, -0.1
2958, 2.2, 0.2, -0.1
2959, 2.2, 1.325, -0.1
2960, 2.2, 1.275, -0.1
2961, 2.2, 1.225, -0.1
2962, 2.2, 1.175, -0.1
2963, 2.2, 1.125, -0.1
2964, 2.2, 1.075, -0.1
2965, 2.2, 1.025, -0.1
2966, 2.2, 0.975, -0.1
2967, 2.2, 0.925, -0.1
2968, 2.2, 0.875, -0.1
2969, 2.2, 0.825, -0.1
2970, 2.2, 0.775, -0.1
2971, 2.2, 0.725, -0.1
2972, 2.2, 0.675, -0.1
2973, 2.2, 0.625, -0.1
2974, 2.2, 0.575, -0.1
2975, 2.2, 0.525, -0.1
2976, 2.2, 0.475, -0.1
2977, 2.2, 0.425, -0.1
2978, 2.2, 0.375, -0.1
2979, 2.2, 0.325, -0.1
2980, 2.2, 0.275, -0.1
2981, 2.2, 0.225, -0.1
2982, 2.2, 0.175, -0.1
2983, 1.2416666666667, 1.35, -0.1
2984, 1.2833333333333, 1.35, -0.1
2985, 1.325, 1.35, -0.1
2986, 1.3666666666667, 1.35, -0.1
2987, 1.4083333333333, 1.35, -0.1
2988, 1.45, 1.35, -0.1
2989, 1.4916666666667, 1.35, -0.1
2990, 1.5333333333333, 1.35, -0.1
2991, 1.575, 1.35, -0.1
2992, 1.6166666666667, 1.35, -0.1
2993, 1.6583333333333, 1.35, -0.1
2994, 1.7, 1.35, -0.1
2995, 1.7416666666667, 1.35, -0.1
2996, 1.7833333333333, 1.35, -0.1
2997, 1.825, 1.35, -0.1
2998, 1.8666666666667, 1.35, -0.1
2999, 1.9083333333333, 1.35, -0.1
3000, 1.95, 1.35, -0.1
3001, 1.9916666666667, 1.35, -0.1
3002, 2.0333333333333, 1.35, -0.1
3003, 2.075, 1.35, -0.1
3004, 2.1166666666667, 1.35, -0.1
3005, 2.1583333333333, 1.35, -0.1
3006, 1.2208333333333, 1.35, -0.1
3007, 1.2625, 1.35, -0.1
3008, 1.3041666666667, 1.35, -0.1
3009, 1.3458333333333, 1.35, -0.1
3010, 1.3875, 1.35, -0.1
3011, 1.4291666666667, 1.35, -0.1
3012, 1.4708333333333, 1.35, -0.1
3013, 1.5125, 1.35, -0.1
3014, 1.5541666666667, 1.35, -0.1
3015, 1.5958333333333, 1.35, -0.1
3016, 1.6375, 1.35, -0.1
3017, 1.6791666666667, 1.35, -0.1
3018, 1.7208333333333, 1.35, -0.1
3019, 1.7625, 1.35, -0.1
3020, 1.8041666666667, 1.35, -0.1
3021, 1.8458333333333, 1.35, -0.1
3022, 1.8875, 1.35, -0.1
3023, 1.9291666666667, 1.35, -0.1
3024, 1.9708333333333, 1.35, -0.1
3025, 2.0125, 1.35, -0.1
3026, 2.0541666666667, 1.35, -0.1
3027, 2.0958333333333, 1.35, -0.1
3028, 2.1375, 1.35, -0.1
3029, 2.1791666666667, 1.35, -0.1
3030, 1.2416666666667, 0.15, -0.1
3031, 1.2833333333333, 0.15, -0.1
3032, 1.325, 0.15, -0.1
3033, 1.3666666666667, 0.15, -0.1
3034, 1.4083333333333, 0.15, -0.1
3035, 1.45, 0.15, -0.1
3036, 1.4916666666667, 0.15, -0.1
3037, 1.5333333333333, 0.15, -0.1
3038, 1.575, 0.15, -0.1
3039, 1.6166666666667, 0.15, -0.1
3040, 1.6583333333333, 0.15, -0.1
3041, 1.7, 0.15, -0.1
3042, 1.7416666666667, 0.15, -0.1
3043, 1.7833333333333, 0.15, -0.1
3044, 1.825, 0.15, -0.1
3045, 1.8666666666667, 0.15, -0.1
3046, 1.9083333333333, 0.15, -0.1
3047, 1.95, 0.15, -0.1
3048, 1.9916666666667, 0.15, -0.1
3049, 2.0333333333333, 0.15, -0.1
3050, 2.075, 0.15, -0.1
3051, 2.1166666666667, 0.15, -0.1
3052, 2.1583333333333, 0.15, -0.1
3053, 1.2208333333333, 0.15, -0.1
3054, 1.2625, 0.15, -0.1
3055, 1.3041666666667, 0.15, -0.1
3056, 1.3458333333333, 0.15, -0.1
3057, 1.3875, 0.15, -0.1
3058, 1.4291666666667, 0.15, -0.1
3059, 1.4708333333333, 0.15, -0.1
3060, 1.5125, 0.15, -0.1
3061, 1.5541666666667, 0.15, -0.1
3062, 1.5958333333333, 0.15, -0.1
3063, 1.6375, 0.15, -0.1
3064, 1.6791666666667, 0.15, -0.1
3065, 1.7208333333333, 0.15, -0.1
3066, 1.7625, 0.15, -0.1
3067, 1.8041666666667, 0.15, -0.1
3068, 1.8458333333333, 0.15, -0.1
3069, 1.8875, 0.15, -0.1
3070, 1.9291666666667, 0.15, -0.1
3071, 1.9708333333333, 0.15, -0.1
3072, 2.0125, 0.15, -0.1
3073, 2.0541666666667, 0.15, -0.1
3074, 2.0958333333333, 0.15, -0.1
3075, 2.1375, 0.15, -0.1
3076, 2.1791666666667, 0.15, -0.1
3077, 1.15, 1.35, -0.05
3078, 1.175, 1.35, -0.1
3079, 1.15, 0.15, -0.05
3080, 1.175, 0.15, -0.1
3081, 1.15, 1.3, -0.1
3082, 1.15, 1.25, -0.1
3083, 1.15, 1.2, -0.1
3084, 1.15, 1.15, -0.1
3085, 1.15, 1.1, -0.1
3086, 1.15, 1.05, -0.1
3087, 1.15, 1, -0.1
3088, 1.15, 0.95, -0.1
3089, 1.15, 0.9, -0.1
3090, 1.15, 0.85, -0.1
3091, 1.15, 0.8, -0.1
3092, 1.15, 0.75, -0.1
3093, 1.15, 0.7, -0.1
3094, 1.15, 0.65, -0.1
3095, 1.15, 0.6, -0.1
3096, 1.15, 0.55, -0.1
3097, 1.15, 0.5, -0.1
3098, 1.15, 0.45, -0.1
3099, 1.15, 0.4, -0.1
3100, 1.15, 0.35, -0.1
3101, 1.15, 0.3, -0.1
3102, 1.15, 0.25, -0.1
3103, 1.15, 0.2, -0.1
3104, 1.15, 1.325, -0.1
3105, 1.15, 1.275, -0.1
3106, 1.15, 1.225, -0.1
3107, 1.15, 1.175, -0.1
3108, 1.15, 1.125, -0.1
3109, 1.15, 1.075, -0.1
3110, 1.15, 1.025, -0.1
3111, 1.15, 0.975, -0.1
3112, 1.15, 0.925, -0.1
3113, 1.15, 0.875, -0.1
3114, 1.15, 0.825, -0.1
3115, 1.15, 0.775, -0.1
3116, 1.15, 0.725, -0.1
3117, 1.15, 0.675, -0.1
3118, 1.15, 0.625, -0.1
3119, 1.15, 0.575, -0.1
3120, 1.15, 0.525, -0.1
3121, 1.15, 0.475, -0.1
3122, 1.15, 0.425, -0.1
3123, 1.15, 0.375, -0.1
3124, 1.15, 0.325, -0.1
3125, 1.15, 0.275, -0.1
3126, 1.15, 0.225, -0.1
3127, 1.15, 0.175, -0.1
3128, 1.05, 0.15, -0.05
3129, 1.025, 0.15, -0.1
3130, 1.05, 1.35, -0.05
3131, 1.025, 1.35, -0.1
3132, 1.05, 0.2, -0.1
3133, 1.05, 0.25, -0.1
3134, 1.05, 0.3, -0.1
3135, 1.05, 0.35, -0.1
3136, 1.05, 0.4, -0.1
3137, 1.05, 0.45, -0.1
3138, 1.05, 0.5, -0.1
3139, 1.05, 0.55, -0.1
3140, 1.05, 0.6, -0.1
3141, 1.05, 0.65, -0.1
3142, 1.05, 0.7, -0.1
3143, 1.05, 0.75, -0.1
3144, 1.05, 0.8, -0.1
3145, 1.05, 0.85, -0.1
3146, 1.05, 0.9, -0.1
3147, 1.05, 0.95, -0.1
3148, 1.05, 1, -0.1
3149, 1.05, 1.05, -0.1
3150, 1.05, 1.1, -0.1
3151, 1.05, 1.15, -0.1
3152, 1.05, 1.2, -0.1
3153, 1.05, 1.25, -0.1
3154, 1.05, 1.3, -0.1
3155, 1.05, 0.175, -0.1
3156, 1.05, 0.225, -0.1
3157, 1.05, 0.275, -0.1
3158, 1.05, 0.325, -0.1
3159, 1.05, 0.375, -0.1
3160, 1.05, 0.425, -0.1
3161, 1.05, 0.475, -0.1
3162, 1.05, 0.525, -0.1
3163, 1.05, 0.575, -0.1
3164, 1.05, 0.625, -0.1
3165, 1.05, 0.675, -0.1
3166, 1.05, 0.725, -0.1
3167, 1.05, 0.775, -0.1
3168, 1.05, 0.825, -0.1
3169, 1.05, 0.875, -0.1
3170, 1.05, 0.925, -0.1
3171, 1.05, 0.975, -0.1
3172, 1.05, 1.025, -0.1
3173, 1.05, 1.075, -0.1
3174, 1.05, 1.125, -0.1
3175, 1.05, 1.175, -0.1
3176, 1.05, 1.225, -0.1
3177, 1.05, 1.275, -0.1
3178, 1.05, 1.325, -0.1
3179, 1, 1.54, 0
3180, 1, 1.58, 0
3181, 1, 1.62, 0
3182, 1, 1.66, 0
3183, 1, 1.52, 0
3184, 1, 1.56, 0
3185, 1, 1.6, 0
3186, 1, 1.64, 0
3187, 1, 1.68, 0
3188, 0, 1.54, 0
3189, 0, 1.58, 0
3190, 0, 1.62, 0
3191, 0, 1.66, 0
3192, 0, 1.52, 0
3193, 0, 1.56, 0
3194, 0, 1.6, 0
3195, 0, 1.64, 0
3196, 0, 1.68, 0
3197, 0.041666666666667, 1.7, 0
3198, 0.083333333333333, 1.7, 0
3199, 0.125, 1.7, 0
3200, 0.16666666666667, 1.7, 0
3201, 0.20833333333333, 1.7, 0
3202, 0.25, 1.7, 0
3203, 0.29166666666667, 1.7, 0
3204, 0.33333333333333, 1.7, 0
3205, 0.375, 1.7, 0
3206, 0.41666666666667, 1.7, 0
3207, 0.45833333333333, 1.7, 0
3208, 0.5, 1.7, 0
3209, 0.54166666666667, 1.7, 0
3210, 0.58333333333333, 1.7, 0
3211, 0.625, 1.7, 0
3212, 0.66666666666667, 1.7, 0
3213, 0.70833333333333, 1.7, 0
3214, 0.75, 1.7, 0
3215, 0.79166666666667, 1.7, 0
3216, 0.83333333333333, 1.7, 0
3217, 0.875, 1.7, 0
3218, 0.91666666666667, 1.7, 0
3219, 0.95833333333333, 1.7, 0
3220, 0.020833333333333, 1.7, 0
3221, 0.0625, 1.7, 0
3222, 0.10416666666667, 1.7, 0
3223, 0.14583333333333, 1.7, 0
3224, 0.1875, 1.7, 0
3225, 0.22916666666667, 1.7, 0
3226, 0.27083333333333, 1.7, 0
3227, 0.3125, 1.7, 0
3228, 0.35416666666667, 1.7, 0
3229, 0.39583333333333, 1.7, 0
3230, 0.4375, 1.7, 0
3231, 0.47916666666667, 1.7, 0
3232, 0.52083333333333, 1.7, 0
3233, 0.5625, 1.7, 0
3234, 0.60416666666667, 1.7, 0
3235, 0.64583333333333, 1.7, 0
3236, 0.6875, 1.7, 0
3237, 0.72916666666667, 1.7, 0
3238, 0.77083333333333, 1.7, 0
3239, 0.8125, 1.7, 0
3240, 0.85416666666667, 1.7, 0
3241, 0.89583333333333, 1.7, 0
3242, 0.9375, 1.7, 0
3243, 0.97916666666667, 1.7, 0
3244, 1, 1.54, 0.5
3245, 1, 1.58, 0.5
3246, 1, 1.62, 0.5
3247, 1, 1.66, 0.5
3248, 1, 1.52, 0.5
3249, 1, 1.56, 0.5
3250, 1, 1.6, 0.5
3251, 1, 1.64, 0.5
3252, 1, 1.68, 0.5
3253, 1, 1.7, 0.041666666666667
3254, 1, 1.7, 0.083333333333333
3255, 1, 1.7, 0.125
3256, 1, 1.7, 0.16666666666667
3257, 1, 1.7, 0.20833333333333
3258, 1, 1.7, 0.25
3259, 1, 1.7, 0.29166666666667
3260, 1, 1.7, 0.33333333333333
3261, 1, 1.7, 0.375
3262, 1, 1.7, 0.41666666666667
3263, 1, 1.7, 0.45833333333333
3264, 1, 1.7, 0.020833333333333
3265, 1, 1.7, 0.0625
3266, 1, 1.7, 0.10416666666667
3267, 1, 1.7, 0.14583333333333
3268, 1, 1.7, 0.1875
3269, 1, 1.7, 0.22916666666667
3270, 1, 1.7, 0.27083333333333
3271, 1, 1.7, 0.3125
3272, 1, 1.7, 0.35416666666667
3273, 1, 1.7, 0.39583333333333
3274, 1, 1.7, 0.4375
3275, 1, 1.7, 0.47916666666667
3276, 0, 1.54, 0.5
3277, 0, 1.58, 0.5
3278, 0, 1.62, 0.5
3279, 0, 1.66, 0.5
3280, 0, 1.52, 0.5
3281, 0, 1.56, 0.5
3282, 0, 1.6, 0.5
3283, 0, 1.64, 0.5
3284, 0, 1.68, 0.5
3285, 0.041666666666667, 1.7, 0.5
3286, 0.083333333333333, 1.7, 0.5
3287, 0.125, 1.7, 0.5
3288, 0.16666666666667, 1.7, 0.5
3289, 0.20833333333333, 1.7, 0.5
3290, 0.25, 1.7, 0.5
3291, 0.29166666666667, 1.7, 0.5
3292, 0.33333333333333, 1.7, 0.5
3293, 0.375, 1.7, 0.5
3294, 0.41666666666667, 1.7, 0.5
3295, 0.45833333333333, 1.7, 0.5
3296, 0.5, 1.7, 0.5
3297, 0.54166666666667, 1.7, 0.5
3298, 0.58333333333333, 1.7, 0.5
3299, 0.625, 1.7, 0.5
3300, 0.66666666666667, 1.7, 0.5
3301, 0.70833333333333, 1.7, 0.5
3302, 0.75, 1.7, 0.5
3303, 0.79166666666667, 1.7, 0.5
3304, 0.83333333333333, 1.7, 0.5
3305, 0.875, 1.7, 0.5
3306, 0.91666666666667, 1.7, 0.5
3307, 0.95833333333333, 1.7, 0.5
3308, 0.020833333333333, 1.7, 0.5
3309, 0.0625, 1.7, 0.5
3310, 0.10416666666667, 1.7, 0.5
3311, 0.14583333333333, 1.7, 0.5
3312, 0.1875, 1.7, 0.5
3313, 0.22916666666667, 1.7, 0.5
3314, 0.27083333333333, 1.7, 0.5
3315, 0.3125, 1.7, 0.5
3316, 0.35416666666667, 1.7, 0.5
3317, 0.39583333333333, 1.7, 0.5
3318, 0.4375, 1.7, 0.5
3319, 0.47916666666667, 1.7, 0.5
3320, 0.52083333333333, 1.7, 0.5
3321, 0.5625, 1.7, 0.5
3322, 0.60416666666667, 1.7, 0.5
3323, 0.64583333333333, 1.7, 0.5
3324, 0.6875, 1.7, 0.5
3325, 0.72916666666667, 1.7, 0.5
3326, 0.77083333333333, 1.7, 0.5
3327, 0.8125, 1.7, 0.5
3328, 0.85416666666667, 1.7, 0.5
3329, 0.89583333333333, 1.7, 0.5
3330, 0.9375, 1.7, 0.5
3331, 0.97916666666667, 1.7, 0.5
3332, 0, 1.7, 0.041666666666667
3333, 0, 1.7, 0.083333333333333
3334, 0, 1.7, 0.125
3335, 0, 1.7, 0.16666666666667
3336, 0, 1.7, 0.20833333333333
3337, 0, 1.7, 0.25
3338, 0, 1.7, 0.29166666666667
3339, 0, 1.7, 0.33333333333333
3340, 0, 1.7, 0.375
3341, 0, 1.7, 0.41666666666667
3342, 0, 1.7, 0.45833333333333
3343, 0, 1.7, 0.020833333333333
3344, 0, 1.7, 0.0625
3345, 0, 1.7, 0.10416666666667
3346, 0, 1.7, 0.14583333333333
3347, 0, 1.7, 0.1875
3348, 0, 1.7, 0.22916666666667
3349, 0, 1.7, 0.27083333333333
3350, 0, 1.7, 0.3125
3351, 0, 1.7, 0.35416666666667
3352, 0, 1.7, 0.39583333333333
3353, 0, 1.7, 0.4375
3354, 0, 1.7, 0.47916666666667
3355, 1.2, 1.54, 0.5
3356, 1.2, 1.58, 0.5
3357, 1.2, 1.62, 0.5
3358, 1.2, 1.66, 0.5
3359, 1.2, 1.52, 0.5
3360, 1.2, 1.56, 0.5
3361, 1.2, 1.6, 0.5
3362, 1.2, 1.64, 0.5
3363, 1.2, 1.68, 0.5
3364, 1.04, 1.7, 0.5
3365, 1.08, 1.7, 0.5
3366, 1.12, 1.7, 0.5
3367, 1.16, 1.7, 0.5
3368, 1.02, 1.7, 0.5
3369, 1.06, 1.7, 0.5
3370, 1.1, 1.7, 0.5
3371, 1.14, 1.7, 0.5
3372, 1.18, 1.7, 0.5
3373, 1.2, 1.54, 0
3374, 1.2, 1.58, 0
3375, 1.2, 1.62, 0
3376, 1.2, 1.66, 0
3377, 1.2, 1.52, 0
3378, 1.2, 1.56, 0
3379, 1.2, 1.6, 0
3380, 1.2, 1.64, 0
3381, 1.2, 1.68, 0
3382, 1.04, 1.7, 0
3383, 1.08, 1.7, 0
3384, 1.12, 1.7, 0
3385, 1.16, 1.7, 0
3386, 1.02, 1.7, 0
3387, 1.06, 1.7, 0
3388, 1.1, 1.7, 0
3389, 1.14, 1.7, 0
3390, 1.18, 1.7, 0
3391, 1.2, 1.7, 0.041666666666667
3392, 1.2, 1.7, 0.083333333333333
3393, 1.2, 1.7, 0.125
3394, 1.2, 1.7, 0.16666666666667
3395, 1.2, 1.7, 0.20833333333333
3396, 1.2, 1.7, 0.25
3397, 1.2, 1.7, 0.29166666666667
3398, 1.2, 1.7, 0.33333333333333
3399, 1.2, 1.7, 0.375
3400, 1.2, 1.7, 0.41666666666667
3401, 1.2, 1.7, 0.45833333333333
3402, 1.2, 1.7, 0.020833333333333
3403, 1.2, 1.7, 0.0625
3404, 1.2, 1.7, 0.10416666666667
3405, 1.2, 1.7, 0.14583333333333
3406, 1.2, 1.7, 0.1875
3407, 1.2, 1.7, 0.22916666666667
3408, 1.2, 1.7, 0.27083333333333
3409, 1.2, 1.7, 0.3125
3410, 1.2, 1.7, 0.35416666666667
3411, 1.2, 1.7, 0.39583333333333
3412, 1.2, 1.7, 0.4375
3413, 1.2, 1.7, 0.47916666666667
3414, 2.2, 1.54, 0.5
3415, 2.2, 1.58, 0.5
3416, 2.2, 1.62, 0.5
3417, 2.2, 1.66, 0.5
3418, 2.2, 1.52, 0.5
3419, 2.2, 1.56, 0.5
3420, 2.2, 1.6, 0.5
3421, 2.2, 1.64, 0.5
3422, 2.2, 1.68, 0.5
3423, 1.2416666666667, 1.7, 0.5
3424, 1.2833333333333, 1.7, 0.5
3425, 1.325, 1.7, 0.5
3426, 1.3666666666667, 1.7, 0.5
3427, 1.4083333333333, 1.7, 0.5
3428, 1.45, 1.7, 0.5
3429, 1.4916666666667, 1.7, 0.5
3430, 1.5333333333333, 1.7, 0.5
3431, 1.575, 1.7, 0.5
3432, 1.6166666666667, 1.7, 0.5
3433, 1.6583333333333, 1.7, 0.5
3434, 1.7, 1.7, 0.5
3435, 1.7416666666667, 1.7, 0.5
3436, 1.7833333333333, 1.7, 0.5
3437, 1.825, 1.7, 0.5
3438, 1.8666666666667, 1.7, 0.5
3439, 1.9083333333333, 1.7, 0.5
3440, 1.95, 1.7, 0.5
3441, 1.9916666666667, 1.7, 0.5
3442, 2.0333333333333, 1.7, 0.5
3443, 2.075, 1.7, 0.5
3444, 2.1166666666667, 1.7, 0.5
3445, 2.1583333333333, 1.7, 0.5
3446, 1.2208333333333, 1.7, 0.5
3447, 1.2625, 1.7, 0.5
3448, 1.3041666666667, 1.7, 0.5
3449, 1.3458333333333, 1.7, 0.5
3450, 1.3875, 1.7, 0.5
3451, 1.4291666666667, 1.7, 0.5
3452, 1.4708333333333, 1.7, 0.5
3453, 1.5125, 1.7, 0.5
3454, 1.5541666666667, 1.7, 0.5
3455, 1.5958333333333, 1.7, 0.5
3456, 1.6375, 1.7, 0.5
3457, 1.6791666666667, 1.7, 0.5
3458, 1.7208333333333, 1.7, 0.5
3459, 1.7625, 1.7, 0.5
3460, 1.8041666666667, 1.7, 0.5
3461, 1.8458333333333, 1.7, 0.5
3462, 1.8875, 1.7, 0.5
3463, 1.9291666666667, 1.7, 0.5
3464, 1.9708333333333, 1.7, 0.5
3465, 2.0125, 1.7, 0.5
3466, 2.0541666666667, 1.7, 0.5
3467, 2.0958333333333, 1.7, 0.5
3468, 2.1375, 1.7, 0.5
3469, 2.1791666666667, 1.7, 0.5
3470, 2.2, 1.54, 0
3471, 2.2, 1.58, 0
3472, 2.2, 1.62, 0
3473, 2.2, 1.66, 0
3474, 2.2, 1.52, 0
3475, 2.2, 1.56, 0
3476, 2.2, 1.6, 0
3477, 2.2, 1.64, 0
3478, 2.2, 1.68, 0
3479, 1.2416666666667, 1.7, 0
3480, 1.2833333333333, 1.7, 0
3481, 1.325, 1.7, 0
3482, 1.3666666666667, 1.7, 0
3483, 1.4083333333333, 1.7, 0
3484, 1.45, 1.7, 0
3485, 1.4916666666667, 1.7, 0
3486, 1.5333333333333, 1.7, 0
3487, 1.575, 1.7, 0
3488, 1.6166666666667, 1.7, 0
3489, 1.6583333333333, 1.7, 0
3490, 1.7, 1.7, 0
3491, 1.7416666666667, 1.7, 0
3492, 1.7833333333333, 1.7, 0
3493, 1.825, 1.7, 0
3494, 1.8666666666667, 1.7, 0
3495, 1.9083333333333, 1.7, 0
3496, 1.95, 1.7, 0
3497, 1.9916666666667, 1.7, 0
3498, 2.0333333333333, 1.7, 0
3499, 2.075, 1.7, 0
3500, 2.1166666666667, 1.7, 0
3501, 2.1583333333333, 1.7, 0
3502, 1.2208333333333, 1.7, 0
3503, 1.2625, 1.7, 0
3504, 1.3041666666667, 1.7, 0
3505, 1.3458333333333, 1.7, 0
3506, 1.3875, 1.7, 0
3507, 1.4291666666667, 1.7, 0
3508, 1.4708333333333, 1.7, 0
3509, 1.5125, 1.7, 0
3510, 1.5541666666667, 1.7, 0
3511, 1.5958333333333, 1.7, 0
3512, 1.6375, 1.7, 0
3513, 1.6791666666667, 1.7, 0
3514, 1.7208333333333, 1.7, 0
3515, 1.7625, 1.7, 0
3516, 1.8041666666667, 1.7, 0
3517, 1.8458333333333, 1.7, 0
3518, 1.8875, 1.7, 0
3519, 1.9291666666667, 1.7, 0
3520, 1.9708333333333, 1.7, 0
3521, 2.0125, 1.7, 0
3522, 2.0541666666667, 1.7, 0
3523, 2.0958333333333, 1.7, 0
3524, 2.1375, 1.7, 0
3525, 2.1791666666667, 1.7, 0
3526, 2.2, 1.7, 0.041666666666667
3527, 2.2, 1.7, 0.083333333333333
3528, 2.2, 1.7, 0.125
3529, 2.2, 1.7, 0.16666666666667
3530, 2.2, 1.7, 0.20833333333333
3531, 2.2, 1.7, 0.25
3532, 2.2, 1.7, 0.29166666666667
3533, 2.2, 1.7, 0.33333333333333
3534, 2.2, 1.7, 0.375
3535, 2.2, 1.7, 0.41666666666667
3536, 2.2, 1.7, 0.45833333333333
3537, 2.2, 1.7, 0.020833333333333
3538, 2.2, 1.7, 0.0625
3539, 2.2, 1.7, 0.10416666666667
3540, 2.2, 1.7, 0.14583333333333
3541, 2.2, 1.7, 0.1875
3542, 2.2, 1.7, 0.22916666666667
3543, 2.2, 1.7, 0.27083333333333
3544, 2.2, 1.7, 0.3125
3545, 2.2, 1.7, 0.35416666666667
3546, 2.2, 1.7, 0.39583333333333
3547, 2.2, 1.7, 0.4375
3548, 2.2, 1.7, 0.47916666666667
3549, 1, -0.04, 0
3550, 1, -0.08, 0
3551, 1, -0.12, 0
3552, 1, -0.16, 0
3553, 1, -0.02, 0
3554, 1, -0.06, 0
3555, 1, -0.1, 0
3556, 1, -0.14, 0
3557, 1, -0.18, 0
3558, 0, -0.04, 0
3559, 0, -0.08, 0
3560, 0, -0.12, 0
3561, 0, -0.16, 0
3562, 0, -0.02, 0
3563, 0, -0.06, 0
3564, 0, -0.1, 0
3565, 0, -0.14, 0
3566, 0, -0.18, 0
3567, 0.041666666666667, -0.2, 0
3568, 0.083333333333333, -0.2, 0
3569, 0.125, -0.2, 0
3570, 0.16666666666667, -0.2, 0
3571, 0.20833333333333, -0.2, 0
3572, 0.25, -0.2, 0
3573, 0.29166666666667, -0.2, 0
3574, 0.33333333333333, -0.2, 0
3575, 0.375, -0.2, 0
3576, 0.41666666666667, -0.2, 0
3577, 0.45833333333333, -0.2, 0
3578, 0.5, -0.2, 0
3579, 0.54166666666667, -0.2, 0
3580, 0.58333333333333, -0.2, 0
3581, 0.625, -0.2, 0
3582, 0.66666666666667, -0.2, 0
3583, 0.70833333333333, -0.2, 0
3584, 0.75, -0.2, 0
3585, 0.79166666666667, -0.2, 0
3586, 0.83333333333333, -0.2, 0
3587, 0.875, -0.2, 0
3588, 0.91666666666667, -0.2, 0
3589, 0.95833333333333, -0.2, 0
3590, 0.020833333333333, -0.2, 0
3591, 0.0625, -0.2, 0
3592, 0.10416666666667, -0.2, 0
3593, 0.14583333333333, -0.2, 0
3594, 0.1875, -0.2, 0
3595, 0.22916666666667, -0.2, 0
3596, 0.27083333333333, -0.2, 0
3597, 0.3125, -0.2, 0
3598, 0.35416666666667, -0.2, 0
3599, 0.39583333333333, -0.2, 0
3600, 0.4375, -0.2, 0
3601, 0.47916666666667, -0.2, 0
3602, 0.52083333333333, -0.2, 0
3603, 0.5625, -0.2, 0
3604, 0.60416666666667, -0.2, 0
3605, 0.64583333333333, -0.2, 0
3606, 0.6875, -0.2, 0
3607, 0.72916666666667, -0.2, 0
3608, 0.77083333333333, -0.2, 0
3609, 0.8125, -0.2, 0
3610, 0.85416666666667, -0.2, 0
3611, 0.89583333333333, -0.2, 0
3612, 0.9375, -0.2, 0
3613, 0.97916666666667, -0.2, 0
3614, 1, -0.04, 0.5
3615, 1, -0.08, 0.5
3616, 1, -0.12, 0.5
3617, 1, -0.16, 0.5
3618, 1, -0.02, 0.5
3619, 1, -0.06, 0.5
3620, 1, -0.1, 0.5
3621, 1, -0.14, 0.5
3622, 1, -0.18, 0.5
3623, 1, -0.2, 0.041666666666667
3624, 1, -0.2, 0.083333333333333
3625, 1, -0.2, 0.125
3626, 1, -0.2, 0.16666666666667
3627, 1, -0.2, 0.20833333333333
3628, 1, -0.2, 0.25
3629, 1, -0.2, 0.29166666666667
3630, 1, -0.2, 0.33333333333333
3631, 1, -0.2, 0.375
3632, 1, -0.2, 0.41666666666667
3633, 1, -0.2, 0.45833333333333
3634, 1, -0.2, 0.020833333333333
3635, 1, -0.2, 0.0625
3636, 1, -0.2, 0.10416666666667
3637, 1, -0.2, 0.14583333333333
3638, 1, -0.2, 0.1875
3639, 1, -0.2, 0.22916666666667
3640, 1, -0.2, 0.27083333333333
3641, 1, -0.2, 0.3125
3642, 1, -0.2, 0.35416666666667
3643, 1, -0.2, 0.39583333333333
3644, 1, -0.2, 0.4375
3645, 1, -0.2, 0.47916666666667
3646, 0, -0.04, 0.5
3647, 0, -0.08, 0.5
3648, 0, -0.12, 0.5
3649, 0, -0.16, 0.5
3650, 0, -0.02, 0.5
3651, 0, -0.06, 0.5
3652, 0, -0.1, 0.5
3653, 0, -0.14, 0.5
3654, 0, -0.18, 0.5
3655, 0.041666666666667, -0.2, 0.5
3656, 0.083333333333333, -0.2, 0.5
3657, 0.125, -0.2, 0.5
3658, 0.16666666666667, -0.2, 0.5
3659, 0.20833333333333, -0.2, 0.5
3660, 0.25, -0.2, 0.5
3661, 0.29166666666667, -0.2, 0.5
3662, 0.33333333333333, -0.2, 0.5
3663, 0.375, -0.2, 0.5
3664, 0.41666666666667, -0.2, 0.5
3665, 0.45833333333333, -0.2, 0.5
3666, 0.5, -0.2, 0.5
3667, 0.54166666666667, -0.2, 0.5
3668, 0.58333333333333, -0.2, 0.5
3669, 0.625, -0.2, 0.5
3670, 0.66666666666667, -0.2, 0.5
3671, 0.70833333333333, -0.2, 0.5
3672, 0.75, -0.2, 0.5
3673, 0.79166666666667, -0.2, 0.5
3674, 0.83333333333333, -0.2, 0.5
3675, 0.875, -0.2, 0.5
3676, 0.91666666666667, -0.2, 0.5
3677, 0.95833333333333, -0.2, 0.5
3678, 0.020833333333333, -0.2, 0.5
3679, 0.0625, -0.2, 0.5
3680, 0.10416666666667, -0.2, 0.5
3681, 0.14583333333333, -0.2, 0.5
3682, 0.1875, -0.2, 0.5
3683, 0.22916666666667, -0.2, 0.5
3684, 0.27083333333333, -0.2, 0.5
3685, 0.3125, -0.2, 0.5
3686, 0.35416666666667, -0.2, 0.5
3687, 0.39583333333333, -0.2, 0.5
3688, 0.4375, -0.2, 0.5
3689, 0.47916666666667, -0.2, 0.5
3690, 0.52083333333333, -0.2, 0.5
3691, 0.5625, -0.2, 0.5
3692, 0.60416666666667, -0.2, 0.5
3693, 0.64583333333333, -0.2, 0.5
3694, 0.6875, -0.2, 0.5
3695, 0.72916666666667, -0.2, 0.5
3696, 0.77083333333333, -0.2, 0.5
3697, 0.8125, -0.2, 0.5
3698, 0.85416666666667, -0.2, 0.5
3699, 0.89583333333333, -0.2, 0.5
3700, 0.9375, -0.2, 0.5
3701, 0.97916666666667, -0.2, 0.5
3702, 0, -0.2, 0.041666666666667
3703, 0, -0.2, 0.083333333333333
3704, 0, -0.2, 0.125
3705, 0, -0.2, 0.16666666666667
3706, 0, -0.2, 0.20833333333333
3707, 0, -0.2, 0.25
3708, 0, -0.2, 0.29166666666667
3709, 0, -0.2, 0.33333333333333
3710, 0, -0.2, 0.375
3711, 0, -0.2, 0.41666666666667
3712, 0, -0.2, 0.45833333333333
3713, 0, -0.2, 0.020833333333333
3714, 0, -0.2, 0.0625
3715, 0, -0.2, 0.10416666666667
3716, 0, -0.2, 0.14583333333333
3717, 0, -0.2, 0.1875
3718, 0, -0.2, 0.22916666666667
3719, 0, -0.2, 0.27083333333333
3720, 0, -0.2, 0.3125
3721, 0, -0.2, 0.35416666666667
3722, 0, -0.2, 0.39583333333333
3723, 0, -0.2, 0.4375
3724, 0, -0.2, 0.47916666666667
3725, -0.1, -0.04, 0.5
3726, -0.1, -0.08, 0.5
3727, -0.1, -0.12, 0.5
3728, -0.1, -0.16, 0.5
3729, -0.1, -0.02, 0.5
3730, -0.1, -0.06, 0.5
3731, -0.1, -0.1, 0.5
3732, -0.1, -0.14, 0.5
3733, -0.1, -0.18, 0.5
3734, -0.05, -0.2, 0.5
3735, -0.1, -0.04, 0
3736, -0.1, -0.08, 0
3737, -0.1, -0.12, 0
3738, -0.1, -0.16, 0
3739, -0.1, -0.02, 0
3740, -0.1, -0.06, 0
3741, -0.1, -0.1, 0
3742, -0.1, -0.14, 0
3743, -0.1, -0.18, 0
3744, -0.05, -0.2, 0
3745, -0.1, -0.2, 0.041666666666667
3746, -0.1, -0.2, 0.083333333333333
3747, -0.1, -0.2, 0.125
3748, -0.1, -0.2, 0.16666666666667
3749, -0.1, -0.2, 0.20833333333333
3750, -0.1, -0.2, 0.25
3751, -0.1, -0.2, 0.29166666666667
3752, -0.1, -0.2, 0.33333333333333
3753, -0.1, -0.2, 0.375
3754, -0.1, -0.2, 0.41666666666667
3755, -0.1, -0.2, 0.45833333333333
3756, -0.1, -0.2, 0.020833333333333
3757, -0.1, -0.2, 0.0625
3758, -0.1, -0.2, 0.10416666666667
3759, -0.1, -0.2, 0.14583333333333
3760, -0.1, -0.2, 0.1875
3761, -0.1, -0.2, 0.22916666666667
3762, -0.1, -0.2, 0.27083333333333
3763, -0.1, -0.2, 0.3125
