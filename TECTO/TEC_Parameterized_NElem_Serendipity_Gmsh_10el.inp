72671, 2.075, 0.5, 0.125
72672, 2.075, 0.45, 0.125
72673, 2.075, 0.4, 0.125
72674, 2.075, 0.35, 0.125
72675, 2.075, 0.3, 0.125
72676, 2.075, 0.25, 0.125
72677, 2.075, 0.2, 0.125
72678, 2.1166666666667, 1.3, 0.125
72679, 2.1166666666667, 1.25, 0.125
72680, 2.1166666666667, 1.2, 0.125
72681, 2.1166666666667, 1.15, 0.125
72682, 2.1166666666667, 1.1, 0.125
72683, 2.1166666666667, 1.05, 0.125
72684, 2.1166666666667, 1, 0.125
72685, 2.1166666666667, 0.95, 0.125
72686, 2.1166666666667, 0.9, 0.125
72687, 2.1166666666667, 0.85, 0.125
72688, 2.1166666666667, 0.8, 0.125
72689, 2.1166666666667, 0.75, 0.125
72690, 2.1166666666667, 0.7, 0.125
72691, 2.1166666666667, 0.65, 0.125
72692, 2.1166666666667, 0.6, 0.125
72693, 2.1166666666667, 0.55, 0.125
72694, 2.1166666666667, 0.5, 0.125
72695, 2.1166666666667, 0.45, 0.125
72696, 2.1166666666667, 0.4, 0.125
72697, 2.1166666666667, 0.35, 0.125
72698, 2.1166666666667, 0.3, 0.125
72699, 2.1166666666667, 0.25, 0.125
72700, 2.1166666666667, 0.2, 0.125
72701, 2.1583333333333, 1.3, 0.125
72702, 2.1583333333333, 1.25, 0.125
72703, 2.1583333333333, 1.2, 0.125
72704, 2.1583333333333, 1.15, 0.125
72705, 2.1583333333333, 1.1, 0.125
72706, 2.1583333333333, 1.05, 0.125
72707, 2.1583333333333, 1, 0.125
72708, 2.1583333333333, 0.95, 0.125
72709, 2.1583333333333, 0.9, 0.125
72710, 2.1583333333333, 0.85, 0.125
72711, 2.1583333333333, 0.8, 0.125
72712, 2.1583333333333, 0.75, 0.125
72713, 2.1583333333333, 0.7, 0.125
72714, 2.1583333333333, 0.65, 0.125
72715, 2.1583333333333, 0.6, 0.125
72716, 2.1583333333333, 0.55, 0.125
72717, 2.1583333333333, 0.5, 0.125
72718, 2.1583333333333, 0.45, 0.125
72719, 2.1583333333333, 0.4, 0.125
72720, 2.1583333333333, 0.35, 0.125
72721, 2.1583333333333, 0.3, 0.125
72722, 2.1583333333333, 0.25, 0.125
72723, 2.1583333333333, 0.2, 0.125
72724, 1.2416666666667, 1.3, 0.16666666666667
72725, 1.2416666666667, 1.25, 0.16666666666667
72726, 1.2416666666667, 1.2, 0.16666666666667
72727, 1.2416666666667, 1.15, 0.16666666666667
72728, 1.2416666666667, 1.1, 0.16666666666667
72729, 1.2416666666667, 1.05, 0.16666666666667
72730, 1.2416666666667, 1, 0.16666666666667
72731, 1.2416666666667, 0.95, 0.16666666666667
72732, 1.2416666666667, 0.9, 0.16666666666667
72733, 1.2416666666667, 0.85, 0.16666666666667
72734, 1.2416666666667, 0.8, 0.16666666666667
72735, 1.2416666666667, 0.75, 0.16666666666667
72736, 1.2416666666667, 0.7, 0.16666666666667
72737, 1.2416666666667, 0.65, 0.16666666666667
72738, 1.2416666666667, 0.6, 0.16666666666667
72739, 1.2416666666667, 0.55, 0.16666666666667
72740, 1.2416666666667, 0.5, 0.16666666666667
72741, 1.2416666666667, 0.45, 0.16666666666667
72742, 1.2416666666667, 0.4, 0.16666666666667
72743, 1.2416666666667, 0.35, 0.16666666666667
72744, 1.2416666666667, 0.3, 0.16666666666667
72745, 1.2416666666667, 0.25, 0.16666666666667
72746, 1.2416666666667, 0.2, 0.16666666666667
72747, 1.2833333333333, 1.3, 0.16666666666667
72748, 1.2833333333333, 1.25, 0.16666666666667
72749, 1.2833333333333, 1.2, 0.16666666666667
72750, 1.2833333333333, 1.15, 0.16666666666667
72751, 1.2833333333333, 1.1, 0.16666666666667
72752, 1.2833333333333, 1.05, 0.16666666666667
72753, 1.2833333333333, 1, 0.16666666666667
72754, 1.2833333333333, 0.95, 0.16666666666667
72755, 1.2833333333333, 0.9, 0.16666666666667
72756, 1.2833333333333, 0.85, 0.16666666666667
72757, 1.2833333333333, 0.8, 0.16666666666667
72758, 1.2833333333333, 0.75, 0.16666666666667
72759, 1.2833333333333, 0.7, 0.16666666666667
72760, 1.2833333333333, 0.65, 0.16666666666667
72761, 1.2833333333333, 0.6, 0.16666666666667
72762, 1.2833333333333, 0.55, 0.16666666666667
72763, 1.2833333333333, 0.5, 0.16666666666667
72764, 1.2833333333333, 0.45, 0.16666666666667
72765, 1.2833333333333, 0.4, 0.16666666666667
72766, 1.2833333333333, 0.35, 0.16666666666667
72767, 1.2833333333333, 0.3, 0.16666666666667
72768, 1.2833333333333, 0.25, 0.16666666666667
72769, 1.2833333333333, 0.2, 0.16666666666667
72770, 1.325, 1.3, 0.16666666666667
72771, 1.325, 1.25, 0.16666666666667
72772, 1.325, 1.2, 0.16666666666667
72773, 1.325, 1.15, 0.16666666666667
72774, 1.325, 1.1, 0.16666666666667
72775, 1.325, 1.05, 0.16666666666667
72776, 1.325, 1, 0.16666666666667
72777, 1.325, 0.95, 0.16666666666667
72778, 1.325, 0.9, 0.16666666666667
72779, 1.325, 0.85, 0.16666666666667
72780, 1.325, 0.8, 0.16666666666667
72781, 1.325, 0.75, 0.16666666666667
72782, 1.325, 0.7, 0.16666666666667
72783, 1.325, 0.65, 0.16666666666667
72784, 1.325, 0.6, 0.16666666666667
72785, 1.325, 0.55, 0.16666666666667
72786, 1.325, 0.5, 0.16666666666667
72787, 1.325, 0.45, 0.16666666666667
72788, 1.325, 0.4, 0.16666666666667
72789, 1.325, 0.35, 0.16666666666667
72790, 1.325, 0.3, 0.16666666666667
72791, 1.325, 0.25, 0.16666666666667
72792, 1.325, 0.2, 0.16666666666667
72793, 1.3666666666667, 1.3, 0.16666666666667
72794, 1.3666666666667, 1.25, 0.16666666666667
72795, 1.3666666666667, 1.2, 0.16666666666667
72796, 1.3666666666667, 1.15, 0.16666666666667
72797, 1.3666666666667, 1.1, 0.16666666666667
72798, 1.3666666666667, 1.05, 0.16666666666667
72799, 1.3666666666667, 1, 0.16666666666667
72800, 1.3666666666667, 0.95, 0.16666666666667
72801, 1.3666666666667, 0.9, 0.16666666666667
72802, 1.3666666666667, 0.85, 0.16666666666667
72803, 1.3666666666667, 0.8, 0.16666666666667
72804, 1.3666666666667, 0.75, 0.16666666666667
72805, 1.3666666666667, 0.7, 0.16666666666667
72806, 1.3666666666667, 0.65, 0.16666666666667
72807, 1.3666666666667, 0.6, 0.16666666666667
72808, 1.3666666666667, 0.55, 0.16666666666667
72809, 1.3666666666667, 0.5, 0.16666666666667
72810, 1.3666666666667, 0.45, 0.16666666666667
72811, 1.3666666666667, 0.4, 0.16666666666667
72812, 1.3666666666667, 0.35, 0.16666666666667
72813, 1.3666666666667, 0.3, 0.16666666666667
72814, 1.3666666666667, 0.25, 0.16666666666667
72815, 1.3666666666667, 0.2, 0.16666666666667
72816, 1.4083333333333, 1.3, 0.16666666666667
72817, 1.4083333333333, 1.25, 0.16666666666667
72818, 1.4083333333333, 1.2, 0.16666666666667
72819, 1.4083333333333, 1.15, 0.16666666666667
72820, 1.4083333333333, 1.1, 0.16666666666667
72821, 1.4083333333333, 1.05, 0.16666666666667
72822, 1.4083333333333, 1, 0.16666666666667
72823, 1.4083333333333, 0.95, 0.16666666666667
72824, 1.4083333333333, 0.9, 0.16666666666667
72825, 1.4083333333333, 0.85, 0.16666666666667
72826, 1.4083333333333, 0.8, 0.16666666666667
72827, 1.4083333333333, 0.75, 0.16666666666667
72828, 1.4083333333333, 0.7, 0.16666666666667
72829, 1.4083333333333, 0.65, 0.16666666666667
72830, 1.4083333333333, 0.6, 0.16666666666667
72831, 1.4083333333333, 0.55, 0.16666666666667
72832, 1.4083333333333, 0.5, 0.16666666666667
72833, 1.4083333333333, 0.45, 0.16666666666667
72834, 1.4083333333333, 0.4, 0.16666666666667
72835, 1.4083333333333, 0.35, 0.16666666666667
72836, 1.4083333333333, 0.3, 0.16666666666667
72837, 1.4083333333333, 0.25, 0.16666666666667
72838, 1.4083333333333, 0.2, 0.16666666666667
72839, 1.45, 1.3, 0.16666666666667
72840, 1.45, 1.25, 0.16666666666667
72841, 1.45, 1.2, 0.16666666666667
72842, 1.45, 1.15, 0.16666666666667
72843, 1.45, 1.1, 0.16666666666667
72844, 1.45, 1.05, 0.16666666666667
72845, 1.45, 1, 0.16666666666667
72846, 1.45, 0.95, 0.16666666666667
72847, 1.45, 0.9, 0.16666666666667
72848, 1.45, 0.85, 0.16666666666667
72849, 1.45, 0.8, 0.16666666666667
72850, 1.45, 0.75, 0.16666666666667
72851, 1.45, 0.7, 0.16666666666667
72852, 1.45, 0.65, 0.16666666666667
72853, 1.45, 0.6, 0.16666666666667
72854, 1.45, 0.55, 0.16666666666667
72855, 1.45, 0.5, 0.16666666666667
72856, 1.45, 0.45, 0.16666666666667
72857, 1.45, 0.4, 0.16666666666667
72858, 1.45, 0.35, 0.16666666666667
72859, 1.45, 0.3, 0.16666666666667
72860, 1.45, 0.25, 0.16666666666667
72861, 1.45, 0.2, 0.16666666666667
72862, 1.4916666666667, 1.3, 0.16666666666667
72863, 1.4916666666667, 1.25, 0.16666666666667
72864, 1.4916666666667, 1.2, 0.16666666666667
72865, 1.4916666666667, 1.15, 0.16666666666667
72866, 1.4916666666667, 1.1, 0.16666666666667
72867, 1.4916666666667, 1.05, 0.16666666666667
72868, 1.4916666666667, 1, 0.16666666666667
72869, 1.4916666666667, 0.95, 0.16666666666667
72870, 1.4916666666667, 0.9, 0.16666666666667
72871, 1.4916666666667, 0.85, 0.16666666666667
72872, 1.4916666666667, 0.8, 0.16666666666667
72873, 1.4916666666667, 0.75, 0.16666666666667
72874, 1.4916666666667, 0.7, 0.16666666666667
72875, 1.4916666666667, 0.65, 0.16666666666667
72876, 1.4916666666667, 0.6, 0.16666666666667
72877, 1.4916666666667, 0.55, 0.16666666666667
72878, 1.4916666666667, 0.5, 0.16666666666667
72879, 1.4916666666667, 0.45, 0.16666666666667
72880, 1.4916666666667, 0.4, 0.16666666666667
72881, 1.4916666666667, 0.35, 0.16666666666667
72882, 1.4916666666667, 0.3, 0.16666666666667
72883, 1.4916666666667, 0.25, 0.16666666666667
72884, 1.4916666666667, 0.2, 0.16666666666667
72885, 1.5333333333333, 1.3, 0.16666666666667
72886, 1.5333333333333, 1.25, 0.16666666666667
72887, 1.5333333333333, 1.2, 0.16666666666667
72888, 1.5333333333333, 1.15, 0.16666666666667
72889, 1.5333333333333, 1.1, 0.16666666666667
72890, 1.5333333333333, 1.05, 0.16666666666667
72891, 1.5333333333333, 1, 0.16666666666667
72892, 1.5333333333333, 0.95, 0.16666666666667
72893, 1.5333333333333, 0.9, 0.16666666666667
72894, 1.5333333333333, 0.85, 0.16666666666667
72895, 1.5333333333333, 0.8, 0.16666666666667
72896, 1.5333333333333, 0.75, 0.16666666666667
72897, 1.5333333333333, 0.7, 0.16666666666667
72898, 1.5333333333333, 0.65, 0.16666666666667
72899, 1.5333333333333, 0.6, 0.16666666666667
72900, 1.5333333333333, 0.55, 0.16666666666667
72901, 1.5333333333333, 0.5, 0.16666666666667
72902, 1.5333333333333, 0.45, 0.16666666666667
72903, 1.5333333333333, 0.4, 0.16666666666667
72904, 1.5333333333333, 0.35, 0.16666666666667
72905, 1.5333333333333, 0.3, 0.16666666666667
72906, 1.5333333333333, 0.25, 0.16666666666667
72907, 1.5333333333333, 0.2, 0.16666666666667
72908, 1.575, 1.3, 0.16666666666667
72909, 1.575, 1.25, 0.16666666666667
72910, 1.575, 1.2, 0.16666666666667
72911, 1.575, 1.15, 0.16666666666667
72912, 1.575, 1.1, 0.16666666666667
72913, 1.575, 1.05, 0.16666666666667
72914, 1.575, 1, 0.16666666666667
72915, 1.575, 0.95, 0.16666666666667
72916, 1.575, 0.9, 0.16666666666667
72917, 1.575, 0.85, 0.16666666666667
72918, 1.575, 0.8, 0.16666666666667
72919, 1.575, 0.75, 0.16666666666667
72920, 1.575, 0.7, 0.16666666666667
72921, 1.575, 0.65, 0.16666666666667
72922, 1.575, 0.6, 0.16666666666667
72923, 1.575, 0.55, 0.16666666666667
72924, 1.575, 0.5, 0.16666666666667
72925, 1.575, 0.45, 0.16666666666667
72926, 1.575, 0.4, 0.16666666666667
72927, 1.575, 0.35, 0.16666666666667
72928, 1.575, 0.3, 0.16666666666667
72929, 1.575, 0.25, 0.16666666666667
72930, 1.575, 0.2, 0.16666666666667
72931, 1.6166666666667, 1.3, 0.16666666666667
72932, 1.6166666666667, 1.25, 0.16666666666667
72933, 1.6166666666667, 1.2, 0.16666666666667
72934, 1.6166666666667, 1.15, 0.16666666666667
72935, 1.6166666666667, 1.1, 0.16666666666667
72936, 1.6166666666667, 1.05, 0.16666666666667
72937, 1.6166666666667, 1, 0.16666666666667
72938, 1.6166666666667, 0.95, 0.16666666666667
72939, 1.6166666666667, 0.9, 0.16666666666667
72940, 1.6166666666667, 0.85, 0.16666666666667
72941, 1.6166666666667, 0.8, 0.16666666666667
72942, 1.6166666666667, 0.75, 0.16666666666667
72943, 1.6166666666667, 0.7, 0.16666666666667
72944, 1.6166666666667, 0.65, 0.16666666666667
72945, 1.6166666666667, 0.6, 0.16666666666667
72946, 1.6166666666667, 0.55, 0.16666666666667
72947, 1.6166666666667, 0.5, 0.16666666666667
72948, 1.6166666666667, 0.45, 0.16666666666667
72949, 1.6166666666667, 0.4, 0.16666666666667
72950, 1.6166666666667, 0.35, 0.16666666666667
72951, 1.6166666666667, 0.3, 0.16666666666667
72952, 1.6166666666667, 0.25, 0.16666666666667
72953, 1.6166666666667, 0.2, 0.16666666666667
72954, 1.6583333333333, 1.3, 0.16666666666667
72955, 1.6583333333333, 1.25, 0.16666666666667
72956, 1.6583333333333, 1.2, 0.16666666666667
72957, 1.6583333333333, 1.15, 0.16666666666667
72958, 1.6583333333333, 1.1, 0.16666666666667
72959, 1.6583333333333, 1.05, 0.16666666666667
72960, 1.6583333333333, 1, 0.16666666666667
72961, 1.6583333333333, 0.95, 0.16666666666667
72962, 1.6583333333333, 0.9, 0.16666666666667
72963, 1.6583333333333, 0.85, 0.16666666666667
72964, 1.6583333333333, 0.8, 0.16666666666667
72965, 1.6583333333333, 0.75, 0.16666666666667
72966, 1.6583333333333, 0.7, 0.16666666666667
72967, 1.6583333333333, 0.65, 0.16666666666667
72968, 1.6583333333333, 0.6, 0.16666666666667
72969, 1.6583333333333, 0.55, 0.16666666666667
72970, 1.6583333333333, 0.5, 0.16666666666667
72971, 1.6583333333333, 0.45, 0.16666666666667
72972, 1.6583333333333, 0.4, 0.16666666666667
72973, 1.6583333333333, 0.35, 0.16666666666667
72974, 1.6583333333333, 0.3, 0.16666666666667
72975, 1.6583333333333, 0.25, 0.16666666666667
72976, 1.6583333333333, 0.2, 0.16666666666667
72977, 1.7, 1.3, 0.16666666666667
72978, 1.7, 1.25, 0.16666666666667
72979, 1.7, 1.2, 0.16666666666667
72980, 1.7, 1.15, 0.16666666666667
72981, 1.7, 1.1, 0.16666666666667
72982, 1.7, 1.05, 0.16666666666667
72983, 1.7, 1, 0.16666666666667
72984, 1.7, 0.95, 0.16666666666667
72985, 1.7, 0.9, 0.16666666666667
72986, 1.7, 0.85, 0.16666666666667
72987, 1.7, 0.8, 0.16666666666667
72988, 1.7, 0.75, 0.16666666666667
72989, 1.7, 0.7, 0.16666666666667
72990, 1.7, 0.65, 0.16666666666667
72991, 1.7, 0.6, 0.16666666666667
72992, 1.7, 0.55, 0.16666666666667
72993, 1.7, 0.5, 0.16666666666667
72994, 1.7, 0.45, 0.16666666666667
72995, 1.7, 0.4, 0.16666666666667
72996, 1.7, 0.35, 0.16666666666667
72997, 1.7, 0.3, 0.16666666666667
72998, 1.7, 0.25, 0.16666666666667
72999, 1.7, 0.2, 0.16666666666667
73000, 1.7416666666667, 1.3, 0.16666666666667
73001, 1.7416666666667, 1.25, 0.16666666666667
73002, 1.7416666666667, 1.2, 0.16666666666667
73003, 1.7416666666667, 1.15, 0.16666666666667
73004, 1.7416666666667, 1.1, 0.16666666666667
73005, 1.7416666666667, 1.05, 0.16666666666667
73006, 1.7416666666667, 1, 0.16666666666667
73007, 1.7416666666667, 0.95, 0.16666666666667
73008, 1.7416666666667, 0.9, 0.16666666666667
73009, 1.7416666666667, 0.85, 0.16666666666667
73010, 1.7416666666667, 0.8, 0.16666666666667
73011, 1.7416666666667, 0.75, 0.16666666666667
73012, 1.7416666666667, 0.7, 0.16666666666667
73013, 1.7416666666667, 0.65, 0.16666666666667
73014, 1.7416666666667, 0.6, 0.16666666666667
73015, 1.7416666666667, 0.55, 0.16666666666667
73016, 1.7416666666667, 0.5, 0.16666666666667
73017, 1.7416666666667, 0.45, 0.16666666666667
73018, 1.7416666666667, 0.4, 0.16666666666667
73019, 1.7416666666667, 0.35, 0.16666666666667
73020, 1.7416666666667, 0.3, 0.16666666666667
73021, 1.7416666666667, 0.25, 0.16666666666667
73022, 1.7416666666667, 0.2, 0.16666666666667
73023, 1.7833333333333, 1.3, 0.16666666666667
73024, 1.7833333333333, 1.25, 0.16666666666667
73025, 1.7833333333333, 1.2, 0.16666666666667
73026, 1.7833333333333, 1.15, 0.16666666666667
73027, 1.7833333333333, 1.1, 0.16666666666667
73028, 1.7833333333333, 1.05, 0.16666666666667
73029, 1.7833333333333, 1, 0.16666666666667
73030, 1.7833333333333, 0.95, 0.16666666666667
73031, 1.7833333333333, 0.9, 0.16666666666667
73032, 1.7833333333333, 0.85, 0.16666666666667
73033, 1.7833333333333, 0.8, 0.16666666666667
73034, 1.7833333333333, 0.75, 0.16666666666667
73035, 1.7833333333333, 0.7, 0.16666666666667
73036, 1.7833333333333, 0.65, 0.16666666666667
73037, 1.7833333333333, 0.6, 0.16666666666667
73038, 1.7833333333333, 0.55, 0.16666666666667
73039, 1.7833333333333, 0.5, 0.16666666666667
73040, 1.7833333333333, 0.45, 0.16666666666667
73041, 1.7833333333333, 0.4, 0.16666666666667
73042, 1.7833333333333, 0.35, 0.16666666666667
73043, 1.7833333333333, 0.3, 0.16666666666667
73044, 1.7833333333333, 0.25, 0.16666666666667
73045, 1.7833333333333, 0.2, 0.16666666666667
73046, 1.825, 1.3, 0.16666666666667
73047, 1.825, 1.25, 0.16666666666667
73048, 1.825, 1.2, 0.16666666666667
73049, 1.825, 1.15, 0.16666666666667
73050, 1.825, 1.1, 0.16666666666667
73051, 1.825, 1.05, 0.16666666666667
73052, 1.825, 1, 0.16666666666667
73053, 1.825, 0.95, 0.16666666666667
73054, 1.825, 0.9, 0.16666666666667
73055, 1.825, 0.85, 0.16666666666667
73056, 1.825, 0.8, 0.16666666666667
73057, 1.825, 0.75, 0.16666666666667
73058, 1.825, 0.7, 0.16666666666667
73059, 1.825, 0.65, 0.16666666666667
73060, 1.825, 0.6, 0.16666666666667
73061, 1.825, 0.55, 0.16666666666667
73062, 1.825, 0.5, 0.16666666666667
73063, 1.825, 0.45, 0.16666666666667
73064, 1.825, 0.4, 0.16666666666667
73065, 1.825, 0.35, 0.16666666666667
73066, 1.825, 0.3, 0.16666666666667
73067, 1.825, 0.25, 0.16666666666667
73068, 1.825, 0.2, 0.16666666666667
73069, 1.8666666666667, 1.3, 0.16666666666667
73070, 1.8666666666667, 1.25, 0.16666666666667
73071, 1.8666666666667, 1.2, 0.16666666666667
73072, 1.8666666666667, 1.15, 0.16666666666667
73073, 1.8666666666667, 1.1, 0.16666666666667
73074, 1.8666666666667, 1.05, 0.16666666666667
73075, 1.8666666666667, 1, 0.16666666666667
73076, 1.8666666666667, 0.95, 0.16666666666667
73077, 1.8666666666667, 0.9, 0.16666666666667
73078, 1.8666666666667, 0.85, 0.16666666666667
73079, 1.8666666666667, 0.8, 0.16666666666667
73080, 1.8666666666667, 0.75, 0.16666666666667
73081, 1.8666666666667, 0.7, 0.16666666666667
73082, 1.8666666666667, 0.65, 0.16666666666667
73083, 1.8666666666667, 0.6, 0.16666666666667
73084, 1.8666666666667, 0.55, 0.16666666666667
73085, 1.8666666666667, 0.5, 0.16666666666667
73086, 1.8666666666667, 0.45, 0.16666666666667
73087, 1.8666666666667, 0.4, 0.16666666666667
73088, 1.8666666666667, 0.35, 0.16666666666667
73089, 1.8666666666667, 0.3, 0.16666666666667
73090, 1.8666666666667, 0.25, 0.16666666666667
73091, 1.8666666666667, 0.2, 0.16666666666667
73092, 1.9083333333333, 1.3, 0.16666666666667
73093, 1.9083333333333, 1.25, 0.16666666666667
73094, 1.9083333333333, 1.2, 0.16666666666667
73095, 1.9083333333333, 1.15, 0.16666666666667
73096, 1.9083333333333, 1.1, 0.16666666666667
73097, 1.9083333333333, 1.05, 0.16666666666667
73098, 1.9083333333333, 1, 0.16666666666667
73099, 1.9083333333333, 0.95, 0.16666666666667
73100, 1.9083333333333, 0.9, 0.16666666666667
73101, 1.9083333333333, 0.85, 0.16666666666667
73102, 1.9083333333333, 0.8, 0.16666666666667
73103, 1.9083333333333, 0.75, 0.16666666666667
73104, 1.9083333333333, 0.7, 0.16666666666667
73105, 1.9083333333333, 0.65, 0.16666666666667
73106, 1.9083333333333, 0.6, 0.16666666666667
73107, 1.9083333333333, 0.55, 0.16666666666667
73108, 1.9083333333333, 0.5, 0.16666666666667
73109, 1.9083333333333, 0.45, 0.16666666666667
73110, 1.9083333333333, 0.4, 0.16666666666667
73111, 1.9083333333333, 0.35, 0.16666666666667
73112, 1.9083333333333, 0.3, 0.16666666666667
73113, 1.9083333333333, 0.25, 0.16666666666667
73114, 1.9083333333333, 0.2, 0.16666666666667
73115, 1.95, 1.3, 0.16666666666667
73116, 1.95, 1.25, 0.16666666666667
73117, 1.95, 1.2, 0.16666666666667
73118, 1.95, 1.15, 0.16666666666667
73119, 1.95, 1.1, 0.16666666666667
73120, 1.95, 1.05, 0.16666666666667
73121, 1.95, 1, 0.16666666666667
73122, 1.95, 0.95, 0.16666666666667
73123, 1.95, 0.9, 0.16666666666667
73124, 1.95, 0.85, 0.16666666666667
73125, 1.95, 0.8, 0.16666666666667
73126, 1.95, 0.75, 0.16666666666667
73127, 1.95, 0.7, 0.16666666666667
73128, 1.95, 0.65, 0.16666666666667
73129, 1.95, 0.6, 0.16666666666667
73130, 1.95, 0.55, 0.16666666666667
73131, 1.95, 0.5, 0.16666666666667
73132, 1.95, 0.45, 0.16666666666667
73133, 1.95, 0.4, 0.16666666666667
73134, 1.95, 0.35, 0.16666666666667
73135, 1.95, 0.3, 0.16666666666667
73136, 1.95, 0.25, 0.16666666666667
73137, 1.95, 0.2, 0.16666666666667
73138, 1.9916666666667, 1.3, 0.16666666666667
73139, 1.9916666666667, 1.25, 0.16666666666667
73140, 1.9916666666667, 1.2, 0.16666666666667
73141, 1.9916666666667, 1.15, 0.16666666666667
73142, 1.9916666666667, 1.1, 0.16666666666667
73143, 1.9916666666667, 1.05, 0.16666666666667
73144, 1.9916666666667, 1, 0.16666666666667
73145, 1.9916666666667, 0.95, 0.16666666666667
73146, 1.9916666666667, 0.9, 0.16666666666667
73147, 1.9916666666667, 0.85, 0.16666666666667
73148, 1.9916666666667, 0.8, 0.16666666666667
73149, 1.9916666666667, 0.75, 0.16666666666667
73150, 1.9916666666667, 0.7, 0.16666666666667
73151, 1.9916666666667, 0.65, 0.16666666666667
73152, 1.9916666666667, 0.6, 0.16666666666667
73153, 1.9916666666667, 0.55, 0.16666666666667
73154, 1.9916666666667, 0.5, 0.16666666666667
73155, 1.9916666666667, 0.45, 0.16666666666667
73156, 1.9916666666667, 0.4, 0.16666666666667
73157, 1.9916666666667, 0.35, 0.16666666666667
73158, 1.9916666666667, 0.3, 0.16666666666667
73159, 1.9916666666667, 0.25, 0.16666666666667
73160, 1.9916666666667, 0.2, 0.16666666666667
73161, 2.0333333333333, 1.3, 0.16666666666667
73162, 2.0333333333333, 1.25, 0.16666666666667
73163, 2.0333333333333, 1.2, 0.16666666666667
73164, 2.0333333333333, 1.15, 0.16666666666667
73165, 2.0333333333333, 1.1, 0.16666666666667
73166, 2.0333333333333, 1.05, 0.16666666666667
73167, 2.0333333333333, 1, 0.16666666666667
73168, 2.0333333333333, 0.95, 0.16666666666667
73169, 2.0333333333333, 0.9, 0.16666666666667
73170, 2.0333333333333, 0.85, 0.16666666666667
73171, 2.0333333333333, 0.8, 0.16666666666667
73172, 2.0333333333333, 0.75, 0.16666666666667
73173, 2.0333333333333, 0.7, 0.16666666666667
73174, 2.0333333333333, 0.65, 0.16666666666667
73175, 2.0333333333333, 0.6, 0.16666666666667
73176, 2.0333333333333, 0.55, 0.16666666666667
73177, 2.0333333333333, 0.5, 0.16666666666667
73178, 2.0333333333333, 0.45, 0.16666666666667
73179, 2.0333333333333, 0.4, 0.16666666666667
73180, 2.0333333333333, 0.35, 0.16666666666667
73181, 2.0333333333333, 0.3, 0.16666666666667
73182, 2.0333333333333, 0.25, 0.16666666666667
73183, 2.0333333333333, 0.2, 0.16666666666667
73184, 2.075, 1.3, 0.16666666666667
73185, 2.075, 1.25, 0.16666666666667
73186, 2.075, 1.2, 0.16666666666667
73187, 2.075, 1.15, 0.16666666666667
73188, 2.075, 1.1, 0.16666666666667
73189, 2.075, 1.05, 0.16666666666667
73190, 2.075, 1, 0.16666666666667
73191, 2.075, 0.95, 0.16666666666667
73192, 2.075, 0.9, 0.16666666666667
73193, 2.075, 0.85, 0.16666666666667
73194, 2.075, 0.8, 0.16666666666667
73195, 2.075, 0.75, 0.16666666666667
73196, 2.075, 0.7, 0.16666666666667
73197, 2.075, 0.65, 0.16666666666667
73198, 2.075, 0.6, 0.16666666666667
73199, 2.075, 0.55, 0.16666666666667
73200, 2.075, 0.5, 0.16666666666667
73201, 2.075, 0.45, 0.16666666666667
73202, 2.075, 0.4, 0.16666666666667
73203, 2.075, 0.35, 0.16666666666667
73204, 2.075, 0.3, 0.16666666666667
73205, 2.075, 0.25, 0.16666666666667
73206, 2.075, 0.2, 0.16666666666667
73207, 2.1166666666667, 1.3, 0.16666666666667
73208, 2.1166666666667, 1.25, 0.16666666666667
73209, 2.1166666666667, 1.2, 0.16666666666667
73210, 2.1166666666667, 1.15, 0.16666666666667
73211, 2.1166666666667, 1.1, 0.16666666666667
73212, 2.1166666666667, 1.05, 0.16666666666667
73213, 2.1166666666667, 1, 0.16666666666667
73214, 2.1166666666667, 0.95, 0.16666666666667
73215, 2.1166666666667, 0.9, 0.16666666666667
73216, 2.1166666666667, 0.85, 0.16666666666667
73217, 2.1166666666667, 0.8, 0.16666666666667
73218, 2.1166666666667, 0.75, 0.16666666666667
73219, 2.1166666666667, 0.7, 0.16666666666667
73220, 2.1166666666667, 0.65, 0.16666666666667
73221, 2.1166666666667, 0.6, 0.16666666666667
73222, 2.1166666666667, 0.55, 0.16666666666667
73223, 2.1166666666667, 0.5, 0.16666666666667
73224, 2.1166666666667, 0.45, 0.16666666666667
73225, 2.1166666666667, 0.4, 0.16666666666667
73226, 2.1166666666667, 0.35, 0.16666666666667
73227, 2.1166666666667, 0.3, 0.16666666666667
73228, 2.1166666666667, 0.25, 0.16666666666667
73229, 2.1166666666667, 0.2, 0.16666666666667
73230, 2.1583333333333, 1.3, 0.16666666666667
73231, 2.1583333333333, 1.25, 0.16666666666667
73232, 2.1583333333333, 1.2, 0.16666666666667
73233, 2.1583333333333, 1.15, 0.16666666666667
73234, 2.1583333333333, 1.1, 0.16666666666667
73235, 2.1583333333333, 1.05, 0.16666666666667
73236, 2.1583333333333, 1, 0.16666666666667
73237, 2.1583333333333, 0.95, 0.16666666666667
73238, 2.1583333333333, 0.9, 0.16666666666667
73239, 2.1583333333333, 0.85, 0.16666666666667
73240, 2.1583333333333, 0.8, 0.16666666666667
73241, 2.1583333333333, 0.75, 0.16666666666667
73242, 2.1583333333333, 0.7, 0.16666666666667
73243, 2.1583333333333, 0.65, 0.16666666666667
73244, 2.1583333333333, 0.6, 0.16666666666667
73245, 2.1583333333333, 0.55, 0.16666666666667
73246, 2.1583333333333, 0.5, 0.16666666666667
73247, 2.1583333333333, 0.45, 0.16666666666667
73248, 2.1583333333333, 0.4, 0.16666666666667
73249, 2.1583333333333, 0.35, 0.16666666666667
73250, 2.1583333333333, 0.3, 0.16666666666667
73251, 2.1583333333333, 0.25, 0.16666666666667
73252, 2.1583333333333, 0.2, 0.16666666666667
73253, 1.2416666666667, 1.3, 0.20833333333333
73254, 1.2416666666667, 1.25, 0.20833333333333
73255, 1.2416666666667, 1.2, 0.20833333333333
73256, 1.2416666666667, 1.15, 0.20833333333333
73257, 1.2416666666667, 1.1, 0.20833333333333
73258, 1.2416666666667, 1.05, 0.20833333333333
73259, 1.2416666666667, 1, 0.20833333333333
73260, 1.2416666666667, 0.95, 0.20833333333333
73261, 1.2416666666667, 0.9, 0.20833333333333
73262, 1.2416666666667, 0.85, 0.20833333333333
73263, 1.2416666666667, 0.8, 0.20833333333333
73264, 1.2416666666667, 0.75, 0.20833333333333
73265, 1.2416666666667, 0.7, 0.20833333333333
73266, 1.2416666666667, 0.65, 0.20833333333333
73267, 1.2416666666667, 0.6, 0.20833333333333
73268, 1.2416666666667, 0.55, 0.20833333333333
73269, 1.2416666666667, 0.5, 0.20833333333333
73270, 1.2416666666667, 0.45, 0.20833333333333
73271, 1.2416666666667, 0.4, 0.20833333333333
73272, 1.2416666666667, 0.35, 0.20833333333333
73273, 1.2416666666667, 0.3, 0.20833333333333
73274, 1.2416666666667, 0.25, 0.20833333333333
73275, 1.2416666666667, 0.2, 0.20833333333333
73276, 1.2833333333333, 1.3, 0.20833333333333
73277, 1.2833333333333, 1.25, 0.20833333333333
73278, 1.2833333333333, 1.2, 0.20833333333333
73279, 1.2833333333333, 1.15, 0.20833333333333
73280, 1.2833333333333, 1.1, 0.20833333333333
73281, 1.2833333333333, 1.05, 0.20833333333333
73282, 1.2833333333333, 1, 0.20833333333333
73283, 1.2833333333333, 0.95, 0.20833333333333
73284, 1.2833333333333, 0.9, 0.20833333333333
73285, 1.2833333333333, 0.85, 0.20833333333333
73286, 1.2833333333333, 0.8, 0.20833333333333
73287, 1.2833333333333, 0.75, 0.20833333333333
73288, 1.2833333333333, 0.7, 0.20833333333333
73289, 1.2833333333333, 0.65, 0.20833333333333
73290, 1.2833333333333, 0.6, 0.20833333333333
73291, 1.2833333333333, 0.55, 0.20833333333333
73292, 1.2833333333333, 0.5, 0.20833333333333
73293, 1.2833333333333, 0.45, 0.20833333333333
73294, 1.2833333333333, 0.4, 0.20833333333333
73295, 1.2833333333333, 0.35, 0.20833333333333
73296, 1.2833333333333, 0.3, 0.20833333333333
73297, 1.2833333333333, 0.25, 0.20833333333333
73298, 1.2833333333333, 0.2, 0.20833333333333
73299, 1.325, 1.3, 0.20833333333333
73300, 1.325, 1.25, 0.20833333333333
73301, 1.325, 1.2, 0.20833333333333
73302, 1.325, 1.15, 0.20833333333333
73303, 1.325, 1.1, 0.20833333333333
73304, 1.325, 1.05, 0.20833333333333
73305, 1.325, 1, 0.20833333333333
73306, 1.325, 0.95, 0.20833333333333
73307, 1.325, 0.9, 0.20833333333333
73308, 1.325, 0.85, 0.20833333333333
73309, 1.325, 0.8, 0.20833333333333
73310, 1.325, 0.75, 0.20833333333333
73311, 1.325, 0.7, 0.20833333333333
73312, 1.325, 0.65, 0.20833333333333
73313, 1.325, 0.6, 0.20833333333333
73314, 1.325, 0.55, 0.20833333333333
73315, 1.325, 0.5, 0.20833333333333
73316, 1.325, 0.45, 0.20833333333333
73317, 1.325, 0.4, 0.20833333333333
73318, 1.325, 0.35, 0.20833333333333
73319, 1.325, 0.3, 0.20833333333333
73320, 1.325, 0.25, 0.20833333333333
73321, 1.325, 0.2, 0.20833333333333
73322, 1.3666666666667, 1.3, 0.20833333333333
73323, 1.3666666666667, 1.25, 0.20833333333333
73324, 1.3666666666667, 1.2, 0.20833333333333
73325, 1.3666666666667, 1.15, 0.20833333333333
73326, 1.3666666666667, 1.1, 0.20833333333333
73327, 1.3666666666667, 1.05, 0.20833333333333
73328, 1.3666666666667, 1, 0.20833333333333
73329, 1.3666666666667, 0.95, 0.20833333333333
73330, 1.3666666666667, 0.9, 0.20833333333333
73331, 1.3666666666667, 0.85, 0.20833333333333
73332, 1.3666666666667, 0.8, 0.20833333333333
73333, 1.3666666666667, 0.75, 0.20833333333333
73334, 1.3666666666667, 0.7, 0.20833333333333
73335, 1.3666666666667, 0.65, 0.20833333333333
73336, 1.3666666666667, 0.6, 0.20833333333333
73337, 1.3666666666667, 0.55, 0.20833333333333
73338, 1.3666666666667, 0.5, 0.20833333333333
73339, 1.3666666666667, 0.45, 0.20833333333333
73340, 1.3666666666667, 0.4, 0.20833333333333
73341, 1.3666666666667, 0.35, 0.20833333333333
73342, 1.3666666666667, 0.3, 0.20833333333333
73343, 1.3666666666667, 0.25, 0.20833333333333
73344, 1.3666666666667, 0.2, 0.20833333333333
73345, 1.4083333333333, 1.3, 0.20833333333333
73346, 1.4083333333333, 1.25, 0.20833333333333
73347, 1.4083333333333, 1.2, 0.20833333333333
73348, 1.4083333333333, 1.15, 0.20833333333333
73349, 1.4083333333333, 1.1, 0.20833333333333
73350, 1.4083333333333, 1.05, 0.20833333333333
73351, 1.4083333333333, 1, 0.20833333333333
73352, 1.4083333333333, 0.95, 0.20833333333333
73353, 1.4083333333333, 0.9, 0.20833333333333
73354, 1.4083333333333, 0.85, 0.20833333333333
73355, 1.4083333333333, 0.8, 0.20833333333333
73356, 1.4083333333333, 0.75, 0.20833333333333
73357, 1.4083333333333, 0.7, 0.20833333333333
73358, 1.4083333333333, 0.65, 0.20833333333333
73359, 1.4083333333333, 0.6, 0.20833333333333
73360, 1.4083333333333, 0.55, 0.20833333333333
73361, 1.4083333333333, 0.5, 0.20833333333333
73362, 1.4083333333333, 0.45, 0.20833333333333
73363, 1.4083333333333, 0.4, 0.20833333333333
73364, 1.4083333333333, 0.35, 0.20833333333333
73365, 1.4083333333333, 0.3, 0.20833333333333
73366, 1.4083333333333, 0.25, 0.20833333333333
73367, 1.4083333333333, 0.2, 0.20833333333333
73368, 1.45, 1.3, 0.20833333333333
73369, 1.45, 1.25, 0.20833333333333
73370, 1.45, 1.2, 0.20833333333333
73371, 1.45, 1.15, 0.20833333333333
73372, 1.45, 1.1, 0.20833333333333
73373, 1.45, 1.05, 0.20833333333333
73374, 1.45, 1, 0.20833333333333
73375, 1.45, 0.95, 0.20833333333333
73376, 1.45, 0.9, 0.20833333333333
73377, 1.45, 0.85, 0.20833333333333
73378, 1.45, 0.8, 0.20833333333333
73379, 1.45, 0.75, 0.20833333333333
73380, 1.45, 0.7, 0.20833333333333
73381, 1.45, 0.65, 0.20833333333333
73382, 1.45, 0.6, 0.20833333333333
73383, 1.45, 0.55, 0.20833333333333
73384, 1.45, 0.5, 0.20833333333333
73385, 1.45, 0.45, 0.20833333333333
73386, 1.45, 0.4, 0.20833333333333
73387, 1.45, 0.35, 0.20833333333333
73388, 1.45, 0.3, 0.20833333333333
73389, 1.45, 0.25, 0.20833333333333
73390, 1.45, 0.2, 0.20833333333333
73391, 1.4916666666667, 1.3, 0.20833333333333
73392, 1.4916666666667, 1.25, 0.20833333333333
73393, 1.4916666666667, 1.2, 0.20833333333333
73394, 1.4916666666667, 1.15, 0.20833333333333
73395, 1.4916666666667, 1.1, 0.20833333333333
73396, 1.4916666666667, 1.05, 0.20833333333333
73397, 1.4916666666667, 1, 0.20833333333333
73398, 1.4916666666667, 0.95, 0.20833333333333
73399, 1.4916666666667, 0.9, 0.20833333333333
73400, 1.4916666666667, 0.85, 0.20833333333333
73401, 1.4916666666667, 0.8, 0.20833333333333
73402, 1.4916666666667, 0.75, 0.20833333333333
73403, 1.4916666666667, 0.7, 0.20833333333333
73404, 1.4916666666667, 0.65, 0.20833333333333
73405, 1.4916666666667, 0.6, 0.20833333333333
73406, 1.4916666666667, 0.55, 0.20833333333333
73407, 1.4916666666667, 0.5, 0.20833333333333
73408, 1.4916666666667, 0.45, 0.20833333333333
73409, 1.4916666666667, 0.4, 0.20833333333333
73410, 1.4916666666667, 0.35, 0.20833333333333
73411, 1.4916666666667, 0.3, 0.20833333333333
73412, 1.4916666666667, 0.25, 0.20833333333333
73413, 1.4916666666667, 0.2, 0.20833333333333
73414, 1.5333333333333, 1.3, 0.20833333333333
73415, 1.5333333333333, 1.25, 0.20833333333333
73416, 1.5333333333333, 1.2, 0.20833333333333
73417, 1.5333333333333, 1.15, 0.20833333333333
73418, 1.5333333333333, 1.1, 0.20833333333333
73419, 1.5333333333333, 1.05, 0.20833333333333
73420, 1.5333333333333, 1, 0.20833333333333
73421, 1.5333333333333, 0.95, 0.20833333333333
73422, 1.5333333333333, 0.9, 0.20833333333333
73423, 1.5333333333333, 0.85, 0.20833333333333
73424, 1.5333333333333, 0.8, 0.20833333333333
73425, 1.5333333333333, 0.75, 0.20833333333333
73426, 1.5333333333333, 0.7, 0.20833333333333
73427, 1.5333333333333, 0.65, 0.20833333333333
73428, 1.5333333333333, 0.6, 0.20833333333333
73429, 1.5333333333333, 0.55, 0.20833333333333
73430, 1.5333333333333, 0.5, 0.20833333333333
73431, 1.5333333333333, 0.45, 0.20833333333333
73432, 1.5333333333333, 0.4, 0.20833333333333
73433, 1.5333333333333, 0.35, 0.20833333333333
73434, 1.5333333333333, 0.3, 0.20833333333333
73435, 1.5333333333333, 0.25, 0.20833333333333
73436, 1.5333333333333, 0.2, 0.20833333333333
73437, 1.575, 1.3, 0.20833333333333
73438, 1.575, 1.25, 0.20833333333333
73439, 1.575, 1.2, 0.20833333333333
73440, 1.575, 1.15, 0.20833333333333
73441, 1.575, 1.1, 0.20833333333333
73442, 1.575, 1.05, 0.20833333333333
73443, 1.575, 1, 0.20833333333333
73444, 1.575, 0.95, 0.20833333333333
73445, 1.575, 0.9, 0.20833333333333
73446, 1.575, 0.85, 0.20833333333333
73447, 1.575, 0.8, 0.20833333333333
73448, 1.575, 0.75, 0.20833333333333
73449, 1.575, 0.7, 0.20833333333333
73450, 1.575, 0.65, 0.20833333333333
73451, 1.575, 0.6, 0.20833333333333
73452, 1.575, 0.55, 0.20833333333333
73453, 1.575, 0.5, 0.20833333333333
73454, 1.575, 0.45, 0.20833333333333
73455, 1.575, 0.4, 0.20833333333333
73456, 1.575, 0.35, 0.20833333333333
73457, 1.575, 0.3, 0.20833333333333
73458, 1.575, 0.25, 0.20833333333333
73459, 1.575, 0.2, 0.20833333333333
73460, 1.6166666666667, 1.3, 0.20833333333333
73461, 1.6166666666667, 1.25, 0.20833333333333
73462, 1.6166666666667, 1.2, 0.20833333333333
73463, 1.6166666666667, 1.15, 0.20833333333333
73464, 1.6166666666667, 1.1, 0.20833333333333
73465, 1.6166666666667, 1.05, 0.20833333333333
73466, 1.6166666666667, 1, 0.20833333333333
73467, 1.6166666666667, 0.95, 0.20833333333333
73468, 1.6166666666667, 0.9, 0.20833333333333
73469, 1.6166666666667, 0.85, 0.20833333333333
73470, 1.6166666666667, 0.8, 0.20833333333333
73471, 1.6166666666667, 0.75, 0.20833333333333
73472, 1.6166666666667, 0.7, 0.20833333333333
73473, 1.6166666666667, 0.65, 0.20833333333333
73474, 1.6166666666667, 0.6, 0.20833333333333
73475, 1.6166666666667, 0.55, 0.20833333333333
73476, 1.6166666666667, 0.5, 0.20833333333333
73477, 1.6166666666667, 0.45, 0.20833333333333
73478, 1.6166666666667, 0.4, 0.20833333333333
73479, 1.6166666666667, 0.35, 0.20833333333333
73480, 1.6166666666667, 0.3, 0.20833333333333
73481, 1.6166666666667, 0.25, 0.20833333333333
73482, 1.6166666666667, 0.2, 0.20833333333333
73483, 1.6583333333333, 1.3, 0.20833333333333
73484, 1.6583333333333, 1.25, 0.20833333333333
73485, 1.6583333333333, 1.2, 0.20833333333333
73486, 1.6583333333333, 1.15, 0.20833333333333
73487, 1.6583333333333, 1.1, 0.20833333333333
73488, 1.6583333333333, 1.05, 0.20833333333333
73489, 1.6583333333333, 1, 0.20833333333333
73490, 1.6583333333333, 0.95, 0.20833333333333
73491, 1.6583333333333, 0.9, 0.20833333333333
73492, 1.6583333333333, 0.85, 0.20833333333333
73493, 1.6583333333333, 0.8, 0.20833333333333
73494, 1.6583333333333, 0.75, 0.20833333333333
73495, 1.6583333333333, 0.7, 0.20833333333333
73496, 1.6583333333333, 0.65, 0.20833333333333
73497, 1.6583333333333, 0.6, 0.20833333333333
73498, 1.6583333333333, 0.55, 0.20833333333333
73499, 1.6583333333333, 0.5, 0.20833333333333
73500, 1.6583333333333, 0.45, 0.20833333333333
73501, 1.6583333333333, 0.4, 0.20833333333333
73502, 1.6583333333333, 0.35, 0.20833333333333
73503, 1.6583333333333, 0.3, 0.20833333333333
73504, 1.6583333333333, 0.25, 0.20833333333333
73505, 1.6583333333333, 0.2, 0.20833333333333
73506, 1.7, 1.3, 0.20833333333333
73507, 1.7, 1.25, 0.20833333333333
73508, 1.7, 1.2, 0.20833333333333
73509, 1.7, 1.15, 0.20833333333333
73510, 1.7, 1.1, 0.20833333333333
73511, 1.7, 1.05, 0.20833333333333
73512, 1.7, 1, 0.20833333333333
73513, 1.7, 0.95, 0.20833333333333
73514, 1.7, 0.9, 0.20833333333333
73515, 1.7, 0.85, 0.20833333333333
73516, 1.7, 0.8, 0.20833333333333
73517, 1.7, 0.75, 0.20833333333333
73518, 1.7, 0.7, 0.20833333333333
73519, 1.7, 0.65, 0.20833333333333
73520, 1.7, 0.6, 0.20833333333333
73521, 1.7, 0.55, 0.20833333333333
73522, 1.7, 0.5, 0.20833333333333
73523, 1.7, 0.45, 0.20833333333333
73524, 1.7, 0.4, 0.20833333333333
73525, 1.7, 0.35, 0.20833333333333
73526, 1.7, 0.3, 0.20833333333333
73527, 1.7, 0.25, 0.20833333333333
73528, 1.7, 0.2, 0.20833333333333
73529, 1.7416666666667, 1.3, 0.20833333333333
73530, 1.7416666666667, 1.25, 0.20833333333333
73531, 1.7416666666667, 1.2, 0.20833333333333
73532, 1.7416666666667, 1.15, 0.20833333333333
73533, 1.7416666666667, 1.1, 0.20833333333333
73534, 1.7416666666667, 1.05, 0.20833333333333
73535, 1.7416666666667, 1, 0.20833333333333
73536, 1.7416666666667, 0.95, 0.20833333333333
73537, 1.7416666666667, 0.9, 0.20833333333333
73538, 1.7416666666667, 0.85, 0.20833333333333
73539, 1.7416666666667, 0.8, 0.20833333333333
73540, 1.7416666666667, 0.75, 0.20833333333333
73541, 1.7416666666667, 0.7, 0.20833333333333
73542, 1.7416666666667, 0.65, 0.20833333333333
73543, 1.7416666666667, 0.6, 0.20833333333333
73544, 1.7416666666667, 0.55, 0.20833333333333
73545, 1.7416666666667, 0.5, 0.20833333333333
73546, 1.7416666666667, 0.45, 0.20833333333333
73547, 1.7416666666667, 0.4, 0.20833333333333
73548, 1.7416666666667, 0.35, 0.20833333333333
73549, 1.7416666666667, 0.3, 0.20833333333333
73550, 1.7416666666667, 0.25, 0.20833333333333
73551, 1.7416666666667, 0.2, 0.20833333333333
73552, 1.7833333333333, 1.3, 0.20833333333333
73553, 1.7833333333333, 1.25, 0.20833333333333
73554, 1.7833333333333, 1.2, 0.20833333333333
73555, 1.7833333333333, 1.15, 0.20833333333333
73556, 1.7833333333333, 1.1, 0.20833333333333
73557, 1.7833333333333, 1.05, 0.20833333333333
73558, 1.7833333333333, 1, 0.20833333333333
73559, 1.7833333333333, 0.95, 0.20833333333333
73560, 1.7833333333333, 0.9, 0.20833333333333
73561, 1.7833333333333, 0.85, 0.20833333333333
73562, 1.7833333333333, 0.8, 0.20833333333333
73563, 1.7833333333333, 0.75, 0.20833333333333
73564, 1.7833333333333, 0.7, 0.20833333333333
73565, 1.7833333333333, 0.65, 0.20833333333333
73566, 1.7833333333333, 0.6, 0.20833333333333
73567, 1.7833333333333, 0.55, 0.20833333333333
73568, 1.7833333333333, 0.5, 0.20833333333333
73569, 1.7833333333333, 0.45, 0.20833333333333
73570, 1.7833333333333, 0.4, 0.20833333333333
73571, 1.7833333333333, 0.35, 0.20833333333333
73572, 1.7833333333333, 0.3, 0.20833333333333
73573, 1.7833333333333, 0.25, 0.20833333333333
73574, 1.7833333333333, 0.2, 0.20833333333333
73575, 1.825, 1.3, 0.20833333333333
73576, 1.825, 1.25, 0.20833333333333
73577, 1.825, 1.2, 0.20833333333333
73578, 1.825, 1.15, 0.20833333333333
73579, 1.825, 1.1, 0.20833333333333
73580, 1.825, 1.05, 0.20833333333333
73581, 1.825, 1, 0.20833333333333
73582, 1.825, 0.95, 0.20833333333333
73583, 1.825, 0.9, 0.20833333333333
73584, 1.825, 0.85, 0.20833333333333
73585, 1.825, 0.8, 0.20833333333333
73586, 1.825, 0.75, 0.20833333333333
73587, 1.825, 0.7, 0.20833333333333
73588, 1.825, 0.65, 0.20833333333333
73589, 1.825, 0.6, 0.20833333333333
73590, 1.825, 0.55, 0.20833333333333
73591, 1.825, 0.5, 0.20833333333333
73592, 1.825, 0.45, 0.20833333333333
73593, 1.825, 0.4, 0.20833333333333
73594, 1.825, 0.35, 0.20833333333333
73595, 1.825, 0.3, 0.20833333333333
73596, 1.825, 0.25, 0.20833333333333
73597, 1.825, 0.2, 0.20833333333333
73598, 1.8666666666667, 1.3, 0.20833333333333
73599, 1.8666666666667, 1.25, 0.20833333333333
73600, 1.8666666666667, 1.2, 0.20833333333333
73601, 1.8666666666667, 1.15, 0.20833333333333
73602, 1.8666666666667, 1.1, 0.20833333333333
73603, 1.8666666666667, 1.05, 0.20833333333333
73604, 1.8666666666667, 1, 0.20833333333333
73605, 1.8666666666667, 0.95, 0.20833333333333
73606, 1.8666666666667, 0.9, 0.20833333333333
73607, 1.8666666666667, 0.85, 0.20833333333333
73608, 1.8666666666667, 0.8, 0.20833333333333
73609, 1.8666666666667, 0.75, 0.20833333333333
73610, 1.8666666666667, 0.7, 0.20833333333333
73611, 1.8666666666667, 0.65, 0.20833333333333
73612, 1.8666666666667, 0.6, 0.20833333333333
73613, 1.8666666666667, 0.55, 0.20833333333333
73614, 1.8666666666667, 0.5, 0.20833333333333
73615, 1.8666666666667, 0.45, 0.20833333333333
73616, 1.8666666666667, 0.4, 0.20833333333333
73617, 1.8666666666667, 0.35, 0.20833333333333
73618, 1.8666666666667, 0.3, 0.20833333333333
73619, 1.8666666666667, 0.25, 0.20833333333333
73620, 1.8666666666667, 0.2, 0.20833333333333
73621, 1.9083333333333, 1.3, 0.20833333333333
73622, 1.9083333333333, 1.25, 0.20833333333333
73623, 1.9083333333333, 1.2, 0.20833333333333
73624, 1.9083333333333, 1.15, 0.20833333333333
73625, 1.9083333333333, 1.1, 0.20833333333333
73626, 1.9083333333333, 1.05, 0.20833333333333
73627, 1.9083333333333, 1, 0.20833333333333
73628, 1.9083333333333, 0.95, 0.20833333333333
73629, 1.9083333333333, 0.9, 0.20833333333333
73630, 1.9083333333333, 0.85, 0.20833333333333
73631, 1.9083333333333, 0.8, 0.20833333333333
73632, 1.9083333333333, 0.75, 0.20833333333333
73633, 1.9083333333333, 0.7, 0.20833333333333
73634, 1.9083333333333, 0.65, 0.20833333333333
73635, 1.9083333333333, 0.6, 0.20833333333333
73636, 1.9083333333333, 0.55, 0.20833333333333
73637, 1.9083333333333, 0.5, 0.20833333333333
73638, 1.9083333333333, 0.45, 0.20833333333333
73639, 1.9083333333333, 0.4, 0.20833333333333
73640, 1.9083333333333, 0.35, 0.20833333333333
73641, 1.9083333333333, 0.3, 0.20833333333333
73642, 1.9083333333333, 0.25, 0.20833333333333
73643, 1.9083333333333, 0.2, 0.20833333333333
73644, 1.95, 1.3, 0.20833333333333
73645, 1.95, 1.25, 0.20833333333333
73646, 1.95, 1.2, 0.20833333333333
73647, 1.95, 1.15, 0.20833333333333
73648, 1.95, 1.1, 0.20833333333333
73649, 1.95, 1.05, 0.20833333333333
73650, 1.95, 1, 0.20833333333333
73651, 1.95, 0.95, 0.20833333333333
73652, 1.95, 0.9, 0.20833333333333
73653, 1.95, 0.85, 0.20833333333333
73654, 1.95, 0.8, 0.20833333333333
73655, 1.95, 0.75, 0.20833333333333
73656, 1.95, 0.7, 0.20833333333333
73657, 1.95, 0.65, 0.20833333333333
73658, 1.95, 0.6, 0.20833333333333
73659, 1.95, 0.55, 0.20833333333333
73660, 1.95, 0.5, 0.20833333333333
73661, 1.95, 0.45, 0.20833333333333
73662, 1.95, 0.4, 0.20833333333333
73663, 1.95, 0.35, 0.20833333333333
73664, 1.95, 0.3, 0.20833333333333
73665, 1.95, 0.25, 0.20833333333333
73666, 1.95, 0.2, 0.20833333333333
73667, 1.9916666666667, 1.3, 0.20833333333333
73668, 1.9916666666667, 1.25, 0.20833333333333
73669, 1.9916666666667, 1.2, 0.20833333333333
73670, 1.9916666666667, 1.15, 0.20833333333333
73671, 1.9916666666667, 1.1, 0.20833333333333
73672, 1.9916666666667, 1.05, 0.20833333333333
73673, 1.9916666666667, 1, 0.20833333333333
73674, 1.9916666666667, 0.95, 0.20833333333333
73675, 1.9916666666667, 0.9, 0.20833333333333
73676, 1.9916666666667, 0.85, 0.20833333333333
73677, 1.9916666666667, 0.8, 0.20833333333333
73678, 1.9916666666667, 0.75, 0.20833333333333
73679, 1.9916666666667, 0.7, 0.20833333333333
73680, 1.9916666666667, 0.65, 0.20833333333333
73681, 1.9916666666667, 0.6, 0.20833333333333
73682, 1.9916666666667, 0.55, 0.20833333333333
73683, 1.9916666666667, 0.5, 0.20833333333333
73684, 1.9916666666667, 0.45, 0.20833333333333
73685, 1.9916666666667, 0.4, 0.20833333333333
73686, 1.9916666666667, 0.35, 0.20833333333333
73687, 1.9916666666667, 0.3, 0.20833333333333
73688, 1.9916666666667, 0.25, 0.20833333333333
73689, 1.9916666666667, 0.2, 0.20833333333333
73690, 2.0333333333333, 1.3, 0.20833333333333
73691, 2.0333333333333, 1.25, 0.20833333333333
73692, 2.0333333333333, 1.2, 0.20833333333333
73693, 2.0333333333333, 1.15, 0.20833333333333
73694, 2.0333333333333, 1.1, 0.20833333333333
73695, 2.0333333333333, 1.05, 0.20833333333333
73696, 2.0333333333333, 1, 0.20833333333333
73697, 2.0333333333333, 0.95, 0.20833333333333
73698, 2.0333333333333, 0.9, 0.20833333333333
73699, 2.0333333333333, 0.85, 0.20833333333333
73700, 2.0333333333333, 0.8, 0.20833333333333
73701, 2.0333333333333, 0.75, 0.20833333333333
73702, 2.0333333333333, 0.7, 0.20833333333333
73703, 2.0333333333333, 0.65, 0.20833333333333
73704, 2.0333333333333, 0.6, 0.20833333333333
73705, 2.0333333333333, 0.55, 0.20833333333333
73706, 2.0333333333333, 0.5, 0.20833333333333
73707, 2.0333333333333, 0.45, 0.20833333333333
73708, 2.0333333333333, 0.4, 0.20833333333333
73709, 2.0333333333333, 0.35, 0.20833333333333
73710, 2.0333333333333, 0.3, 0.20833333333333
73711, 2.0333333333333, 0.25, 0.20833333333333
73712, 2.0333333333333, 0.2, 0.20833333333333
73713, 2.075, 1.3, 0.20833333333333
73714, 2.075, 1.25, 0.20833333333333
73715, 2.075, 1.2, 0.20833333333333
73716, 2.075, 1.15, 0.20833333333333
73717, 2.075, 1.1, 0.20833333333333
73718, 2.075, 1.05, 0.20833333333333
73719, 2.075, 1, 0.20833333333333
73720, 2.075, 0.95, 0.20833333333333
73721, 2.075, 0.9, 0.20833333333333
73722, 2.075, 0.85, 0.20833333333333
73723, 2.075, 0.8, 0.20833333333333
73724, 2.075, 0.75, 0.20833333333333
73725, 2.075, 0.7, 0.20833333333333
73726, 2.075, 0.65, 0.20833333333333
73727, 2.075, 0.6, 0.20833333333333
73728, 2.075, 0.55, 0.20833333333333
73729, 2.075, 0.5, 0.20833333333333
73730, 2.075, 0.45, 0.20833333333333
73731, 2.075, 0.4, 0.20833333333333
73732, 2.075, 0.35, 0.20833333333333
73733, 2.075, 0.3, 0.20833333333333
73734, 2.075, 0.25, 0.20833333333333
73735, 2.075, 0.2, 0.20833333333333
73736, 2.1166666666667, 1.3, 0.20833333333333
73737, 2.1166666666667, 1.25, 0.20833333333333
73738, 2.1166666666667, 1.2, 0.20833333333333
73739, 2.1166666666667, 1.15, 0.20833333333333
73740, 2.1166666666667, 1.1, 0.20833333333333
73741, 2.1166666666667, 1.05, 0.20833333333333
73742, 2.1166666666667, 1, 0.20833333333333
73743, 2.1166666666667, 0.95, 0.20833333333333
73744, 2.1166666666667, 0.9, 0.20833333333333
73745, 2.1166666666667, 0.85, 0.20833333333333
73746, 2.1166666666667, 0.8, 0.20833333333333
73747, 2.1166666666667, 0.75, 0.20833333333333
73748, 2.1166666666667, 0.7, 0.20833333333333
73749, 2.1166666666667, 0.65, 0.20833333333333
73750, 2.1166666666667, 0.6, 0.20833333333333
73751, 2.1166666666667, 0.55, 0.20833333333333
73752, 2.1166666666667, 0.5, 0.20833333333333
73753, 2.1166666666667, 0.45, 0.20833333333333
73754, 2.1166666666667, 0.4, 0.20833333333333
73755, 2.1166666666667, 0.35, 0.20833333333333
73756, 2.1166666666667, 0.3, 0.20833333333333
73757, 2.1166666666667, 0.25, 0.20833333333333
73758, 2.1166666666667, 0.2, 0.20833333333333
73759, 2.1583333333333, 1.3, 0.20833333333333
73760, 2.1583333333333, 1.25, 0.20833333333333
73761, 2.1583333333333, 1.2, 0.20833333333333
73762, 2.1583333333333, 1.15, 0.20833333333333
73763, 2.1583333333333, 1.1, 0.20833333333333
73764, 2.1583333333333, 1.05, 0.20833333333333
73765, 2.1583333333333, 1, 0.20833333333333
73766, 2.1583333333333, 0.95, 0.20833333333333
73767, 2.1583333333333, 0.9, 0.20833333333333
73768, 2.1583333333333, 0.85, 0.20833333333333
73769, 2.1583333333333, 0.8, 0.20833333333333
73770, 2.1583333333333, 0.75, 0.20833333333333
73771, 2.1583333333333, 0.7, 0.20833333333333
73772, 2.1583333333333, 0.65, 0.20833333333333
73773, 2.1583333333333, 0.6, 0.20833333333333
73774, 2.1583333333333, 0.55, 0.20833333333333
73775, 2.1583333333333, 0.5, 0.20833333333333
73776, 2.1583333333333, 0.45, 0.20833333333333
73777, 2.1583333333333, 0.4, 0.20833333333333
73778, 2.1583333333333, 0.35, 0.20833333333333
73779, 2.1583333333333, 0.3, 0.20833333333333
73780, 2.1583333333333, 0.25, 0.20833333333333
73781, 2.1583333333333, 0.2, 0.20833333333333
73782, 1.2416666666667, 1.3, 0.25
73783, 1.2416666666667, 1.25, 0.25
73784, 1.2416666666667, 1.2, 0.25
73785, 1.2416666666667, 1.15, 0.25
73786, 1.2416666666667, 1.1, 0.25
73787, 1.2416666666667, 1.05, 0.25
73788, 1.2416666666667, 1, 0.25
73789, 1.2416666666667, 0.95, 0.25
73790, 1.2416666666667, 0.9, 0.25
73791, 1.2416666666667, 0.85, 0.25
73792, 1.2416666666667, 0.8, 0.25
73793, 1.2416666666667, 0.75, 0.25
73794, 1.2416666666667, 0.7, 0.25
73795, 1.2416666666667, 0.65, 0.25
73796, 1.2416666666667, 0.6, 0.25
73797, 1.2416666666667, 0.55, 0.25
73798, 1.2416666666667, 0.5, 0.25
73799, 1.2416666666667, 0.45, 0.25
73800, 1.2416666666667, 0.4, 0.25
73801, 1.2416666666667, 0.35, 0.25
73802, 1.2416666666667, 0.3, 0.25
73803, 1.2416666666667, 0.25, 0.25
73804, 1.2416666666667, 0.2, 0.25
73805, 1.2833333333333, 1.3, 0.25
73806, 1.2833333333333, 1.25, 0.25
73807, 1.2833333333333, 1.2, 0.25
73808, 1.2833333333333, 1.15, 0.25
73809, 1.2833333333333, 1.1, 0.25
73810, 1.2833333333333, 1.05, 0.25
73811, 1.2833333333333, 1, 0.25
73812, 1.2833333333333, 0.95, 0.25
73813, 1.2833333333333, 0.9, 0.25
73814, 1.2833333333333, 0.85, 0.25
73815, 1.2833333333333, 0.8, 0.25
73816, 1.2833333333333, 0.75, 0.25
73817, 1.2833333333333, 0.7, 0.25
73818, 1.2833333333333, 0.65, 0.25
73819, 1.2833333333333, 0.6, 0.25
73820, 1.2833333333333, 0.55, 0.25
73821, 1.2833333333333, 0.5, 0.25
73822, 1.2833333333333, 0.45, 0.25
73823, 1.2833333333333, 0.4, 0.25
73824, 1.2833333333333, 0.35, 0.25
73825, 1.2833333333333, 0.3, 0.25
73826, 1.2833333333333, 0.25, 0.25
73827, 1.2833333333333, 0.2, 0.25
73828, 1.325, 1.3, 0.25
73829, 1.325, 1.25, 0.25
73830, 1.325, 1.2, 0.25
73831, 1.325, 1.15, 0.25
73832, 1.325, 1.1, 0.25
73833, 1.325, 1.05, 0.25
73834, 1.325, 1, 0.25
73835, 1.325, 0.95, 0.25
73836, 1.325, 0.9, 0.25
73837, 1.325, 0.85, 0.25
73838, 1.325, 0.8, 0.25
73839, 1.325, 0.75, 0.25
73840, 1.325, 0.7, 0.25
73841, 1.325, 0.65, 0.25
73842, 1.325, 0.6, 0.25
73843, 1.325, 0.55, 0.25
73844, 1.325, 0.5, 0.25
73845, 1.325, 0.45, 0.25
73846, 1.325, 0.4, 0.25
73847, 1.325, 0.35, 0.25
73848, 1.325, 0.3, 0.25
73849, 1.325, 0.25, 0.25
73850, 1.325, 0.2, 0.25
73851, 1.3666666666667, 1.3, 0.25
73852, 1.3666666666667, 1.25, 0.25
73853, 1.3666666666667, 1.2, 0.25
73854, 1.3666666666667, 1.15, 0.25
73855, 1.3666666666667, 1.1, 0.25
73856, 1.3666666666667, 1.05, 0.25
73857, 1.3666666666667, 1, 0.25
73858, 1.3666666666667, 0.95, 0.25
73859, 1.3666666666667, 0.9, 0.25
73860, 1.3666666666667, 0.85, 0.25
73861, 1.3666666666667, 0.8, 0.25
73862, 1.3666666666667, 0.75, 0.25
73863, 1.3666666666667, 0.7, 0.25
73864, 1.3666666666667, 0.65, 0.25
73865, 1.3666666666667, 0.6, 0.25
73866, 1.3666666666667, 0.55, 0.25
73867, 1.3666666666667, 0.5, 0.25
73868, 1.3666666666667, 0.45, 0.25
73869, 1.3666666666667, 0.4, 0.25
73870, 1.3666666666667, 0.35, 0.25
73871, 1.3666666666667, 0.3, 0.25
73872, 1.3666666666667, 0.25, 0.25
73873, 1.3666666666667, 0.2, 0.25
73874, 1.4083333333333, 1.3, 0.25
73875, 1.4083333333333, 1.25, 0.25
73876, 1.4083333333333, 1.2, 0.25
73877, 1.4083333333333, 1.15, 0.25
73878, 1.4083333333333, 1.1, 0.25
73879, 1.4083333333333, 1.05, 0.25
73880, 1.4083333333333, 1, 0.25
73881, 1.4083333333333, 0.95, 0.25
73882, 1.4083333333333, 0.9, 0.25
73883, 1.4083333333333, 0.85, 0.25
73884, 1.4083333333333, 0.8, 0.25
73885, 1.4083333333333, 0.75, 0.25
73886, 1.4083333333333, 0.7, 0.25
73887, 1.4083333333333, 0.65, 0.25
73888, 1.4083333333333, 0.6, 0.25
73889, 1.4083333333333, 0.55, 0.25
73890, 1.4083333333333, 0.5, 0.25
73891, 1.4083333333333, 0.45, 0.25
73892, 1.4083333333333, 0.4, 0.25
73893, 1.4083333333333, 0.35, 0.25
73894, 1.4083333333333, 0.3, 0.25
73895, 1.4083333333333, 0.25, 0.25
73896, 1.4083333333333, 0.2, 0.25
73897, 1.45, 1.3, 0.25
73898, 1.45, 1.25, 0.25
73899, 1.45, 1.2, 0.25
73900, 1.45, 1.15, 0.25
73901, 1.45, 1.1, 0.25
73902, 1.45, 1.05, 0.25
73903, 1.45, 1, 0.25
73904, 1.45, 0.95, 0.25
73905, 1.45, 0.9, 0.25
73906, 1.45, 0.85, 0.25
73907, 1.45, 0.8, 0.25
73908, 1.45, 0.75, 0.25
73909, 1.45, 0.7, 0.25
73910, 1.45, 0.65, 0.25
73911, 1.45, 0.6, 0.25
73912, 1.45, 0.55, 0.25
73913, 1.45, 0.5, 0.25
73914, 1.45, 0.45, 0.25
73915, 1.45, 0.4, 0.25
73916, 1.45, 0.35, 0.25
73917, 1.45, 0.3, 0.25
73918, 1.45, 0.25, 0.25
73919, 1.45, 0.2, 0.25
73920, 1.4916666666667, 1.3, 0.25
73921, 1.4916666666667, 1.25, 0.25
73922, 1.4916666666667, 1.2, 0.25
73923, 1.4916666666667, 1.15, 0.25
73924, 1.4916666666667, 1.1, 0.25
73925, 1.4916666666667, 1.05, 0.25
73926, 1.4916666666667, 1, 0.25
73927, 1.4916666666667, 0.95, 0.25
73928, 1.4916666666667, 0.9, 0.25
73929, 1.4916666666667, 0.85, 0.25
73930, 1.4916666666667, 0.8, 0.25
73931, 1.4916666666667, 0.75, 0.25
73932, 1.4916666666667, 0.7, 0.25
73933, 1.4916666666667, 0.65, 0.25
73934, 1.4916666666667, 0.6, 0.25
73935, 1.4916666666667, 0.55, 0.25
73936, 1.4916666666667, 0.5, 0.25
73937, 1.4916666666667, 0.45, 0.25
73938, 1.4916666666667, 0.4, 0.25
73939, 1.4916666666667, 0.35, 0.25
73940, 1.4916666666667, 0.3, 0.25
73941, 1.4916666666667, 0.25, 0.25
73942, 1.4916666666667, 0.2, 0.25
73943, 1.5333333333333, 1.3, 0.25
73944, 1.5333333333333, 1.25, 0.25
73945, 1.5333333333333, 1.2, 0.25
73946, 1.5333333333333, 1.15, 0.25
73947, 1.5333333333333, 1.1, 0.25
73948, 1.5333333333333, 1.05, 0.25
73949, 1.5333333333333, 1, 0.25
73950, 1.5333333333333, 0.95, 0.25
73951, 1.5333333333333, 0.9, 0.25
73952, 1.5333333333333, 0.85, 0.25
73953, 1.5333333333333, 0.8, 0.25
73954, 1.5333333333333, 0.75, 0.25
73955, 1.5333333333333, 0.7, 0.25
73956, 1.5333333333333, 0.65, 0.25
73957, 1.5333333333333, 0.6, 0.25
73958, 1.5333333333333, 0.55, 0.25
73959, 1.5333333333333, 0.5, 0.25
73960, 1.5333333333333, 0.45, 0.25
73961, 1.5333333333333, 0.4, 0.25
73962, 1.5333333333333, 0.35, 0.25
73963, 1.5333333333333, 0.3, 0.25
73964, 1.5333333333333, 0.25, 0.25
73965, 1.5333333333333, 0.2, 0.25
73966, 1.575, 1.3, 0.25
73967, 1.575, 1.25, 0.25
73968, 1.575, 1.2, 0.25
73969, 1.575, 1.15, 0.25
73970, 1.575, 1.1, 0.25
73971, 1.575, 1.05, 0.25
73972, 1.575, 1, 0.25
73973, 1.575, 0.95, 0.25
73974, 1.575, 0.9, 0.25
73975, 1.575, 0.85, 0.25
73976, 1.575, 0.8, 0.25
73977, 1.575, 0.75, 0.25
73978, 1.575, 0.7, 0.25
73979, 1.575, 0.65, 0.25
73980, 1.575, 0.6, 0.25
73981, 1.575, 0.55, 0.25
73982, 1.575, 0.5, 0.25
73983, 1.575, 0.45, 0.25
73984, 1.575, 0.4, 0.25
73985, 1.575, 0.35, 0.25
73986, 1.575, 0.3, 0.25
73987, 1.575, 0.25, 0.25
73988, 1.575, 0.2, 0.25
73989, 1.6166666666667, 1.3, 0.25
73990, 1.6166666666667, 1.25, 0.25
73991, 1.6166666666667, 1.2, 0.25
73992, 1.6166666666667, 1.15, 0.25
73993, 1.6166666666667, 1.1, 0.25
73994, 1.6166666666667, 1.05, 0.25
73995, 1.6166666666667, 1, 0.25
73996, 1.6166666666667, 0.95, 0.25
73997, 1.6166666666667, 0.9, 0.25
73998, 1.6166666666667, 0.85, 0.25
73999, 1.6166666666667, 0.8, 0.25
74000, 1.6166666666667, 0.75, 0.25
74001, 1.6166666666667, 0.7, 0.25
74002, 1.6166666666667, 0.65, 0.25
74003, 1.6166666666667, 0.6, 0.25
74004, 1.6166666666667, 0.55, 0.25
74005, 1.6166666666667, 0.5, 0.25
74006, 1.6166666666667, 0.45, 0.25
74007, 1.6166666666667, 0.4, 0.25
74008, 1.6166666666667, 0.35, 0.25
74009, 1.6166666666667, 0.3, 0.25
74010, 1.6166666666667, 0.25, 0.25
74011, 1.6166666666667, 0.2, 0.25
74012, 1.6583333333333, 1.3, 0.25
74013, 1.6583333333333, 1.25, 0.25
74014, 1.6583333333333, 1.2, 0.25
74015, 1.6583333333333, 1.15, 0.25
74016, 1.6583333333333, 1.1, 0.25
74017, 1.6583333333333, 1.05, 0.25
74018, 1.6583333333333, 1, 0.25
74019, 1.6583333333333, 0.95, 0.25
74020, 1.6583333333333, 0.9, 0.25
74021, 1.6583333333333, 0.85, 0.25
74022, 1.6583333333333, 0.8, 0.25
74023, 1.6583333333333, 0.75, 0.25
74024, 1.6583333333333, 0.7, 0.25
74025, 1.6583333333333, 0.65, 0.25
74026, 1.6583333333333, 0.6, 0.25
74027, 1.6583333333333, 0.55, 0.25
74028, 1.6583333333333, 0.5, 0.25
74029, 1.6583333333333, 0.45, 0.25
74030, 1.6583333333333, 0.4, 0.25
74031, 1.6583333333333, 0.35, 0.25
74032, 1.6583333333333, 0.3, 0.25
74033, 1.6583333333333, 0.25, 0.25
74034, 1.6583333333333, 0.2, 0.25
74035, 1.7, 1.3, 0.25
74036, 1.7, 1.25, 0.25
74037, 1.7, 1.2, 0.25
74038, 1.7, 1.15, 0.25
74039, 1.7, 1.1, 0.25
74040, 1.7, 1.05, 0.25
74041, 1.7, 1, 0.25
74042, 1.7, 0.95, 0.25
74043, 1.7, 0.9, 0.25
74044, 1.7, 0.85, 0.25
74045, 1.7, 0.8, 0.25
74046, 1.7, 0.75, 0.25
74047, 1.7, 0.7, 0.25
74048, 1.7, 0.65, 0.25
74049, 1.7, 0.6, 0.25
74050, 1.7, 0.55, 0.25
74051, 1.7, 0.5, 0.25
74052, 1.7, 0.45, 0.25
74053, 1.7, 0.4, 0.25
74054, 1.7, 0.35, 0.25
74055, 1.7, 0.3, 0.25
74056, 1.7, 0.25, 0.25
74057, 1.7, 0.2, 0.25
74058, 1.7416666666667, 1.3, 0.25
74059, 1.7416666666667, 1.25, 0.25
74060, 1.7416666666667, 1.2, 0.25
74061, 1.7416666666667, 1.15, 0.25
74062, 1.7416666666667, 1.1, 0.25
74063, 1.7416666666667, 1.05, 0.25
74064, 1.7416666666667, 1, 0.25
74065, 1.7416666666667, 0.95, 0.25
74066, 1.7416666666667, 0.9, 0.25
74067, 1.7416666666667, 0.85, 0.25
74068, 1.7416666666667, 0.8, 0.25
74069, 1.7416666666667, 0.75, 0.25
74070, 1.7416666666667, 0.7, 0.25
74071, 1.7416666666667, 0.65, 0.25
74072, 1.7416666666667, 0.6, 0.25
74073, 1.7416666666667, 0.55, 0.25
74074, 1.7416666666667, 0.5, 0.25
74075, 1.7416666666667, 0.45, 0.25
74076, 1.7416666666667, 0.4, 0.25
74077, 1.7416666666667, 0.35, 0.25
74078, 1.7416666666667, 0.3, 0.25
74079, 1.7416666666667, 0.25, 0.25
74080, 1.7416666666667, 0.2, 0.25
74081, 1.7833333333333, 1.3, 0.25
74082, 1.7833333333333, 1.25, 0.25
74083, 1.7833333333333, 1.2, 0.25
74084, 1.7833333333333, 1.15, 0.25
74085, 1.7833333333333, 1.1, 0.25
74086, 1.7833333333333, 1.05, 0.25
74087, 1.7833333333333, 1, 0.25
74088, 1.7833333333333, 0.95, 0.25
74089, 1.7833333333333, 0.9, 0.25
74090, 1.7833333333333, 0.85, 0.25
74091, 1.7833333333333, 0.8, 0.25
74092, 1.7833333333333, 0.75, 0.25
74093, 1.7833333333333, 0.7, 0.25
74094, 1.7833333333333, 0.65, 0.25
74095, 1.7833333333333, 0.6, 0.25
74096, 1.7833333333333, 0.55, 0.25
74097, 1.7833333333333, 0.5, 0.25
74098, 1.7833333333333, 0.45, 0.25
74099, 1.7833333333333, 0.4, 0.25
74100, 1.7833333333333, 0.35, 0.25
74101, 1.7833333333333, 0.3, 0.25
74102, 1.7833333333333, 0.25, 0.25
74103, 1.7833333333333, 0.2, 0.25
74104, 1.825, 1.3, 0.25
74105, 1.825, 1.25, 0.25
74106, 1.825, 1.2, 0.25
74107, 1.825, 1.15, 0.25
74108, 1.825, 1.1, 0.25
74109, 1.825, 1.05, 0.25
74110, 1.825, 1, 0.25
74111, 1.825, 0.95, 0.25
74112, 1.825, 0.9, 0.25
74113, 1.825, 0.85, 0.25
74114, 1.825, 0.8, 0.25
74115, 1.825, 0.75, 0.25
74116, 1.825, 0.7, 0.25
74117, 1.825, 0.65, 0.25
74118, 1.825, 0.6, 0.25
74119, 1.825, 0.55, 0.25
74120, 1.825, 0.5, 0.25
74121, 1.825, 0.45, 0.25
74122, 1.825, 0.4, 0.25
74123, 1.825, 0.35, 0.25
74124, 1.825, 0.3, 0.25
74125, 1.825, 0.25, 0.25
74126, 1.825, 0.2, 0.25
74127, 1.8666666666667, 1.3, 0.25
74128, 1.8666666666667, 1.25, 0.25
74129, 1.8666666666667, 1.2, 0.25
74130, 1.8666666666667, 1.15, 0.25
74131, 1.8666666666667, 1.1, 0.25
74132, 1.8666666666667, 1.05, 0.25
74133, 1.8666666666667, 1, 0.25
74134, 1.8666666666667, 0.95, 0.25
74135, 1.8666666666667, 0.9, 0.25
74136, 1.8666666666667, 0.85, 0.25
74137, 1.8666666666667, 0.8, 0.25
74138, 1.8666666666667, 0.75, 0.25
74139, 1.8666666666667, 0.7, 0.25
74140, 1.8666666666667, 0.65, 0.25
74141, 1.8666666666667, 0.6, 0.25
74142, 1.8666666666667, 0.55, 0.25
74143, 1.8666666666667, 0.5, 0.25
74144, 1.8666666666667, 0.45, 0.25
74145, 1.8666666666667, 0.4, 0.25
74146, 1.8666666666667, 0.35, 0.25
74147, 1.8666666666667, 0.3, 0.25
74148, 1.8666666666667, 0.25, 0.25
74149, 1.8666666666667, 0.2, 0.25
74150, 1.9083333333333, 1.3, 0.25
74151, 1.9083333333333, 1.25, 0.25
74152, 1.9083333333333, 1.2, 0.25
74153, 1.9083333333333, 1.15, 0.25
74154, 1.9083333333333, 1.1, 0.25
74155, 1.9083333333333, 1.05, 0.25
74156, 1.9083333333333, 1, 0.25
74157, 1.9083333333333, 0.95, 0.25
74158, 1.9083333333333, 0.9, 0.25
74159, 1.9083333333333, 0.85, 0.25
74160, 1.9083333333333, 0.8, 0.25
74161, 1.9083333333333, 0.75, 0.25
74162, 1.9083333333333, 0.7, 0.25
74163, 1.9083333333333, 0.65, 0.25
74164, 1.9083333333333, 0.6, 0.25
74165, 1.9083333333333, 0.55, 0.25
74166, 1.9083333333333, 0.5, 0.25
74167, 1.9083333333333, 0.45, 0.25
74168, 1.9083333333333, 0.4, 0.25
74169, 1.9083333333333, 0.35, 0.25
74170, 1.9083333333333, 0.3, 0.25
74171, 1.9083333333333, 0.25, 0.25
74172, 1.9083333333333, 0.2, 0.25
74173, 1.95, 1.3, 0.25
74174, 1.95, 1.25, 0.25
74175, 1.95, 1.2, 0.25
74176, 1.95, 1.15, 0.25
74177, 1.95, 1.1, 0.25
74178, 1.95, 1.05, 0.25
74179, 1.95, 1, 0.25
74180, 1.95, 0.95, 0.25
74181, 1.95, 0.9, 0.25
74182, 1.95, 0.85, 0.25
74183, 1.95, 0.8, 0.25
74184, 1.95, 0.75, 0.25
74185, 1.95, 0.7, 0.25
74186, 1.95, 0.65, 0.25
74187, 1.95, 0.6, 0.25
74188, 1.95, 0.55, 0.25
74189, 1.95, 0.5, 0.25
74190, 1.95, 0.45, 0.25
74191, 1.95, 0.4, 0.25
74192, 1.95, 0.35, 0.25
74193, 1.95, 0.3, 0.25
74194, 1.95, 0.25, 0.25
74195, 1.95, 0.2, 0.25
74196, 1.9916666666667, 1.3, 0.25
74197, 1.9916666666667, 1.25, 0.25
74198, 1.9916666666667, 1.2, 0.25
74199, 1.9916666666667, 1.15, 0.25
74200, 1.9916666666667, 1.1, 0.25
74201, 1.9916666666667, 1.05, 0.25
74202, 1.9916666666667, 1, 0.25
74203, 1.9916666666667, 0.95, 0.25
74204, 1.9916666666667, 0.9, 0.25
74205, 1.9916666666667, 0.85, 0.25
74206, 1.9916666666667, 0.8, 0.25
74207, 1.9916666666667, 0.75, 0.25
74208, 1.9916666666667, 0.7, 0.25
74209, 1.9916666666667, 0.65, 0.25
74210, 1.9916666666667, 0.6, 0.25
74211, 1.9916666666667, 0.55, 0.25
74212, 1.9916666666667, 0.5, 0.25
74213, 1.9916666666667, 0.45, 0.25
74214, 1.9916666666667, 0.4, 0.25
74215, 1.9916666666667, 0.35, 0.25
74216, 1.9916666666667, 0.3, 0.25
74217, 1.9916666666667, 0.25, 0.25
74218, 1.9916666666667, 0.2, 0.25
74219, 2.0333333333333, 1.3, 0.25
74220, 2.0333333333333, 1.25, 0.25
74221, 2.0333333333333, 1.2, 0.25
74222, 2.0333333333333, 1.15, 0.25
74223, 2.0333333333333, 1.1, 0.25
74224, 2.0333333333333, 1.05, 0.25
74225, 2.0333333333333, 1, 0.25
74226, 2.0333333333333, 0.95, 0.25
74227, 2.0333333333333, 0.9, 0.25
74228, 2.0333333333333, 0.85, 0.25
74229, 2.0333333333333, 0.8, 0.25
74230, 2.0333333333333, 0.75, 0.25
74231, 2.0333333333333, 0.7, 0.25
74232, 2.0333333333333, 0.65, 0.25
74233, 2.0333333333333, 0.6, 0.25
74234, 2.0333333333333, 0.55, 0.25
74235, 2.0333333333333, 0.5, 0.25
74236, 2.0333333333333, 0.45, 0.25
74237, 2.0333333333333, 0.4, 0.25
74238, 2.0333333333333, 0.35, 0.25
74239, 2.0333333333333, 0.3, 0.25
74240, 2.0333333333333, 0.25, 0.25
74241, 2.0333333333333, 0.2, 0.25
74242, 2.075, 1.3, 0.25
74243, 2.075, 1.25, 0.25
74244, 2.075, 1.2, 0.25
74245, 2.075, 1.15, 0.25
74246, 2.075, 1.1, 0.25
74247, 2.075, 1.05, 0.25
74248, 2.075, 1, 0.25
74249, 2.075, 0.95, 0.25
74250, 2.075, 0.9, 0.25
74251, 2.075, 0.85, 0.25
74252, 2.075, 0.8, 0.25
74253, 2.075, 0.75, 0.25
74254, 2.075, 0.7, 0.25
74255, 2.075, 0.65, 0.25
74256, 2.075, 0.6, 0.25
74257, 2.075, 0.55, 0.25
74258, 2.075, 0.5, 0.25
74259, 2.075, 0.45, 0.25
74260, 2.075, 0.4, 0.25
74261, 2.075, 0.35, 0.25
74262, 2.075, 0.3, 0.25
74263, 2.075, 0.25, 0.25
74264, 2.075, 0.2, 0.25
74265, 2.1166666666667, 1.3, 0.25
74266, 2.1166666666667, 1.25, 0.25
74267, 2.1166666666667, 1.2, 0.25
74268, 2.1166666666667, 1.15, 0.25
74269, 2.1166666666667, 1.1, 0.25
74270, 2.1166666666667, 1.05, 0.25
74271, 2.1166666666667, 1, 0.25
74272, 2.1166666666667, 0.95, 0.25
74273, 2.1166666666667, 0.9, 0.25
74274, 2.1166666666667, 0.85, 0.25
74275, 2.1166666666667, 0.8, 0.25
74276, 2.1166666666667, 0.75, 0.25
74277, 2.1166666666667, 0.7, 0.25
74278, 2.1166666666667, 0.65, 0.25
74279, 2.1166666666667, 0.6, 0.25
74280, 2.1166666666667, 0.55, 0.25
74281, 2.1166666666667, 0.5, 0.25
74282, 2.1166666666667, 0.45, 0.25
74283, 2.1166666666667, 0.4, 0.25
74284, 2.1166666666667, 0.35, 0.25
74285, 2.1166666666667, 0.3, 0.25
74286, 2.1166666666667, 0.25, 0.25
74287, 2.1166666666667, 0.2, 0.25
74288, 2.1583333333333, 1.3, 0.25
74289, 2.1583333333333, 1.25, 0.25
74290, 2.1583333333333, 1.2, 0.25
74291, 2.1583333333333, 1.15, 0.25
74292, 2.1583333333333, 1.1, 0.25
74293, 2.1583333333333, 1.05, 0.25
74294, 2.1583333333333, 1, 0.25
74295, 2.1583333333333, 0.95, 0.25
74296, 2.1583333333333, 0.9, 0.25
74297, 2.1583333333333, 0.85, 0.25
74298, 2.1583333333333, 0.8, 0.25
74299, 2.1583333333333, 0.75, 0.25
74300, 2.1583333333333, 0.7, 0.25
74301, 2.1583333333333, 0.65, 0.25
74302, 2.1583333333333, 0.6, 0.25
74303, 2.1583333333333, 0.55, 0.25
74304, 2.1583333333333, 0.5, 0.25
74305, 2.1583333333333, 0.45, 0.25
74306, 2.1583333333333, 0.4, 0.25
74307, 2.1583333333333, 0.35, 0.25
74308, 2.1583333333333, 0.3, 0.25
74309, 2.1583333333333, 0.25, 0.25
74310, 2.1583333333333, 0.2, 0.25
74311, 1.2416666666667, 1.3, 0.29166666666667
74312, 1.2416666666667, 1.25, 0.29166666666667
74313, 1.2416666666667, 1.2, 0.29166666666667
74314, 1.2416666666667, 1.15, 0.29166666666667
74315, 1.2416666666667, 1.1, 0.29166666666667
74316, 1.2416666666667, 1.05, 0.29166666666667
74317, 1.2416666666667, 1, 0.29166666666667
74318, 1.2416666666667, 0.95, 0.29166666666667
74319, 1.2416666666667, 0.9, 0.29166666666667
74320, 1.2416666666667, 0.85, 0.29166666666667
74321, 1.2416666666667, 0.8, 0.29166666666667
74322, 1.2416666666667, 0.75, 0.29166666666667
74323, 1.2416666666667, 0.7, 0.29166666666667
74324, 1.2416666666667, 0.65, 0.29166666666667
74325, 1.2416666666667, 0.6, 0.29166666666667
74326, 1.2416666666667, 0.55, 0.29166666666667
74327, 1.2416666666667, 0.5, 0.29166666666667
74328, 1.2416666666667, 0.45, 0.29166666666667
74329, 1.2416666666667, 0.4, 0.29166666666667
74330, 1.2416666666667, 0.35, 0.29166666666667
74331, 1.2416666666667, 0.3, 0.29166666666667
74332, 1.2416666666667, 0.25, 0.29166666666667
74333, 1.2416666666667, 0.2, 0.29166666666667
74334, 1.2833333333333, 1.3, 0.29166666666667
74335, 1.2833333333333, 1.25, 0.29166666666667
74336, 1.2833333333333, 1.2, 0.29166666666667
74337, 1.2833333333333, 1.15, 0.29166666666667
74338, 1.2833333333333, 1.1, 0.29166666666667
74339, 1.2833333333333, 1.05, 0.29166666666667
74340, 1.2833333333333, 1, 0.29166666666667
74341, 1.2833333333333, 0.95, 0.29166666666667
74342, 1.2833333333333, 0.9, 0.29166666666667
74343, 1.2833333333333, 0.85, 0.29166666666667
74344, 1.2833333333333, 0.8, 0.29166666666667
74345, 1.2833333333333, 0.75, 0.29166666666667
74346, 1.2833333333333, 0.7, 0.29166666666667
74347, 1.2833333333333, 0.65, 0.29166666666667
74348, 1.2833333333333, 0.6, 0.29166666666667
74349, 1.2833333333333, 0.55, 0.29166666666667
74350, 1.2833333333333, 0.5, 0.29166666666667
74351, 1.2833333333333, 0.45, 0.29166666666667
74352, 1.2833333333333, 0.4, 0.29166666666667
74353, 1.2833333333333, 0.35, 0.29166666666667
74354, 1.2833333333333, 0.3, 0.29166666666667
74355, 1.2833333333333, 0.25, 0.29166666666667
74356, 1.2833333333333, 0.2, 0.29166666666667
74357, 1.325, 1.3, 0.29166666666667
74358, 1.325, 1.25, 0.29166666666667
74359, 1.325, 1.2, 0.29166666666667
74360, 1.325, 1.15, 0.29166666666667
74361, 1.325, 1.1, 0.29166666666667
74362, 1.325, 1.05, 0.29166666666667
74363, 1.325, 1, 0.29166666666667
74364, 1.325, 0.95, 0.29166666666667
74365, 1.325, 0.9, 0.29166666666667
74366, 1.325, 0.85, 0.29166666666667
74367, 1.325, 0.8, 0.29166666666667
74368, 1.325, 0.75, 0.29166666666667
74369, 1.325, 0.7, 0.29166666666667
74370, 1.325, 0.65, 0.29166666666667
74371, 1.325, 0.6, 0.29166666666667
74372, 1.325, 0.55, 0.29166666666667
74373, 1.325, 0.5, 0.29166666666667
74374, 1.325, 0.45, 0.29166666666667
74375, 1.325, 0.4, 0.29166666666667
74376, 1.325, 0.35, 0.29166666666667
74377, 1.325, 0.3, 0.29166666666667
74378, 1.325, 0.25, 0.29166666666667
74379, 1.325, 0.2, 0.29166666666667
74380, 1.3666666666667, 1.3, 0.29166666666667
74381, 1.3666666666667, 1.25, 0.29166666666667
74382, 1.3666666666667, 1.2, 0.29166666666667
74383, 1.3666666666667, 1.15, 0.29166666666667
74384, 1.3666666666667, 1.1, 0.29166666666667
74385, 1.3666666666667, 1.05, 0.29166666666667
74386, 1.3666666666667, 1, 0.29166666666667
74387, 1.3666666666667, 0.95, 0.29166666666667
74388, 1.3666666666667, 0.9, 0.29166666666667
74389, 1.3666666666667, 0.85, 0.29166666666667
74390, 1.3666666666667, 0.8, 0.29166666666667
74391, 1.3666666666667, 0.75, 0.29166666666667
74392, 1.3666666666667, 0.7, 0.29166666666667
74393, 1.3666666666667, 0.65, 0.29166666666667
74394, 1.3666666666667, 0.6, 0.29166666666667
74395, 1.3666666666667, 0.55, 0.29166666666667
74396, 1.3666666666667, 0.5, 0.29166666666667
74397, 1.3666666666667, 0.45, 0.29166666666667
74398, 1.3666666666667, 0.4, 0.29166666666667
74399, 1.3666666666667, 0.35, 0.29166666666667
74400, 1.3666666666667, 0.3, 0.29166666666667
74401, 1.3666666666667, 0.25, 0.29166666666667
74402, 1.3666666666667, 0.2, 0.29166666666667
74403, 1.4083333333333, 1.3, 0.29166666666667
74404, 1.4083333333333, 1.25, 0.29166666666667
74405, 1.4083333333333, 1.2, 0.29166666666667
74406, 1.4083333333333, 1.15, 0.29166666666667
74407, 1.4083333333333, 1.1, 0.29166666666667
74408, 1.4083333333333, 1.05, 0.29166666666667
74409, 1.4083333333333, 1, 0.29166666666667
74410, 1.4083333333333, 0.95, 0.29166666666667
74411, 1.4083333333333, 0.9, 0.29166666666667
74412, 1.4083333333333, 0.85, 0.29166666666667
74413, 1.4083333333333, 0.8, 0.29166666666667
74414, 1.4083333333333, 0.75, 0.29166666666667
74415, 1.4083333333333, 0.7, 0.29166666666667
74416, 1.4083333333333, 0.65, 0.29166666666667
74417, 1.4083333333333, 0.6, 0.29166666666667
74418, 1.4083333333333, 0.55, 0.29166666666667
74419, 1.4083333333333, 0.5, 0.29166666666667
74420, 1.4083333333333, 0.45, 0.29166666666667
74421, 1.4083333333333, 0.4, 0.29166666666667
74422, 1.4083333333333, 0.35, 0.29166666666667
74423, 1.4083333333333, 0.3, 0.29166666666667
74424, 1.4083333333333, 0.25, 0.29166666666667
74425, 1.4083333333333, 0.2, 0.29166666666667
74426, 1.45, 1.3, 0.29166666666667
74427, 1.45, 1.25, 0.29166666666667
74428, 1.45, 1.2, 0.29166666666667
74429, 1.45, 1.15, 0.29166666666667
74430, 1.45, 1.1, 0.29166666666667
74431, 1.45, 1.05, 0.29166666666667
74432, 1.45, 1, 0.29166666666667
74433, 1.45, 0.95, 0.29166666666667
74434, 1.45, 0.9, 0.29166666666667
74435, 1.45, 0.85, 0.29166666666667
74436, 1.45, 0.8, 0.29166666666667
74437, 1.45, 0.75, 0.29166666666667
74438, 1.45, 0.7, 0.29166666666667
74439, 1.45, 0.65, 0.29166666666667
74440, 1.45, 0.6, 0.29166666666667
74441, 1.45, 0.55, 0.29166666666667
74442, 1.45, 0.5, 0.29166666666667
74443, 1.45, 0.45, 0.29166666666667
74444, 1.45, 0.4, 0.29166666666667
74445, 1.45, 0.35, 0.29166666666667
74446, 1.45, 0.3, 0.29166666666667
74447, 1.45, 0.25, 0.29166666666667
74448, 1.45, 0.2, 0.29166666666667
74449, 1.4916666666667, 1.3, 0.29166666666667
74450, 1.4916666666667, 1.25, 0.29166666666667
74451, 1.4916666666667, 1.2, 0.29166666666667
74452, 1.4916666666667, 1.15, 0.29166666666667
74453, 1.4916666666667, 1.1, 0.29166666666667
74454, 1.4916666666667, 1.05, 0.29166666666667
74455, 1.4916666666667, 1, 0.29166666666667
74456, 1.4916666666667, 0.95, 0.29166666666667
74457, 1.4916666666667, 0.9, 0.29166666666667
74458, 1.4916666666667, 0.85, 0.29166666666667
74459, 1.4916666666667, 0.8, 0.29166666666667
74460, 1.4916666666667, 0.75, 0.29166666666667
74461, 1.4916666666667, 0.7, 0.29166666666667
74462, 1.4916666666667, 0.65, 0.29166666666667
74463, 1.4916666666667, 0.6, 0.29166666666667
74464, 1.4916666666667, 0.55, 0.29166666666667
74465, 1.4916666666667, 0.5, 0.29166666666667
74466, 1.4916666666667, 0.45, 0.29166666666667
74467, 1.4916666666667, 0.4, 0.29166666666667
74468, 1.4916666666667, 0.35, 0.29166666666667
74469, 1.4916666666667, 0.3, 0.29166666666667
74470, 1.4916666666667, 0.25, 0.29166666666667
74471, 1.4916666666667, 0.2, 0.29166666666667
74472, 1.5333333333333, 1.3, 0.29166666666667
74473, 1.5333333333333, 1.25, 0.29166666666667
74474, 1.5333333333333, 1.2, 0.29166666666667
74475, 1.5333333333333, 1.15, 0.29166666666667
74476, 1.5333333333333, 1.1, 0.29166666666667
74477, 1.5333333333333, 1.05, 0.29166666666667
74478, 1.5333333333333, 1, 0.29166666666667
74479, 1.5333333333333, 0.95, 0.29166666666667
74480, 1.5333333333333, 0.9, 0.29166666666667
74481, 1.5333333333333, 0.85, 0.29166666666667
74482, 1.5333333333333, 0.8, 0.29166666666667
74483, 1.5333333333333, 0.75, 0.29166666666667
74484, 1.5333333333333, 0.7, 0.29166666666667
74485, 1.5333333333333, 0.65, 0.29166666666667
74486, 1.5333333333333, 0.6, 0.29166666666667
74487, 1.5333333333333, 0.55, 0.29166666666667
74488, 1.5333333333333, 0.5, 0.29166666666667
74489, 1.5333333333333, 0.45, 0.29166666666667
74490, 1.5333333333333, 0.4, 0.29166666666667
74491, 1.5333333333333, 0.35, 0.29166666666667
74492, 1.5333333333333, 0.3, 0.29166666666667
74493, 1.5333333333333, 0.25, 0.29166666666667
74494, 1.5333333333333, 0.2, 0.29166666666667
74495, 1.575, 1.3, 0.29166666666667
74496, 1.575, 1.25, 0.29166666666667
74497, 1.575, 1.2, 0.29166666666667
74498, 1.575, 1.15, 0.29166666666667
74499, 1.575, 1.1, 0.29166666666667
74500, 1.575, 1.05, 0.29166666666667
74501, 1.575, 1, 0.29166666666667
74502, 1.575, 0.95, 0.29166666666667
74503, 1.575, 0.9, 0.29166666666667
74504, 1.575, 0.85, 0.29166666666667
74505, 1.575, 0.8, 0.29166666666667
74506, 1.575, 0.75, 0.29166666666667
74507, 1.575, 0.7, 0.29166666666667
74508, 1.575, 0.65, 0.29166666666667
74509, 1.575, 0.6, 0.29166666666667
74510, 1.575, 0.55, 0.29166666666667
74511, 1.575, 0.5, 0.29166666666667
74512, 1.575, 0.45, 0.29166666666667
74513, 1.575, 0.4, 0.29166666666667
74514, 1.575, 0.35, 0.29166666666667
74515, 1.575, 0.3, 0.29166666666667
74516, 1.575, 0.25, 0.29166666666667
74517, 1.575, 0.2, 0.29166666666667
74518, 1.6166666666667, 1.3, 0.29166666666667
74519, 1.6166666666667, 1.25, 0.29166666666667
74520, 1.6166666666667, 1.2, 0.29166666666667
74521, 1.6166666666667, 1.15, 0.29166666666667
74522, 1.6166666666667, 1.1, 0.29166666666667
74523, 1.6166666666667, 1.05, 0.29166666666667
74524, 1.6166666666667, 1, 0.29166666666667
74525, 1.6166666666667, 0.95, 0.29166666666667
74526, 1.6166666666667, 0.9, 0.29166666666667
74527, 1.6166666666667, 0.85, 0.29166666666667
74528, 1.6166666666667, 0.8, 0.29166666666667
74529, 1.6166666666667, 0.75, 0.29166666666667
74530, 1.6166666666667, 0.7, 0.29166666666667
74531, 1.6166666666667, 0.65, 0.29166666666667
74532, 1.6166666666667, 0.6, 0.29166666666667
74533, 1.6166666666667, 0.55, 0.29166666666667
74534, 1.6166666666667, 0.5, 0.29166666666667
74535, 1.6166666666667, 0.45, 0.29166666666667
74536, 1.6166666666667, 0.4, 0.29166666666667
74537, 1.6166666666667, 0.35, 0.29166666666667
74538, 1.6166666666667, 0.3, 0.29166666666667
74539, 1.6166666666667, 0.25, 0.29166666666667
74540, 1.6166666666667, 0.2, 0.29166666666667
74541, 1.6583333333333, 1.3, 0.29166666666667
74542, 1.6583333333333, 1.25, 0.29166666666667
74543, 1.6583333333333, 1.2, 0.29166666666667
74544, 1.6583333333333, 1.15, 0.29166666666667
74545, 1.6583333333333, 1.1, 0.29166666666667
74546, 1.6583333333333, 1.05, 0.29166666666667
74547, 1.6583333333333, 1, 0.29166666666667
74548, 1.6583333333333, 0.95, 0.29166666666667
74549, 1.6583333333333, 0.9, 0.29166666666667
74550, 1.6583333333333, 0.85, 0.29166666666667
74551, 1.6583333333333, 0.8, 0.29166666666667
74552, 1.6583333333333, 0.75, 0.29166666666667
74553, 1.6583333333333, 0.7, 0.29166666666667
74554, 1.6583333333333, 0.65, 0.29166666666667
74555, 1.6583333333333, 0.6, 0.29166666666667
74556, 1.6583333333333, 0.55, 0.29166666666667
74557, 1.6583333333333, 0.5, 0.29166666666667
74558, 1.6583333333333, 0.45, 0.29166666666667
74559, 1.6583333333333, 0.4, 0.29166666666667
74560, 1.6583333333333, 0.35, 0.29166666666667
74561, 1.6583333333333, 0.3, 0.29166666666667
74562, 1.6583333333333, 0.25, 0.29166666666667
74563, 1.6583333333333, 0.2, 0.29166666666667
74564, 1.7, 1.3, 0.29166666666667
74565, 1.7, 1.25, 0.29166666666667
74566, 1.7, 1.2, 0.29166666666667
74567, 1.7, 1.15, 0.29166666666667
74568, 1.7, 1.1, 0.29166666666667
74569, 1.7, 1.05, 0.29166666666667
74570, 1.7, 1, 0.29166666666667
74571, 1.7, 0.95, 0.29166666666667
74572, 1.7, 0.9, 0.29166666666667
74573, 1.7, 0.85, 0.29166666666667
74574, 1.7, 0.8, 0.29166666666667
74575, 1.7, 0.75, 0.29166666666667
74576, 1.7, 0.7, 0.29166666666667
74577, 1.7, 0.65, 0.29166666666667
74578, 1.7, 0.6, 0.29166666666667
74579, 1.7, 0.55, 0.29166666666667
74580, 1.7, 0.5, 0.29166666666667
74581, 1.7, 0.45, 0.29166666666667
74582, 1.7, 0.4, 0.29166666666667
74583, 1.7, 0.35, 0.29166666666667
74584, 1.7, 0.3, 0.29166666666667
74585, 1.7, 0.25, 0.29166666666667
74586, 1.7, 0.2, 0.29166666666667
74587, 1.7416666666667, 1.3, 0.29166666666667
74588, 1.7416666666667, 1.25, 0.29166666666667
74589, 1.7416666666667, 1.2, 0.29166666666667
74590, 1.7416666666667, 1.15, 0.29166666666667
74591, 1.7416666666667, 1.1, 0.29166666666667
74592, 1.7416666666667, 1.05, 0.29166666666667
74593, 1.7416666666667, 1, 0.29166666666667
74594, 1.7416666666667, 0.95, 0.29166666666667
74595, 1.7416666666667, 0.9, 0.29166666666667
74596, 1.7416666666667, 0.85, 0.29166666666667
74597, 1.7416666666667, 0.8, 0.29166666666667
74598, 1.7416666666667, 0.75, 0.29166666666667
74599, 1.7416666666667, 0.7, 0.29166666666667
74600, 1.7416666666667, 0.65, 0.29166666666667
74601, 1.7416666666667, 0.6, 0.29166666666667
74602, 1.7416666666667, 0.55, 0.29166666666667
74603, 1.7416666666667, 0.5, 0.29166666666667
74604, 1.7416666666667, 0.45, 0.29166666666667
74605, 1.7416666666667, 0.4, 0.29166666666667
74606, 1.7416666666667, 0.35, 0.29166666666667
74607, 1.7416666666667, 0.3, 0.29166666666667
74608, 1.7416666666667, 0.25, 0.29166666666667
74609, 1.7416666666667, 0.2, 0.29166666666667
74610, 1.7833333333333, 1.3, 0.29166666666667
74611, 1.7833333333333, 1.25, 0.29166666666667
74612, 1.7833333333333, 1.2, 0.29166666666667
74613, 1.7833333333333, 1.15, 0.29166666666667
74614, 1.7833333333333, 1.1, 0.29166666666667
74615, 1.7833333333333, 1.05, 0.29166666666667
74616, 1.7833333333333, 1, 0.29166666666667
74617, 1.7833333333333, 0.95, 0.29166666666667
74618, 1.7833333333333, 0.9, 0.29166666666667
74619, 1.7833333333333, 0.85, 0.29166666666667
74620, 1.7833333333333, 0.8, 0.29166666666667
74621, 1.7833333333333, 0.75, 0.29166666666667
74622, 1.7833333333333, 0.7, 0.29166666666667
74623, 1.7833333333333, 0.65, 0.29166666666667
74624, 1.7833333333333, 0.6, 0.29166666666667
74625, 1.7833333333333, 0.55, 0.29166666666667
74626, 1.7833333333333, 0.5, 0.29166666666667
74627, 1.7833333333333, 0.45, 0.29166666666667
74628, 1.7833333333333, 0.4, 0.29166666666667
74629, 1.7833333333333, 0.35, 0.29166666666667
74630, 1.7833333333333, 0.3, 0.29166666666667
74631, 1.7833333333333, 0.25, 0.29166666666667
74632, 1.7833333333333, 0.2, 0.29166666666667
74633, 1.825, 1.3, 0.29166666666667
74634, 1.825, 1.25, 0.29166666666667
74635, 1.825, 1.2, 0.29166666666667
74636, 1.825, 1.15, 0.29166666666667
74637, 1.825, 1.1, 0.29166666666667
74638, 1.825, 1.05, 0.29166666666667
74639, 1.825, 1, 0.29166666666667
74640, 1.825, 0.95, 0.29166666666667
74641, 1.825, 0.9, 0.29166666666667
74642, 1.825, 0.85, 0.29166666666667
74643, 1.825, 0.8, 0.29166666666667
74644, 1.825, 0.75, 0.29166666666667
74645, 1.825, 0.7, 0.29166666666667
74646, 1.825, 0.65, 0.29166666666667
74647, 1.825, 0.6, 0.29166666666667
74648, 1.825, 0.55, 0.29166666666667
74649, 1.825, 0.5, 0.29166666666667
74650, 1.825, 0.45, 0.29166666666667
74651, 1.825, 0.4, 0.29166666666667
74652, 1.825, 0.35, 0.29166666666667
74653, 1.825, 0.3, 0.29166666666667
74654, 1.825, 0.25, 0.29166666666667
74655, 1.825, 0.2, 0.29166666666667
74656, 1.8666666666667, 1.3, 0.29166666666667
74657, 1.8666666666667, 1.25, 0.29166666666667
74658, 1.8666666666667, 1.2, 0.29166666666667
74659, 1.8666666666667, 1.15, 0.29166666666667
74660, 1.8666666666667, 1.1, 0.29166666666667
74661, 1.8666666666667, 1.05, 0.29166666666667
74662, 1.8666666666667, 1, 0.29166666666667
74663, 1.8666666666667, 0.95, 0.29166666666667
74664, 1.8666666666667, 0.9, 0.29166666666667
74665, 1.8666666666667, 0.85, 0.29166666666667
74666, 1.8666666666667, 0.8, 0.29166666666667
74667, 1.8666666666667, 0.75, 0.29166666666667
74668, 1.8666666666667, 0.7, 0.29166666666667
74669, 1.8666666666667, 0.65, 0.29166666666667
74670, 1.8666666666667, 0.6, 0.29166666666667
74671, 1.8666666666667, 0.55, 0.29166666666667
74672, 1.8666666666667, 0.5, 0.29166666666667
74673, 1.8666666666667, 0.45, 0.29166666666667
74674, 1.8666666666667, 0.4, 0.29166666666667
74675, 1.8666666666667, 0.35, 0.29166666666667
74676, 1.8666666666667, 0.3, 0.29166666666667
74677, 1.8666666666667, 0.25, 0.29166666666667
74678, 1.8666666666667, 0.2, 0.29166666666667
74679, 1.9083333333333, 1.3, 0.29166666666667
74680, 1.9083333333333, 1.25, 0.29166666666667
74681, 1.9083333333333, 1.2, 0.29166666666667
74682, 1.9083333333333, 1.15, 0.29166666666667
74683, 1.9083333333333, 1.1, 0.29166666666667
74684, 1.9083333333333, 1.05, 0.29166666666667
74685, 1.9083333333333, 1, 0.29166666666667
74686, 1.9083333333333, 0.95, 0.29166666666667
74687, 1.9083333333333, 0.9, 0.29166666666667
74688, 1.9083333333333, 0.85, 0.29166666666667
74689, 1.9083333333333, 0.8, 0.29166666666667
74690, 1.9083333333333, 0.75, 0.29166666666667
74691, 1.9083333333333, 0.7, 0.29166666666667
74692, 1.9083333333333, 0.65, 0.29166666666667
74693, 1.9083333333333, 0.6, 0.29166666666667
74694, 1.9083333333333, 0.55, 0.29166666666667
74695, 1.9083333333333, 0.5, 0.29166666666667
74696, 1.9083333333333, 0.45, 0.29166666666667
74697, 1.9083333333333, 0.4, 0.29166666666667
74698, 1.9083333333333, 0.35, 0.29166666666667
74699, 1.9083333333333, 0.3, 0.29166666666667
74700, 1.9083333333333, 0.25, 0.29166666666667
74701, 1.9083333333333, 0.2, 0.29166666666667
74702, 1.95, 1.3, 0.29166666666667
74703, 1.95, 1.25, 0.29166666666667
74704, 1.95, 1.2, 0.29166666666667
74705, 1.95, 1.15, 0.29166666666667
74706, 1.95, 1.1, 0.29166666666667
74707, 1.95, 1.05, 0.29166666666667
74708, 1.95, 1, 0.29166666666667
74709, 1.95, 0.95, 0.29166666666667
74710, 1.95, 0.9, 0.29166666666667
74711, 1.95, 0.85, 0.29166666666667
74712, 1.95, 0.8, 0.29166666666667
74713, 1.95, 0.75, 0.29166666666667
74714, 1.95, 0.7, 0.29166666666667
74715, 1.95, 0.65, 0.29166666666667
74716, 1.95, 0.6, 0.29166666666667
74717, 1.95, 0.55, 0.29166666666667
74718, 1.95, 0.5, 0.29166666666667
74719, 1.95, 0.45, 0.29166666666667
74720, 1.95, 0.4, 0.29166666666667
74721, 1.95, 0.35, 0.29166666666667
74722, 1.95, 0.3, 0.29166666666667
74723, 1.95, 0.25, 0.29166666666667
74724, 1.95, 0.2, 0.29166666666667
74725, 1.9916666666667, 1.3, 0.29166666666667
74726, 1.9916666666667, 1.25, 0.29166666666667
74727, 1.9916666666667, 1.2, 0.29166666666667
74728, 1.9916666666667, 1.15, 0.29166666666667
74729, 1.9916666666667, 1.1, 0.29166666666667
74730, 1.9916666666667, 1.05, 0.29166666666667
74731, 1.9916666666667, 1, 0.29166666666667
74732, 1.9916666666667, 0.95, 0.29166666666667
74733, 1.9916666666667, 0.9, 0.29166666666667
74734, 1.9916666666667, 0.85, 0.29166666666667
74735, 1.9916666666667, 0.8, 0.29166666666667
74736, 1.9916666666667, 0.75, 0.29166666666667
74737, 1.9916666666667, 0.7, 0.29166666666667
74738, 1.9916666666667, 0.65, 0.29166666666667
74739, 1.9916666666667, 0.6, 0.29166666666667
74740, 1.9916666666667, 0.55, 0.29166666666667
74741, 1.9916666666667, 0.5, 0.29166666666667
74742, 1.9916666666667, 0.45, 0.29166666666667
74743, 1.9916666666667, 0.4, 0.29166666666667
74744, 1.9916666666667, 0.35, 0.29166666666667
74745, 1.9916666666667, 0.3, 0.29166666666667
74746, 1.9916666666667, 0.25, 0.29166666666667
74747, 1.9916666666667, 0.2, 0.29166666666667
74748, 2.0333333333333, 1.3, 0.29166666666667
74749, 2.0333333333333, 1.25, 0.29166666666667
74750, 2.0333333333333, 1.2, 0.29166666666667
74751, 2.0333333333333, 1.15, 0.29166666666667
74752, 2.0333333333333, 1.1, 0.29166666666667
74753, 2.0333333333333, 1.05, 0.29166666666667
74754, 2.0333333333333, 1, 0.29166666666667
74755, 2.0333333333333, 0.95, 0.29166666666667
74756, 2.0333333333333, 0.9, 0.29166666666667
74757, 2.0333333333333, 0.85, 0.29166666666667
74758, 2.0333333333333, 0.8, 0.29166666666667
74759, 2.0333333333333, 0.75, 0.29166666666667
74760, 2.0333333333333, 0.7, 0.29166666666667
74761, 2.0333333333333, 0.65, 0.29166666666667
74762, 2.0333333333333, 0.6, 0.29166666666667
74763, 2.0333333333333, 0.55, 0.29166666666667
74764, 2.0333333333333, 0.5, 0.29166666666667
74765, 2.0333333333333, 0.45, 0.29166666666667
74766, 2.0333333333333, 0.4, 0.29166666666667
74767, 2.0333333333333, 0.35, 0.29166666666667
74768, 2.0333333333333, 0.3, 0.29166666666667
74769, 2.0333333333333, 0.25, 0.29166666666667
74770, 2.0333333333333, 0.2, 0.29166666666667
74771, 2.075, 1.3, 0.29166666666667
74772, 2.075, 1.25, 0.29166666666667
74773, 2.075, 1.2, 0.29166666666667
74774, 2.075, 1.15, 0.29166666666667
74775, 2.075, 1.1, 0.29166666666667
74776, 2.075, 1.05, 0.29166666666667
74777, 2.075, 1, 0.29166666666667
74778, 2.075, 0.95, 0.29166666666667
74779, 2.075, 0.9, 0.29166666666667
74780, 2.075, 0.85, 0.29166666666667
74781, 2.075, 0.8, 0.29166666666667
74782, 2.075, 0.75, 0.29166666666667
74783, 2.075, 0.7, 0.29166666666667
74784, 2.075, 0.65, 0.29166666666667
74785, 2.075, 0.6, 0.29166666666667
74786, 2.075, 0.55, 0.29166666666667
74787, 2.075, 0.5, 0.29166666666667
74788, 2.075, 0.45, 0.29166666666667
74789, 2.075, 0.4, 0.29166666666667
74790, 2.075, 0.35, 0.29166666666667
74791, 2.075, 0.3, 0.29166666666667
74792, 2.075, 0.25, 0.29166666666667
74793, 2.075, 0.2, 0.29166666666667
74794, 2.1166666666667, 1.3, 0.29166666666667
74795, 2.1166666666667, 1.25, 0.29166666666667
74796, 2.1166666666667, 1.2, 0.29166666666667
74797, 2.1166666666667, 1.15, 0.29166666666667
74798, 2.1166666666667, 1.1, 0.29166666666667
74799, 2.1166666666667, 1.05, 0.29166666666667
74800, 2.1166666666667, 1, 0.29166666666667
74801, 2.1166666666667, 0.95, 0.29166666666667
74802, 2.1166666666667, 0.9, 0.29166666666667
74803, 2.1166666666667, 0.85, 0.29166666666667
74804, 2.1166666666667, 0.8, 0.29166666666667
74805, 2.1166666666667, 0.75, 0.29166666666667
74806, 2.1166666666667, 0.7, 0.29166666666667
74807, 2.1166666666667, 0.65, 0.29166666666667
74808, 2.1166666666667, 0.6, 0.29166666666667
74809, 2.1166666666667, 0.55, 0.29166666666667
74810, 2.1166666666667, 0.5, 0.29166666666667
74811, 2.1166666666667, 0.45, 0.29166666666667
74812, 2.1166666666667, 0.4, 0.29166666666667
74813, 2.1166666666667, 0.35, 0.29166666666667
74814, 2.1166666666667, 0.3, 0.29166666666667
74815, 2.1166666666667, 0.25, 0.29166666666667
74816, 2.1166666666667, 0.2, 0.29166666666667
74817, 2.1583333333333, 1.3, 0.29166666666667
74818, 2.1583333333333, 1.25, 0.29166666666667
74819, 2.1583333333333, 1.2, 0.29166666666667
74820, 2.1583333333333, 1.15, 0.29166666666667
74821, 2.1583333333333, 1.1, 0.29166666666667
74822, 2.1583333333333, 1.05, 0.29166666666667
74823, 2.1583333333333, 1, 0.29166666666667
74824, 2.1583333333333, 0.95, 0.29166666666667
74825, 2.1583333333333, 0.9, 0.29166666666667
74826, 2.1583333333333, 0.85, 0.29166666666667
74827, 2.1583333333333, 0.8, 0.29166666666667
74828, 2.1583333333333, 0.75, 0.29166666666667
74829, 2.1583333333333, 0.7, 0.29166666666667
74830, 2.1583333333333, 0.65, 0.29166666666667
74831, 2.1583333333333, 0.6, 0.29166666666667
74832, 2.1583333333333, 0.55, 0.29166666666667
74833, 2.1583333333333, 0.5, 0.29166666666667
74834, 2.1583333333333, 0.45, 0.29166666666667
74835, 2.1583333333333, 0.4, 0.29166666666667
74836, 2.1583333333333, 0.35, 0.29166666666667
74837, 2.1583333333333, 0.3, 0.29166666666667
74838, 2.1583333333333, 0.25, 0.29166666666667
74839, 2.1583333333333, 0.2, 0.29166666666667
74840, 1.2416666666667, 1.3, 0.33333333333333
74841, 1.2416666666667, 1.25, 0.33333333333333
74842, 1.2416666666667, 1.2, 0.33333333333333
74843, 1.2416666666667, 1.15, 0.33333333333333
74844, 1.2416666666667, 1.1, 0.33333333333333
74845, 1.2416666666667, 1.05, 0.33333333333333
74846, 1.2416666666667, 1, 0.33333333333333
74847, 1.2416666666667, 0.95, 0.33333333333333
74848, 1.2416666666667, 0.9, 0.33333333333333
74849, 1.2416666666667, 0.85, 0.33333333333333
74850, 1.2416666666667, 0.8, 0.33333333333333
74851, 1.2416666666667, 0.75, 0.33333333333333
74852, 1.2416666666667, 0.7, 0.33333333333333
74853, 1.2416666666667, 0.65, 0.33333333333333
74854, 1.2416666666667, 0.6, 0.33333333333333
74855, 1.2416666666667, 0.55, 0.33333333333333
74856, 1.2416666666667, 0.5, 0.33333333333333
74857, 1.2416666666667, 0.45, 0.33333333333333
74858, 1.2416666666667, 0.4, 0.33333333333333
74859, 1.2416666666667, 0.35, 0.33333333333333
74860, 1.2416666666667, 0.3, 0.33333333333333
74861, 1.2416666666667, 0.25, 0.33333333333333
74862, 1.2416666666667, 0.2, 0.33333333333333
74863, 1.2833333333333, 1.3, 0.33333333333333
74864, 1.2833333333333, 1.25, 0.33333333333333
74865, 1.2833333333333, 1.2, 0.33333333333333
74866, 1.2833333333333, 1.15, 0.33333333333333
74867, 1.2833333333333, 1.1, 0.33333333333333
74868, 1.2833333333333, 1.05, 0.33333333333333
74869, 1.2833333333333, 1, 0.33333333333333
74870, 1.2833333333333, 0.95, 0.33333333333333
74871, 1.2833333333333, 0.9, 0.33333333333333
74872, 1.2833333333333, 0.85, 0.33333333333333
74873, 1.2833333333333, 0.8, 0.33333333333333
74874, 1.2833333333333, 0.75, 0.33333333333333
74875, 1.2833333333333, 0.7, 0.33333333333333
74876, 1.2833333333333, 0.65, 0.33333333333333
74877, 1.2833333333333, 0.6, 0.33333333333333
74878, 1.2833333333333, 0.55, 0.33333333333333
74879, 1.2833333333333, 0.5, 0.33333333333333
74880, 1.2833333333333, 0.45, 0.33333333333333
74881, 1.2833333333333, 0.4, 0.33333333333333
74882, 1.2833333333333, 0.35, 0.33333333333333
74883, 1.2833333333333, 0.3, 0.33333333333333
74884, 1.2833333333333, 0.25, 0.33333333333333
74885, 1.2833333333333, 0.2, 0.33333333333333
74886, 1.325, 1.3, 0.33333333333333
74887, 1.325, 1.25, 0.33333333333333
74888, 1.325, 1.2, 0.33333333333333
74889, 1.325, 1.15, 0.33333333333333
74890, 1.325, 1.1, 0.33333333333333
74891, 1.325, 1.05, 0.33333333333333
74892, 1.325, 1, 0.33333333333333
74893, 1.325, 0.95, 0.33333333333333
74894, 1.325, 0.9, 0.33333333333333
74895, 1.325, 0.85, 0.33333333333333
74896, 1.325, 0.8, 0.33333333333333
74897, 1.325, 0.75, 0.33333333333333
74898, 1.325, 0.7, 0.33333333333333
74899, 1.325, 0.65, 0.33333333333333
74900, 1.325, 0.6, 0.33333333333333
74901, 1.325, 0.55, 0.33333333333333
74902, 1.325, 0.5, 0.33333333333333
74903, 1.325, 0.45, 0.33333333333333
74904, 1.325, 0.4, 0.33333333333333
74905, 1.325, 0.35, 0.33333333333333
74906, 1.325, 0.3, 0.33333333333333
74907, 1.325, 0.25, 0.33333333333333
74908, 1.325, 0.2, 0.33333333333333
74909, 1.3666666666667, 1.3, 0.33333333333333
74910, 1.3666666666667, 1.25, 0.33333333333333
74911, 1.3666666666667, 1.2, 0.33333333333333
74912, 1.3666666666667, 1.15, 0.33333333333333
74913, 1.3666666666667, 1.1, 0.33333333333333
74914, 1.3666666666667, 1.05, 0.33333333333333
74915, 1.3666666666667, 1, 0.33333333333333
74916, 1.3666666666667, 0.95, 0.33333333333333
74917, 1.3666666666667, 0.9, 0.33333333333333
74918, 1.3666666666667, 0.85, 0.33333333333333
74919, 1.3666666666667, 0.8, 0.33333333333333
74920, 1.3666666666667, 0.75, 0.33333333333333
74921, 1.3666666666667, 0.7, 0.33333333333333
74922, 1.3666666666667, 0.65, 0.33333333333333
74923, 1.3666666666667, 0.6, 0.33333333333333
74924, 1.3666666666667, 0.55, 0.33333333333333
74925, 1.3666666666667, 0.5, 0.33333333333333
74926, 1.3666666666667, 0.45, 0.33333333333333
74927, 1.3666666666667, 0.4, 0.33333333333333
74928, 1.3666666666667, 0.35, 0.33333333333333
74929, 1.3666666666667, 0.3, 0.33333333333333
74930, 1.3666666666667, 0.25, 0.33333333333333
74931, 1.3666666666667, 0.2, 0.33333333333333
74932, 1.4083333333333, 1.3, 0.33333333333333
74933, 1.4083333333333, 1.25, 0.33333333333333
74934, 1.4083333333333, 1.2, 0.33333333333333
74935, 1.4083333333333, 1.15, 0.33333333333333
74936, 1.4083333333333, 1.1, 0.33333333333333
74937, 1.4083333333333, 1.05, 0.33333333333333
74938, 1.4083333333333, 1, 0.33333333333333
74939, 1.4083333333333, 0.95, 0.33333333333333
74940, 1.4083333333333, 0.9, 0.33333333333333
74941, 1.4083333333333, 0.85, 0.33333333333333
74942, 1.4083333333333, 0.8, 0.33333333333333
74943, 1.4083333333333, 0.75, 0.33333333333333
74944, 1.4083333333333, 0.7, 0.33333333333333
74945, 1.4083333333333, 0.65, 0.33333333333333
74946, 1.4083333333333, 0.6, 0.33333333333333
74947, 1.4083333333333, 0.55, 0.33333333333333
74948, 1.4083333333333, 0.5, 0.33333333333333
74949, 1.4083333333333, 0.45, 0.33333333333333
74950, 1.4083333333333, 0.4, 0.33333333333333
74951, 1.4083333333333, 0.35, 0.33333333333333
74952, 1.4083333333333, 0.3, 0.33333333333333
74953, 1.4083333333333, 0.25, 0.33333333333333
74954, 1.4083333333333, 0.2, 0.33333333333333
74955, 1.45, 1.3, 0.33333333333333
74956, 1.45, 1.25, 0.33333333333333
74957, 1.45, 1.2, 0.33333333333333
74958, 1.45, 1.15, 0.33333333333333
74959, 1.45, 1.1, 0.33333333333333
74960, 1.45, 1.05, 0.33333333333333
74961, 1.45, 1, 0.33333333333333
74962, 1.45, 0.95, 0.33333333333333
74963, 1.45, 0.9, 0.33333333333333
74964, 1.45, 0.85, 0.33333333333333
74965, 1.45, 0.8, 0.33333333333333
74966, 1.45, 0.75, 0.33333333333333
74967, 1.45, 0.7, 0.33333333333333
74968, 1.45, 0.65, 0.33333333333333
74969, 1.45, 0.6, 0.33333333333333
74970, 1.45, 0.55, 0.33333333333333
74971, 1.45, 0.5, 0.33333333333333
74972, 1.45, 0.45, 0.33333333333333
74973, 1.45, 0.4, 0.33333333333333
74974, 1.45, 0.35, 0.33333333333333
74975, 1.45, 0.3, 0.33333333333333
74976, 1.45, 0.25, 0.33333333333333
74977, 1.45, 0.2, 0.33333333333333
74978, 1.4916666666667, 1.3, 0.33333333333333
74979, 1.4916666666667, 1.25, 0.33333333333333
74980, 1.4916666666667, 1.2, 0.33333333333333
74981, 1.4916666666667, 1.15, 0.33333333333333
74982, 1.4916666666667, 1.1, 0.33333333333333
74983, 1.4916666666667, 1.05, 0.33333333333333
74984, 1.4916666666667, 1, 0.33333333333333
74985, 1.4916666666667, 0.95, 0.33333333333333
74986, 1.4916666666667, 0.9, 0.33333333333333
74987, 1.4916666666667, 0.85, 0.33333333333333
74988, 1.4916666666667, 0.8, 0.33333333333333
74989, 1.4916666666667, 0.75, 0.33333333333333
74990, 1.4916666666667, 0.7, 0.33333333333333
74991, 1.4916666666667, 0.65, 0.33333333333333
74992, 1.4916666666667, 0.6, 0.33333333333333
74993, 1.4916666666667, 0.55, 0.33333333333333
74994, 1.4916666666667, 0.5, 0.33333333333333
74995, 1.4916666666667, 0.45, 0.33333333333333
74996, 1.4916666666667, 0.4, 0.33333333333333
74997, 1.4916666666667, 0.35, 0.33333333333333
74998, 1.4916666666667, 0.3, 0.33333333333333
74999, 1.4916666666667, 0.25, 0.33333333333333
75000, 1.4916666666667, 0.2, 0.33333333333333
75001, 1.5333333333333, 1.3, 0.33333333333333
75002, 1.5333333333333, 1.25, 0.33333333333333
75003, 1.5333333333333, 1.2, 0.33333333333333
75004, 1.5333333333333, 1.15, 0.33333333333333
75005, 1.5333333333333, 1.1, 0.33333333333333
75006, 1.5333333333333, 1.05, 0.33333333333333
75007, 1.5333333333333, 1, 0.33333333333333
75008, 1.5333333333333, 0.95, 0.33333333333333
75009, 1.5333333333333, 0.9, 0.33333333333333
75010, 1.5333333333333, 0.85, 0.33333333333333
75011, 1.5333333333333, 0.8, 0.33333333333333
75012, 1.5333333333333, 0.75, 0.33333333333333
75013, 1.5333333333333, 0.7, 0.33333333333333
75014, 1.5333333333333, 0.65, 0.33333333333333
75015, 1.5333333333333, 0.6, 0.33333333333333
75016, 1.5333333333333, 0.55, 0.33333333333333
75017, 1.5333333333333, 0.5, 0.33333333333333
75018, 1.5333333333333, 0.45, 0.33333333333333
75019, 1.5333333333333, 0.4, 0.33333333333333
75020, 1.5333333333333, 0.35, 0.33333333333333
75021, 1.5333333333333, 0.3, 0.33333333333333
75022, 1.5333333333333, 0.25, 0.33333333333333
75023, 1.5333333333333, 0.2, 0.33333333333333
75024, 1.575, 1.3, 0.33333333333333
75025, 1.575, 1.25, 0.33333333333333
75026, 1.575, 1.2, 0.33333333333333
75027, 1.575, 1.15, 0.33333333333333
75028, 1.575, 1.1, 0.33333333333333
75029, 1.575, 1.05, 0.33333333333333
75030, 1.575, 1, 0.33333333333333
75031, 1.575, 0.95, 0.33333333333333
75032, 1.575, 0.9, 0.33333333333333
75033, 1.575, 0.85, 0.33333333333333
75034, 1.575, 0.8, 0.33333333333333
75035, 1.575, 0.75, 0.33333333333333
75036, 1.575, 0.7, 0.33333333333333
75037, 1.575, 0.65, 0.33333333333333
75038, 1.575, 0.6, 0.33333333333333
75039, 1.575, 0.55, 0.33333333333333
75040, 1.575, 0.5, 0.33333333333333
75041, 1.575, 0.45, 0.33333333333333
75042, 1.575, 0.4, 0.33333333333333
75043, 1.575, 0.35, 0.33333333333333
75044, 1.575, 0.3, 0.33333333333333
75045, 1.575, 0.25, 0.33333333333333
75046, 1.575, 0.2, 0.33333333333333
75047, 1.6166666666667, 1.3, 0.33333333333333
75048, 1.6166666666667, 1.25, 0.33333333333333
75049, 1.6166666666667, 1.2, 0.33333333333333
75050, 1.6166666666667, 1.15, 0.33333333333333
75051, 1.6166666666667, 1.1, 0.33333333333333
75052, 1.6166666666667, 1.05, 0.33333333333333
75053, 1.6166666666667, 1, 0.33333333333333
75054, 1.6166666666667, 0.95, 0.33333333333333
75055, 1.6166666666667, 0.9, 0.33333333333333
75056, 1.6166666666667, 0.85, 0.33333333333333
75057, 1.6166666666667, 0.8, 0.33333333333333
75058, 1.6166666666667, 0.75, 0.33333333333333
75059, 1.6166666666667, 0.7, 0.33333333333333
75060, 1.6166666666667, 0.65, 0.33333333333333
75061, 1.6166666666667, 0.6, 0.33333333333333
75062, 1.6166666666667, 0.55, 0.33333333333333
75063, 1.6166666666667, 0.5, 0.33333333333333
75064, 1.6166666666667, 0.45, 0.33333333333333
75065, 1.6166666666667, 0.4, 0.33333333333333
75066, 1.6166666666667, 0.35, 0.33333333333333
75067, 1.6166666666667, 0.3, 0.33333333333333
75068, 1.6166666666667, 0.25, 0.33333333333333
75069, 1.6166666666667, 0.2, 0.33333333333333
75070, 1.6583333333333, 1.3, 0.33333333333333
75071, 1.6583333333333, 1.25, 0.33333333333333
75072, 1.6583333333333, 1.2, 0.33333333333333
75073, 1.6583333333333, 1.15, 0.33333333333333
75074, 1.6583333333333, 1.1, 0.33333333333333
75075, 1.6583333333333, 1.05, 0.33333333333333
75076, 1.6583333333333, 1, 0.33333333333333
75077, 1.6583333333333, 0.95, 0.33333333333333
75078, 1.6583333333333, 0.9, 0.33333333333333
75079, 1.6583333333333, 0.85, 0.33333333333333
75080, 1.6583333333333, 0.8, 0.33333333333333
75081, 1.6583333333333, 0.75, 0.33333333333333
75082, 1.6583333333333, 0.7, 0.33333333333333
75083, 1.6583333333333, 0.65, 0.33333333333333
75084, 1.6583333333333, 0.6, 0.33333333333333
75085, 1.6583333333333, 0.55, 0.33333333333333
75086, 1.6583333333333, 0.5, 0.33333333333333
75087, 1.6583333333333, 0.45, 0.33333333333333
75088, 1.6583333333333, 0.4, 0.33333333333333
75089, 1.6583333333333, 0.35, 0.33333333333333
75090, 1.6583333333333, 0.3, 0.33333333333333
75091, 1.6583333333333, 0.25, 0.33333333333333
75092, 1.6583333333333, 0.2, 0.33333333333333
75093, 1.7, 1.3, 0.33333333333333
75094, 1.7, 1.25, 0.33333333333333
75095, 1.7, 1.2, 0.33333333333333
75096, 1.7, 1.15, 0.33333333333333
75097, 1.7, 1.1, 0.33333333333333
75098, 1.7, 1.05, 0.33333333333333
75099, 1.7, 1, 0.33333333333333
75100, 1.7, 0.95, 0.33333333333333
75101, 1.7, 0.9, 0.33333333333333
75102, 1.7, 0.85, 0.33333333333333
75103, 1.7, 0.8, 0.33333333333333
75104, 1.7, 0.75, 0.33333333333333
75105, 1.7, 0.7, 0.33333333333333
75106, 1.7, 0.65, 0.33333333333333
75107, 1.7, 0.6, 0.33333333333333
75108, 1.7, 0.55, 0.33333333333333
75109, 1.7, 0.5, 0.33333333333333
75110, 1.7, 0.45, 0.33333333333333
75111, 1.7, 0.4, 0.33333333333333
75112, 1.7, 0.35, 0.33333333333333
75113, 1.7, 0.3, 0.33333333333333
75114, 1.7, 0.25, 0.33333333333333
75115, 1.7, 0.2, 0.33333333333333
75116, 1.7416666666667, 1.3, 0.33333333333333
75117, 1.7416666666667, 1.25, 0.33333333333333
75118, 1.7416666666667, 1.2, 0.33333333333333
75119, 1.7416666666667, 1.15, 0.33333333333333
75120, 1.7416666666667, 1.1, 0.33333333333333
75121, 1.7416666666667, 1.05, 0.33333333333333
75122, 1.7416666666667, 1, 0.33333333333333
75123, 1.7416666666667, 0.95, 0.33333333333333
75124, 1.7416666666667, 0.9, 0.33333333333333
75125, 1.7416666666667, 0.85, 0.33333333333333
75126, 1.7416666666667, 0.8, 0.33333333333333
75127, 1.7416666666667, 0.75, 0.33333333333333
75128, 1.7416666666667, 0.7, 0.33333333333333
75129, 1.7416666666667, 0.65, 0.33333333333333
75130, 1.7416666666667, 0.6, 0.33333333333333
75131, 1.7416666666667, 0.55, 0.33333333333333
75132, 1.7416666666667, 0.5, 0.33333333333333
75133, 1.7416666666667, 0.45, 0.33333333333333
75134, 1.7416666666667, 0.4, 0.33333333333333
75135, 1.7416666666667, 0.35, 0.33333333333333
75136, 1.7416666666667, 0.3, 0.33333333333333
75137, 1.7416666666667, 0.25, 0.33333333333333
75138, 1.7416666666667, 0.2, 0.33333333333333
75139, 1.7833333333333, 1.3, 0.33333333333333
75140, 1.7833333333333, 1.25, 0.33333333333333
75141, 1.7833333333333, 1.2, 0.33333333333333
75142, 1.7833333333333, 1.15, 0.33333333333333
75143, 1.7833333333333, 1.1, 0.33333333333333
75144, 1.7833333333333, 1.05, 0.33333333333333
