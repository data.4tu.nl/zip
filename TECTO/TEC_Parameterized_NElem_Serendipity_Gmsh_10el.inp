4919, 11134, 11157, 11158, 11135, 11598, 11599, 11600, 11552
4920, 11135, 11158, 11159, 11136, 11600, 11601, 11602, 11554
4921, 11136, 11159, 11160, 11137, 11602, 11603, 11604, 11556
4922, 11137, 11160, 853, 852, 11604, 11605, 864, 11558
4923, 525, 526, 11161, 11138, 537, 11606, 11607, 11559
4924, 11138, 11161, 11162, 11139, 11607, 11608, 11609, 11561
4925, 11139, 11162, 11163, 11140, 11609, 11610, 11611, 11563
4926, 11140, 11163, 11164, 11141, 11611, 11612, 11613, 11565
4927, 11141, 11164, 11165, 11142, 11613, 11614, 11615, 11567
4928, 11142, 11165, 11166, 11143, 11615, 11616, 11617, 11569
4929, 11143, 11166, 11167, 11144, 11617, 11618, 11619, 11571
4930, 11144, 11167, 11168, 11145, 11619, 11620, 11621, 11573
4931, 11145, 11168, 11169, 11146, 11621, 11622, 11623, 11575
4932, 11146, 11169, 11170, 11147, 11623, 11624, 11625, 11577
4933, 11147, 11170, 11171, 11148, 11625, 11626, 11627, 11579
4934, 11148, 11171, 11172, 11149, 11627, 11628, 11629, 11581
4935, 11149, 11172, 11173, 11150, 11629, 11630, 11631, 11583
4936, 11150, 11173, 11174, 11151, 11631, 11632, 11633, 11585
4937, 11151, 11174, 11175, 11152, 11633, 11634, 11635, 11587
4938, 11152, 11175, 11176, 11153, 11635, 11636, 11637, 11589
4939, 11153, 11176, 11177, 11154, 11637, 11638, 11639, 11591
4940, 11154, 11177, 11178, 11155, 11639, 11640, 11641, 11593
4941, 11155, 11178, 11179, 11156, 11641, 11642, 11643, 11595
4942, 11156, 11179, 11180, 11157, 11643, 11644, 11645, 11597
4943, 11157, 11180, 11181, 11158, 11645, 11646, 11647, 11599
4944, 11158, 11181, 11182, 11159, 11647, 11648, 11649, 11601
4945, 11159, 11182, 11183, 11160, 11649, 11650, 11651, 11603
4946, 11160, 11183, 854, 853, 11651, 11652, 865, 11605
4947, 526, 527, 11184, 11161, 538, 11653, 11654, 11606
4948, 11161, 11184, 11185, 11162, 11654, 11655, 11656, 11608
4949, 11162, 11185, 11186, 11163, 11656, 11657, 11658, 11610
4950, 11163, 11186, 11187, 11164, 11658, 11659, 11660, 11612
4951, 11164, 11187, 11188, 11165, 11660, 11661, 11662, 11614
4952, 11165, 11188, 11189, 11166, 11662, 11663, 11664, 11616
4953, 11166, 11189, 11190, 11167, 11664, 11665, 11666, 11618
4954, 11167, 11190, 11191, 11168, 11666, 11667, 11668, 11620
4955, 11168, 11191, 11192, 11169, 11668, 11669, 11670, 11622
4956, 11169, 11192, 11193, 11170, 11670, 11671, 11672, 11624
4957, 11170, 11193, 11194, 11171, 11672, 11673, 11674, 11626
4958, 11171, 11194, 11195, 11172, 11674, 11675, 11676, 11628
4959, 11172, 11195, 11196, 11173, 11676, 11677, 11678, 11630
4960, 11173, 11196, 11197, 11174, 11678, 11679, 11680, 11632
4961, 11174, 11197, 11198, 11175, 11680, 11681, 11682, 11634
4962, 11175, 11198, 11199, 11176, 11682, 11683, 11684, 11636
4963, 11176, 11199, 11200, 11177, 11684, 11685, 11686, 11638
4964, 11177, 11200, 11201, 11178, 11686, 11687, 11688, 11640
4965, 11178, 11201, 11202, 11179, 11688, 11689, 11690, 11642
4966, 11179, 11202, 11203, 11180, 11690, 11691, 11692, 11644
4967, 11180, 11203, 11204, 11181, 11692, 11693, 11694, 11646
4968, 11181, 11204, 11205, 11182, 11694, 11695, 11696, 11648
4969, 11182, 11205, 11206, 11183, 11696, 11697, 11698, 11650
4970, 11183, 11206, 855, 854, 11698, 11699, 866, 11652
4971, 527, 528, 11207, 11184, 539, 11700, 11701, 11653
4972, 11184, 11207, 11208, 11185, 11701, 11702, 11703, 11655
4973, 11185, 11208, 11209, 11186, 11703, 11704, 11705, 11657
4974, 11186, 11209, 11210, 11187, 11705, 11706, 11707, 11659
4975, 11187, 11210, 11211, 11188, 11707, 11708, 11709, 11661
4976, 11188, 11211, 11212, 11189, 11709, 11710, 11711, 11663
4977, 11189, 11212, 11213, 11190, 11711, 11712, 11713, 11665
4978, 11190, 11213, 11214, 11191, 11713, 11714, 11715, 11667
4979, 11191, 11214, 11215, 11192, 11715, 11716, 11717, 11669
4980, 11192, 11215, 11216, 11193, 11717, 11718, 11719, 11671
4981, 11193, 11216, 11217, 11194, 11719, 11720, 11721, 11673
4982, 11194, 11217, 11218, 11195, 11721, 11722, 11723, 11675
4983, 11195, 11218, 11219, 11196, 11723, 11724, 11725, 11677
4984, 11196, 11219, 11220, 11197, 11725, 11726, 11727, 11679
4985, 11197, 11220, 11221, 11198, 11727, 11728, 11729, 11681
4986, 11198, 11221, 11222, 11199, 11729, 11730, 11731, 11683
4987, 11199, 11222, 11223, 11200, 11731, 11732, 11733, 11685
4988, 11200, 11223, 11224, 11201, 11733, 11734, 11735, 11687
4989, 11201, 11224, 11225, 11202, 11735, 11736, 11737, 11689
4990, 11202, 11225, 11226, 11203, 11737, 11738, 11739, 11691
4991, 11203, 11226, 11227, 11204, 11739, 11740, 11741, 11693
4992, 11204, 11227, 11228, 11205, 11741, 11742, 11743, 11695
4993, 11205, 11228, 11229, 11206, 11743, 11744, 11745, 11697
4994, 11206, 11229, 856, 855, 11745, 11746, 867, 11699
4995, 528, 12, 752, 11207, 540, 775, 11747, 11700
4996, 11207, 752, 753, 11208, 11747, 776, 11748, 11702
4997, 11208, 753, 754, 11209, 11748, 777, 11749, 11704
4998, 11209, 754, 755, 11210, 11749, 778, 11750, 11706
4999, 11210, 755, 756, 11211, 11750, 779, 11751, 11708
5000, 11211, 756, 757, 11212, 11751, 780, 11752, 11710
5001, 11212, 757, 758, 11213, 11752, 781, 11753, 11712
5002, 11213, 758, 759, 11214, 11753, 782, 11754, 11714
5003, 11214, 759, 760, 11215, 11754, 783, 11755, 11716
5004, 11215, 760, 761, 11216, 11755, 784, 11756, 11718
5005, 11216, 761, 762, 11217, 11756, 785, 11757, 11720
5006, 11217, 762, 763, 11218, 11757, 786, 11758, 11722
5007, 11218, 763, 764, 11219, 11758, 787, 11759, 11724
5008, 11219, 764, 765, 11220, 11759, 788, 11760, 11726
5009, 11220, 765, 766, 11221, 11760, 789, 11761, 11728
5010, 11221, 766, 767, 11222, 11761, 790, 11762, 11730
5011, 11222, 767, 768, 11223, 11762, 791, 11763, 11732
5012, 11223, 768, 769, 11224, 11763, 792, 11764, 11734
5013, 11224, 769, 770, 11225, 11764, 793, 11765, 11736
5014, 11225, 770, 771, 11226, 11765, 794, 11766, 11738
5015, 11226, 771, 772, 11227, 11766, 795, 11767, 11740
5016, 11227, 772, 773, 11228, 11767, 796, 11768, 11742
5017, 11228, 773, 774, 11229, 11768, 797, 11769, 11744
5018, 11229, 774, 16, 856, 11769, 798, 868, 11746
*ELEMENT, type=CPS8, ELSET=Surface16
5019, 14, 846, 11770, 635, 857, 12023, 12024, 658
5020, 846, 847, 11771, 11770, 858, 12025, 12026, 12023
5021, 847, 848, 11772, 11771, 859, 12027, 12028, 12025
5022, 848, 849, 11773, 11772, 860, 12029, 12030, 12027
5023, 849, 850, 11774, 11773, 861, 12031, 12032, 12029
5024, 850, 851, 11775, 11774, 862, 12033, 12034, 12031
5025, 851, 852, 11776, 11775, 863, 12035, 12036, 12033
5026, 852, 853, 11777, 11776, 864, 12037, 12038, 12035
5027, 853, 854, 11778, 11777, 865, 12039, 12040, 12037
5028, 854, 855, 11779, 11778, 866, 12041, 12042, 12039
5029, 855, 856, 11780, 11779, 867, 12043, 12044, 12041
5030, 856, 16, 799, 11780, 868, 822, 12045, 12043
5031, 635, 11770, 11781, 636, 12024, 12046, 12047, 659
5032, 11770, 11771, 11782, 11781, 12026, 12048, 12049, 12046
5033, 11771, 11772, 11783, 11782, 12028, 12050, 12051, 12048
5034, 11772, 11773, 11784, 11783, 12030, 12052, 12053, 12050
5035, 11773, 11774, 11785, 11784, 12032, 12054, 12055, 12052
5036, 11774, 11775, 11786, 11785, 12034, 12056, 12057, 12054
5037, 11775, 11776, 11787, 11786, 12036, 12058, 12059, 12056
5038, 11776, 11777, 11788, 11787, 12038, 12060, 12061, 12058
5039, 11777, 11778, 11789, 11788, 12040, 12062, 12063, 12060
5040, 11778, 11779, 11790, 11789, 12042, 12064, 12065, 12062
5041, 11779, 11780, 11791, 11790, 12044, 12066, 12067, 12064
5042, 11780, 799, 800, 11791, 12045, 823, 12068, 12066
5043, 636, 11781, 11792, 637, 12047, 12069, 12070, 660
5044, 11781, 11782, 11793, 11792, 12049, 12071, 12072, 12069
5045, 11782, 11783, 11794, 11793, 12051, 12073, 12074, 12071
5046, 11783, 11784, 11795, 11794, 12053, 12075, 12076, 12073
5047, 11784, 11785, 11796, 11795, 12055, 12077, 12078, 12075
5048, 11785, 11786, 11797, 11796, 12057, 12079, 12080, 12077
5049, 11786, 11787, 11798, 11797, 12059, 12081, 12082, 12079
5050, 11787, 11788, 11799, 11798, 12061, 12083, 12084, 12081
5051, 11788, 11789, 11800, 11799, 12063, 12085, 12086, 12083
5052, 11789, 11790, 11801, 11800, 12065, 12087, 12088, 12085
5053, 11790, 11791, 11802, 11801, 12067, 12089, 12090, 12087
5054, 11791, 800, 801, 11802, 12068, 824, 12091, 12089
5055, 637, 11792, 11803, 638, 12070, 12092, 12093, 661
5056, 11792, 11793, 11804, 11803, 12072, 12094, 12095, 12092
5057, 11793, 11794, 11805, 11804, 12074, 12096, 12097, 12094
5058, 11794, 11795, 11806, 11805, 12076, 12098, 12099, 12096
5059, 11795, 11796, 11807, 11806, 12078, 12100, 12101, 12098
5060, 11796, 11797, 11808, 11807, 12080, 12102, 12103, 12100
5061, 11797, 11798, 11809, 11808, 12082, 12104, 12105, 12102
5062, 11798, 11799, 11810, 11809, 12084, 12106, 12107, 12104
5063, 11799, 11800, 11811, 11810, 12086, 12108, 12109, 12106
5064, 11800, 11801, 11812, 11811, 12088, 12110, 12111, 12108
5065, 11801, 11802, 11813, 11812, 12090, 12112, 12113, 12110
5066, 11802, 801, 802, 11813, 12091, 825, 12114, 12112
5067, 638, 11803, 11814, 639, 12093, 12115, 12116, 662
5068, 11803, 11804, 11815, 11814, 12095, 12117, 12118, 12115
5069, 11804, 11805, 11816, 11815, 12097, 12119, 12120, 12117
5070, 11805, 11806, 11817, 11816, 12099, 12121, 12122, 12119
5071, 11806, 11807, 11818, 11817, 12101, 12123, 12124, 12121
5072, 11807, 11808, 11819, 11818, 12103, 12125, 12126, 12123
5073, 11808, 11809, 11820, 11819, 12105, 12127, 12128, 12125
5074, 11809, 11810, 11821, 11820, 12107, 12129, 12130, 12127
5075, 11810, 11811, 11822, 11821, 12109, 12131, 12132, 12129
5076, 11811, 11812, 11823, 11822, 12111, 12133, 12134, 12131
5077, 11812, 11813, 11824, 11823, 12113, 12135, 12136, 12133
5078, 11813, 802, 803, 11824, 12114, 826, 12137, 12135
5079, 639, 11814, 11825, 640, 12116, 12138, 12139, 663
5080, 11814, 11815, 11826, 11825, 12118, 12140, 12141, 12138
5081, 11815, 11816, 11827, 11826, 12120, 12142, 12143, 12140
5082, 11816, 11817, 11828, 11827, 12122, 12144, 12145, 12142
5083, 11817, 11818, 11829, 11828, 12124, 12146, 12147, 12144
5084, 11818, 11819, 11830, 11829, 12126, 12148, 12149, 12146
5085, 11819, 11820, 11831, 11830, 12128, 12150, 12151, 12148
5086, 11820, 11821, 11832, 11831, 12130, 12152, 12153, 12150
5087, 11821, 11822, 11833, 11832, 12132, 12154, 12155, 12152
5088, 11822, 11823, 11834, 11833, 12134, 12156, 12157, 12154
5089, 11823, 11824, 11835, 11834, 12136, 12158, 12159, 12156
5090, 11824, 803, 804, 11835, 12137, 827, 12160, 12158
5091, 640, 11825, 11836, 641, 12139, 12161, 12162, 664
5092, 11825, 11826, 11837, 11836, 12141, 12163, 12164, 12161
5093, 11826, 11827, 11838, 11837, 12143, 12165, 12166, 12163
5094, 11827, 11828, 11839, 11838, 12145, 12167, 12168, 12165
5095, 11828, 11829, 11840, 11839, 12147, 12169, 12170, 12167
5096, 11829, 11830, 11841, 11840, 12149, 12171, 12172, 12169
5097, 11830, 11831, 11842, 11841, 12151, 12173, 12174, 12171
5098, 11831, 11832, 11843, 11842, 12153, 12175, 12176, 12173
5099, 11832, 11833, 11844, 11843, 12155, 12177, 12178, 12175
5100, 11833, 11834, 11845, 11844, 12157, 12179, 12180, 12177
5101, 11834, 11835, 11846, 11845, 12159, 12181, 12182, 12179
5102, 11835, 804, 805, 11846, 12160, 828, 12183, 12181
5103, 641, 11836, 11847, 642, 12162, 12184, 12185, 665
5104, 11836, 11837, 11848, 11847, 12164, 12186, 12187, 12184
5105, 11837, 11838, 11849, 11848, 12166, 12188, 12189, 12186
5106, 11838, 11839, 11850, 11849, 12168, 12190, 12191, 12188
5107, 11839, 11840, 11851, 11850, 12170, 12192, 12193, 12190
5108, 11840, 11841, 11852, 11851, 12172, 12194, 12195, 12192
5109, 11841, 11842, 11853, 11852, 12174, 12196, 12197, 12194
5110, 11842, 11843, 11854, 11853, 12176, 12198, 12199, 12196
5111, 11843, 11844, 11855, 11854, 12178, 12200, 12201, 12198
5112, 11844, 11845, 11856, 11855, 12180, 12202, 12203, 12200
5113, 11845, 11846, 11857, 11856, 12182, 12204, 12205, 12202
5114, 11846, 805, 806, 11857, 12183, 829, 12206, 12204
5115, 642, 11847, 11858, 643, 12185, 12207, 12208, 666
5116, 11847, 11848, 11859, 11858, 12187, 12209, 12210, 12207
5117, 11848, 11849, 11860, 11859, 12189, 12211, 12212, 12209
5118, 11849, 11850, 11861, 11860, 12191, 12213, 12214, 12211
5119, 11850, 11851, 11862, 11861, 12193, 12215, 12216, 12213
5120, 11851, 11852, 11863, 11862, 12195, 12217, 12218, 12215
5121, 11852, 11853, 11864, 11863, 12197, 12219, 12220, 12217
5122, 11853, 11854, 11865, 11864, 12199, 12221, 12222, 12219
5123, 11854, 11855, 11866, 11865, 12201, 12223, 12224, 12221
5124, 11855, 11856, 11867, 11866, 12203, 12225, 12226, 12223
5125, 11856, 11857, 11868, 11867, 12205, 12227, 12228, 12225
5126, 11857, 806, 807, 11868, 12206, 830, 12229, 12227
5127, 643, 11858, 11869, 644, 12208, 12230, 12231, 667
5128, 11858, 11859, 11870, 11869, 12210, 12232, 12233, 12230
5129, 11859, 11860, 11871, 11870, 12212, 12234, 12235, 12232
5130, 11860, 11861, 11872, 11871, 12214, 12236, 12237, 12234
5131, 11861, 11862, 11873, 11872, 12216, 12238, 12239, 12236
5132, 11862, 11863, 11874, 11873, 12218, 12240, 12241, 12238
5133, 11863, 11864, 11875, 11874, 12220, 12242, 12243, 12240
5134, 11864, 11865, 11876, 11875, 12222, 12244, 12245, 12242
5135, 11865, 11866, 11877, 11876, 12224, 12246, 12247, 12244
5136, 11866, 11867, 11878, 11877, 12226, 12248, 12249, 12246
5137, 11867, 11868, 11879, 11878, 12228, 12250, 12251, 12248
5138, 11868, 807, 808, 11879, 12229, 831, 12252, 12250
5139, 644, 11869, 11880, 645, 12231, 12253, 12254, 668
5140, 11869, 11870, 11881, 11880, 12233, 12255, 12256, 12253
5141, 11870, 11871, 11882, 11881, 12235, 12257, 12258, 12255
5142, 11871, 11872, 11883, 11882, 12237, 12259, 12260, 12257
5143, 11872, 11873, 11884, 11883, 12239, 12261, 12262, 12259
5144, 11873, 11874, 11885, 11884, 12241, 12263, 12264, 12261
5145, 11874, 11875, 11886, 11885, 12243, 12265, 12266, 12263
5146, 11875, 11876, 11887, 11886, 12245, 12267, 12268, 12265
5147, 11876, 11877, 11888, 11887, 12247, 12269, 12270, 12267
5148, 11877, 11878, 11889, 11888, 12249, 12271, 12272, 12269
5149, 11878, 11879, 11890, 11889, 12251, 12273, 12274, 12271
5150, 11879, 808, 809, 11890, 12252, 832, 12275, 12273
5151, 645, 11880, 11891, 646, 12254, 12276, 12277, 669
5152, 11880, 11881, 11892, 11891, 12256, 12278, 12279, 12276
5153, 11881, 11882, 11893, 11892, 12258, 12280, 12281, 12278
5154, 11882, 11883, 11894, 11893, 12260, 12282, 12283, 12280
5155, 11883, 11884, 11895, 11894, 12262, 12284, 12285, 12282
5156, 11884, 11885, 11896, 11895, 12264, 12286, 12287, 12284
5157, 11885, 11886, 11897, 11896, 12266, 12288, 12289, 12286
5158, 11886, 11887, 11898, 11897, 12268, 12290, 12291, 12288
5159, 11887, 11888, 11899, 11898, 12270, 12292, 12293, 12290
5160, 11888, 11889, 11900, 11899, 12272, 12294, 12295, 12292
5161, 11889, 11890, 11901, 11900, 12274, 12296, 12297, 12294
5162, 11890, 809, 810, 11901, 12275, 833, 12298, 12296
5163, 646, 11891, 11902, 647, 12277, 12299, 12300, 670
5164, 11891, 11892, 11903, 11902, 12279, 12301, 12302, 12299
5165, 11892, 11893, 11904, 11903, 12281, 12303, 12304, 12301
5166, 11893, 11894, 11905, 11904, 12283, 12305, 12306, 12303
5167, 11894, 11895, 11906, 11905, 12285, 12307, 12308, 12305
5168, 11895, 11896, 11907, 11906, 12287, 12309, 12310, 12307
5169, 11896, 11897, 11908, 11907, 12289, 12311, 12312, 12309
5170, 11897, 11898, 11909, 11908, 12291, 12313, 12314, 12311
5171, 11898, 11899, 11910, 11909, 12293, 12315, 12316, 12313
5172, 11899, 11900, 11911, 11910, 12295, 12317, 12318, 12315
5173, 11900, 11901, 11912, 11911, 12297, 12319, 12320, 12317
5174, 11901, 810, 811, 11912, 12298, 834, 12321, 12319
5175, 647, 11902, 11913, 648, 12300, 12322, 12323, 671
5176, 11902, 11903, 11914, 11913, 12302, 12324, 12325, 12322
5177, 11903, 11904, 11915, 11914, 12304, 12326, 12327, 12324
5178, 11904, 11905, 11916, 11915, 12306, 12328, 12329, 12326
5179, 11905, 11906, 11917, 11916, 12308, 12330, 12331, 12328
5180, 11906, 11907, 11918, 11917, 12310, 12332, 12333, 12330
5181, 11907, 11908, 11919, 11918, 12312, 12334, 12335, 12332
5182, 11908, 11909, 11920, 11919, 12314, 12336, 12337, 12334
5183, 11909, 11910, 11921, 11920, 12316, 12338, 12339, 12336
5184, 11910, 11911, 11922, 11921, 12318, 12340, 12341, 12338
5185, 11911, 11912, 11923, 11922, 12320, 12342, 12343, 12340
5186, 11912, 811, 812, 11923, 12321, 835, 12344, 12342
5187, 648, 11913, 11924, 649, 12323, 12345, 12346, 672
5188, 11913, 11914, 11925, 11924, 12325, 12347, 12348, 12345
5189, 11914, 11915, 11926, 11925, 12327, 12349, 12350, 12347
5190, 11915, 11916, 11927, 11926, 12329, 12351, 12352, 12349
5191, 11916, 11917, 11928, 11927, 12331, 12353, 12354, 12351
5192, 11917, 11918, 11929, 11928, 12333, 12355, 12356, 12353
5193, 11918, 11919, 11930, 11929, 12335, 12357, 12358, 12355
5194, 11919, 11920, 11931, 11930, 12337, 12359, 12360, 12357
5195, 11920, 11921, 11932, 11931, 12339, 12361, 12362, 12359
5196, 11921, 11922, 11933, 11932, 12341, 12363, 12364, 12361
5197, 11922, 11923, 11934, 11933, 12343, 12365, 12366, 12363
5198, 11923, 812, 813, 11934, 12344, 836, 12367, 12365
5199, 649, 11924, 11935, 650, 12346, 12368, 12369, 673
5200, 11924, 11925, 11936, 11935, 12348, 12370, 12371, 12368
5201, 11925, 11926, 11937, 11936, 12350, 12372, 12373, 12370
5202, 11926, 11927, 11938, 11937, 12352, 12374, 12375, 12372
5203, 11927, 11928, 11939, 11938, 12354, 12376, 12377, 12374
5204, 11928, 11929, 11940, 11939, 12356, 12378, 12379, 12376
5205, 11929, 11930, 11941, 11940, 12358, 12380, 12381, 12378
5206, 11930, 11931, 11942, 11941, 12360, 12382, 12383, 12380
5207, 11931, 11932, 11943, 11942, 12362, 12384, 12385, 12382
5208, 11932, 11933, 11944, 11943, 12364, 12386, 12387, 12384
5209, 11933, 11934, 11945, 11944, 12366, 12388, 12389, 12386
5210, 11934, 813, 814, 11945, 12367, 837, 12390, 12388
5211, 650, 11935, 11946, 651, 12369, 12391, 12392, 674
5212, 11935, 11936, 11947, 11946, 12371, 12393, 12394, 12391
5213, 11936, 11937, 11948, 11947, 12373, 12395, 12396, 12393
5214, 11937, 11938, 11949, 11948, 12375, 12397, 12398, 12395
5215, 11938, 11939, 11950, 11949, 12377, 12399, 12400, 12397
5216, 11939, 11940, 11951, 11950, 12379, 12401, 12402, 12399
5217, 11940, 11941, 11952, 11951, 12381, 12403, 12404, 12401
5218, 11941, 11942, 11953, 11952, 12383, 12405, 12406, 12403
5219, 11942, 11943, 11954, 11953, 12385, 12407, 12408, 12405
5220, 11943, 11944, 11955, 11954, 12387, 12409, 12410, 12407
5221, 11944, 11945, 11956, 11955, 12389, 12411, 12412, 12409
5222, 11945, 814, 815, 11956, 12390, 838, 12413, 12411
5223, 651, 11946, 11957, 652, 12392, 12414, 12415, 675
5224, 11946, 11947, 11958, 11957, 12394, 12416, 12417, 12414
5225, 11947, 11948, 11959, 11958, 12396, 12418, 12419, 12416
5226, 11948, 11949, 11960, 11959, 12398, 12420, 12421, 12418
5227, 11949, 11950, 11961, 11960, 12400, 12422, 12423, 12420
5228, 11950, 11951, 11962, 11961, 12402, 12424, 12425, 12422
5229, 11951, 11952, 11963, 11962, 12404, 12426, 12427, 12424
5230, 11952, 11953, 11964, 11963, 12406, 12428, 12429, 12426
5231, 11953, 11954, 11965, 11964, 12408, 12430, 12431, 12428
5232, 11954, 11955, 11966, 11965, 12410, 12432, 12433, 12430
5233, 11955, 11956, 11967, 11966, 12412, 12434, 12435, 12432
5234, 11956, 815, 816, 11967, 12413, 839, 12436, 12434
5235, 652, 11957, 11968, 653, 12415, 12437, 12438, 676
5236, 11957, 11958, 11969, 11968, 12417, 12439, 12440, 12437
5237, 11958, 11959, 11970, 11969, 12419, 12441, 12442, 12439
5238, 11959, 11960, 11971, 11970, 12421, 12443, 12444, 12441
5239, 11960, 11961, 11972, 11971, 12423, 12445, 12446, 12443
5240, 11961, 11962, 11973, 11972, 12425, 12447, 12448, 12445
5241, 11962, 11963, 11974, 11973, 12427, 12449, 12450, 12447
5242, 11963, 11964, 11975, 11974, 12429, 12451, 12452, 12449
5243, 11964, 11965, 11976, 11975, 12431, 12453, 12454, 12451
5244, 11965, 11966, 11977, 11976, 12433, 12455, 12456, 12453
5245, 11966, 11967, 11978, 11977, 12435, 12457, 12458, 12455
5246, 11967, 816, 817, 11978, 12436, 840, 12459, 12457
5247, 653, 11968, 11979, 654, 12438, 12460, 12461, 677
5248, 11968, 11969, 11980, 11979, 12440, 12462, 12463, 12460
5249, 11969, 11970, 11981, 11980, 12442, 12464, 12465, 12462
5250, 11970, 11971, 11982, 11981, 12444, 12466, 12467, 12464
5251, 11971, 11972, 11983, 11982, 12446, 12468, 12469, 12466
5252, 11972, 11973, 11984, 11983, 12448, 12470, 12471, 12468
5253, 11973, 11974, 11985, 11984, 12450, 12472, 12473, 12470
5254, 11974, 11975, 11986, 11985, 12452, 12474, 12475, 12472
5255, 11975, 11976, 11987, 11986, 12454, 12476, 12477, 12474
5256, 11976, 11977, 11988, 11987, 12456, 12478, 12479, 12476
5257, 11977, 11978, 11989, 11988, 12458, 12480, 12481, 12478
5258, 11978, 817, 818, 11989, 12459, 841, 12482, 12480
5259, 654, 11979, 11990, 655, 12461, 12483, 12484, 678
5260, 11979, 11980, 11991, 11990, 12463, 12485, 12486, 12483
5261, 11980, 11981, 11992, 11991, 12465, 12487, 12488, 12485
5262, 11981, 11982, 11993, 11992, 12467, 12489, 12490, 12487
5263, 11982, 11983, 11994, 11993, 12469, 12491, 12492, 12489
5264, 11983, 11984, 11995, 11994, 12471, 12493, 12494, 12491
5265, 11984, 11985, 11996, 11995, 12473, 12495, 12496, 12493
5266, 11985, 11986, 11997, 11996, 12475, 12497, 12498, 12495
5267, 11986, 11987, 11998, 11997, 12477, 12499, 12500, 12497
5268, 11987, 11988, 11999, 11998, 12479, 12501, 12502, 12499
5269, 11988, 11989, 12000, 11999, 12481, 12503, 12504, 12501
5270, 11989, 818, 819, 12000, 12482, 842, 12505, 12503
5271, 655, 11990, 12001, 656, 12484, 12506, 12507, 679
5272, 11990, 11991, 12002, 12001, 12486, 12508, 12509, 12506
5273, 11991, 11992, 12003, 12002, 12488, 12510, 12511, 12508
5274, 11992, 11993, 12004, 12003, 12490, 12512, 12513, 12510
5275, 11993, 11994, 12005, 12004, 12492, 12514, 12515, 12512
5276, 11994, 11995, 12006, 12005, 12494, 12516, 12517, 12514
5277, 11995, 11996, 12007, 12006, 12496, 12518, 12519, 12516
5278, 11996, 11997, 12008, 12007, 12498, 12520, 12521, 12518
5279, 11997, 11998, 12009, 12008, 12500, 12522, 12523, 12520
5280, 11998, 11999, 12010, 12009, 12502, 12524, 12525, 12522
5281, 11999, 12000, 12011, 12010, 12504, 12526, 12527, 12524
5282, 12000, 819, 820, 12011, 12505, 843, 12528, 12526
5283, 656, 12001, 12012, 657, 12507, 12529, 12530, 680
5284, 12001, 12002, 12013, 12012, 12509, 12531, 12532, 12529
5285, 12002, 12003, 12014, 12013, 12511, 12533, 12534, 12531
5286, 12003, 12004, 12015, 12014, 12513, 12535, 12536, 12533
5287, 12004, 12005, 12016, 12015, 12515, 12537, 12538, 12535
5288, 12005, 12006, 12017, 12016, 12517, 12539, 12540, 12537
5289, 12006, 12007, 12018, 12017, 12519, 12541, 12542, 12539
5290, 12007, 12008, 12019, 12018, 12521, 12543, 12544, 12541
5291, 12008, 12009, 12020, 12019, 12523, 12545, 12546, 12543
5292, 12009, 12010, 12021, 12020, 12525, 12547, 12548, 12545
5293, 12010, 12011, 12022, 12021, 12527, 12549, 12550, 12547
5294, 12011, 820, 821, 12022, 12528, 844, 12551, 12549
5295, 657, 12012, 729, 13, 12530, 12552, 740, 681
5296, 12012, 12013, 730, 729, 12532, 12553, 741, 12552
5297, 12013, 12014, 731, 730, 12534, 12554, 742, 12553
5298, 12014, 12015, 732, 731, 12536, 12555, 743, 12554
5299, 12015, 12016, 733, 732, 12538, 12556, 744, 12555
5300, 12016, 12017, 734, 733, 12540, 12557, 745, 12556
5301, 12017, 12018, 735, 734, 12542, 12558, 746, 12557
5302, 12018, 12019, 736, 735, 12544, 12559, 747, 12558
5303, 12019, 12020, 737, 736, 12546, 12560, 748, 12559
5304, 12020, 12021, 738, 737, 12548, 12561, 749, 12560
5305, 12021, 12022, 739, 738, 12550, 12562, 750, 12561
5306, 12022, 821, 15, 739, 12551, 845, 751, 12562
*ELEMENT, type=CPS8, ELSET=Surface17
5307, 14, 18, 871, 635, 870, 894, 12563, 658
5308, 635, 871, 872, 636, 12563, 895, 12564, 659
5309, 636, 872, 873, 637, 12564, 896, 12565, 660
5310, 637, 873, 874, 638, 12565, 897, 12566, 661
5311, 638, 874, 875, 639, 12566, 898, 12567, 662
5312, 639, 875, 876, 640, 12567, 899, 12568, 663
5313, 640, 876, 877, 641, 12568, 900, 12569, 664
5314, 641, 877, 878, 642, 12569, 901, 12570, 665
5315, 642, 878, 879, 643, 12570, 902, 12571, 666
5316, 643, 879, 880, 644, 12571, 903, 12572, 667
5317, 644, 880, 881, 645, 12572, 904, 12573, 668
5318, 645, 881, 882, 646, 12573, 905, 12574, 669
5319, 646, 882, 883, 647, 12574, 906, 12575, 670
5320, 647, 883, 884, 648, 12575, 907, 12576, 671
5321, 648, 884, 885, 649, 12576, 908, 12577, 672
5322, 649, 885, 886, 650, 12577, 909, 12578, 673
5323, 650, 886, 887, 651, 12578, 910, 12579, 674
5324, 651, 887, 888, 652, 12579, 911, 12580, 675
5325, 652, 888, 889, 653, 12580, 912, 12581, 676
5326, 653, 889, 890, 654, 12581, 913, 12582, 677
5327, 654, 890, 891, 655, 12582, 914, 12583, 678
5328, 655, 891, 892, 656, 12583, 915, 12584, 679
5329, 656, 892, 893, 657, 12584, 916, 12585, 680
5330, 657, 893, 17, 13, 12585, 917, 869, 681
*ELEMENT, type=CPS8, ELSET=Surface18
5331, 13, 17, 919, 729, 869, 930, 12586, 740
5332, 729, 919, 920, 730, 12586, 931, 12587, 741
5333, 730, 920, 921, 731, 12587, 932, 12588, 742
5334, 731, 921, 922, 732, 12588, 933, 12589, 743
5335, 732, 922, 923, 733, 12589, 934, 12590, 744
5336, 733, 923, 924, 734, 12590, 935, 12591, 745
5337, 734, 924, 925, 735, 12591, 936, 12592, 746
5338, 735, 925, 926, 736, 12592, 937, 12593, 747
5339, 736, 926, 927, 737, 12593, 938, 12594, 748
5340, 737, 927, 928, 738, 12594, 939, 12595, 749
5341, 738, 928, 929, 739, 12595, 940, 12596, 750
5342, 739, 929, 19, 15, 12596, 941, 918, 751
*ELEMENT, type=CPS8, ELSET=Surface19
5343, 16, 799, 943, 20, 822, 12597, 966, 942
5344, 799, 800, 944, 943, 823, 12598, 967, 12597
5345, 800, 801, 945, 944, 824, 12599, 968, 12598
5346, 801, 802, 946, 945, 825, 12600, 969, 12599
5347, 802, 803, 947, 946, 826, 12601, 970, 12600
5348, 803, 804, 948, 947, 827, 12602, 971, 12601
5349, 804, 805, 949, 948, 828, 12603, 972, 12602
5350, 805, 806, 950, 949, 829, 12604, 973, 12603
5351, 806, 807, 951, 950, 830, 12605, 974, 12604
5352, 807, 808, 952, 951, 831, 12606, 975, 12605
5353, 808, 809, 953, 952, 832, 12607, 976, 12606
5354, 809, 810, 954, 953, 833, 12608, 977, 12607
5355, 810, 811, 955, 954, 834, 12609, 978, 12608
5356, 811, 812, 956, 955, 835, 12610, 979, 12609
5357, 812, 813, 957, 956, 836, 12611, 980, 12610
5358, 813, 814, 958, 957, 837, 12612, 981, 12611
5359, 814, 815, 959, 958, 838, 12613, 982, 12612
5360, 815, 816, 960, 959, 839, 12614, 983, 12613
5361, 816, 817, 961, 960, 840, 12615, 984, 12614
5362, 817, 818, 962, 961, 841, 12616, 985, 12615
5363, 818, 819, 963, 962, 842, 12617, 986, 12616
5364, 819, 820, 964, 963, 843, 12618, 987, 12617
5365, 820, 821, 965, 964, 844, 12619, 988, 12618
5366, 821, 15, 19, 965, 845, 918, 989, 12619
*ELEMENT, type=CPS8, ELSET=Surface20
5367, 14, 846, 990, 18, 857, 12620, 1001, 870
5368, 846, 847, 991, 990, 858, 12621, 1002, 12620
5369, 847, 848, 992, 991, 859, 12622, 1003, 12621
5370, 848, 849, 993, 992, 860, 12623, 1004, 12622
5371, 849, 850, 994, 993, 861, 12624, 1005, 12623
5372, 850, 851, 995, 994, 862, 12625, 1006, 12624
5373, 851, 852, 996, 995, 863, 12626, 1007, 12625
5374, 852, 853, 997, 996, 864, 12627, 1008, 12626
5375, 853, 854, 998, 997, 865, 12628, 1009, 12627
5376, 854, 855, 999, 998, 866, 12629, 1010, 12628
5377, 855, 856, 1000, 999, 867, 12630, 1011, 12629
5378, 856, 16, 20, 1000, 868, 942, 1012, 12630
*ELEMENT, type=CPS8, ELSET=Surface21
5379, 18, 990, 12631, 871, 1001, 12884, 12885, 894
5380, 990, 991, 12632, 12631, 1002, 12886, 12887, 12884
5381, 991, 992, 12633, 12632, 1003, 12888, 12889, 12886
5382, 992, 993, 12634, 12633, 1004, 12890, 12891, 12888
5383, 993, 994, 12635, 12634, 1005, 12892, 12893, 12890
5384, 994, 995, 12636, 12635, 1006, 12894, 12895, 12892
5385, 995, 996, 12637, 12636, 1007, 12896, 12897, 12894
5386, 996, 997, 12638, 12637, 1008, 12898, 12899, 12896
5387, 997, 998, 12639, 12638, 1009, 12900, 12901, 12898
5388, 998, 999, 12640, 12639, 1010, 12902, 12903, 12900
5389, 999, 1000, 12641, 12640, 1011, 12904, 12905, 12902
5390, 1000, 20, 943, 12641, 1012, 966, 12906, 12904
5391, 871, 12631, 12642, 872, 12885, 12907, 12908, 895
5392, 12631, 12632, 12643, 12642, 12887, 12909, 12910, 12907
5393, 12632, 12633, 12644, 12643, 12889, 12911, 12912, 12909
5394, 12633, 12634, 12645, 12644, 12891, 12913, 12914, 12911
5395, 12634, 12635, 12646, 12645, 12893, 12915, 12916, 12913
5396, 12635, 12636, 12647, 12646, 12895, 12917, 12918, 12915
5397, 12636, 12637, 12648, 12647, 12897, 12919, 12920, 12917
5398, 12637, 12638, 12649, 12648, 12899, 12921, 12922, 12919
5399, 12638, 12639, 12650, 12649, 12901, 12923, 12924, 12921
5400, 12639, 12640, 12651, 12650, 12903, 12925, 12926, 12923
5401, 12640, 12641, 12652, 12651, 12905, 12927, 12928, 12925
5402, 12641, 943, 944, 12652, 12906, 967, 12929, 12927
5403, 872, 12642, 12653, 873, 12908, 12930, 12931, 896
5404, 12642, 12643, 12654, 12653, 12910, 12932, 12933, 12930
5405, 12643, 12644, 12655, 12654, 12912, 12934, 12935, 12932
5406, 12644, 12645, 12656, 12655, 12914, 12936, 12937, 12934
5407, 12645, 12646, 12657, 12656, 12916, 12938, 12939, 12936
5408, 12646, 12647, 12658, 12657, 12918, 12940, 12941, 12938
5409, 12647, 12648, 12659, 12658, 12920, 12942, 12943, 12940
5410, 12648, 12649, 12660, 12659, 12922, 12944, 12945, 12942
5411, 12649, 12650, 12661, 12660, 12924, 12946, 12947, 12944
5412, 12650, 12651, 12662, 12661, 12926, 12948, 12949, 12946
5413, 12651, 12652, 12663, 12662, 12928, 12950, 12951, 12948
5414, 12652, 944, 945, 12663, 12929, 968, 12952, 12950
5415, 873, 12653, 12664, 874, 12931, 12953, 12954, 897
5416, 12653, 12654, 12665, 12664, 12933, 12955, 12956, 12953
5417, 12654, 12655, 12666, 12665, 12935, 12957, 12958, 12955
5418, 12655, 12656, 12667, 12666, 12937, 12959, 12960, 12957
5419, 12656, 12657, 12668, 12667, 12939, 12961, 12962, 12959
5420, 12657, 12658, 12669, 12668, 12941, 12963, 12964, 12961
5421, 12658, 12659, 12670, 12669, 12943, 12965, 12966, 12963
5422, 12659, 12660, 12671, 12670, 12945, 12967, 12968, 12965
5423, 12660, 12661, 12672, 12671, 12947, 12969, 12970, 12967
5424, 12661, 12662, 12673, 12672, 12949, 12971, 12972, 12969
5425, 12662, 12663, 12674, 12673, 12951, 12973, 12974, 12971
5426, 12663, 945, 946, 12674, 12952, 969, 12975, 12973
5427, 874, 12664, 12675, 875, 12954, 12976, 12977, 898
5428, 12664, 12665, 12676, 12675, 12956, 12978, 12979, 12976
5429, 12665, 12666, 12677, 12676, 12958, 12980, 12981, 12978
5430, 12666, 12667, 12678, 12677, 12960, 12982, 12983, 12980
5431, 12667, 12668, 12679, 12678, 12962, 12984, 12985, 12982
5432, 12668, 12669, 12680, 12679, 12964, 12986, 12987, 12984
5433, 12669, 12670, 12681, 12680, 12966, 12988, 12989, 12986
5434, 12670, 12671, 12682, 12681, 12968, 12990, 12991, 12988
5435, 12671, 12672, 12683, 12682, 12970, 12992, 12993, 12990
5436, 12672, 12673, 12684, 12683, 12972, 12994, 12995, 12992
5437, 12673, 12674, 12685, 12684, 12974, 12996, 12997, 12994
5438, 12674, 946, 947, 12685, 12975, 970, 12998, 12996
5439, 875, 12675, 12686, 876, 12977, 12999, 13000, 899
5440, 12675, 12676, 12687, 12686, 12979, 13001, 13002, 12999
5441, 12676, 12677, 12688, 12687, 12981, 13003, 13004, 13001
5442, 12677, 12678, 12689, 12688, 12983, 13005, 13006, 13003
5443, 12678, 12679, 12690, 12689, 12985, 13007, 13008, 13005
5444, 12679, 12680, 12691, 12690, 12987, 13009, 13010, 13007
5445, 12680, 12681, 12692, 12691, 12989, 13011, 13012, 13009
5446, 12681, 12682, 12693, 12692, 12991, 13013, 13014, 13011
5447, 12682, 12683, 12694, 12693, 12993, 13015, 13016, 13013
5448, 12683, 12684, 12695, 12694, 12995, 13017, 13018, 13015
5449, 12684, 12685, 12696, 12695, 12997, 13019, 13020, 13017
5450, 12685, 947, 948, 12696, 12998, 971, 13021, 13019
5451, 876, 12686, 12697, 877, 13000, 13022, 13023, 900
5452, 12686, 12687, 12698, 12697, 13002, 13024, 13025, 13022
5453, 12687, 12688, 12699, 12698, 13004, 13026, 13027, 13024
5454, 12688, 12689, 12700, 12699, 13006, 13028, 13029, 13026
5455, 12689, 12690, 12701, 12700, 13008, 13030, 13031, 13028
5456, 12690, 12691, 12702, 12701, 13010, 13032, 13033, 13030
5457, 12691, 12692, 12703, 12702, 13012, 13034, 13035, 13032
5458, 12692, 12693, 12704, 12703, 13014, 13036, 13037, 13034
5459, 12693, 12694, 12705, 12704, 13016, 13038, 13039, 13036
5460, 12694, 12695, 12706, 12705, 13018, 13040, 13041, 13038
5461, 12695, 12696, 12707, 12706, 13020, 13042, 13043, 13040
5462, 12696, 948, 949, 12707, 13021, 972, 13044, 13042
5463, 877, 12697, 12708, 878, 13023, 13045, 13046, 901
5464, 12697, 12698, 12709, 12708, 13025, 13047, 13048, 13045
5465, 12698, 12699, 12710, 12709, 13027, 13049, 13050, 13047
5466, 12699, 12700, 12711, 12710, 13029, 13051, 13052, 13049
5467, 12700, 12701, 12712, 12711, 13031, 13053, 13054, 13051
5468, 12701, 12702, 12713, 12712, 13033, 13055, 13056, 13053
5469, 12702, 12703, 12714, 12713, 13035, 13057, 13058, 13055
5470, 12703, 12704, 12715, 12714, 13037, 13059, 13060, 13057
5471, 12704, 12705, 12716, 12715, 13039, 13061, 13062, 13059
5472, 12705, 12706, 12717, 12716, 13041, 13063, 13064, 13061
5473, 12706, 12707, 12718, 12717, 13043, 13065, 13066, 13063
5474, 12707, 949, 950, 12718, 13044, 973, 13067, 13065
5475, 878, 12708, 12719, 879, 13046, 13068, 13069, 902
5476, 12708, 12709, 12720, 12719, 13048, 13070, 13071, 13068
5477, 12709, 12710, 12721, 12720, 13050, 13072, 13073, 13070
5478, 12710, 12711, 12722, 12721, 13052, 13074, 13075, 13072
5479, 12711, 12712, 12723, 12722, 13054, 13076, 13077, 13074
5480, 12712, 12713, 12724, 12723, 13056, 13078, 13079, 13076
5481, 12713, 12714, 12725, 12724, 13058, 13080, 13081, 13078
5482, 12714, 12715, 12726, 12725, 13060, 13082, 13083, 13080
5483, 12715, 12716, 12727, 12726, 13062, 13084, 13085, 13082
5484, 12716, 12717, 12728, 12727, 13064, 13086, 13087, 13084
5485, 12717, 12718, 12729, 12728, 13066, 13088, 13089, 13086
5486, 12718, 950, 951, 12729, 13067, 974, 13090, 13088
5487, 879, 12719, 12730, 880, 13069, 13091, 13092, 903
5488, 12719, 12720, 12731, 12730, 13071, 13093, 13094, 13091
5489, 12720, 12721, 12732, 12731, 13073, 13095, 13096, 13093
5490, 12721, 12722, 12733, 12732, 13075, 13097, 13098, 13095
5491, 12722, 12723, 12734, 12733, 13077, 13099, 13100, 13097
5492, 12723, 12724, 12735, 12734, 13079, 13101, 13102, 13099
5493, 12724, 12725, 12736, 12735, 13081, 13103, 13104, 13101
5494, 12725, 12726, 12737, 12736, 13083, 13105, 13106, 13103
5495, 12726, 12727, 12738, 12737, 13085, 13107, 13108, 13105
5496, 12727, 12728, 12739, 12738, 13087, 13109, 13110, 13107
5497, 12728, 12729, 12740, 12739, 13089, 13111, 13112, 13109
5498, 12729, 951, 952, 12740, 13090, 975, 13113, 13111
5499, 880, 12730, 12741, 881, 13092, 13114, 13115, 904
5500, 12730, 12731, 12742, 12741, 13094, 13116, 13117, 13114
5501, 12731, 12732, 12743, 12742, 13096, 13118, 13119, 13116
5502, 12732, 12733, 12744, 12743, 13098, 13120, 13121, 13118
5503, 12733, 12734, 12745, 12744, 13100, 13122, 13123, 13120
5504, 12734, 12735, 12746, 12745, 13102, 13124, 13125, 13122
5505, 12735, 12736, 12747, 12746, 13104, 13126, 13127, 13124
5506, 12736, 12737, 12748, 12747, 13106, 13128, 13129, 13126
5507, 12737, 12738, 12749, 12748, 13108, 13130, 13131, 13128
5508, 12738, 12739, 12750, 12749, 13110, 13132, 13133, 13130
5509, 12739, 12740, 12751, 12750, 13112, 13134, 13135, 13132
5510, 12740, 952, 953, 12751, 13113, 976, 13136, 13134
5511, 881, 12741, 12752, 882, 13115, 13137, 13138, 905
5512, 12741, 12742, 12753, 12752, 13117, 13139, 13140, 13137
5513, 12742, 12743, 12754, 12753, 13119, 13141, 13142, 13139
5514, 12743, 12744, 12755, 12754, 13121, 13143, 13144, 13141
5515, 12744, 12745, 12756, 12755, 13123, 13145, 13146, 13143
5516, 12745, 12746, 12757, 12756, 13125, 13147, 13148, 13145
5517, 12746, 12747, 12758, 12757, 13127, 13149, 13150, 13147
5518, 12747, 12748, 12759, 12758, 13129, 13151, 13152, 13149
5519, 12748, 12749, 12760, 12759, 13131, 13153, 13154, 13151
5520, 12749, 12750, 12761, 12760, 13133, 13155, 13156, 13153
5521, 12750, 12751, 12762, 12761, 13135, 13157, 13158, 13155
5522, 12751, 953, 954, 12762, 13136, 977, 13159, 13157
5523, 882, 12752, 12763, 883, 13138, 13160, 13161, 906
5524, 12752, 12753, 12764, 12763, 13140, 13162, 13163, 13160
5525, 12753, 12754, 12765, 12764, 13142, 13164, 13165, 13162
5526, 12754, 12755, 12766, 12765, 13144, 13166, 13167, 13164
5527, 12755, 12756, 12767, 12766, 13146, 13168, 13169, 13166
5528, 12756, 12757, 12768, 12767, 13148, 13170, 13171, 13168
5529, 12757, 12758, 12769, 12768, 13150, 13172, 13173, 13170
5530, 12758, 12759, 12770, 12769, 13152, 13174, 13175, 13172
5531, 12759, 12760, 12771, 12770, 13154, 13176, 13177, 13174
5532, 12760, 12761, 12772, 12771, 13156, 13178, 13179, 13176
5533, 12761, 12762, 12773, 12772, 13158, 13180, 13181, 13178
5534, 12762, 954, 955, 12773, 13159, 978, 13182, 13180
5535, 883, 12763, 12774, 884, 13161, 13183, 13184, 907
5536, 12763, 12764, 12775, 12774, 13163, 13185, 13186, 13183
5537, 12764, 12765, 12776, 12775, 13165, 13187, 13188, 13185
5538, 12765, 12766, 12777, 12776, 13167, 13189, 13190, 13187
5539, 12766, 12767, 12778, 12777, 13169, 13191, 13192, 13189
5540, 12767, 12768, 12779, 12778, 13171, 13193, 13194, 13191
5541, 12768, 12769, 12780, 12779, 13173, 13195, 13196, 13193
5542, 12769, 12770, 12781, 12780, 13175, 13197, 13198, 13195
5543, 12770, 12771, 12782, 12781, 13177, 13199, 13200, 13197
5544, 12771, 12772, 12783, 12782, 13179, 13201, 13202, 13199
5545, 12772, 12773, 12784, 12783, 13181, 13203, 13204, 13201
5546, 12773, 955, 956, 12784, 13182, 979, 13205, 13203
5547, 884, 12774, 12785, 885, 13184, 13206, 13207, 908
5548, 12774, 12775, 12786, 12785, 13186, 13208, 13209, 13206
5549, 12775, 12776, 12787, 12786, 13188, 13210, 13211, 13208
5550, 12776, 12777, 12788, 12787, 13190, 13212, 13213, 13210
5551, 12777, 12778, 12789, 12788, 13192, 13214, 13215, 13212
5552, 12778, 12779, 12790, 12789, 13194, 13216, 13217, 13214
5553, 12779, 12780, 12791, 12790, 13196, 13218, 13219, 13216
5554, 12780, 12781, 12792, 12791, 13198, 13220, 13221, 13218
5555, 12781, 12782, 12793, 12792, 13200, 13222, 13223, 13220
5556, 12782, 12783, 12794, 12793, 13202, 13224, 13225, 13222
5557, 12783, 12784, 12795, 12794, 13204, 13226, 13227, 13224
5558, 12784, 956, 957, 12795, 13205, 980, 13228, 13226
5559, 885, 12785, 12796, 886, 13207, 13229, 13230, 909
5560, 12785, 12786, 12797, 12796, 13209, 13231, 13232, 13229
5561, 12786, 12787, 12798, 12797, 13211, 13233, 13234, 13231
5562, 12787, 12788, 12799, 12798, 13213, 13235, 13236, 13233
5563, 12788, 12789, 12800, 12799, 13215, 13237, 13238, 13235
5564, 12789, 12790, 12801, 12800, 13217, 13239, 13240, 13237
5565, 12790, 12791, 12802, 12801, 13219, 13241, 13242, 13239
5566, 12791, 12792, 12803, 12802, 13221, 13243, 13244, 13241
5567, 12792, 12793, 12804, 12803, 13223, 13245, 13246, 13243
5568, 12793, 12794, 12805, 12804, 13225, 13247, 13248, 13245
5569, 12794, 12795, 12806, 12805, 13227, 13249, 13250, 13247
5570, 12795, 957, 958, 12806, 13228, 981, 13251, 13249
5571, 886, 12796, 12807, 887, 13230, 13252, 13253, 910
5572, 12796, 12797, 12808, 12807, 13232, 13254, 13255, 13252
5573, 12797, 12798, 12809, 12808, 13234, 13256, 13257, 13254
5574, 12798, 12799, 12810, 12809, 13236, 13258, 13259, 13256
5575, 12799, 12800, 12811, 12810, 13238, 13260, 13261, 13258
5576, 12800, 12801, 12812, 12811, 13240, 13262, 13263, 13260
5577, 12801, 12802, 12813, 12812, 13242, 13264, 13265, 13262
5578, 12802, 12803, 12814, 12813, 13244, 13266, 13267, 13264
5579, 12803, 12804, 12815, 12814, 13246, 13268, 13269, 13266
5580, 12804, 12805, 12816, 12815, 13248, 13270, 13271, 13268
5581, 12805, 12806, 12817, 12816, 13250, 13272, 13273, 13270
5582, 12806, 958, 959, 12817, 13251, 982, 13274, 13272
5583, 887, 12807, 12818, 888, 13253, 13275, 13276, 911
5584, 12807, 12808, 12819, 12818, 13255, 13277, 13278, 13275
5585, 12808, 12809, 12820, 12819, 13257, 13279, 13280, 13277
5586, 12809, 12810, 12821, 12820, 13259, 13281, 13282, 13279
5587, 12810, 12811, 12822, 12821, 13261, 13283, 13284, 13281
5588, 12811, 12812, 12823, 12822, 13263, 13285, 13286, 13283
5589, 12812, 12813, 12824, 12823, 13265, 13287, 13288, 13285
5590, 12813, 12814, 12825, 12824, 13267, 13289, 13290, 13287
5591, 12814, 12815, 12826, 12825, 13269, 13291, 13292, 13289
5592, 12815, 12816, 12827, 12826, 13271, 13293, 13294, 13291
5593, 12816, 12817, 12828, 12827, 13273, 13295, 13296, 13293
5594, 12817, 959, 960, 12828, 13274, 983, 13297, 13295
5595, 888, 12818, 12829, 889, 13276, 13298, 13299, 912
5596, 12818, 12819, 12830, 12829, 13278, 13300, 13301, 13298
5597, 12819, 12820, 12831, 12830, 13280, 13302, 13303, 13300
5598, 12820, 12821, 12832, 12831, 13282, 13304, 13305, 13302
5599, 12821, 12822, 12833, 12832, 13284, 13306, 13307, 13304
5600, 12822, 12823, 12834, 12833, 13286, 13308, 13309, 13306
5601, 12823, 12824, 12835, 12834, 13288, 13310, 13311, 13308
5602, 12824, 12825, 12836, 12835, 13290, 13312, 13313, 13310
5603, 12825, 12826, 12837, 12836, 13292, 13314, 13315, 13312
5604, 12826, 12827, 12838, 12837, 13294, 13316, 13317, 13314
5605, 12827, 12828, 12839, 12838, 13296, 13318, 13319, 13316
5606, 12828, 960, 961, 12839, 13297, 984, 13320, 13318
5607, 889, 12829, 12840, 890, 13299, 13321, 13322, 913
5608, 12829, 12830, 12841, 12840, 13301, 13323, 13324, 13321
5609, 12830, 12831, 12842, 12841, 13303, 13325, 13326, 13323
5610, 12831, 12832, 12843, 12842, 13305, 13327, 13328, 13325
5611, 12832, 12833, 12844, 12843, 13307, 13329, 13330, 13327
5612, 12833, 12834, 12845, 12844, 13309, 13331, 13332, 13329
5613, 12834, 12835, 12846, 12845, 13311, 13333, 13334, 13331
5614, 12835, 12836, 12847, 12846, 13313, 13335, 13336, 13333
5615, 12836, 12837, 12848, 12847, 13315, 13337, 13338, 13335
5616, 12837, 12838, 12849, 12848, 13317, 13339, 13340, 13337
5617, 12838, 12839, 12850, 12849, 13319, 13341, 13342, 13339
5618, 12839, 961, 962, 12850, 13320, 985, 13343, 13341
5619, 890, 12840, 12851, 891, 13322, 13344, 13345, 914
5620, 12840, 12841, 12852, 12851, 13324, 13346, 13347, 13344
5621, 12841, 12842, 12853, 12852, 13326, 13348, 13349, 13346
5622, 12842, 12843, 12854, 12853, 13328, 13350, 13351, 13348
5623, 12843, 12844, 12855, 12854, 13330, 13352, 13353, 13350
5624, 12844, 12845, 12856, 12855, 13332, 13354, 13355, 13352
5625, 12845, 12846, 12857, 12856, 13334, 13356, 13357, 13354
5626, 12846, 12847, 12858, 12857, 13336, 13358, 13359, 13356
5627, 12847, 12848, 12859, 12858, 13338, 13360, 13361, 13358
5628, 12848, 12849, 12860, 12859, 13340, 13362, 13363, 13360
5629, 12849, 12850, 12861, 12860, 13342, 13364, 13365, 13362
5630, 12850, 962, 963, 12861, 13343, 986, 13366, 13364
5631, 891, 12851, 12862, 892, 13345, 13367, 13368, 915
5632, 12851, 12852, 12863, 12862, 13347, 13369, 13370, 13367
5633, 12852, 12853, 12864, 12863, 13349, 13371, 13372, 13369
5634, 12853, 12854, 12865, 12864, 13351, 13373, 13374, 13371
5635, 12854, 12855, 12866, 12865, 13353, 13375, 13376, 13373
5636, 12855, 12856, 12867, 12866, 13355, 13377, 13378, 13375
5637, 12856, 12857, 12868, 12867, 13357, 13379, 13380, 13377
5638, 12857, 12858, 12869, 12868, 13359, 13381, 13382, 13379
5639, 12858, 12859, 12870, 12869, 13361, 13383, 13384, 13381
5640, 12859, 12860, 12871, 12870, 13363, 13385, 13386, 13383
5641, 12860, 12861, 12872, 12871, 13365, 13387, 13388, 13385
5642, 12861, 963, 964, 12872, 13366, 987, 13389, 13387
5643, 892, 12862, 12873, 893, 13368, 13390, 13391, 916
5644, 12862, 12863, 12874, 12873, 13370, 13392, 13393, 13390
5645, 12863, 12864, 12875, 12874, 13372, 13394, 13395, 13392
5646, 12864, 12865, 12876, 12875, 13374, 13396, 13397, 13394
5647, 12865, 12866, 12877, 12876, 13376, 13398, 13399, 13396
5648, 12866, 12867, 12878, 12877, 13378, 13400, 13401, 13398
5649, 12867, 12868, 12879, 12878, 13380, 13402, 13403, 13400
5650, 12868, 12869, 12880, 12879, 13382, 13404, 13405, 13402
5651, 12869, 12870, 12881, 12880, 13384, 13406, 13407, 13404
5652, 12870, 12871, 12882, 12881, 13386, 13408, 13409, 13406
5653, 12871, 12872, 12883, 12882, 13388, 13410, 13411, 13408
5654, 12872, 964, 965, 12883, 13389, 988, 13412, 13410
5655, 893, 12873, 919, 17, 13391, 13413, 930, 917
5656, 12873, 12874, 920, 919, 13393, 13414, 931, 13413
5657, 12874, 12875, 921, 920, 13395, 13415, 932, 13414
5658, 12875, 12876, 922, 921, 13397, 13416, 933, 13415
5659, 12876, 12877, 923, 922, 13399, 13417, 934, 13416
5660, 12877, 12878, 924, 923, 13401, 13418, 935, 13417
5661, 12878, 12879, 925, 924, 13403, 13419, 936, 13418
5662, 12879, 12880, 926, 925, 13405, 13420, 937, 13419
5663, 12880, 12881, 927, 926, 13407, 13421, 938, 13420
5664, 12881, 12882, 928, 927, 13409, 13422, 939, 13421
5665, 12882, 12883, 929, 928, 13411, 13423, 940, 13422
5666, 12883, 965, 19, 929, 13412, 989, 941, 13423
*ELEMENT, type=CPS8, ELSET=Surface22
5667, 18, 1018, 13424, 871, 1020, 13470, 13471, 894
5668, 1018, 1019, 13425, 13424, 1021, 13472, 13473, 13470
5669, 1019, 22, 1023, 13425, 1022, 1046, 13474, 13472
5670, 871, 13424, 13426, 872, 13471, 13475, 13476, 895
5671, 13424, 13425, 13427, 13426, 13473, 13477, 13478, 13475
5672, 13425, 1023, 1024, 13427, 13474, 1047, 13479, 13477
5673, 872, 13426, 13428, 873, 13476, 13480, 13481, 896
5674, 13426, 13427, 13429, 13428, 13478, 13482, 13483, 13480
5675, 13427, 1024, 1025, 13429, 13479, 1048, 13484, 13482
5676, 873, 13428, 13430, 874, 13481, 13485, 13486, 897
5677, 13428, 13429, 13431, 13430, 13483, 13487, 13488, 13485
5678, 13429, 1025, 1026, 13431, 13484, 1049, 13489, 13487
5679, 874, 13430, 13432, 875, 13486, 13490, 13491, 898
5680, 13430, 13431, 13433, 13432, 13488, 13492, 13493, 13490
5681, 13431, 1026, 1027, 13433, 13489, 1050, 13494, 13492
5682, 875, 13432, 13434, 876, 13491, 13495, 13496, 899
5683, 13432, 13433, 13435, 13434, 13493, 13497, 13498, 13495
5684, 13433, 1027, 1028, 13435, 13494, 1051, 13499, 13497
5685, 876, 13434, 13436, 877, 13496, 13500, 13501, 900
5686, 13434, 13435, 13437, 13436, 13498, 13502, 13503, 13500
5687, 13435, 1028, 1029, 13437, 13499, 1052, 13504, 13502
5688, 877, 13436, 13438, 878, 13501, 13505, 13506, 901
5689, 13436, 13437, 13439, 13438, 13503, 13507, 13508, 13505
5690, 13437, 1029, 1030, 13439, 13504, 1053, 13509, 13507
5691, 878, 13438, 13440, 879, 13506, 13510, 13511, 902
5692, 13438, 13439, 13441, 13440, 13508, 13512, 13513, 13510
5693, 13439, 1030, 1031, 13441, 13509, 1054, 13514, 13512
5694, 879, 13440, 13442, 880, 13511, 13515, 13516, 903
5695, 13440, 13441, 13443, 13442, 13513, 13517, 13518, 13515
5696, 13441, 1031, 1032, 13443, 13514, 1055, 13519, 13517
5697, 880, 13442, 13444, 881, 13516, 13520, 13521, 904
5698, 13442, 13443, 13445, 13444, 13518, 13522, 13523, 13520
5699, 13443, 1032, 1033, 13445, 13519, 1056, 13524, 13522
5700, 881, 13444, 13446, 882, 13521, 13525, 13526, 905
5701, 13444, 13445, 13447, 13446, 13523, 13527, 13528, 13525
5702, 13445, 1033, 1034, 13447, 13524, 1057, 13529, 13527
5703, 882, 13446, 13448, 883, 13526, 13530, 13531, 906
5704, 13446, 13447, 13449, 13448, 13528, 13532, 13533, 13530
5705, 13447, 1034, 1035, 13449, 13529, 1058, 13534, 13532
5706, 883, 13448, 13450, 884, 13531, 13535, 13536, 907
5707, 13448, 13449, 13451, 13450, 13533, 13537, 13538, 13535
5708, 13449, 1035, 1036, 13451, 13534, 1059, 13539, 13537
5709, 884, 13450, 13452, 885, 13536, 13540, 13541, 908
5710, 13450, 13451, 13453, 13452, 13538, 13542, 13543, 13540
5711, 13451, 1036, 1037, 13453, 13539, 1060, 13544, 13542
5712, 885, 13452, 13454, 886, 13541, 13545, 13546, 909
5713, 13452, 13453, 13455, 13454, 13543, 13547, 13548, 13545
5714, 13453, 1037, 1038, 13455, 13544, 1061, 13549, 13547
5715, 886, 13454, 13456, 887, 13546, 13550, 13551, 910
5716, 13454, 13455, 13457, 13456, 13548, 13552, 13553, 13550
5717, 13455, 1038, 1039, 13457, 13549, 1062, 13554, 13552
5718, 887, 13456, 13458, 888, 13551, 13555, 13556, 911
5719, 13456, 13457, 13459, 13458, 13553, 13557, 13558, 13555
5720, 13457, 1039, 1040, 13459, 13554, 1063, 13559, 13557
5721, 888, 13458, 13460, 889, 13556, 13560, 13561, 912
5722, 13458, 13459, 13461, 13460, 13558, 13562, 13563, 13560
5723, 13459, 1040, 1041, 13461, 13559, 1064, 13564, 13562
5724, 889, 13460, 13462, 890, 13561, 13565, 13566, 913
5725, 13460, 13461, 13463, 13462, 13563, 13567, 13568, 13565
5726, 13461, 1041, 1042, 13463, 13564, 1065, 13569, 13567
5727, 890, 13462, 13464, 891, 13566, 13570, 13571, 914
5728, 13462, 13463, 13465, 13464, 13568, 13572, 13573, 13570
5729, 13463, 1042, 1043, 13465, 13569, 1066, 13574, 13572
5730, 891, 13464, 13466, 892, 13571, 13575, 13576, 915
5731, 13464, 13465, 13467, 13466, 13573, 13577, 13578, 13575
5732, 13465, 1043, 1044, 13467, 13574, 1067, 13579, 13577
5733, 892, 13466, 13468, 893, 13576, 13580, 13581, 916
5734, 13466, 13467, 13469, 13468, 13578, 13582, 13583, 13580
5735, 13467, 1044, 1045, 13469, 13579, 1068, 13584, 13582
5736, 893, 13468, 1013, 17, 13581, 13585, 1015, 917
5737, 13468, 13469, 1014, 1013, 13583, 13586, 1016, 13585
5738, 13469, 1045, 21, 1014, 13584, 1069, 1017, 13586
*ELEMENT, type=CPS8, ELSET=Surface23
5739, 17, 1013, 13587, 919, 1015, 13609, 13610, 930
5740, 1013, 1014, 13588, 13587, 1016, 13611, 13612, 13609
5741, 1014, 21, 1075, 13588, 1017, 1086, 13613, 13611
5742, 919, 13587, 13589, 920, 13610, 13614, 13615, 931
5743, 13587, 13588, 13590, 13589, 13612, 13616, 13617, 13614
5744, 13588, 1075, 1076, 13590, 13613, 1087, 13618, 13616
5745, 920, 13589, 13591, 921, 13615, 13619, 13620, 932
5746, 13589, 13590, 13592, 13591, 13617, 13621, 13622, 13619
5747, 13590, 1076, 1077, 13592, 13618, 1088, 13623, 13621
5748, 921, 13591, 13593, 922, 13620, 13624, 13625, 933
5749, 13591, 13592, 13594, 13593, 13622, 13626, 13627, 13624
5750, 13592, 1077, 1078, 13594, 13623, 1089, 13628, 13626
5751, 922, 13593, 13595, 923, 13625, 13629, 13630, 934
5752, 13593, 13594, 13596, 13595, 13627, 13631, 13632, 13629
5753, 13594, 1078, 1079, 13596, 13628, 1090, 13633, 13631
5754, 923, 13595, 13597, 924, 13630, 13634, 13635, 935
5755, 13595, 13596, 13598, 13597, 13632, 13636, 13637, 13634
5756, 13596, 1079, 1080, 13598, 13633, 1091, 13638, 13636
5757, 924, 13597, 13599, 925, 13635, 13639, 13640, 936
5758, 13597, 13598, 13600, 13599, 13637, 13641, 13642, 13639
5759, 13598, 1080, 1081, 13600, 13638, 1092, 13643, 13641
5760, 925, 13599, 13601, 926, 13640, 13644, 13645, 937
5761, 13599, 13600, 13602, 13601, 13642, 13646, 13647, 13644
5762, 13600, 1081, 1082, 13602, 13643, 1093, 13648, 13646
5763, 926, 13601, 13603, 927, 13645, 13649, 13650, 938
5764, 13601, 13602, 13604, 13603, 13647, 13651, 13652, 13649
5765, 13602, 1082, 1083, 13604, 13648, 1094, 13653, 13651
5766, 927, 13603, 13605, 928, 13650, 13654, 13655, 939
5767, 13603, 13604, 13606, 13605, 13652, 13656, 13657, 13654
5768, 13604, 1083, 1084, 13606, 13653, 1095, 13658, 13656
5769, 928, 13605, 13607, 929, 13655, 13659, 13660, 940
5770, 13605, 13606, 13608, 13607, 13657, 13661, 13662, 13659
5771, 13606, 1084, 1085, 13608, 13658, 1096, 13663, 13661
5772, 929, 13607, 1070, 19, 13660, 13664, 1072, 941
5773, 13607, 13608, 1071, 1070, 13662, 13665, 1073, 13664
5774, 13608, 1085, 23, 1071, 13663, 1097, 1074, 13665
*ELEMENT, type=CPS8, ELSET=Surface24
5775, 20, 943, 13666, 1098, 966, 13712, 13713, 1100
5776, 1098, 13666, 13667, 1099, 13713, 13714, 13715, 1101
5777, 1099, 13667, 1103, 24, 13715, 13716, 1126, 1102
5778, 943, 944, 13668, 13666, 967, 13717, 13718, 13712
5779, 13666, 13668, 13669, 13667, 13718, 13719, 13720, 13714
5780, 13667, 13669, 1104, 1103, 13720, 13721, 1127, 13716
5781, 944, 945, 13670, 13668, 968, 13722, 13723, 13717
5782, 13668, 13670, 13671, 13669, 13723, 13724, 13725, 13719
5783, 13669, 13671, 1105, 1104, 13725, 13726, 1128, 13721
5784, 945, 946, 13672, 13670, 969, 13727, 13728, 13722
5785, 13670, 13672, 13673, 13671, 13728, 13729, 13730, 13724
5786, 13671, 13673, 1106, 1105, 13730, 13731, 1129, 13726
5787, 946, 947, 13674, 13672, 970, 13732, 13733, 13727
5788, 13672, 13674, 13675, 13673, 13733, 13734, 13735, 13729
5789, 13673, 13675, 1107, 1106, 13735, 13736, 1130, 13731
5790, 947, 948, 13676, 13674, 971, 13737, 13738, 13732
5791, 13674, 13676, 13677, 13675, 13738, 13739, 13740, 13734
5792, 13675, 13677, 1108, 1107, 13740, 13741, 1131, 13736
5793, 948, 949, 13678, 13676, 972, 13742, 13743, 13737
5794, 13676, 13678, 13679, 13677, 13743, 13744, 13745, 13739
5795, 13677, 13679, 1109, 1108, 13745, 13746, 1132, 13741
5796, 949, 950, 13680, 13678, 973, 13747, 13748, 13742
5797, 13678, 13680, 13681, 13679, 13748, 13749, 13750, 13744
5798, 13679, 13681, 1110, 1109, 13750, 13751, 1133, 13746
5799, 950, 951, 13682, 13680, 974, 13752, 13753, 13747
5800, 13680, 13682, 13683, 13681, 13753, 13754, 13755, 13749
5801, 13681, 13683, 1111, 1110, 13755, 13756, 1134, 13751
5802, 951, 952, 13684, 13682, 975, 13757, 13758, 13752
5803, 13682, 13684, 13685, 13683, 13758, 13759, 13760, 13754
5804, 13683, 13685, 1112, 1111, 13760, 13761, 1135, 13756
5805, 952, 953, 13686, 13684, 976, 13762, 13763, 13757
5806, 13684, 13686, 13687, 13685, 13763, 13764, 13765, 13759
5807, 13685, 13687, 1113, 1112, 13765, 13766, 1136, 13761
5808, 953, 954, 13688, 13686, 977, 13767, 13768, 13762
5809, 13686, 13688, 13689, 13687, 13768, 13769, 13770, 13764
5810, 13687, 13689, 1114, 1113, 13770, 13771, 1137, 13766
5811, 954, 955, 13690, 13688, 978, 13772, 13773, 13767
5812, 13688, 13690, 13691, 13689, 13773, 13774, 13775, 13769
5813, 13689, 13691, 1115, 1114, 13775, 13776, 1138, 13771
5814, 955, 956, 13692, 13690, 979, 13777, 13778, 13772
5815, 13690, 13692, 13693, 13691, 13778, 13779, 13780, 13774
5816, 13691, 13693, 1116, 1115, 13780, 13781, 1139, 13776
5817, 956, 957, 13694, 13692, 980, 13782, 13783, 13777
5818, 13692, 13694, 13695, 13693, 13783, 13784, 13785, 13779
5819, 13693, 13695, 1117, 1116, 13785, 13786, 1140, 13781
5820, 957, 958, 13696, 13694, 981, 13787, 13788, 13782
5821, 13694, 13696, 13697, 13695, 13788, 13789, 13790, 13784
5822, 13695, 13697, 1118, 1117, 13790, 13791, 1141, 13786
5823, 958, 959, 13698, 13696, 982, 13792, 13793, 13787
5824, 13696, 13698, 13699, 13697, 13793, 13794, 13795, 13789
5825, 13697, 13699, 1119, 1118, 13795, 13796, 1142, 13791
5826, 959, 960, 13700, 13698, 983, 13797, 13798, 13792
5827, 13698, 13700, 13701, 13699, 13798, 13799, 13800, 13794
5828, 13699, 13701, 1120, 1119, 13800, 13801, 1143, 13796
5829, 960, 961, 13702, 13700, 984, 13802, 13803, 13797
5830, 13700, 13702, 13703, 13701, 13803, 13804, 13805, 13799
5831, 13701, 13703, 1121, 1120, 13805, 13806, 1144, 13801
5832, 961, 962, 13704, 13702, 985, 13807, 13808, 13802
5833, 13702, 13704, 13705, 13703, 13808, 13809, 13810, 13804
5834, 13703, 13705, 1122, 1121, 13810, 13811, 1145, 13806
5835, 962, 963, 13706, 13704, 986, 13812, 13813, 13807
5836, 13704, 13706, 13707, 13705, 13813, 13814, 13815, 13809
5837, 13705, 13707, 1123, 1122, 13815, 13816, 1146, 13811
5838, 963, 964, 13708, 13706, 987, 13817, 13818, 13812
5839, 13706, 13708, 13709, 13707, 13818, 13819, 13820, 13814
5840, 13707, 13709, 1124, 1123, 13820, 13821, 1147, 13816
5841, 964, 965, 13710, 13708, 988, 13822, 13823, 13817
5842, 13708, 13710, 13711, 13709, 13823, 13824, 13825, 13819
5843, 13709, 13711, 1125, 1124, 13825, 13826, 1148, 13821
5844, 965, 19, 1070, 13710, 989, 1072, 13827, 13822
5845, 13710, 1070, 1071, 13711, 13827, 1073, 13828, 13824
5846, 13711, 1071, 23, 1125, 13828, 1074, 1149, 13826
*ELEMENT, type=CPS8, ELSET=Surface25
5847, 18, 990, 13829, 1018, 1001, 13851, 13852, 1020
5848, 1018, 13829, 13830, 1019, 13852, 13853, 13854, 1021
5849, 1019, 13830, 1150, 22, 13854, 13855, 1161, 1022
5850, 990, 991, 13831, 13829, 1002, 13856, 13857, 13851
5851, 13829, 13831, 13832, 13830, 13857, 13858, 13859, 13853
5852, 13830, 13832, 1151, 1150, 13859, 13860, 1162, 13855
5853, 991, 992, 13833, 13831, 1003, 13861, 13862, 13856
5854, 13831, 13833, 13834, 13832, 13862, 13863, 13864, 13858
5855, 13832, 13834, 1152, 1151, 13864, 13865, 1163, 13860
5856, 992, 993, 13835, 13833, 1004, 13866, 13867, 13861
5857, 13833, 13835, 13836, 13834, 13867, 13868, 13869, 13863
5858, 13834, 13836, 1153, 1152, 13869, 13870, 1164, 13865
5859, 993, 994, 13837, 13835, 1005, 13871, 13872, 13866
5860, 13835, 13837, 13838, 13836, 13872, 13873, 13874, 13868
5861, 13836, 13838, 1154, 1153, 13874, 13875, 1165, 13870
5862, 994, 995, 13839, 13837, 1006, 13876, 13877, 13871
5863, 13837, 13839, 13840, 13838, 13877, 13878, 13879, 13873
5864, 13838, 13840, 1155, 1154, 13879, 13880, 1166, 13875
5865, 995, 996, 13841, 13839, 1007, 13881, 13882, 13876
5866, 13839, 13841, 13842, 13840, 13882, 13883, 13884, 13878
5867, 13840, 13842, 1156, 1155, 13884, 13885, 1167, 13880
5868, 996, 997, 13843, 13841, 1008, 13886, 13887, 13881
5869, 13841, 13843, 13844, 13842, 13887, 13888, 13889, 13883
5870, 13842, 13844, 1157, 1156, 13889, 13890, 1168, 13885
5871, 997, 998, 13845, 13843, 1009, 13891, 13892, 13886
5872, 13843, 13845, 13846, 13844, 13892, 13893, 13894, 13888
5873, 13844, 13846, 1158, 1157, 13894, 13895, 1169, 13890
5874, 998, 999, 13847, 13845, 1010, 13896, 13897, 13891
5875, 13845, 13847, 13848, 13846, 13897, 13898, 13899, 13893
5876, 13846, 13848, 1159, 1158, 13899, 13900, 1170, 13895
5877, 999, 1000, 13849, 13847, 1011, 13901, 13902, 13896
5878, 13847, 13849, 13850, 13848, 13902, 13903, 13904, 13898
5879, 13848, 13850, 1160, 1159, 13904, 13905, 1171, 13900
5880, 1000, 20, 1098, 13849, 1012, 1100, 13906, 13901
5881, 13849, 1098, 1099, 13850, 13906, 1101, 13907, 13903
5882, 13850, 1099, 24, 1160, 13907, 1102, 1172, 13905
*ELEMENT, type=CPS8, ELSET=Surface26
5883, 22, 1150, 13908, 1023, 1161, 14161, 14162, 1046
5884, 1150, 1151, 13909, 13908, 1162, 14163, 14164, 14161
5885, 1151, 1152, 13910, 13909, 1163, 14165, 14166, 14163
5886, 1152, 1153, 13911, 13910, 1164, 14167, 14168, 14165
5887, 1153, 1154, 13912, 13911, 1165, 14169, 14170, 14167
5888, 1154, 1155, 13913, 13912, 1166, 14171, 14172, 14169
5889, 1155, 1156, 13914, 13913, 1167, 14173, 14174, 14171
5890, 1156, 1157, 13915, 13914, 1168, 14175, 14176, 14173
5891, 1157, 1158, 13916, 13915, 1169, 14177, 14178, 14175
5892, 1158, 1159, 13917, 13916, 1170, 14179, 14180, 14177
5893, 1159, 1160, 13918, 13917, 1171, 14181, 14182, 14179
5894, 1160, 24, 1103, 13918, 1172, 1126, 14183, 14181
5895, 1023, 13908, 13919, 1024, 14162, 14184, 14185, 1047
5896, 13908, 13909, 13920, 13919, 14164, 14186, 14187, 14184
5897, 13909, 13910, 13921, 13920, 14166, 14188, 14189, 14186
5898, 13910, 13911, 13922, 13921, 14168, 14190, 14191, 14188
5899, 13911, 13912, 13923, 13922, 14170, 14192, 14193, 14190
5900, 13912, 13913, 13924, 13923, 14172, 14194, 14195, 14192
5901, 13913, 13914, 13925, 13924, 14174, 14196, 14197, 14194
5902, 13914, 13915, 13926, 13925, 14176, 14198, 14199, 14196
5903, 13915, 13916, 13927, 13926, 14178, 14200, 14201, 14198
5904, 13916, 13917, 13928, 13927, 14180, 14202, 14203, 14200
5905, 13917, 13918, 13929, 13928, 14182, 14204, 14205, 14202
5906, 13918, 1103, 1104, 13929, 14183, 1127, 14206, 14204
5907, 1024, 13919, 13930, 1025, 14185, 14207, 14208, 1048
5908, 13919, 13920, 13931, 13930, 14187, 14209, 14210, 14207
5909, 13920, 13921, 13932, 13931, 14189, 14211, 14212, 14209
5910, 13921, 13922, 13933, 13932, 14191, 14213, 14214, 14211
5911, 13922, 13923, 13934, 13933, 14193, 14215, 14216, 14213
5912, 13923, 13924, 13935, 13934, 14195, 14217, 14218, 14215
5913, 13924, 13925, 13936, 13935, 14197, 14219, 14220, 14217
5914, 13925, 13926, 13937, 13936, 14199, 14221, 14222, 14219
5915, 13926, 13927, 13938, 13937, 14201, 14223, 14224, 14221
5916, 13927, 13928, 13939, 13938, 14203, 14225, 14226, 14223
5917, 13928, 13929, 13940, 13939, 14205, 14227, 14228, 14225
5918, 13929, 1104, 1105, 13940, 14206, 1128, 14229, 14227
5919, 1025, 13930, 13941, 1026, 14208, 14230, 14231, 1049
5920, 13930, 13931, 13942, 13941, 14210, 14232, 14233, 14230
5921, 13931, 13932, 13943, 13942, 14212, 14234, 14235, 14232
5922, 13932, 13933, 13944, 13943, 14214, 14236, 14237, 14234
5923, 13933, 13934, 13945, 13944, 14216, 14238, 14239, 14236
5924, 13934, 13935, 13946, 13945, 14218, 14240, 14241, 14238
5925, 13935, 13936, 13947, 13946, 14220, 14242, 14243, 14240
5926, 13936, 13937, 13948, 13947, 14222, 14244, 14245, 14242
5927, 13937, 13938, 13949, 13948, 14224, 14246, 14247, 14244
5928, 13938, 13939, 13950, 13949, 14226, 14248, 14249, 14246
5929, 13939, 13940, 13951, 13950, 14228, 14250, 14251, 14248
5930, 13940, 1105, 1106, 13951, 14229, 1129, 14252, 14250
5931, 1026, 13941, 13952, 1027, 14231, 14253, 14254, 1050
5932, 13941, 13942, 13953, 13952, 14233, 14255, 14256, 14253
5933, 13942, 13943, 13954, 13953, 14235, 14257, 14258, 14255
5934, 13943, 13944, 13955, 13954, 14237, 14259, 14260, 14257
5935, 13944, 13945, 13956, 13955, 14239, 14261, 14262, 14259
5936, 13945, 13946, 13957, 13956, 14241, 14263, 14264, 14261
5937, 13946, 13947, 13958, 13957, 14243, 14265, 14266, 14263
5938, 13947, 13948, 13959, 13958, 14245, 14267, 14268, 14265
5939, 13948, 13949, 13960, 13959, 14247, 14269, 14270, 14267
5940, 13949, 13950, 13961, 13960, 14249, 14271, 14272, 14269
5941, 13950, 13951, 13962, 13961, 14251, 14273, 14274, 14271
5942, 13951, 1106, 1107, 13962, 14252, 1130, 14275, 14273
5943, 1027, 13952, 13963, 1028, 14254, 14276, 14277, 1051
5944, 13952, 13953, 13964, 13963, 14256, 14278, 14279, 14276
5945, 13953, 13954, 13965, 13964, 14258, 14280, 14281, 14278
5946, 13954, 13955, 13966, 13965, 14260, 14282, 14283, 14280
5947, 13955, 13956, 13967, 13966, 14262, 14284, 14285, 14282
5948, 13956, 13957, 13968, 13967, 14264, 14286, 14287, 14284
5949, 13957, 13958, 13969, 13968, 14266, 14288, 14289, 14286
5950, 13958, 13959, 13970, 13969, 14268, 14290, 14291, 14288
5951, 13959, 13960, 13971, 13970, 14270, 14292, 14293, 14290
5952, 13960, 13961, 13972, 13971, 14272, 14294, 14295, 14292
5953, 13961, 13962, 13973, 13972, 14274, 14296, 14297, 14294
5954, 13962, 1107, 1108, 13973, 14275, 1131, 14298, 14296
5955, 1028, 13963, 13974, 1029, 14277, 14299, 14300, 1052
5956, 13963, 13964, 13975, 13974, 14279, 14301, 14302, 14299
5957, 13964, 13965, 13976, 13975, 14281, 14303, 14304, 14301
5958, 13965, 13966, 13977, 13976, 14283, 14305, 14306, 14303
5959, 13966, 13967, 13978, 13977, 14285, 14307, 14308, 14305
5960, 13967, 13968, 13979, 13978, 14287, 14309, 14310, 14307
5961, 13968, 13969, 13980, 13979, 14289, 14311, 14312, 14309
5962, 13969, 13970, 13981, 13980, 14291, 14313, 14314, 14311
5963, 13970, 13971, 13982, 13981, 14293, 14315, 14316, 14313
5964, 13971, 13972, 13983, 13982, 14295, 14317, 14318, 14315
5965, 13972, 13973, 13984, 13983, 14297, 14319, 14320, 14317
5966, 13973, 1108, 1109, 13984, 14298, 1132, 14321, 14319
5967, 1029, 13974, 13985, 1030, 14300, 14322, 14323, 1053
5968, 13974, 13975, 13986, 13985, 14302, 14324, 14325, 14322
5969, 13975, 13976, 13987, 13986, 14304, 14326, 14327, 14324
5970, 13976, 13977, 13988, 13987, 14306, 14328, 14329, 14326
5971, 13977, 13978, 13989, 13988, 14308, 14330, 14331, 14328
5972, 13978, 13979, 13990, 13989, 14310, 14332, 14333, 14330
5973, 13979, 13980, 13991, 13990, 14312, 14334, 14335, 14332
5974, 13980, 13981, 13992, 13991, 14314, 14336, 14337, 14334
5975, 13981, 13982, 13993, 13992, 14316, 14338, 14339, 14336
5976, 13982, 13983, 13994, 13993, 14318, 14340, 14341, 14338
5977, 13983, 13984, 13995, 13994, 14320, 14342, 14343, 14340
5978, 13984, 1109, 1110, 13995, 14321, 1133, 14344, 14342
5979, 1030, 13985, 13996, 1031, 14323, 14345, 14346, 1054
5980, 13985, 13986, 13997, 13996, 14325, 14347, 14348, 14345
5981, 13986, 13987, 13998, 13997, 14327, 14349, 14350, 14347
5982, 13987, 13988, 13999, 13998, 14329, 14351, 14352, 14349
5983, 13988, 13989, 14000, 13999, 14331, 14353, 14354, 14351
5984, 13989, 13990, 14001, 14000, 14333, 14355, 14356, 14353
5985, 13990, 13991, 14002, 14001, 14335, 14357, 14358, 14355
5986, 13991, 13992, 14003, 14002, 14337, 14359, 14360, 14357
5987, 13992, 13993, 14004, 14003, 14339, 14361, 14362, 14359
5988, 13993, 13994, 14005, 14004, 14341, 14363, 14364, 14361
5989, 13994, 13995, 14006, 14005, 14343, 14365, 14366, 14363
5990, 13995, 1110, 1111, 14006, 14344, 1134, 14367, 14365
5991, 1031, 13996, 14007, 1032, 14346, 14368, 14369, 1055
5992, 13996, 13997, 14008, 14007, 14348, 14370, 14371, 14368
5993, 13997, 13998, 14009, 14008, 14350, 14372, 14373, 14370
5994, 13998, 13999, 14010, 14009, 14352, 14374, 14375, 14372
5995, 13999, 14000, 14011, 14010, 14354, 14376, 14377, 14374
5996, 14000, 14001, 14012, 14011, 14356, 14378, 14379, 14376
5997, 14001, 14002, 14013, 14012, 14358, 14380, 14381, 14378
5998, 14002, 14003, 14014, 14013, 14360, 14382, 14383, 14380
5999, 14003, 14004, 14015, 14014, 14362, 14384, 14385, 14382
6000, 14004, 14005, 14016, 14015, 14364, 14386, 14387, 14384
6001, 14005, 14006, 14017, 14016, 14366, 14388, 14389, 14386
6002, 14006, 1111, 1112, 14017, 14367, 1135, 14390, 14388
6003, 1032, 14007, 14018, 1033, 14369, 14391, 14392, 1056
6004, 14007, 14008, 14019, 14018, 14371, 14393, 14394, 14391
6005, 14008, 14009, 14020, 14019, 14373, 14395, 14396, 14393
6006, 14009, 14010, 14021, 14020, 14375, 14397, 14398, 14395
6007, 14010, 14011, 14022, 14021, 14377, 14399, 14400, 14397
6008, 14011, 14012, 14023, 14022, 14379, 14401, 14402, 14399
6009, 14012, 14013, 14024, 14023, 14381, 14403, 14404, 14401
6010, 14013, 14014, 14025, 14024, 14383, 14405, 14406, 14403
6011, 14014, 14015, 14026, 14025, 14385, 14407, 14408, 14405
6012, 14015, 14016, 14027, 14026, 14387, 14409, 14410, 14407
6013, 14016, 14017, 14028, 14027, 14389, 14411, 14412, 14409
6014, 14017, 1112, 1113, 14028, 14390, 1136, 14413, 14411
6015, 1033, 14018, 14029, 1034, 14392, 14414, 14415, 1057
6016, 14018, 14019, 14030, 14029, 14394, 14416, 14417, 14414
6017, 14019, 14020, 14031, 14030, 14396, 14418, 14419, 14416
6018, 14020, 14021, 14032, 14031, 14398, 14420, 14421, 14418
6019, 14021, 14022, 14033, 14032, 14400, 14422, 14423, 14420
6020, 14022, 14023, 14034, 14033, 14402, 14424, 14425, 14422
6021, 14023, 14024, 14035, 14034, 14404, 14426, 14427, 14424
6022, 14024, 14025, 14036, 14035, 14406, 14428, 14429, 14426
6023, 14025, 14026, 14037, 14036, 14408, 14430, 14431, 14428
6024, 14026, 14027, 14038, 14037, 14410, 14432, 14433, 14430
6025, 14027, 14028, 14039, 14038, 14412, 14434, 14435, 14432
6026, 14028, 1113, 1114, 14039, 14413, 1137, 14436, 14434
6027, 1034, 14029, 14040, 1035, 14415, 14437, 14438, 1058
6028, 14029, 14030, 14041, 14040, 14417, 14439, 14440, 14437
6029, 14030, 14031, 14042, 14041, 14419, 14441, 14442, 14439
6030, 14031, 14032, 14043, 14042, 14421, 14443, 14444, 14441
6031, 14032, 14033, 14044, 14043, 14423, 14445, 14446, 14443
6032, 14033, 14034, 14045, 14044, 14425, 14447, 14448, 14445
6033, 14034, 14035, 14046, 14045, 14427, 14449, 14450, 14447
6034, 14035, 14036, 14047, 14046, 14429, 14451, 14452, 14449
6035, 14036, 14037, 14048, 14047, 14431, 14453, 14454, 14451
6036, 14037, 14038, 14049, 14048, 14433, 14455, 14456, 14453
6037, 14038, 14039, 14050, 14049, 14435, 14457, 14458, 14455
6038, 14039, 1114, 1115, 14050, 14436, 1138, 14459, 14457
6039, 1035, 14040, 14051, 1036, 14438, 14460, 14461, 1059
6040, 14040, 14041, 14052, 14051, 14440, 14462, 14463, 14460
6041, 14041, 14042, 14053, 14052, 14442, 14464, 14465, 14462
6042, 14042, 14043, 14054, 14053, 14444, 14466, 14467, 14464
6043, 14043, 14044, 14055, 14054, 14446, 14468, 14469, 14466
6044, 14044, 14045, 14056, 14055, 14448, 14470, 14471, 14468
6045, 14045, 14046, 14057, 14056, 14450, 14472, 14473, 14470
6046, 14046, 14047, 14058, 14057, 14452, 14474, 14475, 14472
6047, 14047, 14048, 14059, 14058, 14454, 14476, 14477, 14474
6048, 14048, 14049, 14060, 14059, 14456, 14478, 14479, 14476
6049, 14049, 14050, 14061, 14060, 14458, 14480, 14481, 14478
6050, 14050, 1115, 1116, 14061, 14459, 1139, 14482, 14480
6051, 1036, 14051, 14062, 1037, 14461, 14483, 14484, 1060
6052, 14051, 14052, 14063, 14062, 14463, 14485, 14486, 14483
6053, 14052, 14053, 14064, 14063, 14465, 14487, 14488, 14485
6054, 14053, 14054, 14065, 14064, 14467, 14489, 14490, 14487
6055, 14054, 14055, 14066, 14065, 14469, 14491, 14492, 14489
6056, 14055, 14056, 14067, 14066, 14471, 14493, 14494, 14491
6057, 14056, 14057, 14068, 14067, 14473, 14495, 14496, 14493
6058, 14057, 14058, 14069, 14068, 14475, 14497, 14498, 14495
6059, 14058, 14059, 14070, 14069, 14477, 14499, 14500, 14497
6060, 14059, 14060, 14071, 14070, 14479, 14501, 14502, 14499
6061, 14060, 14061, 14072, 14071, 14481, 14503, 14504, 14501
6062, 14061, 1116, 1117, 14072, 14482, 1140, 14505, 14503
6063, 1037, 14062, 14073, 1038, 14484, 14506, 14507, 1061
6064, 14062, 14063, 14074, 14073, 14486, 14508, 14509, 14506
6065, 14063, 14064, 14075, 14074, 14488, 14510, 14511, 14508
6066, 14064, 14065, 14076, 14075, 14490, 14512, 14513, 14510
6067, 14065, 14066, 14077, 14076, 14492, 14514, 14515, 14512
6068, 14066, 14067, 14078, 14077, 14494, 14516, 14517, 14514
6069, 14067, 14068, 14079, 14078, 14496, 14518, 14519, 14516
6070, 14068, 14069, 14080, 14079, 14498, 14520, 14521, 14518
6071, 14069, 14070, 14081, 14080, 14500, 14522, 14523, 14520
6072, 14070, 14071, 14082, 14081, 14502, 14524, 14525, 14522
6073, 14071, 14072, 14083, 14082, 14504, 14526, 14527, 14524
6074, 14072, 1117, 1118, 14083, 14505, 1141, 14528, 14526
6075, 1038, 14073, 14084, 1039, 14507, 14529, 14530, 1062
6076, 14073, 14074, 14085, 14084, 14509, 14531, 14532, 14529
6077, 14074, 14075, 14086, 14085, 14511, 14533, 14534, 14531
6078, 14075, 14076, 14087, 14086, 14513, 14535, 14536, 14533
6079, 14076, 14077, 14088, 14087, 14515, 14537, 14538, 14535
6080, 14077, 14078, 14089, 14088, 14517, 14539, 14540, 14537
6081, 14078, 14079, 14090, 14089, 14519, 14541, 14542, 14539
6082, 14079, 14080, 14091, 14090, 14521, 14543, 14544, 14541
6083, 14080, 14081, 14092, 14091, 14523, 14545, 14546, 14543
6084, 14081, 14082, 14093, 14092, 14525, 14547, 14548, 14545
6085, 14082, 14083, 14094, 14093, 14527, 14549, 14550, 14547
6086, 14083, 1118, 1119, 14094, 14528, 1142, 14551, 14549
6087, 1039, 14084, 14095, 1040, 14530, 14552, 14553, 1063
6088, 14084, 14085, 14096, 14095, 14532, 14554, 14555, 14552
6089, 14085, 14086, 14097, 14096, 14534, 14556, 14557, 14554
6090, 14086, 14087, 14098, 14097, 14536, 14558, 14559, 14556
6091, 14087, 14088, 14099, 14098, 14538, 14560, 14561, 14558
6092, 14088, 14089, 14100, 14099, 14540, 14562, 14563, 14560
6093, 14089, 14090, 14101, 14100, 14542, 14564, 14565, 14562
6094, 14090, 14091, 14102, 14101, 14544, 14566, 14567, 14564
6095, 14091, 14092, 14103, 14102, 14546, 14568, 14569, 14566
6096, 14092, 14093, 14104, 14103, 14548, 14570, 14571, 14568
6097, 14093, 14094, 14105, 14104, 14550, 14572, 14573, 14570
6098, 14094, 1119, 1120, 14105, 14551, 1143, 14574, 14572
6099, 1040, 14095, 14106, 1041, 14553, 14575, 14576, 1064
6100, 14095, 14096, 14107, 14106, 14555, 14577, 14578, 14575
6101, 14096, 14097, 14108, 14107, 14557, 14579, 14580, 14577
6102, 14097, 14098, 14109, 14108, 14559, 14581, 14582, 14579
6103, 14098, 14099, 14110, 14109, 14561, 14583, 14584, 14581
6104, 14099, 14100, 14111, 14110, 14563, 14585, 14586, 14583
6105, 14100, 14101, 14112, 14111, 14565, 14587, 14588, 14585
6106, 14101, 14102, 14113, 14112, 14567, 14589, 14590, 14587
6107, 14102, 14103, 14114, 14113, 14569, 14591, 14592, 14589
6108, 14103, 14104, 14115, 14114, 14571, 14593, 14594, 14591
6109, 14104, 14105, 14116, 14115, 14573, 14595, 14596, 14593
6110, 14105, 1120, 1121, 14116, 14574, 1144, 14597, 14595
6111, 1041, 14106, 14117, 1042, 14576, 14598, 14599, 1065
6112, 14106, 14107, 14118, 14117, 14578, 14600, 14601, 14598
6113, 14107, 14108, 14119, 14118, 14580, 14602, 14603, 14600
6114, 14108, 14109, 14120, 14119, 14582, 14604, 14605, 14602
6115, 14109, 14110, 14121, 14120, 14584, 14606, 14607, 14604
6116, 14110, 14111, 14122, 14121, 14586, 14608, 14609, 14606
6117, 14111, 14112, 14123, 14122, 14588, 14610, 14611, 14608
6118, 14112, 14113, 14124, 14123, 14590, 14612, 14613, 14610
6119, 14113, 14114, 14125, 14124, 14592, 14614, 14615, 14612
6120, 14114, 14115, 14126, 14125, 14594, 14616, 14617, 14614
6121, 14115, 14116, 14127, 14126, 14596, 14618, 14619, 14616
6122, 14116, 1121, 1122, 14127, 14597, 1145, 14620, 14618
6123, 1042, 14117, 14128, 1043, 14599, 14621, 14622, 1066
6124, 14117, 14118, 14129, 14128, 14601, 14623, 14624, 14621
6125, 14118, 14119, 14130, 14129, 14603, 14625, 14626, 14623
6126, 14119, 14120, 14131, 14130, 14605, 14627, 14628, 14625
6127, 14120, 14121, 14132, 14131, 14607, 14629, 14630, 14627
6128, 14121, 14122, 14133, 14132, 14609, 14631, 14632, 14629
6129, 14122, 14123, 14134, 14133, 14611, 14633, 14634, 14631
6130, 14123, 14124, 14135, 14134, 14613, 14635, 14636, 14633
6131, 14124, 14125, 14136, 14135, 14615, 14637, 14638, 14635
6132, 14125, 14126, 14137, 14136, 14617, 14639, 14640, 14637
6133, 14126, 14127, 14138, 14137, 14619, 14641, 14642, 14639
6134, 14127, 1122, 1123, 14138, 14620, 1146, 14643, 14641
6135, 1043, 14128, 14139, 1044, 14622, 14644, 14645, 1067
6136, 14128, 14129, 14140, 14139, 14624, 14646, 14647, 14644
6137, 14129, 14130, 14141, 14140, 14626, 14648, 14649, 14646
6138, 14130, 14131, 14142, 14141, 14628, 14650, 14651, 14648
6139, 14131, 14132, 14143, 14142, 14630, 14652, 14653, 14650
6140, 14132, 14133, 14144, 14143, 14632, 14654, 14655, 14652
6141, 14133, 14134, 14145, 14144, 14634, 14656, 14657, 14654
6142, 14134, 14135, 14146, 14145, 14636, 14658, 14659, 14656
6143, 14135, 14136, 14147, 14146, 14638, 14660, 14661, 14658
6144, 14136, 14137, 14148, 14147, 14640, 14662, 14663, 14660
6145, 14137, 14138, 14149, 14148, 14642, 14664, 14665, 14662
6146, 14138, 1123, 1124, 14149, 14643, 1147, 14666, 14664
6147, 1044, 14139, 14150, 1045, 14645, 14667, 14668, 1068
6148, 14139, 14140, 14151, 14150, 14647, 14669, 14670, 14667
6149, 14140, 14141, 14152, 14151, 14649, 14671, 14672, 14669
6150, 14141, 14142, 14153, 14152, 14651, 14673, 14674, 14671
6151, 14142, 14143, 14154, 14153, 14653, 14675, 14676, 14673
6152, 14143, 14144, 14155, 14154, 14655, 14677, 14678, 14675
6153, 14144, 14145, 14156, 14155, 14657, 14679, 14680, 14677
6154, 14145, 14146, 14157, 14156, 14659, 14681, 14682, 14679
6155, 14146, 14147, 14158, 14157, 14661, 14683, 14684, 14681
6156, 14147, 14148, 14159, 14158, 14663, 14685, 14686, 14683
6157, 14148, 14149, 14160, 14159, 14665, 14687, 14688, 14685
6158, 14149, 1124, 1125, 14160, 14666, 1148, 14689, 14687
6159, 1045, 14150, 1075, 21, 14668, 14690, 1086, 1069
6160, 14150, 14151, 1076, 1075, 14670, 14691, 1087, 14690
6161, 14151, 14152, 1077, 1076, 14672, 14692, 1088, 14691
6162, 14152, 14153, 1078, 1077, 14674, 14693, 1089, 14692
6163, 14153, 14154, 1079, 1078, 14676, 14694, 1090, 14693
6164, 14154, 14155, 1080, 1079, 14678, 14695, 1091, 14694
6165, 14155, 14156, 1081, 1080, 14680, 14696, 1092, 14695
6166, 14156, 14157, 1082, 1081, 14682, 14697, 1093, 14696
6167, 14157, 14158, 1083, 1082, 14684, 14698, 1094, 14697
6168, 14158, 14159, 1084, 1083, 14686, 14699, 1095, 14698
6169, 14159, 14160, 1085, 1084, 14688, 14700, 1096, 14699
6170, 14160, 1125, 23, 1085, 14689, 1149, 1097, 14700
*ELEMENT, type=CPS8, ELSET=Surface27
6171, 19, 1173, 14701, 1070, 1177, 14709, 14710, 1072
6172, 1173, 1174, 14702, 14701, 1178, 14711, 14712, 14709
6173, 1174, 1175, 14703, 14702, 1179, 14713, 14714, 14711
6174, 1175, 1176, 14704, 14703, 1180, 14715, 14716, 14713
6175, 1176, 25, 1191, 14704, 1181, 1193, 14717, 14715
6176, 1070, 14701, 14705, 1071, 14710, 14718, 14719, 1073
6177, 14701, 14702, 14706, 14705, 14712, 14720, 14721, 14718
6178, 14702, 14703, 14707, 14706, 14714, 14722, 14723, 14720
6179, 14703, 14704, 14708, 14707, 14716, 14724, 14725, 14722
6180, 14704, 1191, 1192, 14708, 14717, 1194, 14726, 14724
6181, 1071, 14705, 1182, 23, 14719, 14727, 1186, 1074
6182, 14705, 14706, 1183, 1182, 14721, 14728, 1187, 14727
6183, 14706, 14707, 1184, 1183, 14723, 14729, 1188, 14728
6184, 14707, 14708, 1185, 1184, 14725, 14730, 1189, 14729
6185, 14708, 1192, 26, 1185, 14726, 1195, 1190, 14730
*ELEMENT, type=CPS8, ELSET=Surface28
6186, 17, 1013, 14731, 1196, 1015, 14739, 14740, 1200
6187, 1196, 14731, 14732, 1197, 14740, 14741, 14742, 1201
6188, 1197, 14732, 14733, 1198, 14742, 14743, 14744, 1202
6189, 1198, 14733, 14734, 1199, 14744, 14745, 14746, 1203
6190, 1199, 14734, 1214, 27, 14746, 14747, 1216, 1204
6191, 1013, 1014, 14735, 14731, 1016, 14748, 14749, 14739
6192, 14731, 14735, 14736, 14732, 14749, 14750, 14751, 14741
6193, 14732, 14736, 14737, 14733, 14751, 14752, 14753, 14743
6194, 14733, 14737, 14738, 14734, 14753, 14754, 14755, 14745
6195, 14734, 14738, 1215, 1214, 14755, 14756, 1217, 14747
6196, 1014, 21, 1205, 14735, 1017, 1209, 14757, 14748
6197, 14735, 1205, 1206, 14736, 14757, 1210, 14758, 14750
6198, 14736, 1206, 1207, 14737, 14758, 1211, 14759, 14752
6199, 14737, 1207, 1208, 14738, 14759, 1212, 14760, 14754
6200, 14738, 1208, 28, 1215, 14760, 1213, 1218, 14756
*ELEMENT, type=CPS8, ELSET=Surface29
6201, 17, 1196, 14761, 919, 1200, 14805, 14806, 930
6202, 1196, 1197, 14762, 14761, 1201, 14807, 14808, 14805
6203, 1197, 1198, 14763, 14762, 1202, 14809, 14810, 14807
6204, 1198, 1199, 14764, 14763, 1203, 14811, 14812, 14809
6205, 1199, 27, 1219, 14764, 1204, 1230, 14813, 14811
6206, 919, 14761, 14765, 920, 14806, 14814, 14815, 931
6207, 14761, 14762, 14766, 14765, 14808, 14816, 14817, 14814
6208, 14762, 14763, 14767, 14766, 14810, 14818, 14819, 14816
6209, 14763, 14764, 14768, 14767, 14812, 14820, 14821, 14818
6210, 14764, 1219, 1220, 14768, 14813, 1231, 14822, 14820
6211, 920, 14765, 14769, 921, 14815, 14823, 14824, 932
6212, 14765, 14766, 14770, 14769, 14817, 14825, 14826, 14823
6213, 14766, 14767, 14771, 14770, 14819, 14827, 14828, 14825
6214, 14767, 14768, 14772, 14771, 14821, 14829, 14830, 14827
6215, 14768, 1220, 1221, 14772, 14822, 1232, 14831, 14829
6216, 921, 14769, 14773, 922, 14824, 14832, 14833, 933
6217, 14769, 14770, 14774, 14773, 14826, 14834, 14835, 14832
6218, 14770, 14771, 14775, 14774, 14828, 14836, 14837, 14834
6219, 14771, 14772, 14776, 14775, 14830, 14838, 14839, 14836
6220, 14772, 1221, 1222, 14776, 14831, 1233, 14840, 14838
6221, 922, 14773, 14777, 923, 14833, 14841, 14842, 934
6222, 14773, 14774, 14778, 14777, 14835, 14843, 14844, 14841
6223, 14774, 14775, 14779, 14778, 14837, 14845, 14846, 14843
6224, 14775, 14776, 14780, 14779, 14839, 14847, 14848, 14845
6225, 14776, 1222, 1223, 14780, 14840, 1234, 14849, 14847
6226, 923, 14777, 14781, 924, 14842, 14850, 14851, 935
6227, 14777, 14778, 14782, 14781, 14844, 14852, 14853, 14850
6228, 14778, 14779, 14783, 14782, 14846, 14854, 14855, 14852
6229, 14779, 14780, 14784, 14783, 14848, 14856, 14857, 14854
6230, 14780, 1223, 1224, 14784, 14849, 1235, 14858, 14856
6231, 924, 14781, 14785, 925, 14851, 14859, 14860, 936
6232, 14781, 14782, 14786, 14785, 14853, 14861, 14862, 14859
6233, 14782, 14783, 14787, 14786, 14855, 14863, 14864, 14861
6234, 14783, 14784, 14788, 14787, 14857, 14865, 14866, 14863
6235, 14784, 1224, 1225, 14788, 14858, 1236, 14867, 14865
6236, 925, 14785, 14789, 926, 14860, 14868, 14869, 937
6237, 14785, 14786, 14790, 14789, 14862, 14870, 14871, 14868
6238, 14786, 14787, 14791, 14790, 14864, 14872, 14873, 14870
6239, 14787, 14788, 14792, 14791, 14866, 14874, 14875, 14872
6240, 14788, 1225, 1226, 14792, 14867, 1237, 14876, 14874
6241, 926, 14789, 14793, 927, 14869, 14877, 14878, 938
6242, 14789, 14790, 14794, 14793, 14871, 14879, 14880, 14877
6243, 14790, 14791, 14795, 14794, 14873, 14881, 14882, 14879
6244, 14791, 14792, 14796, 14795, 14875, 14883, 14884, 14881
6245, 14792, 1226, 1227, 14796, 14876, 1238, 14885, 14883
6246, 927, 14793, 14797, 928, 14878, 14886, 14887, 939
6247, 14793, 14794, 14798, 14797, 14880, 14888, 14889, 14886
6248, 14794, 14795, 14799, 14798, 14882, 14890, 14891, 14888
6249, 14795, 14796, 14800, 14799, 14884, 14892, 14893, 14890
6250, 14796, 1227, 1228, 14800, 14885, 1239, 14894, 14892
6251, 928, 14797, 14801, 929, 14887, 14895, 14896, 940
6252, 14797, 14798, 14802, 14801, 14889, 14897, 14898, 14895
6253, 14798, 14799, 14803, 14802, 14891, 14899, 14900, 14897
6254, 14799, 14800, 14804, 14803, 14893, 14901, 14902, 14899
6255, 14800, 1228, 1229, 14804, 14894, 1240, 14903, 14901
6256, 929, 14801, 1173, 19, 14896, 14904, 1177, 941
6257, 14801, 14802, 1174, 1173, 14898, 14905, 1178, 14904
6258, 14802, 14803, 1175, 1174, 14900, 14906, 1179, 14905
6259, 14803, 14804, 1176, 1175, 14902, 14907, 1180, 14906
6260, 14804, 1229, 25, 1176, 14903, 1241, 1181, 14907
*ELEMENT, type=CPS8, ELSET=Surface30
6261, 21, 1075, 14908, 1205, 1086, 14952, 14953, 1209
6262, 1205, 14908, 14909, 1206, 14953, 14954, 14955, 1210
6263, 1206, 14909, 14910, 1207, 14955, 14956, 14957, 1211
6264, 1207, 14910, 14911, 1208, 14957, 14958, 14959, 1212
6265, 1208, 14911, 1242, 28, 14959, 14960, 1253, 1213
6266, 1075, 1076, 14912, 14908, 1087, 14961, 14962, 14952
6267, 14908, 14912, 14913, 14909, 14962, 14963, 14964, 14954
6268, 14909, 14913, 14914, 14910, 14964, 14965, 14966, 14956
6269, 14910, 14914, 14915, 14911, 14966, 14967, 14968, 14958
6270, 14911, 14915, 1243, 1242, 14968, 14969, 1254, 14960
6271, 1076, 1077, 14916, 14912, 1088, 14970, 14971, 14961
6272, 14912, 14916, 14917, 14913, 14971, 14972, 14973, 14963
6273, 14913, 14917, 14918, 14914, 14973, 14974, 14975, 14965
6274, 14914, 14918, 14919, 14915, 14975, 14976, 14977, 14967
6275, 14915, 14919, 1244, 1243, 14977, 14978, 1255, 14969
6276, 1077, 1078, 14920, 14916, 1089, 14979, 14980, 14970
6277, 14916, 14920, 14921, 14917, 14980, 14981, 14982, 14972
6278, 14917, 14921, 14922, 14918, 14982, 14983, 14984, 14974
6279, 14918, 14922, 14923, 14919, 14984, 14985, 14986, 14976
6280, 14919, 14923, 1245, 1244, 14986, 14987, 1256, 14978
6281, 1078, 1079, 14924, 14920, 1090, 14988, 14989, 14979
6282, 14920, 14924, 14925, 14921, 14989, 14990, 14991, 14981
6283, 14921, 14925, 14926, 14922, 14991, 14992, 14993, 14983
6284, 14922, 14926, 14927, 14923, 14993, 14994, 14995, 14985
6285, 14923, 14927, 1246, 1245, 14995, 14996, 1257, 14987
6286, 1079, 1080, 14928, 14924, 1091, 14997, 14998, 14988
6287, 14924, 14928, 14929, 14925, 14998, 14999, 15000, 14990
6288, 14925, 14929, 14930, 14926, 15000, 15001, 15002, 14992
6289, 14926, 14930, 14931, 14927, 15002, 15003, 15004, 14994
6290, 14927, 14931, 1247, 1246, 15004, 15005, 1258, 14996
6291, 1080, 1081, 14932, 14928, 1092, 15006, 15007, 14997
6292, 14928, 14932, 14933, 14929, 15007, 15008, 15009, 14999
6293, 14929, 14933, 14934, 14930, 15009, 15010, 15011, 15001
6294, 14930, 14934, 14935, 14931, 15011, 15012, 15013, 15003
6295, 14931, 14935, 1248, 1247, 15013, 15014, 1259, 15005
6296, 1081, 1082, 14936, 14932, 1093, 15015, 15016, 15006
6297, 14932, 14936, 14937, 14933, 15016, 15017, 15018, 15008
6298, 14933, 14937, 14938, 14934, 15018, 15019, 15020, 15010
6299, 14934, 14938, 14939, 14935, 15020, 15021, 15022, 15012
6300, 14935, 14939, 1249, 1248, 15022, 15023, 1260, 15014
6301, 1082, 1083, 14940, 14936, 1094, 15024, 15025, 15015
6302, 14936, 14940, 14941, 14937, 15025, 15026, 15027, 15017
6303, 14937, 14941, 14942, 14938, 15027, 15028, 15029, 15019
6304, 14938, 14942, 14943, 14939, 15029, 15030, 15031, 15021
6305, 14939, 14943, 1250, 1249, 15031, 15032, 1261, 15023
6306, 1083, 1084, 14944, 14940, 1095, 15033, 15034, 15024
6307, 14940, 14944, 14945, 14941, 15034, 15035, 15036, 15026
6308, 14941, 14945, 14946, 14942, 15036, 15037, 15038, 15028
6309, 14942, 14946, 14947, 14943, 15038, 15039, 15040, 15030
6310, 14943, 14947, 1251, 1250, 15040, 15041, 1262, 15032
6311, 1084, 1085, 14948, 14944, 1096, 15042, 15043, 15033
6312, 14944, 14948, 14949, 14945, 15043, 15044, 15045, 15035
6313, 14945, 14949, 14950, 14946, 15045, 15046, 15047, 15037
6314, 14946, 14950, 14951, 14947, 15047, 15048, 15049, 15039
6315, 14947, 14951, 1252, 1251, 15049, 15050, 1263, 15041
6316, 1085, 23, 1182, 14948, 1097, 1186, 15051, 15042
6317, 14948, 1182, 1183, 14949, 15051, 1187, 15052, 15044
6318, 14949, 1183, 1184, 14950, 15052, 1188, 15053, 15046
6319, 14950, 1184, 1185, 14951, 15053, 1189, 15054, 15048
6320, 14951, 1185, 26, 1252, 15054, 1190, 1264, 15050
*ELEMENT, type=CPS8, ELSET=Surface31
6321, 27, 1214, 15055, 1219, 1216, 15077, 15078, 1230
6322, 1214, 1215, 15056, 15055, 1217, 15079, 15080, 15077
6323, 1215, 28, 1242, 15056, 1218, 1253, 15081, 15079
6324, 1219, 15055, 15057, 1220, 15078, 15082, 15083, 1231
6325, 15055, 15056, 15058, 15057, 15080, 15084, 15085, 15082
6326, 15056, 1242, 1243, 15058, 15081, 1254, 15086, 15084
6327, 1220, 15057, 15059, 1221, 15083, 15087, 15088, 1232
6328, 15057, 15058, 15060, 15059, 15085, 15089, 15090, 15087
6329, 15058, 1243, 1244, 15060, 15086, 1255, 15091, 15089
6330, 1221, 15059, 15061, 1222, 15088, 15092, 15093, 1233
6331, 15059, 15060, 15062, 15061, 15090, 15094, 15095, 15092
6332, 15060, 1244, 1245, 15062, 15091, 1256, 15096, 15094
6333, 1222, 15061, 15063, 1223, 15093, 15097, 15098, 1234
6334, 15061, 15062, 15064, 15063, 15095, 15099, 15100, 15097
6335, 15062, 1245, 1246, 15064, 15096, 1257, 15101, 15099
6336, 1223, 15063, 15065, 1224, 15098, 15102, 15103, 1235
6337, 15063, 15064, 15066, 15065, 15100, 15104, 15105, 15102
6338, 15064, 1246, 1247, 15066, 15101, 1258, 15106, 15104
6339, 1224, 15065, 15067, 1225, 15103, 15107, 15108, 1236
6340, 15065, 15066, 15068, 15067, 15105, 15109, 15110, 15107
6341, 15066, 1247, 1248, 15068, 15106, 1259, 15111, 15109
6342, 1225, 15067, 15069, 1226, 15108, 15112, 15113, 1237
6343, 15067, 15068, 15070, 15069, 15110, 15114, 15115, 15112
6344, 15068, 1248, 1249, 15070, 15111, 1260, 15116, 15114
6345, 1226, 15069, 15071, 1227, 15113, 15117, 15118, 1238
6346, 15069, 15070, 15072, 15071, 15115, 15119, 15120, 15117
6347, 15070, 1249, 1250, 15072, 15116, 1261, 15121, 15119
6348, 1227, 15071, 15073, 1228, 15118, 15122, 15123, 1239
6349, 15071, 15072, 15074, 15073, 15120, 15124, 15125, 15122
6350, 15072, 1250, 1251, 15074, 15121, 1262, 15126, 15124
6351, 1228, 15073, 15075, 1229, 15123, 15127, 15128, 1240
6352, 15073, 15074, 15076, 15075, 15125, 15129, 15130, 15127
6353, 15074, 1251, 1252, 15076, 15126, 1263, 15131, 15129
6354, 1229, 15075, 1191, 25, 15128, 15132, 1193, 1241
6355, 15075, 15076, 1192, 1191, 15130, 15133, 1194, 15132
6356, 15076, 1252, 26, 1192, 15131, 1264, 1195, 15133
*ELEMENT, type=CPS8, ELSET=Surface32
6357, 25, 1265, 15134, 1191, 1288, 15180, 15181, 1193
6358, 1265, 1266, 15135, 15134, 1289, 15182, 15183, 15180
6359, 1266, 1267, 15136, 15135, 1290, 15184, 15185, 15182
6360, 1267, 1268, 15137, 15136, 1291, 15186, 15187, 15184
6361, 1268, 1269, 15138, 15137, 1292, 15188, 15189, 15186
6362, 1269, 1270, 15139, 15138, 1293, 15190, 15191, 15188
6363, 1270, 1271, 15140, 15139, 1294, 15192, 15193, 15190
6364, 1271, 1272, 15141, 15140, 1295, 15194, 15195, 15192
6365, 1272, 1273, 15142, 15141, 1296, 15196, 15197, 15194
6366, 1273, 1274, 15143, 15142, 1297, 15198, 15199, 15196
6367, 1274, 1275, 15144, 15143, 1298, 15200, 15201, 15198
6368, 1275, 1276, 15145, 15144, 1299, 15202, 15203, 15200
6369, 1276, 1277, 15146, 15145, 1300, 15204, 15205, 15202
6370, 1277, 1278, 15147, 15146, 1301, 15206, 15207, 15204
6371, 1278, 1279, 15148, 15147, 1302, 15208, 15209, 15206
6372, 1279, 1280, 15149, 15148, 1303, 15210, 15211, 15208
6373, 1280, 1281, 15150, 15149, 1304, 15212, 15213, 15210
6374, 1281, 1282, 15151, 15150, 1305, 15214, 15215, 15212
6375, 1282, 1283, 15152, 15151, 1306, 15216, 15217, 15214
6376, 1283, 1284, 15153, 15152, 1307, 15218, 15219, 15216
6377, 1284, 1285, 15154, 15153, 1308, 15220, 15221, 15218
6378, 1285, 1286, 15155, 15154, 1309, 15222, 15223, 15220
6379, 1286, 1287, 15156, 15155, 1310, 15224, 15225, 15222
6380, 1287, 29, 1359, 15156, 1311, 1361, 15226, 15224
6381, 1191, 15134, 15157, 1192, 15181, 15227, 15228, 1194
6382, 15134, 15135, 15158, 15157, 15183, 15229, 15230, 15227
6383, 15135, 15136, 15159, 15158, 15185, 15231, 15232, 15229
6384, 15136, 15137, 15160, 15159, 15187, 15233, 15234, 15231
6385, 15137, 15138, 15161, 15160, 15189, 15235, 15236, 15233
6386, 15138, 15139, 15162, 15161, 15191, 15237, 15238, 15235
6387, 15139, 15140, 15163, 15162, 15193, 15239, 15240, 15237
6388, 15140, 15141, 15164, 15163, 15195, 15241, 15242, 15239
6389, 15141, 15142, 15165, 15164, 15197, 15243, 15244, 15241
6390, 15142, 15143, 15166, 15165, 15199, 15245, 15246, 15243
6391, 15143, 15144, 15167, 15166, 15201, 15247, 15248, 15245
6392, 15144, 15145, 15168, 15167, 15203, 15249, 15250, 15247
6393, 15145, 15146, 15169, 15168, 15205, 15251, 15252, 15249
6394, 15146, 15147, 15170, 15169, 15207, 15253, 15254, 15251
6395, 15147, 15148, 15171, 15170, 15209, 15255, 15256, 15253
6396, 15148, 15149, 15172, 15171, 15211, 15257, 15258, 15255
6397, 15149, 15150, 15173, 15172, 15213, 15259, 15260, 15257
6398, 15150, 15151, 15174, 15173, 15215, 15261, 15262, 15259
6399, 15151, 15152, 15175, 15174, 15217, 15263, 15264, 15261
6400, 15152, 15153, 15176, 15175, 15219, 15265, 15266, 15263
6401, 15153, 15154, 15177, 15176, 15221, 15267, 15268, 15265
6402, 15154, 15155, 15178, 15177, 15223, 15269, 15270, 15267
6403, 15155, 15156, 15179, 15178, 15225, 15271, 15272, 15269
6404, 15156, 1359, 1360, 15179, 15226, 1362, 15273, 15271
6405, 1192, 15157, 1312, 26, 15228, 15274, 1335, 1195
6406, 15157, 15158, 1313, 1312, 15230, 15275, 1336, 15274
6407, 15158, 15159, 1314, 1313, 15232, 15276, 1337, 15275
6408, 15159, 15160, 1315, 1314, 15234, 15277, 1338, 15276
6409, 15160, 15161, 1316, 1315, 15236, 15278, 1339, 15277
6410, 15161, 15162, 1317, 1316, 15238, 15279, 1340, 15278
6411, 15162, 15163, 1318, 1317, 15240, 15280, 1341, 15279
6412, 15163, 15164, 1319, 1318, 15242, 15281, 1342, 15280
6413, 15164, 15165, 1320, 1319, 15244, 15282, 1343, 15281
6414, 15165, 15166, 1321, 1320, 15246, 15283, 1344, 15282
6415, 15166, 15167, 1322, 1321, 15248, 15284, 1345, 15283
6416, 15167, 15168, 1323, 1322, 15250, 15285, 1346, 15284
6417, 15168, 15169, 1324, 1323, 15252, 15286, 1347, 15285
6418, 15169, 15170, 1325, 1324, 15254, 15287, 1348, 15286
6419, 15170, 15171, 1326, 1325, 15256, 15288, 1349, 15287
6420, 15171, 15172, 1327, 1326, 15258, 15289, 1350, 15288
6421, 15172, 15173, 1328, 1327, 15260, 15290, 1351, 15289
6422, 15173, 15174, 1329, 1328, 15262, 15291, 1352, 15290
6423, 15174, 15175, 1330, 1329, 15264, 15292, 1353, 15291
6424, 15175, 15176, 1331, 1330, 15266, 15293, 1354, 15292
6425, 15176, 15177, 1332, 1331, 15268, 15294, 1355, 15293
6426, 15177, 15178, 1333, 1332, 15270, 15295, 1356, 15294
6427, 15178, 15179, 1334, 1333, 15272, 15296, 1357, 15295
6428, 15179, 1360, 30, 1334, 15273, 1363, 1358, 15296
*ELEMENT, type=CPS8, ELSET=Surface33
6429, 27, 1214, 15297, 1364, 1216, 15343, 15344, 1387
6430, 1364, 15297, 15298, 1365, 15344, 15345, 15346, 1388
6431, 1365, 15298, 15299, 1366, 15346, 15347, 15348, 1389
6432, 1366, 15299, 15300, 1367, 15348, 15349, 15350, 1390
6433, 1367, 15300, 15301, 1368, 15350, 15351, 15352, 1391
6434, 1368, 15301, 15302, 1369, 15352, 15353, 15354, 1392
6435, 1369, 15302, 15303, 1370, 15354, 15355, 15356, 1393
6436, 1370, 15303, 15304, 1371, 15356, 15357, 15358, 1394
6437, 1371, 15304, 15305, 1372, 15358, 15359, 15360, 1395
6438, 1372, 15305, 15306, 1373, 15360, 15361, 15362, 1396
6439, 1373, 15306, 15307, 1374, 15362, 15363, 15364, 1397
6440, 1374, 15307, 15308, 1375, 15364, 15365, 15366, 1398
6441, 1375, 15308, 15309, 1376, 15366, 15367, 15368, 1399
6442, 1376, 15309, 15310, 1377, 15368, 15369, 15370, 1400
6443, 1377, 15310, 15311, 1378, 15370, 15371, 15372, 1401
6444, 1378, 15311, 15312, 1379, 15372, 15373, 15374, 1402
6445, 1379, 15312, 15313, 1380, 15374, 15375, 15376, 1403
6446, 1380, 15313, 15314, 1381, 15376, 15377, 15378, 1404
6447, 1381, 15314, 15315, 1382, 15378, 15379, 15380, 1405
6448, 1382, 15315, 15316, 1383, 15380, 15381, 15382, 1406
6449, 1383, 15316, 15317, 1384, 15382, 15383, 15384, 1407
6450, 1384, 15317, 15318, 1385, 15384, 15385, 15386, 1408
6451, 1385, 15318, 15319, 1386, 15386, 15387, 15388, 1409
6452, 1386, 15319, 1458, 31, 15388, 15389, 1460, 1410
6453, 1214, 1215, 15320, 15297, 1217, 15390, 15391, 15343
6454, 15297, 15320, 15321, 15298, 15391, 15392, 15393, 15345
6455, 15298, 15321, 15322, 15299, 15393, 15394, 15395, 15347
6456, 15299, 15322, 15323, 15300, 15395, 15396, 15397, 15349
6457, 15300, 15323, 15324, 15301, 15397, 15398, 15399, 15351
6458, 15301, 15324, 15325, 15302, 15399, 15400, 15401, 15353
6459, 15302, 15325, 15326, 15303, 15401, 15402, 15403, 15355
6460, 15303, 15326, 15327, 15304, 15403, 15404, 15405, 15357
6461, 15304, 15327, 15328, 15305, 15405, 15406, 15407, 15359
6462, 15305, 15328, 15329, 15306, 15407, 15408, 15409, 15361
6463, 15306, 15329, 15330, 15307, 15409, 15410, 15411, 15363
6464, 15307, 15330, 15331, 15308, 15411, 15412, 15413, 15365
6465, 15308, 15331, 15332, 15309, 15413, 15414, 15415, 15367
6466, 15309, 15332, 15333, 15310, 15415, 15416, 15417, 15369
6467, 15310, 15333, 15334, 15311, 15417, 15418, 15419, 15371
6468, 15311, 15334, 15335, 15312, 15419, 15420, 15421, 15373
6469, 15312, 15335, 15336, 15313, 15421, 15422, 15423, 15375
6470, 15313, 15336, 15337, 15314, 15423, 15424, 15425, 15377
6471, 15314, 15337, 15338, 15315, 15425, 15426, 15427, 15379
6472, 15315, 15338, 15339, 15316, 15427, 15428, 15429, 15381
6473, 15316, 15339, 15340, 15317, 15429, 15430, 15431, 15383
6474, 15317, 15340, 15341, 15318, 15431, 15432, 15433, 15385
6475, 15318, 15341, 15342, 15319, 15433, 15434, 15435, 15387
6476, 15319, 15342, 1459, 1458, 15435, 15436, 1461, 15389
6477, 1215, 28, 1411, 15320, 1218, 1434, 15437, 15390
6478, 15320, 1411, 1412, 15321, 15437, 1435, 15438, 15392
6479, 15321, 1412, 1413, 15322, 15438, 1436, 15439, 15394
6480, 15322, 1413, 1414, 15323, 15439, 1437, 15440, 15396
6481, 15323, 1414, 1415, 15324, 15440, 1438, 15441, 15398
6482, 15324, 1415, 1416, 15325, 15441, 1439, 15442, 15400
6483, 15325, 1416, 1417, 15326, 15442, 1440, 15443, 15402
6484, 15326, 1417, 1418, 15327, 15443, 1441, 15444, 15404
6485, 15327, 1418, 1419, 15328, 15444, 1442, 15445, 15406
6486, 15328, 1419, 1420, 15329, 15445, 1443, 15446, 15408
6487, 15329, 1420, 1421, 15330, 15446, 1444, 15447, 15410
6488, 15330, 1421, 1422, 15331, 15447, 1445, 15448, 15412
6489, 15331, 1422, 1423, 15332, 15448, 1446, 15449, 15414
6490, 15332, 1423, 1424, 15333, 15449, 1447, 15450, 15416
6491, 15333, 1424, 1425, 15334, 15450, 1448, 15451, 15418
6492, 15334, 1425, 1426, 15335, 15451, 1449, 15452, 15420
6493, 15335, 1426, 1427, 15336, 15452, 1450, 15453, 15422
6494, 15336, 1427, 1428, 15337, 15453, 1451, 15454, 15424
6495, 15337, 1428, 1429, 15338, 15454, 1452, 15455, 15426
6496, 15338, 1429, 1430, 15339, 15455, 1453, 15456, 15428
6497, 15339, 1430, 1431, 15340, 15456, 1454, 15457, 15430
6498, 15340, 1431, 1432, 15341, 15457, 1455, 15458, 15432
6499, 15341, 1432, 1433, 15342, 15458, 1456, 15459, 15434
6500, 15342, 1433, 32, 1459, 15459, 1457, 1462, 15436
*ELEMENT, type=CPS8, ELSET=Surface34
6501, 27, 1364, 15460, 1219, 1387, 15713, 15714, 1230
6502, 1364, 1365, 15461, 15460, 1388, 15715, 15716, 15713
6503, 1365, 1366, 15462, 15461, 1389, 15717, 15718, 15715
6504, 1366, 1367, 15463, 15462, 1390, 15719, 15720, 15717
6505, 1367, 1368, 15464, 15463, 1391, 15721, 15722, 15719
6506, 1368, 1369, 15465, 15464, 1392, 15723, 15724, 15721
6507, 1369, 1370, 15466, 15465, 1393, 15725, 15726, 15723
6508, 1370, 1371, 15467, 15466, 1394, 15727, 15728, 15725
6509, 1371, 1372, 15468, 15467, 1395, 15729, 15730, 15727
6510, 1372, 1373, 15469, 15468, 1396, 15731, 15732, 15729
6511, 1373, 1374, 15470, 15469, 1397, 15733, 15734, 15731
6512, 1374, 1375, 15471, 15470, 1398, 15735, 15736, 15733
6513, 1375, 1376, 15472, 15471, 1399, 15737, 15738, 15735
6514, 1376, 1377, 15473, 15472, 1400, 15739, 15740, 15737
6515, 1377, 1378, 15474, 15473, 1401, 15741, 15742, 15739
6516, 1378, 1379, 15475, 15474, 1402, 15743, 15744, 15741
6517, 1379, 1380, 15476, 15475, 1403, 15745, 15746, 15743
6518, 1380, 1381, 15477, 15476, 1404, 15747, 15748, 15745
6519, 1381, 1382, 15478, 15477, 1405, 15749, 15750, 15747
6520, 1382, 1383, 15479, 15478, 1406, 15751, 15752, 15749
6521, 1383, 1384, 15480, 15479, 1407, 15753, 15754, 15751
6522, 1384, 1385, 15481, 15480, 1408, 15755, 15756, 15753
6523, 1385, 1386, 15482, 15481, 1409, 15757, 15758, 15755
6524, 1386, 31, 1463, 15482, 1410, 1474, 15759, 15757
6525, 1219, 15460, 15483, 1220, 15714, 15760, 15761, 1231
6526, 15460, 15461, 15484, 15483, 15716, 15762, 15763, 15760
6527, 15461, 15462, 15485, 15484, 15718, 15764, 15765, 15762
6528, 15462, 15463, 15486, 15485, 15720, 15766, 15767, 15764
6529, 15463, 15464, 15487, 15486, 15722, 15768, 15769, 15766
6530, 15464, 15465, 15488, 15487, 15724, 15770, 15771, 15768
6531, 15465, 15466, 15489, 15488, 15726, 15772, 15773, 15770
6532, 15466, 15467, 15490, 15489, 15728, 15774, 15775, 15772
6533, 15467, 15468, 15491, 15490, 15730, 15776, 15777, 15774
6534, 15468, 15469, 15492, 15491, 15732, 15778, 15779, 15776
6535, 15469, 15470, 15493, 15492, 15734, 15780, 15781, 15778
6536, 15470, 15471, 15494, 15493, 15736, 15782, 15783, 15780
6537, 15471, 15472, 15495, 15494, 15738, 15784, 15785, 15782
6538, 15472, 15473, 15496, 15495, 15740, 15786, 15787, 15784
6539, 15473, 15474, 15497, 15496, 15742, 15788, 15789, 15786
6540, 15474, 15475, 15498, 15497, 15744, 15790, 15791, 15788
6541, 15475, 15476, 15499, 15498, 15746, 15792, 15793, 15790
6542, 15476, 15477, 15500, 15499, 15748, 15794, 15795, 15792
6543, 15477, 15478, 15501, 15500, 15750, 15796, 15797, 15794
6544, 15478, 15479, 15502, 15501, 15752, 15798, 15799, 15796
6545, 15479, 15480, 15503, 15502, 15754, 15800, 15801, 15798
6546, 15480, 15481, 15504, 15503, 15756, 15802, 15803, 15800
6547, 15481, 15482, 15505, 15504, 15758, 15804, 15805, 15802
6548, 15482, 1463, 1464, 15505, 15759, 1475, 15806, 15804
6549, 1220, 15483, 15506, 1221, 15761, 15807, 15808, 1232
6550, 15483, 15484, 15507, 15506, 15763, 15809, 15810, 15807
6551, 15484, 15485, 15508, 15507, 15765, 15811, 15812, 15809
6552, 15485, 15486, 15509, 15508, 15767, 15813, 15814, 15811
6553, 15486, 15487, 15510, 15509, 15769, 15815, 15816, 15813
6554, 15487, 15488, 15511, 15510, 15771, 15817, 15818, 15815
6555, 15488, 15489, 15512, 15511, 15773, 15819, 15820, 15817
6556, 15489, 15490, 15513, 15512, 15775, 15821, 15822, 15819
6557, 15490, 15491, 15514, 15513, 15777, 15823, 15824, 15821
6558, 15491, 15492, 15515, 15514, 15779, 15825, 15826, 15823
6559, 15492, 15493, 15516, 15515, 15781, 15827, 15828, 15825
6560, 15493, 15494, 15517, 15516, 15783, 15829, 15830, 15827
6561, 15494, 15495, 15518, 15517, 15785, 15831, 15832, 15829
6562, 15495, 15496, 15519, 15518, 15787, 15833, 15834, 15831
6563, 15496, 15497, 15520, 15519, 15789, 15835, 15836, 15833
6564, 15497, 15498, 15521, 15520, 15791, 15837, 15838, 15835
6565, 15498, 15499, 15522, 15521, 15793, 15839, 15840, 15837
6566, 15499, 15500, 15523, 15522, 15795, 15841, 15842, 15839
6567, 15500, 15501, 15524, 15523, 15797, 15843, 15844, 15841
6568, 15501, 15502, 15525, 15524, 15799, 15845, 15846, 15843
6569, 15502, 15503, 15526, 15525, 15801, 15847, 15848, 15845
6570, 15503, 15504, 15527, 15526, 15803, 15849, 15850, 15847
6571, 15504, 15505, 15528, 15527, 15805, 15851, 15852, 15849
6572, 15505, 1464, 1465, 15528, 15806, 1476, 15853, 15851
6573, 1221, 15506, 15529, 1222, 15808, 15854, 15855, 1233
6574, 15506, 15507, 15530, 15529, 15810, 15856, 15857, 15854
6575, 15507, 15508, 15531, 15530, 15812, 15858, 15859, 15856
6576, 15508, 15509, 15532, 15531, 15814, 15860, 15861, 15858
6577, 15509, 15510, 15533, 15532, 15816, 15862, 15863, 15860
6578, 15510, 15511, 15534, 15533, 15818, 15864, 15865, 15862
6579, 15511, 15512, 15535, 15534, 15820, 15866, 15867, 15864
6580, 15512, 15513, 15536, 15535, 15822, 15868, 15869, 15866
6581, 15513, 15514, 15537, 15536, 15824, 15870, 15871, 15868
6582, 15514, 15515, 15538, 15537, 15826, 15872, 15873, 15870
6583, 15515, 15516, 15539, 15538, 15828, 15874, 15875, 15872
6584, 15516, 15517, 15540, 15539, 15830, 15876, 15877, 15874
6585, 15517, 15518, 15541, 15540, 15832, 15878, 15879, 15876
6586, 15518, 15519, 15542, 15541, 15834, 15880, 15881, 15878
6587, 15519, 15520, 15543, 15542, 15836, 15882, 15883, 15880
6588, 15520, 15521, 15544, 15543, 15838, 15884, 15885, 15882
6589, 15521, 15522, 15545, 15544, 15840, 15886, 15887, 15884
6590, 15522, 15523, 15546, 15545, 15842, 15888, 15889, 15886
6591, 15523, 15524, 15547, 15546, 15844, 15890, 15891, 15888
6592, 15524, 15525, 15548, 15547, 15846, 15892, 15893, 15890
6593, 15525, 15526, 15549, 15548, 15848, 15894, 15895, 15892
6594, 15526, 15527, 15550, 15549, 15850, 15896, 15897, 15894
6595, 15527, 15528, 15551, 15550, 15852, 15898, 15899, 15896
6596, 15528, 1465, 1466, 15551, 15853, 1477, 15900, 15898
6597, 1222, 15529, 15552, 1223, 15855, 15901, 15902, 1234
6598, 15529, 15530, 15553, 15552, 15857, 15903, 15904, 15901
6599, 15530, 15531, 15554, 15553, 15859, 15905, 15906, 15903
6600, 15531, 15532, 15555, 15554, 15861, 15907, 15908, 15905
6601, 15532, 15533, 15556, 15555, 15863, 15909, 15910, 15907
6602, 15533, 15534, 15557, 15556, 15865, 15911, 15912, 15909
6603, 15534, 15535, 15558, 15557, 15867, 15913, 15914, 15911
6604, 15535, 15536, 15559, 15558, 15869, 15915, 15916, 15913
6605, 15536, 15537, 15560, 15559, 15871, 15917, 15918, 15915
6606, 15537, 15538, 15561, 15560, 15873, 15919, 15920, 15917
