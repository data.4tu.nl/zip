66339, 0.041666666666667, 1.4333333333333, 0.39583333333333
66340, 0.041666666666667, 1.45, 0.41666666666667
66341, 0.020833333333333, 1.4666666666667, 0.41666666666667
66342, 0.041666666666667, 1.4666666666667, 0.39583333333333
66343, 0.041666666666667, 1.4833333333333, 0.41666666666667
66344, 0.041666666666667, 1.4166666666667, 0.45833333333333
66345, 0.020833333333333, 1.4333333333333, 0.45833333333333
66346, 0.041666666666667, 1.4333333333333, 0.4375
66347, 0.041666666666667, 1.45, 0.45833333333333
66348, 0.020833333333333, 1.4666666666667, 0.45833333333333
66349, 0.041666666666667, 1.4666666666667, 0.4375
66350, 0.041666666666667, 1.4833333333333, 0.45833333333333
66351, 0.041666666666667, 1.4333333333333, 0.47916666666667
66352, 0.041666666666667, 1.4666666666667, 0.47916666666667
66353, 0.083333333333333, 1.4166666666667, 0.041666666666667
66354, 0.0625, 1.4333333333333, 0.041666666666667
66355, 0.083333333333333, 1.4333333333333, 0.020833333333333
66356, 0.083333333333333, 1.45, 0.041666666666667
66357, 0.0625, 1.4666666666667, 0.041666666666667
66358, 0.083333333333333, 1.4666666666667, 0.020833333333333
66359, 0.083333333333333, 1.4833333333333, 0.041666666666667
66360, 0.083333333333333, 1.4166666666667, 0.083333333333333
66361, 0.0625, 1.4333333333333, 0.083333333333333
66362, 0.083333333333333, 1.4333333333333, 0.0625
66363, 0.083333333333333, 1.45, 0.083333333333333
66364, 0.0625, 1.4666666666667, 0.083333333333333
66365, 0.083333333333333, 1.4666666666667, 0.0625
66366, 0.083333333333333, 1.4833333333333, 0.083333333333333
66367, 0.083333333333333, 1.4166666666667, 0.125
66368, 0.0625, 1.4333333333333, 0.125
66369, 0.083333333333333, 1.4333333333333, 0.10416666666667
66370, 0.083333333333333, 1.45, 0.125
66371, 0.0625, 1.4666666666667, 0.125
66372, 0.083333333333333, 1.4666666666667, 0.10416666666667
66373, 0.083333333333333, 1.4833333333333, 0.125
66374, 0.083333333333333, 1.4166666666667, 0.16666666666667
66375, 0.0625, 1.4333333333333, 0.16666666666667
66376, 0.083333333333333, 1.4333333333333, 0.14583333333333
66377, 0.083333333333333, 1.45, 0.16666666666667
66378, 0.0625, 1.4666666666667, 0.16666666666667
66379, 0.083333333333333, 1.4666666666667, 0.14583333333333
66380, 0.083333333333333, 1.4833333333333, 0.16666666666667
66381, 0.083333333333333, 1.4166666666667, 0.20833333333333
66382, 0.0625, 1.4333333333333, 0.20833333333333
66383, 0.083333333333333, 1.4333333333333, 0.1875
66384, 0.083333333333333, 1.45, 0.20833333333333
66385, 0.0625, 1.4666666666667, 0.20833333333333
66386, 0.083333333333333, 1.4666666666667, 0.1875
66387, 0.083333333333333, 1.4833333333333, 0.20833333333333
66388, 0.083333333333333, 1.4166666666667, 0.25
66389, 0.0625, 1.4333333333333, 0.25
66390, 0.083333333333333, 1.4333333333333, 0.22916666666667
66391, 0.083333333333333, 1.45, 0.25
66392, 0.0625, 1.4666666666667, 0.25
66393, 0.083333333333333, 1.4666666666667, 0.22916666666667
66394, 0.083333333333333, 1.4833333333333, 0.25
66395, 0.083333333333333, 1.4166666666667, 0.29166666666667
66396, 0.0625, 1.4333333333333, 0.29166666666667
66397, 0.083333333333333, 1.4333333333333, 0.27083333333333
66398, 0.083333333333333, 1.45, 0.29166666666667
66399, 0.0625, 1.4666666666667, 0.29166666666667
66400, 0.083333333333333, 1.4666666666667, 0.27083333333333
66401, 0.083333333333333, 1.4833333333333, 0.29166666666667
66402, 0.083333333333333, 1.4166666666667, 0.33333333333333
66403, 0.0625, 1.4333333333333, 0.33333333333333
66404, 0.083333333333333, 1.4333333333333, 0.3125
66405, 0.083333333333333, 1.45, 0.33333333333333
66406, 0.0625, 1.4666666666667, 0.33333333333333
66407, 0.083333333333333, 1.4666666666667, 0.3125
66408, 0.083333333333333, 1.4833333333333, 0.33333333333333
66409, 0.083333333333333, 1.4166666666667, 0.375
66410, 0.0625, 1.4333333333333, 0.375
66411, 0.083333333333333, 1.4333333333333, 0.35416666666667
66412, 0.083333333333333, 1.45, 0.375
66413, 0.0625, 1.4666666666667, 0.375
66414, 0.083333333333333, 1.4666666666667, 0.35416666666667
66415, 0.083333333333333, 1.4833333333333, 0.375
66416, 0.083333333333333, 1.4166666666667, 0.41666666666667
66417, 0.0625, 1.4333333333333, 0.41666666666667
66418, 0.083333333333333, 1.4333333333333, 0.39583333333333
66419, 0.083333333333333, 1.45, 0.41666666666667
66420, 0.0625, 1.4666666666667, 0.41666666666667
66421, 0.083333333333333, 1.4666666666667, 0.39583333333333
66422, 0.083333333333333, 1.4833333333333, 0.41666666666667
66423, 0.083333333333333, 1.4166666666667, 0.45833333333333
66424, 0.0625, 1.4333333333333, 0.45833333333333
66425, 0.083333333333333, 1.4333333333333, 0.4375
66426, 0.083333333333333, 1.45, 0.45833333333333
66427, 0.0625, 1.4666666666667, 0.45833333333333
66428, 0.083333333333333, 1.4666666666667, 0.4375
66429, 0.083333333333333, 1.4833333333333, 0.45833333333333
66430, 0.083333333333333, 1.4333333333333, 0.47916666666667
66431, 0.083333333333333, 1.4666666666667, 0.47916666666667
66432, 0.125, 1.4166666666667, 0.041666666666667
66433, 0.10416666666667, 1.4333333333333, 0.041666666666667
66434, 0.125, 1.4333333333333, 0.020833333333333
66435, 0.125, 1.45, 0.041666666666667
66436, 0.10416666666667, 1.4666666666667, 0.041666666666667
66437, 0.125, 1.4666666666667, 0.020833333333333
66438, 0.125, 1.4833333333333, 0.041666666666667
66439, 0.125, 1.4166666666667, 0.083333333333333
66440, 0.10416666666667, 1.4333333333333, 0.083333333333333
66441, 0.125, 1.4333333333333, 0.0625
66442, 0.125, 1.45, 0.083333333333333
66443, 0.10416666666667, 1.4666666666667, 0.083333333333333
66444, 0.125, 1.4666666666667, 0.0625
66445, 0.125, 1.4833333333333, 0.083333333333333
66446, 0.125, 1.4166666666667, 0.125
66447, 0.10416666666667, 1.4333333333333, 0.125
66448, 0.125, 1.4333333333333, 0.10416666666667
66449, 0.125, 1.45, 0.125
66450, 0.10416666666667, 1.4666666666667, 0.125
66451, 0.125, 1.4666666666667, 0.10416666666667
66452, 0.125, 1.4833333333333, 0.125
66453, 0.125, 1.4166666666667, 0.16666666666667
66454, 0.10416666666667, 1.4333333333333, 0.16666666666667
66455, 0.125, 1.4333333333333, 0.14583333333333
66456, 0.125, 1.45, 0.16666666666667
66457, 0.10416666666667, 1.4666666666667, 0.16666666666667
66458, 0.125, 1.4666666666667, 0.14583333333333
66459, 0.125, 1.4833333333333, 0.16666666666667
66460, 0.125, 1.4166666666667, 0.20833333333333
66461, 0.10416666666667, 1.4333333333333, 0.20833333333333
66462, 0.125, 1.4333333333333, 0.1875
66463, 0.125, 1.45, 0.20833333333333
66464, 0.10416666666667, 1.4666666666667, 0.20833333333333
66465, 0.125, 1.4666666666667, 0.1875
66466, 0.125, 1.4833333333333, 0.20833333333333
66467, 0.125, 1.4166666666667, 0.25
66468, 0.10416666666667, 1.4333333333333, 0.25
66469, 0.125, 1.4333333333333, 0.22916666666667
66470, 0.125, 1.45, 0.25
66471, 0.10416666666667, 1.4666666666667, 0.25
66472, 0.125, 1.4666666666667, 0.22916666666667
66473, 0.125, 1.4833333333333, 0.25
66474, 0.125, 1.4166666666667, 0.29166666666667
66475, 0.10416666666667, 1.4333333333333, 0.29166666666667
66476, 0.125, 1.4333333333333, 0.27083333333333
66477, 0.125, 1.45, 0.29166666666667
66478, 0.10416666666667, 1.4666666666667, 0.29166666666667
66479, 0.125, 1.4666666666667, 0.27083333333333
66480, 0.125, 1.4833333333333, 0.29166666666667
66481, 0.125, 1.4166666666667, 0.33333333333333
66482, 0.10416666666667, 1.4333333333333, 0.33333333333333
66483, 0.125, 1.4333333333333, 0.3125
66484, 0.125, 1.45, 0.33333333333333
66485, 0.10416666666667, 1.4666666666667, 0.33333333333333
66486, 0.125, 1.4666666666667, 0.3125
66487, 0.125, 1.4833333333333, 0.33333333333333
66488, 0.125, 1.4166666666667, 0.375
66489, 0.10416666666667, 1.4333333333333, 0.375
66490, 0.125, 1.4333333333333, 0.35416666666667
66491, 0.125, 1.45, 0.375
66492, 0.10416666666667, 1.4666666666667, 0.375
66493, 0.125, 1.4666666666667, 0.35416666666667
66494, 0.125, 1.4833333333333, 0.375
66495, 0.125, 1.4166666666667, 0.41666666666667
66496, 0.10416666666667, 1.4333333333333, 0.41666666666667
66497, 0.125, 1.4333333333333, 0.39583333333333
66498, 0.125, 1.45, 0.41666666666667
66499, 0.10416666666667, 1.4666666666667, 0.41666666666667
66500, 0.125, 1.4666666666667, 0.39583333333333
66501, 0.125, 1.4833333333333, 0.41666666666667
66502, 0.125, 1.4166666666667, 0.45833333333333
66503, 0.10416666666667, 1.4333333333333, 0.45833333333333
66504, 0.125, 1.4333333333333, 0.4375
66505, 0.125, 1.45, 0.45833333333333
66506, 0.10416666666667, 1.4666666666667, 0.45833333333333
66507, 0.125, 1.4666666666667, 0.4375
66508, 0.125, 1.4833333333333, 0.45833333333333
66509, 0.125, 1.4333333333333, 0.47916666666667
66510, 0.125, 1.4666666666667, 0.47916666666667
66511, 0.16666666666667, 1.4166666666667, 0.041666666666667
66512, 0.14583333333333, 1.4333333333333, 0.041666666666667
66513, 0.16666666666667, 1.4333333333333, 0.020833333333333
66514, 0.16666666666667, 1.45, 0.041666666666667
66515, 0.14583333333333, 1.4666666666667, 0.041666666666667
66516, 0.16666666666667, 1.4666666666667, 0.020833333333333
66517, 0.16666666666667, 1.4833333333333, 0.041666666666667
66518, 0.16666666666667, 1.4166666666667, 0.083333333333333
66519, 0.14583333333333, 1.4333333333333, 0.083333333333333
66520, 0.16666666666667, 1.4333333333333, 0.0625
66521, 0.16666666666667, 1.45, 0.083333333333333
66522, 0.14583333333333, 1.4666666666667, 0.083333333333333
66523, 0.16666666666667, 1.4666666666667, 0.0625
66524, 0.16666666666667, 1.4833333333333, 0.083333333333333
66525, 0.16666666666667, 1.4166666666667, 0.125
66526, 0.14583333333333, 1.4333333333333, 0.125
66527, 0.16666666666667, 1.4333333333333, 0.10416666666667
66528, 0.16666666666667, 1.45, 0.125
66529, 0.14583333333333, 1.4666666666667, 0.125
66530, 0.16666666666667, 1.4666666666667, 0.10416666666667
66531, 0.16666666666667, 1.4833333333333, 0.125
66532, 0.16666666666667, 1.4166666666667, 0.16666666666667
66533, 0.14583333333333, 1.4333333333333, 0.16666666666667
66534, 0.16666666666667, 1.4333333333333, 0.14583333333333
66535, 0.16666666666667, 1.45, 0.16666666666667
66536, 0.14583333333333, 1.4666666666667, 0.16666666666667
66537, 0.16666666666667, 1.4666666666667, 0.14583333333333
66538, 0.16666666666667, 1.4833333333333, 0.16666666666667
66539, 0.16666666666667, 1.4166666666667, 0.20833333333333
66540, 0.14583333333333, 1.4333333333333, 0.20833333333333
66541, 0.16666666666667, 1.4333333333333, 0.1875
66542, 0.16666666666667, 1.45, 0.20833333333333
66543, 0.14583333333333, 1.4666666666667, 0.20833333333333
66544, 0.16666666666667, 1.4666666666667, 0.1875
66545, 0.16666666666667, 1.4833333333333, 0.20833333333333
66546, 0.16666666666667, 1.4166666666667, 0.25
66547, 0.14583333333333, 1.4333333333333, 0.25
66548, 0.16666666666667, 1.4333333333333, 0.22916666666667
66549, 0.16666666666667, 1.45, 0.25
66550, 0.14583333333333, 1.4666666666667, 0.25
66551, 0.16666666666667, 1.4666666666667, 0.22916666666667
66552, 0.16666666666667, 1.4833333333333, 0.25
66553, 0.16666666666667, 1.4166666666667, 0.29166666666667
66554, 0.14583333333333, 1.4333333333333, 0.29166666666667
66555, 0.16666666666667, 1.4333333333333, 0.27083333333333
66556, 0.16666666666667, 1.45, 0.29166666666667
66557, 0.14583333333333, 1.4666666666667, 0.29166666666667
66558, 0.16666666666667, 1.4666666666667, 0.27083333333333
66559, 0.16666666666667, 1.4833333333333, 0.29166666666667
66560, 0.16666666666667, 1.4166666666667, 0.33333333333333
66561, 0.14583333333333, 1.4333333333333, 0.33333333333333
66562, 0.16666666666667, 1.4333333333333, 0.3125
66563, 0.16666666666667, 1.45, 0.33333333333333
66564, 0.14583333333333, 1.4666666666667, 0.33333333333333
66565, 0.16666666666667, 1.4666666666667, 0.3125
66566, 0.16666666666667, 1.4833333333333, 0.33333333333333
66567, 0.16666666666667, 1.4166666666667, 0.375
66568, 0.14583333333333, 1.4333333333333, 0.375
66569, 0.16666666666667, 1.4333333333333, 0.35416666666667
66570, 0.16666666666667, 1.45, 0.375
66571, 0.14583333333333, 1.4666666666667, 0.375
66572, 0.16666666666667, 1.4666666666667, 0.35416666666667
66573, 0.16666666666667, 1.4833333333333, 0.375
66574, 0.16666666666667, 1.4166666666667, 0.41666666666667
66575, 0.14583333333333, 1.4333333333333, 0.41666666666667
66576, 0.16666666666667, 1.4333333333333, 0.39583333333333
66577, 0.16666666666667, 1.45, 0.41666666666667
66578, 0.14583333333333, 1.4666666666667, 0.41666666666667
66579, 0.16666666666667, 1.4666666666667, 0.39583333333333
66580, 0.16666666666667, 1.4833333333333, 0.41666666666667
66581, 0.16666666666667, 1.4166666666667, 0.45833333333333
66582, 0.14583333333333, 1.4333333333333, 0.45833333333333
66583, 0.16666666666667, 1.4333333333333, 0.4375
66584, 0.16666666666667, 1.45, 0.45833333333333
66585, 0.14583333333333, 1.4666666666667, 0.45833333333333
66586, 0.16666666666667, 1.4666666666667, 0.4375
66587, 0.16666666666667, 1.4833333333333, 0.45833333333333
66588, 0.16666666666667, 1.4333333333333, 0.47916666666667
66589, 0.16666666666667, 1.4666666666667, 0.47916666666667
66590, 0.20833333333333, 1.4166666666667, 0.041666666666667
66591, 0.1875, 1.4333333333333, 0.041666666666667
66592, 0.20833333333333, 1.4333333333333, 0.020833333333333
66593, 0.20833333333333, 1.45, 0.041666666666667
66594, 0.1875, 1.4666666666667, 0.041666666666667
66595, 0.20833333333333, 1.4666666666667, 0.020833333333333
66596, 0.20833333333333, 1.4833333333333, 0.041666666666667
66597, 0.20833333333333, 1.4166666666667, 0.083333333333333
66598, 0.1875, 1.4333333333333, 0.083333333333333
66599, 0.20833333333333, 1.4333333333333, 0.0625
66600, 0.20833333333333, 1.45, 0.083333333333333
66601, 0.1875, 1.4666666666667, 0.083333333333333
66602, 0.20833333333333, 1.4666666666667, 0.0625
66603, 0.20833333333333, 1.4833333333333, 0.083333333333333
66604, 0.20833333333333, 1.4166666666667, 0.125
66605, 0.1875, 1.4333333333333, 0.125
66606, 0.20833333333333, 1.4333333333333, 0.10416666666667
66607, 0.20833333333333, 1.45, 0.125
66608, 0.1875, 1.4666666666667, 0.125
66609, 0.20833333333333, 1.4666666666667, 0.10416666666667
66610, 0.20833333333333, 1.4833333333333, 0.125
66611, 0.20833333333333, 1.4166666666667, 0.16666666666667
66612, 0.1875, 1.4333333333333, 0.16666666666667
66613, 0.20833333333333, 1.4333333333333, 0.14583333333333
66614, 0.20833333333333, 1.45, 0.16666666666667
66615, 0.1875, 1.4666666666667, 0.16666666666667
66616, 0.20833333333333, 1.4666666666667, 0.14583333333333
66617, 0.20833333333333, 1.4833333333333, 0.16666666666667
66618, 0.20833333333333, 1.4166666666667, 0.20833333333333
66619, 0.1875, 1.4333333333333, 0.20833333333333
66620, 0.20833333333333, 1.4333333333333, 0.1875
66621, 0.20833333333333, 1.45, 0.20833333333333
66622, 0.1875, 1.4666666666667, 0.20833333333333
66623, 0.20833333333333, 1.4666666666667, 0.1875
66624, 0.20833333333333, 1.4833333333333, 0.20833333333333
66625, 0.20833333333333, 1.4166666666667, 0.25
66626, 0.1875, 1.4333333333333, 0.25
66627, 0.20833333333333, 1.4333333333333, 0.22916666666667
66628, 0.20833333333333, 1.45, 0.25
66629, 0.1875, 1.4666666666667, 0.25
66630, 0.20833333333333, 1.4666666666667, 0.22916666666667
66631, 0.20833333333333, 1.4833333333333, 0.25
66632, 0.20833333333333, 1.4166666666667, 0.29166666666667
66633, 0.1875, 1.4333333333333, 0.29166666666667
66634, 0.20833333333333, 1.4333333333333, 0.27083333333333
66635, 0.20833333333333, 1.45, 0.29166666666667
66636, 0.1875, 1.4666666666667, 0.29166666666667
66637, 0.20833333333333, 1.4666666666667, 0.27083333333333
66638, 0.20833333333333, 1.4833333333333, 0.29166666666667
66639, 0.20833333333333, 1.4166666666667, 0.33333333333333
66640, 0.1875, 1.4333333333333, 0.33333333333333
66641, 0.20833333333333, 1.4333333333333, 0.3125
66642, 0.20833333333333, 1.45, 0.33333333333333
66643, 0.1875, 1.4666666666667, 0.33333333333333
66644, 0.20833333333333, 1.4666666666667, 0.3125
66645, 0.20833333333333, 1.4833333333333, 0.33333333333333
66646, 0.20833333333333, 1.4166666666667, 0.375
66647, 0.1875, 1.4333333333333, 0.375
66648, 0.20833333333333, 1.4333333333333, 0.35416666666667
66649, 0.20833333333333, 1.45, 0.375
66650, 0.1875, 1.4666666666667, 0.375
66651, 0.20833333333333, 1.4666666666667, 0.35416666666667
66652, 0.20833333333333, 1.4833333333333, 0.375
66653, 0.20833333333333, 1.4166666666667, 0.41666666666667
66654, 0.1875, 1.4333333333333, 0.41666666666667
66655, 0.20833333333333, 1.4333333333333, 0.39583333333333
66656, 0.20833333333333, 1.45, 0.41666666666667
66657, 0.1875, 1.4666666666667, 0.41666666666667
66658, 0.20833333333333, 1.4666666666667, 0.39583333333333
66659, 0.20833333333333, 1.4833333333333, 0.41666666666667
66660, 0.20833333333333, 1.4166666666667, 0.45833333333333
66661, 0.1875, 1.4333333333333, 0.45833333333333
66662, 0.20833333333333, 1.4333333333333, 0.4375
66663, 0.20833333333333, 1.45, 0.45833333333333
66664, 0.1875, 1.4666666666667, 0.45833333333333
66665, 0.20833333333333, 1.4666666666667, 0.4375
66666, 0.20833333333333, 1.4833333333333, 0.45833333333333
66667, 0.20833333333333, 1.4333333333333, 0.47916666666667
66668, 0.20833333333333, 1.4666666666667, 0.47916666666667
66669, 0.25, 1.4166666666667, 0.041666666666667
66670, 0.22916666666667, 1.4333333333333, 0.041666666666667
66671, 0.25, 1.4333333333333, 0.020833333333333
66672, 0.25, 1.45, 0.041666666666667
66673, 0.22916666666667, 1.4666666666667, 0.041666666666667
66674, 0.25, 1.4666666666667, 0.020833333333333
66675, 0.25, 1.4833333333333, 0.041666666666667
66676, 0.25, 1.4166666666667, 0.083333333333333
66677, 0.22916666666667, 1.4333333333333, 0.083333333333333
66678, 0.25, 1.4333333333333, 0.0625
66679, 0.25, 1.45, 0.083333333333333
66680, 0.22916666666667, 1.4666666666667, 0.083333333333333
66681, 0.25, 1.4666666666667, 0.0625
66682, 0.25, 1.4833333333333, 0.083333333333333
66683, 0.25, 1.4166666666667, 0.125
66684, 0.22916666666667, 1.4333333333333, 0.125
66685, 0.25, 1.4333333333333, 0.10416666666667
66686, 0.25, 1.45, 0.125
66687, 0.22916666666667, 1.4666666666667, 0.125
66688, 0.25, 1.4666666666667, 0.10416666666667
66689, 0.25, 1.4833333333333, 0.125
66690, 0.25, 1.4166666666667, 0.16666666666667
66691, 0.22916666666667, 1.4333333333333, 0.16666666666667
66692, 0.25, 1.4333333333333, 0.14583333333333
66693, 0.25, 1.45, 0.16666666666667
66694, 0.22916666666667, 1.4666666666667, 0.16666666666667
66695, 0.25, 1.4666666666667, 0.14583333333333
66696, 0.25, 1.4833333333333, 0.16666666666667
66697, 0.25, 1.4166666666667, 0.20833333333333
66698, 0.22916666666667, 1.4333333333333, 0.20833333333333
66699, 0.25, 1.4333333333333, 0.1875
66700, 0.25, 1.45, 0.20833333333333
66701, 0.22916666666667, 1.4666666666667, 0.20833333333333
66702, 0.25, 1.4666666666667, 0.1875
66703, 0.25, 1.4833333333333, 0.20833333333333
66704, 0.25, 1.4166666666667, 0.25
66705, 0.22916666666667, 1.4333333333333, 0.25
66706, 0.25, 1.4333333333333, 0.22916666666667
66707, 0.25, 1.45, 0.25
66708, 0.22916666666667, 1.4666666666667, 0.25
66709, 0.25, 1.4666666666667, 0.22916666666667
66710, 0.25, 1.4833333333333, 0.25
66711, 0.25, 1.4166666666667, 0.29166666666667
66712, 0.22916666666667, 1.4333333333333, 0.29166666666667
66713, 0.25, 1.4333333333333, 0.27083333333333
66714, 0.25, 1.45, 0.29166666666667
66715, 0.22916666666667, 1.4666666666667, 0.29166666666667
66716, 0.25, 1.4666666666667, 0.27083333333333
66717, 0.25, 1.4833333333333, 0.29166666666667
66718, 0.25, 1.4166666666667, 0.33333333333333
66719, 0.22916666666667, 1.4333333333333, 0.33333333333333
66720, 0.25, 1.4333333333333, 0.3125
66721, 0.25, 1.45, 0.33333333333333
66722, 0.22916666666667, 1.4666666666667, 0.33333333333333
66723, 0.25, 1.4666666666667, 0.3125
66724, 0.25, 1.4833333333333, 0.33333333333333
66725, 0.25, 1.4166666666667, 0.375
66726, 0.22916666666667, 1.4333333333333, 0.375
66727, 0.25, 1.4333333333333, 0.35416666666667
66728, 0.25, 1.45, 0.375
66729, 0.22916666666667, 1.4666666666667, 0.375
66730, 0.25, 1.4666666666667, 0.35416666666667
66731, 0.25, 1.4833333333333, 0.375
66732, 0.25, 1.4166666666667, 0.41666666666667
66733, 0.22916666666667, 1.4333333333333, 0.41666666666667
66734, 0.25, 1.4333333333333, 0.39583333333333
66735, 0.25, 1.45, 0.41666666666667
66736, 0.22916666666667, 1.4666666666667, 0.41666666666667
66737, 0.25, 1.4666666666667, 0.39583333333333
66738, 0.25, 1.4833333333333, 0.41666666666667
66739, 0.25, 1.4166666666667, 0.45833333333333
66740, 0.22916666666667, 1.4333333333333, 0.45833333333333
66741, 0.25, 1.4333333333333, 0.4375
66742, 0.25, 1.45, 0.45833333333333
66743, 0.22916666666667, 1.4666666666667, 0.45833333333333
66744, 0.25, 1.4666666666667, 0.4375
66745, 0.25, 1.4833333333333, 0.45833333333333
66746, 0.25, 1.4333333333333, 0.47916666666667
66747, 0.25, 1.4666666666667, 0.47916666666667
66748, 0.29166666666667, 1.4166666666667, 0.041666666666667
66749, 0.27083333333333, 1.4333333333333, 0.041666666666667
66750, 0.29166666666667, 1.4333333333333, 0.020833333333333
66751, 0.29166666666667, 1.45, 0.041666666666667
66752, 0.27083333333333, 1.4666666666667, 0.041666666666667
66753, 0.29166666666667, 1.4666666666667, 0.020833333333333
66754, 0.29166666666667, 1.4833333333333, 0.041666666666667
66755, 0.29166666666667, 1.4166666666667, 0.083333333333333
66756, 0.27083333333333, 1.4333333333333, 0.083333333333333
66757, 0.29166666666667, 1.4333333333333, 0.0625
66758, 0.29166666666667, 1.45, 0.083333333333333
66759, 0.27083333333333, 1.4666666666667, 0.083333333333333
66760, 0.29166666666667, 1.4666666666667, 0.0625
66761, 0.29166666666667, 1.4833333333333, 0.083333333333333
66762, 0.29166666666667, 1.4166666666667, 0.125
66763, 0.27083333333333, 1.4333333333333, 0.125
66764, 0.29166666666667, 1.4333333333333, 0.10416666666667
66765, 0.29166666666667, 1.45, 0.125
66766, 0.27083333333333, 1.4666666666667, 0.125
66767, 0.29166666666667, 1.4666666666667, 0.10416666666667
66768, 0.29166666666667, 1.4833333333333, 0.125
66769, 0.29166666666667, 1.4166666666667, 0.16666666666667
66770, 0.27083333333333, 1.4333333333333, 0.16666666666667
66771, 0.29166666666667, 1.4333333333333, 0.14583333333333
66772, 0.29166666666667, 1.45, 0.16666666666667
66773, 0.27083333333333, 1.4666666666667, 0.16666666666667
66774, 0.29166666666667, 1.4666666666667, 0.14583333333333
66775, 0.29166666666667, 1.4833333333333, 0.16666666666667
66776, 0.29166666666667, 1.4166666666667, 0.20833333333333
66777, 0.27083333333333, 1.4333333333333, 0.20833333333333
66778, 0.29166666666667, 1.4333333333333, 0.1875
66779, 0.29166666666667, 1.45, 0.20833333333333
66780, 0.27083333333333, 1.4666666666667, 0.20833333333333
66781, 0.29166666666667, 1.4666666666667, 0.1875
66782, 0.29166666666667, 1.4833333333333, 0.20833333333333
66783, 0.29166666666667, 1.4166666666667, 0.25
66784, 0.27083333333333, 1.4333333333333, 0.25
66785, 0.29166666666667, 1.4333333333333, 0.22916666666667
66786, 0.29166666666667, 1.45, 0.25
66787, 0.27083333333333, 1.4666666666667, 0.25
66788, 0.29166666666667, 1.4666666666667, 0.22916666666667
66789, 0.29166666666667, 1.4833333333333, 0.25
66790, 0.29166666666667, 1.4166666666667, 0.29166666666667
66791, 0.27083333333333, 1.4333333333333, 0.29166666666667
66792, 0.29166666666667, 1.4333333333333, 0.27083333333333
66793, 0.29166666666667, 1.45, 0.29166666666667
66794, 0.27083333333333, 1.4666666666667, 0.29166666666667
66795, 0.29166666666667, 1.4666666666667, 0.27083333333333
66796, 0.29166666666667, 1.4833333333333, 0.29166666666667
66797, 0.29166666666667, 1.4166666666667, 0.33333333333333
66798, 0.27083333333333, 1.4333333333333, 0.33333333333333
66799, 0.29166666666667, 1.4333333333333, 0.3125
66800, 0.29166666666667, 1.45, 0.33333333333333
66801, 0.27083333333333, 1.4666666666667, 0.33333333333333
66802, 0.29166666666667, 1.4666666666667, 0.3125
66803, 0.29166666666667, 1.4833333333333, 0.33333333333333
66804, 0.29166666666667, 1.4166666666667, 0.375
66805, 0.27083333333333, 1.4333333333333, 0.375
66806, 0.29166666666667, 1.4333333333333, 0.35416666666667
66807, 0.29166666666667, 1.45, 0.375
66808, 0.27083333333333, 1.4666666666667, 0.375
66809, 0.29166666666667, 1.4666666666667, 0.35416666666667
66810, 0.29166666666667, 1.4833333333333, 0.375
66811, 0.29166666666667, 1.4166666666667, 0.41666666666667
66812, 0.27083333333333, 1.4333333333333, 0.41666666666667
66813, 0.29166666666667, 1.4333333333333, 0.39583333333333
66814, 0.29166666666667, 1.45, 0.41666666666667
66815, 0.27083333333333, 1.4666666666667, 0.41666666666667
66816, 0.29166666666667, 1.4666666666667, 0.39583333333333
66817, 0.29166666666667, 1.4833333333333, 0.41666666666667
66818, 0.29166666666667, 1.4166666666667, 0.45833333333333
66819, 0.27083333333333, 1.4333333333333, 0.45833333333333
66820, 0.29166666666667, 1.4333333333333, 0.4375
66821, 0.29166666666667, 1.45, 0.45833333333333
66822, 0.27083333333333, 1.4666666666667, 0.45833333333333
66823, 0.29166666666667, 1.4666666666667, 0.4375
66824, 0.29166666666667, 1.4833333333333, 0.45833333333333
66825, 0.29166666666667, 1.4333333333333, 0.47916666666667
66826, 0.29166666666667, 1.4666666666667, 0.47916666666667
66827, 0.33333333333333, 1.4166666666667, 0.041666666666667
66828, 0.3125, 1.4333333333333, 0.041666666666667
66829, 0.33333333333333, 1.4333333333333, 0.020833333333333
66830, 0.33333333333333, 1.45, 0.041666666666667
66831, 0.3125, 1.4666666666667, 0.041666666666667
66832, 0.33333333333333, 1.4666666666667, 0.020833333333333
66833, 0.33333333333333, 1.4833333333333, 0.041666666666667
66834, 0.33333333333333, 1.4166666666667, 0.083333333333333
66835, 0.3125, 1.4333333333333, 0.083333333333333
66836, 0.33333333333333, 1.4333333333333, 0.0625
66837, 0.33333333333333, 1.45, 0.083333333333333
66838, 0.3125, 1.4666666666667, 0.083333333333333
66839, 0.33333333333333, 1.4666666666667, 0.0625
66840, 0.33333333333333, 1.4833333333333, 0.083333333333333
66841, 0.33333333333333, 1.4166666666667, 0.125
66842, 0.3125, 1.4333333333333, 0.125
66843, 0.33333333333333, 1.4333333333333, 0.10416666666667
66844, 0.33333333333333, 1.45, 0.125
66845, 0.3125, 1.4666666666667, 0.125
66846, 0.33333333333333, 1.4666666666667, 0.10416666666667
66847, 0.33333333333333, 1.4833333333333, 0.125
66848, 0.33333333333333, 1.4166666666667, 0.16666666666667
66849, 0.3125, 1.4333333333333, 0.16666666666667
66850, 0.33333333333333, 1.4333333333333, 0.14583333333333
66851, 0.33333333333333, 1.45, 0.16666666666667
66852, 0.3125, 1.4666666666667, 0.16666666666667
66853, 0.33333333333333, 1.4666666666667, 0.14583333333333
66854, 0.33333333333333, 1.4833333333333, 0.16666666666667
66855, 0.33333333333333, 1.4166666666667, 0.20833333333333
66856, 0.3125, 1.4333333333333, 0.20833333333333
66857, 0.33333333333333, 1.4333333333333, 0.1875
66858, 0.33333333333333, 1.45, 0.20833333333333
66859, 0.3125, 1.4666666666667, 0.20833333333333
66860, 0.33333333333333, 1.4666666666667, 0.1875
66861, 0.33333333333333, 1.4833333333333, 0.20833333333333
66862, 0.33333333333333, 1.4166666666667, 0.25
66863, 0.3125, 1.4333333333333, 0.25
66864, 0.33333333333333, 1.4333333333333, 0.22916666666667
66865, 0.33333333333333, 1.45, 0.25
66866, 0.3125, 1.4666666666667, 0.25
66867, 0.33333333333333, 1.4666666666667, 0.22916666666667
66868, 0.33333333333333, 1.4833333333333, 0.25
66869, 0.33333333333333, 1.4166666666667, 0.29166666666667
66870, 0.3125, 1.4333333333333, 0.29166666666667
66871, 0.33333333333333, 1.4333333333333, 0.27083333333333
66872, 0.33333333333333, 1.45, 0.29166666666667
66873, 0.3125, 1.4666666666667, 0.29166666666667
66874, 0.33333333333333, 1.4666666666667, 0.27083333333333
66875, 0.33333333333333, 1.4833333333333, 0.29166666666667
66876, 0.33333333333333, 1.4166666666667, 0.33333333333333
66877, 0.3125, 1.4333333333333, 0.33333333333333
66878, 0.33333333333333, 1.4333333333333, 0.3125
66879, 0.33333333333333, 1.45, 0.33333333333333
66880, 0.3125, 1.4666666666667, 0.33333333333333
66881, 0.33333333333333, 1.4666666666667, 0.3125
66882, 0.33333333333333, 1.4833333333333, 0.33333333333333
66883, 0.33333333333333, 1.4166666666667, 0.375
66884, 0.3125, 1.4333333333333, 0.375
66885, 0.33333333333333, 1.4333333333333, 0.35416666666667
66886, 0.33333333333333, 1.45, 0.375
66887, 0.3125, 1.4666666666667, 0.375
66888, 0.33333333333333, 1.4666666666667, 0.35416666666667
66889, 0.33333333333333, 1.4833333333333, 0.375
66890, 0.33333333333333, 1.4166666666667, 0.41666666666667
66891, 0.3125, 1.4333333333333, 0.41666666666667
66892, 0.33333333333333, 1.4333333333333, 0.39583333333333
66893, 0.33333333333333, 1.45, 0.41666666666667
66894, 0.3125, 1.4666666666667, 0.41666666666667
66895, 0.33333333333333, 1.4666666666667, 0.39583333333333
66896, 0.33333333333333, 1.4833333333333, 0.41666666666667
66897, 0.33333333333333, 1.4166666666667, 0.45833333333333
66898, 0.3125, 1.4333333333333, 0.45833333333333
66899, 0.33333333333333, 1.4333333333333, 0.4375
66900, 0.33333333333333, 1.45, 0.45833333333333
66901, 0.3125, 1.4666666666667, 0.45833333333333
66902, 0.33333333333333, 1.4666666666667, 0.4375
66903, 0.33333333333333, 1.4833333333333, 0.45833333333333
66904, 0.33333333333333, 1.4333333333333, 0.47916666666667
66905, 0.33333333333333, 1.4666666666667, 0.47916666666667
66906, 0.375, 1.4166666666667, 0.041666666666667
66907, 0.35416666666667, 1.4333333333333, 0.041666666666667
66908, 0.375, 1.4333333333333, 0.020833333333333
66909, 0.375, 1.45, 0.041666666666667
66910, 0.35416666666667, 1.4666666666667, 0.041666666666667
66911, 0.375, 1.4666666666667, 0.020833333333333
66912, 0.375, 1.4833333333333, 0.041666666666667
66913, 0.375, 1.4166666666667, 0.083333333333333
66914, 0.35416666666667, 1.4333333333333, 0.083333333333333
66915, 0.375, 1.4333333333333, 0.0625
66916, 0.375, 1.45, 0.083333333333333
66917, 0.35416666666667, 1.4666666666667, 0.083333333333333
66918, 0.375, 1.4666666666667, 0.0625
66919, 0.375, 1.4833333333333, 0.083333333333333
66920, 0.375, 1.4166666666667, 0.125
66921, 0.35416666666667, 1.4333333333333, 0.125
66922, 0.375, 1.4333333333333, 0.10416666666667
66923, 0.375, 1.45, 0.125
66924, 0.35416666666667, 1.4666666666667, 0.125
66925, 0.375, 1.4666666666667, 0.10416666666667
66926, 0.375, 1.4833333333333, 0.125
66927, 0.375, 1.4166666666667, 0.16666666666667
66928, 0.35416666666667, 1.4333333333333, 0.16666666666667
66929, 0.375, 1.4333333333333, 0.14583333333333
66930, 0.375, 1.45, 0.16666666666667
66931, 0.35416666666667, 1.4666666666667, 0.16666666666667
66932, 0.375, 1.4666666666667, 0.14583333333333
66933, 0.375, 1.4833333333333, 0.16666666666667
66934, 0.375, 1.4166666666667, 0.20833333333333
66935, 0.35416666666667, 1.4333333333333, 0.20833333333333
66936, 0.375, 1.4333333333333, 0.1875
66937, 0.375, 1.45, 0.20833333333333
66938, 0.35416666666667, 1.4666666666667, 0.20833333333333
66939, 0.375, 1.4666666666667, 0.1875
66940, 0.375, 1.4833333333333, 0.20833333333333
66941, 0.375, 1.4166666666667, 0.25
66942, 0.35416666666667, 1.4333333333333, 0.25
66943, 0.375, 1.4333333333333, 0.22916666666667
66944, 0.375, 1.45, 0.25
66945, 0.35416666666667, 1.4666666666667, 0.25
66946, 0.375, 1.4666666666667, 0.22916666666667
66947, 0.375, 1.4833333333333, 0.25
66948, 0.375, 1.4166666666667, 0.29166666666667
66949, 0.35416666666667, 1.4333333333333, 0.29166666666667
66950, 0.375, 1.4333333333333, 0.27083333333333
66951, 0.375, 1.45, 0.29166666666667
66952, 0.35416666666667, 1.4666666666667, 0.29166666666667
66953, 0.375, 1.4666666666667, 0.27083333333333
66954, 0.375, 1.4833333333333, 0.29166666666667
66955, 0.375, 1.4166666666667, 0.33333333333333
66956, 0.35416666666667, 1.4333333333333, 0.33333333333333
66957, 0.375, 1.4333333333333, 0.3125
66958, 0.375, 1.45, 0.33333333333333
66959, 0.35416666666667, 1.4666666666667, 0.33333333333333
66960, 0.375, 1.4666666666667, 0.3125
66961, 0.375, 1.4833333333333, 0.33333333333333
66962, 0.375, 1.4166666666667, 0.375
66963, 0.35416666666667, 1.4333333333333, 0.375
66964, 0.375, 1.4333333333333, 0.35416666666667
66965, 0.375, 1.45, 0.375
66966, 0.35416666666667, 1.4666666666667, 0.375
66967, 0.375, 1.4666666666667, 0.35416666666667
66968, 0.375, 1.4833333333333, 0.375
66969, 0.375, 1.4166666666667, 0.41666666666667
66970, 0.35416666666667, 1.4333333333333, 0.41666666666667
66971, 0.375, 1.4333333333333, 0.39583333333333
66972, 0.375, 1.45, 0.41666666666667
66973, 0.35416666666667, 1.4666666666667, 0.41666666666667
66974, 0.375, 1.4666666666667, 0.39583333333333
66975, 0.375, 1.4833333333333, 0.41666666666667
66976, 0.375, 1.4166666666667, 0.45833333333333
66977, 0.35416666666667, 1.4333333333333, 0.45833333333333
66978, 0.375, 1.4333333333333, 0.4375
66979, 0.375, 1.45, 0.45833333333333
66980, 0.35416666666667, 1.4666666666667, 0.45833333333333
66981, 0.375, 1.4666666666667, 0.4375
66982, 0.375, 1.4833333333333, 0.45833333333333
66983, 0.375, 1.4333333333333, 0.47916666666667
66984, 0.375, 1.4666666666667, 0.47916666666667
66985, 0.41666666666667, 1.4166666666667, 0.041666666666667
66986, 0.39583333333333, 1.4333333333333, 0.041666666666667
66987, 0.41666666666667, 1.4333333333333, 0.020833333333333
66988, 0.41666666666667, 1.45, 0.041666666666667
66989, 0.39583333333333, 1.4666666666667, 0.041666666666667
66990, 0.41666666666667, 1.4666666666667, 0.020833333333333
66991, 0.41666666666667, 1.4833333333333, 0.041666666666667
66992, 0.41666666666667, 1.4166666666667, 0.083333333333333
66993, 0.39583333333333, 1.4333333333333, 0.083333333333333
66994, 0.41666666666667, 1.4333333333333, 0.0625
66995, 0.41666666666667, 1.45, 0.083333333333333
66996, 0.39583333333333, 1.4666666666667, 0.083333333333333
66997, 0.41666666666667, 1.4666666666667, 0.0625
66998, 0.41666666666667, 1.4833333333333, 0.083333333333333
66999, 0.41666666666667, 1.4166666666667, 0.125
67000, 0.39583333333333, 1.4333333333333, 0.125
67001, 0.41666666666667, 1.4333333333333, 0.10416666666667
67002, 0.41666666666667, 1.45, 0.125
67003, 0.39583333333333, 1.4666666666667, 0.125
67004, 0.41666666666667, 1.4666666666667, 0.10416666666667
67005, 0.41666666666667, 1.4833333333333, 0.125
67006, 0.41666666666667, 1.4166666666667, 0.16666666666667
67007, 0.39583333333333, 1.4333333333333, 0.16666666666667
67008, 0.41666666666667, 1.4333333333333, 0.14583333333333
67009, 0.41666666666667, 1.45, 0.16666666666667
67010, 0.39583333333333, 1.4666666666667, 0.16666666666667
67011, 0.41666666666667, 1.4666666666667, 0.14583333333333
67012, 0.41666666666667, 1.4833333333333, 0.16666666666667
67013, 0.41666666666667, 1.4166666666667, 0.20833333333333
67014, 0.39583333333333, 1.4333333333333, 0.20833333333333
67015, 0.41666666666667, 1.4333333333333, 0.1875
67016, 0.41666666666667, 1.45, 0.20833333333333
67017, 0.39583333333333, 1.4666666666667, 0.20833333333333
67018, 0.41666666666667, 1.4666666666667, 0.1875
67019, 0.41666666666667, 1.4833333333333, 0.20833333333333
67020, 0.41666666666667, 1.4166666666667, 0.25
67021, 0.39583333333333, 1.4333333333333, 0.25
67022, 0.41666666666667, 1.4333333333333, 0.22916666666667
67023, 0.41666666666667, 1.45, 0.25
67024, 0.39583333333333, 1.4666666666667, 0.25
67025, 0.41666666666667, 1.4666666666667, 0.22916666666667
67026, 0.41666666666667, 1.4833333333333, 0.25
67027, 0.41666666666667, 1.4166666666667, 0.29166666666667
67028, 0.39583333333333, 1.4333333333333, 0.29166666666667
67029, 0.41666666666667, 1.4333333333333, 0.27083333333333
67030, 0.41666666666667, 1.45, 0.29166666666667
67031, 0.39583333333333, 1.4666666666667, 0.29166666666667
67032, 0.41666666666667, 1.4666666666667, 0.27083333333333
67033, 0.41666666666667, 1.4833333333333, 0.29166666666667
67034, 0.41666666666667, 1.4166666666667, 0.33333333333333
67035, 0.39583333333333, 1.4333333333333, 0.33333333333333
67036, 0.41666666666667, 1.4333333333333, 0.3125
67037, 0.41666666666667, 1.45, 0.33333333333333
67038, 0.39583333333333, 1.4666666666667, 0.33333333333333
67039, 0.41666666666667, 1.4666666666667, 0.3125
67040, 0.41666666666667, 1.4833333333333, 0.33333333333333
67041, 0.41666666666667, 1.4166666666667, 0.375
67042, 0.39583333333333, 1.4333333333333, 0.375
67043, 0.41666666666667, 1.4333333333333, 0.35416666666667
67044, 0.41666666666667, 1.45, 0.375
67045, 0.39583333333333, 1.4666666666667, 0.375
67046, 0.41666666666667, 1.4666666666667, 0.35416666666667
67047, 0.41666666666667, 1.4833333333333, 0.375
67048, 0.41666666666667, 1.4166666666667, 0.41666666666667
67049, 0.39583333333333, 1.4333333333333, 0.41666666666667
67050, 0.41666666666667, 1.4333333333333, 0.39583333333333
67051, 0.41666666666667, 1.45, 0.41666666666667
67052, 0.39583333333333, 1.4666666666667, 0.41666666666667
67053, 0.41666666666667, 1.4666666666667, 0.39583333333333
67054, 0.41666666666667, 1.4833333333333, 0.41666666666667
67055, 0.41666666666667, 1.4166666666667, 0.45833333333333
67056, 0.39583333333333, 1.4333333333333, 0.45833333333333
67057, 0.41666666666667, 1.4333333333333, 0.4375
67058, 0.41666666666667, 1.45, 0.45833333333333
67059, 0.39583333333333, 1.4666666666667, 0.45833333333333
67060, 0.41666666666667, 1.4666666666667, 0.4375
67061, 0.41666666666667, 1.4833333333333, 0.45833333333333
67062, 0.41666666666667, 1.4333333333333, 0.47916666666667
67063, 0.41666666666667, 1.4666666666667, 0.47916666666667
67064, 0.45833333333333, 1.4166666666667, 0.041666666666667
67065, 0.4375, 1.4333333333333, 0.041666666666667
67066, 0.45833333333333, 1.4333333333333, 0.020833333333333
67067, 0.45833333333333, 1.45, 0.041666666666667
67068, 0.4375, 1.4666666666667, 0.041666666666667
67069, 0.45833333333333, 1.4666666666667, 0.020833333333333
67070, 0.45833333333333, 1.4833333333333, 0.041666666666667
67071, 0.45833333333333, 1.4166666666667, 0.083333333333333
67072, 0.4375, 1.4333333333333, 0.083333333333333
67073, 0.45833333333333, 1.4333333333333, 0.0625
67074, 0.45833333333333, 1.45, 0.083333333333333
67075, 0.4375, 1.4666666666667, 0.083333333333333
67076, 0.45833333333333, 1.4666666666667, 0.0625
67077, 0.45833333333333, 1.4833333333333, 0.083333333333333
67078, 0.45833333333333, 1.4166666666667, 0.125
67079, 0.4375, 1.4333333333333, 0.125
67080, 0.45833333333333, 1.4333333333333, 0.10416666666667
67081, 0.45833333333333, 1.45, 0.125
67082, 0.4375, 1.4666666666667, 0.125
67083, 0.45833333333333, 1.4666666666667, 0.10416666666667
67084, 0.45833333333333, 1.4833333333333, 0.125
67085, 0.45833333333333, 1.4166666666667, 0.16666666666667
67086, 0.4375, 1.4333333333333, 0.16666666666667
67087, 0.45833333333333, 1.4333333333333, 0.14583333333333
67088, 0.45833333333333, 1.45, 0.16666666666667
67089, 0.4375, 1.4666666666667, 0.16666666666667
67090, 0.45833333333333, 1.4666666666667, 0.14583333333333
67091, 0.45833333333333, 1.4833333333333, 0.16666666666667
67092, 0.45833333333333, 1.4166666666667, 0.20833333333333
67093, 0.4375, 1.4333333333333, 0.20833333333333
67094, 0.45833333333333, 1.4333333333333, 0.1875
67095, 0.45833333333333, 1.45, 0.20833333333333
67096, 0.4375, 1.4666666666667, 0.20833333333333
67097, 0.45833333333333, 1.4666666666667, 0.1875
67098, 0.45833333333333, 1.4833333333333, 0.20833333333333
67099, 0.45833333333333, 1.4166666666667, 0.25
67100, 0.4375, 1.4333333333333, 0.25
67101, 0.45833333333333, 1.4333333333333, 0.22916666666667
67102, 0.45833333333333, 1.45, 0.25
67103, 0.4375, 1.4666666666667, 0.25
67104, 0.45833333333333, 1.4666666666667, 0.22916666666667
67105, 0.45833333333333, 1.4833333333333, 0.25
67106, 0.45833333333333, 1.4166666666667, 0.29166666666667
67107, 0.4375, 1.4333333333333, 0.29166666666667
67108, 0.45833333333333, 1.4333333333333, 0.27083333333333
67109, 0.45833333333333, 1.45, 0.29166666666667
67110, 0.4375, 1.4666666666667, 0.29166666666667
67111, 0.45833333333333, 1.4666666666667, 0.27083333333333
67112, 0.45833333333333, 1.4833333333333, 0.29166666666667
67113, 0.45833333333333, 1.4166666666667, 0.33333333333333
67114, 0.4375, 1.4333333333333, 0.33333333333333
67115, 0.45833333333333, 1.4333333333333, 0.3125
67116, 0.45833333333333, 1.45, 0.33333333333333
67117, 0.4375, 1.4666666666667, 0.33333333333333
67118, 0.45833333333333, 1.4666666666667, 0.3125
67119, 0.45833333333333, 1.4833333333333, 0.33333333333333
67120, 0.45833333333333, 1.4166666666667, 0.375
67121, 0.4375, 1.4333333333333, 0.375
67122, 0.45833333333333, 1.4333333333333, 0.35416666666667
67123, 0.45833333333333, 1.45, 0.375
67124, 0.4375, 1.4666666666667, 0.375
67125, 0.45833333333333, 1.4666666666667, 0.35416666666667
67126, 0.45833333333333, 1.4833333333333, 0.375
67127, 0.45833333333333, 1.4166666666667, 0.41666666666667
67128, 0.4375, 1.4333333333333, 0.41666666666667
67129, 0.45833333333333, 1.4333333333333, 0.39583333333333
67130, 0.45833333333333, 1.45, 0.41666666666667
67131, 0.4375, 1.4666666666667, 0.41666666666667
67132, 0.45833333333333, 1.4666666666667, 0.39583333333333
67133, 0.45833333333333, 1.4833333333333, 0.41666666666667
67134, 0.45833333333333, 1.4166666666667, 0.45833333333333
67135, 0.4375, 1.4333333333333, 0.45833333333333
67136, 0.45833333333333, 1.4333333333333, 0.4375
67137, 0.45833333333333, 1.45, 0.45833333333333
67138, 0.4375, 1.4666666666667, 0.45833333333333
67139, 0.45833333333333, 1.4666666666667, 0.4375
67140, 0.45833333333333, 1.4833333333333, 0.45833333333333
67141, 0.45833333333333, 1.4333333333333, 0.47916666666667
67142, 0.45833333333333, 1.4666666666667, 0.47916666666667
67143, 0.5, 1.4166666666667, 0.041666666666667
67144, 0.47916666666667, 1.4333333333333, 0.041666666666667
67145, 0.5, 1.4333333333333, 0.020833333333333
67146, 0.5, 1.45, 0.041666666666667
67147, 0.47916666666667, 1.4666666666667, 0.041666666666667
67148, 0.5, 1.4666666666667, 0.020833333333333
67149, 0.5, 1.4833333333333, 0.041666666666667
67150, 0.5, 1.4166666666667, 0.083333333333333
67151, 0.47916666666667, 1.4333333333333, 0.083333333333333
67152, 0.5, 1.4333333333333, 0.0625
67153, 0.5, 1.45, 0.083333333333333
67154, 0.47916666666667, 1.4666666666667, 0.083333333333333
67155, 0.5, 1.4666666666667, 0.0625
67156, 0.5, 1.4833333333333, 0.083333333333333
67157, 0.5, 1.4166666666667, 0.125
67158, 0.47916666666667, 1.4333333333333, 0.125
67159, 0.5, 1.4333333333333, 0.10416666666667
67160, 0.5, 1.45, 0.125
67161, 0.47916666666667, 1.4666666666667, 0.125
67162, 0.5, 1.4666666666667, 0.10416666666667
67163, 0.5, 1.4833333333333, 0.125
67164, 0.5, 1.4166666666667, 0.16666666666667
67165, 0.47916666666667, 1.4333333333333, 0.16666666666667
67166, 0.5, 1.4333333333333, 0.14583333333333
67167, 0.5, 1.45, 0.16666666666667
67168, 0.47916666666667, 1.4666666666667, 0.16666666666667
67169, 0.5, 1.4666666666667, 0.14583333333333
67170, 0.5, 1.4833333333333, 0.16666666666667
67171, 0.5, 1.4166666666667, 0.20833333333333
67172, 0.47916666666667, 1.4333333333333, 0.20833333333333
67173, 0.5, 1.4333333333333, 0.1875
67174, 0.5, 1.45, 0.20833333333333
67175, 0.47916666666667, 1.4666666666667, 0.20833333333333
67176, 0.5, 1.4666666666667, 0.1875
67177, 0.5, 1.4833333333333, 0.20833333333333
67178, 0.5, 1.4166666666667, 0.25
67179, 0.47916666666667, 1.4333333333333, 0.25
67180, 0.5, 1.4333333333333, 0.22916666666667
67181, 0.5, 1.45, 0.25
67182, 0.47916666666667, 1.4666666666667, 0.25
67183, 0.5, 1.4666666666667, 0.22916666666667
67184, 0.5, 1.4833333333333, 0.25
67185, 0.5, 1.4166666666667, 0.29166666666667
67186, 0.47916666666667, 1.4333333333333, 0.29166666666667
67187, 0.5, 1.4333333333333, 0.27083333333333
67188, 0.5, 1.45, 0.29166666666667
67189, 0.47916666666667, 1.4666666666667, 0.29166666666667
67190, 0.5, 1.4666666666667, 0.27083333333333
67191, 0.5, 1.4833333333333, 0.29166666666667
67192, 0.5, 1.4166666666667, 0.33333333333333
67193, 0.47916666666667, 1.4333333333333, 0.33333333333333
67194, 0.5, 1.4333333333333, 0.3125
67195, 0.5, 1.45, 0.33333333333333
67196, 0.47916666666667, 1.4666666666667, 0.33333333333333
67197, 0.5, 1.4666666666667, 0.3125
67198, 0.5, 1.4833333333333, 0.33333333333333
67199, 0.5, 1.4166666666667, 0.375
67200, 0.47916666666667, 1.4333333333333, 0.375
67201, 0.5, 1.4333333333333, 0.35416666666667
67202, 0.5, 1.45, 0.375
67203, 0.47916666666667, 1.4666666666667, 0.375
67204, 0.5, 1.4666666666667, 0.35416666666667
67205, 0.5, 1.4833333333333, 0.375
67206, 0.5, 1.4166666666667, 0.41666666666667
67207, 0.47916666666667, 1.4333333333333, 0.41666666666667
67208, 0.5, 1.4333333333333, 0.39583333333333
67209, 0.5, 1.45, 0.41666666666667
67210, 0.47916666666667, 1.4666666666667, 0.41666666666667
67211, 0.5, 1.4666666666667, 0.39583333333333
67212, 0.5, 1.4833333333333, 0.41666666666667
67213, 0.5, 1.4166666666667, 0.45833333333333
67214, 0.47916666666667, 1.4333333333333, 0.45833333333333
67215, 0.5, 1.4333333333333, 0.4375
67216, 0.5, 1.45, 0.45833333333333
67217, 0.47916666666667, 1.4666666666667, 0.45833333333333
67218, 0.5, 1.4666666666667, 0.4375
67219, 0.5, 1.4833333333333, 0.45833333333333
67220, 0.5, 1.4333333333333, 0.47916666666667
67221, 0.5, 1.4666666666667, 0.47916666666667
67222, 0.54166666666667, 1.4166666666667, 0.041666666666667
67223, 0.52083333333333, 1.4333333333333, 0.041666666666667
67224, 0.54166666666667, 1.4333333333333, 0.020833333333333
67225, 0.54166666666667, 1.45, 0.041666666666667
67226, 0.52083333333333, 1.4666666666667, 0.041666666666667
67227, 0.54166666666667, 1.4666666666667, 0.020833333333333
67228, 0.54166666666667, 1.4833333333333, 0.041666666666667
67229, 0.54166666666667, 1.4166666666667, 0.083333333333333
67230, 0.52083333333333, 1.4333333333333, 0.083333333333333
67231, 0.54166666666667, 1.4333333333333, 0.0625
67232, 0.54166666666667, 1.45, 0.083333333333333
67233, 0.52083333333333, 1.4666666666667, 0.083333333333333
67234, 0.54166666666667, 1.4666666666667, 0.0625
67235, 0.54166666666667, 1.4833333333333, 0.083333333333333
67236, 0.54166666666667, 1.4166666666667, 0.125
67237, 0.52083333333333, 1.4333333333333, 0.125
67238, 0.54166666666667, 1.4333333333333, 0.10416666666667
67239, 0.54166666666667, 1.45, 0.125
67240, 0.52083333333333, 1.4666666666667, 0.125
67241, 0.54166666666667, 1.4666666666667, 0.10416666666667
67242, 0.54166666666667, 1.4833333333333, 0.125
67243, 0.54166666666667, 1.4166666666667, 0.16666666666667
67244, 0.52083333333333, 1.4333333333333, 0.16666666666667
67245, 0.54166666666667, 1.4333333333333, 0.14583333333333
67246, 0.54166666666667, 1.45, 0.16666666666667
67247, 0.52083333333333, 1.4666666666667, 0.16666666666667
67248, 0.54166666666667, 1.4666666666667, 0.14583333333333
67249, 0.54166666666667, 1.4833333333333, 0.16666666666667
67250, 0.54166666666667, 1.4166666666667, 0.20833333333333
67251, 0.52083333333333, 1.4333333333333, 0.20833333333333
67252, 0.54166666666667, 1.4333333333333, 0.1875
67253, 0.54166666666667, 1.45, 0.20833333333333
67254, 0.52083333333333, 1.4666666666667, 0.20833333333333
67255, 0.54166666666667, 1.4666666666667, 0.1875
67256, 0.54166666666667, 1.4833333333333, 0.20833333333333
67257, 0.54166666666667, 1.4166666666667, 0.25
67258, 0.52083333333333, 1.4333333333333, 0.25
67259, 0.54166666666667, 1.4333333333333, 0.22916666666667
67260, 0.54166666666667, 1.45, 0.25
67261, 0.52083333333333, 1.4666666666667, 0.25
67262, 0.54166666666667, 1.4666666666667, 0.22916666666667
67263, 0.54166666666667, 1.4833333333333, 0.25
67264, 0.54166666666667, 1.4166666666667, 0.29166666666667
67265, 0.52083333333333, 1.4333333333333, 0.29166666666667
67266, 0.54166666666667, 1.4333333333333, 0.27083333333333
67267, 0.54166666666667, 1.45, 0.29166666666667
67268, 0.52083333333333, 1.4666666666667, 0.29166666666667
67269, 0.54166666666667, 1.4666666666667, 0.27083333333333
67270, 0.54166666666667, 1.4833333333333, 0.29166666666667
67271, 0.54166666666667, 1.4166666666667, 0.33333333333333
67272, 0.52083333333333, 1.4333333333333, 0.33333333333333
67273, 0.54166666666667, 1.4333333333333, 0.3125
67274, 0.54166666666667, 1.45, 0.33333333333333
67275, 0.52083333333333, 1.4666666666667, 0.33333333333333
67276, 0.54166666666667, 1.4666666666667, 0.3125
67277, 0.54166666666667, 1.4833333333333, 0.33333333333333
67278, 0.54166666666667, 1.4166666666667, 0.375
67279, 0.52083333333333, 1.4333333333333, 0.375
67280, 0.54166666666667, 1.4333333333333, 0.35416666666667
67281, 0.54166666666667, 1.45, 0.375
67282, 0.52083333333333, 1.4666666666667, 0.375
67283, 0.54166666666667, 1.4666666666667, 0.35416666666667
67284, 0.54166666666667, 1.4833333333333, 0.375
67285, 0.54166666666667, 1.4166666666667, 0.41666666666667
67286, 0.52083333333333, 1.4333333333333, 0.41666666666667
67287, 0.54166666666667, 1.4333333333333, 0.39583333333333
67288, 0.54166666666667, 1.45, 0.41666666666667
67289, 0.52083333333333, 1.4666666666667, 0.41666666666667
67290, 0.54166666666667, 1.4666666666667, 0.39583333333333
67291, 0.54166666666667, 1.4833333333333, 0.41666666666667
67292, 0.54166666666667, 1.4166666666667, 0.45833333333333
67293, 0.52083333333333, 1.4333333333333, 0.45833333333333
67294, 0.54166666666667, 1.4333333333333, 0.4375
67295, 0.54166666666667, 1.45, 0.45833333333333
67296, 0.52083333333333, 1.4666666666667, 0.45833333333333
67297, 0.54166666666667, 1.4666666666667, 0.4375
67298, 0.54166666666667, 1.4833333333333, 0.45833333333333
67299, 0.54166666666667, 1.4333333333333, 0.47916666666667
67300, 0.54166666666667, 1.4666666666667, 0.47916666666667
67301, 0.58333333333333, 1.4166666666667, 0.041666666666667
67302, 0.5625, 1.4333333333333, 0.041666666666667
67303, 0.58333333333333, 1.4333333333333, 0.020833333333333
67304, 0.58333333333333, 1.45, 0.041666666666667
67305, 0.5625, 1.4666666666667, 0.041666666666667
67306, 0.58333333333333, 1.4666666666667, 0.020833333333333
67307, 0.58333333333333, 1.4833333333333, 0.041666666666667
67308, 0.58333333333333, 1.4166666666667, 0.083333333333333
67309, 0.5625, 1.4333333333333, 0.083333333333333
67310, 0.58333333333333, 1.4333333333333, 0.0625
67311, 0.58333333333333, 1.45, 0.083333333333333
67312, 0.5625, 1.4666666666667, 0.083333333333333
67313, 0.58333333333333, 1.4666666666667, 0.0625
67314, 0.58333333333333, 1.4833333333333, 0.083333333333333
67315, 0.58333333333333, 1.4166666666667, 0.125
67316, 0.5625, 1.4333333333333, 0.125
67317, 0.58333333333333, 1.4333333333333, 0.10416666666667
67318, 0.58333333333333, 1.45, 0.125
67319, 0.5625, 1.4666666666667, 0.125
67320, 0.58333333333333, 1.4666666666667, 0.10416666666667
67321, 0.58333333333333, 1.4833333333333, 0.125
67322, 0.58333333333333, 1.4166666666667, 0.16666666666667
67323, 0.5625, 1.4333333333333, 0.16666666666667
67324, 0.58333333333333, 1.4333333333333, 0.14583333333333
67325, 0.58333333333333, 1.45, 0.16666666666667
67326, 0.5625, 1.4666666666667, 0.16666666666667
67327, 0.58333333333333, 1.4666666666667, 0.14583333333333
67328, 0.58333333333333, 1.4833333333333, 0.16666666666667
67329, 0.58333333333333, 1.4166666666667, 0.20833333333333
67330, 0.5625, 1.4333333333333, 0.20833333333333
67331, 0.58333333333333, 1.4333333333333, 0.1875
67332, 0.58333333333333, 1.45, 0.20833333333333
67333, 0.5625, 1.4666666666667, 0.20833333333333
67334, 0.58333333333333, 1.4666666666667, 0.1875
67335, 0.58333333333333, 1.4833333333333, 0.20833333333333
67336, 0.58333333333333, 1.4166666666667, 0.25
67337, 0.5625, 1.4333333333333, 0.25
67338, 0.58333333333333, 1.4333333333333, 0.22916666666667
67339, 0.58333333333333, 1.45, 0.25
67340, 0.5625, 1.4666666666667, 0.25
67341, 0.58333333333333, 1.4666666666667, 0.22916666666667
67342, 0.58333333333333, 1.4833333333333, 0.25
67343, 0.58333333333333, 1.4166666666667, 0.29166666666667
67344, 0.5625, 1.4333333333333, 0.29166666666667
67345, 0.58333333333333, 1.4333333333333, 0.27083333333333
67346, 0.58333333333333, 1.45, 0.29166666666667
67347, 0.5625, 1.4666666666667, 0.29166666666667
67348, 0.58333333333333, 1.4666666666667, 0.27083333333333
67349, 0.58333333333333, 1.4833333333333, 0.29166666666667
67350, 0.58333333333333, 1.4166666666667, 0.33333333333333
67351, 0.5625, 1.4333333333333, 0.33333333333333
67352, 0.58333333333333, 1.4333333333333, 0.3125
67353, 0.58333333333333, 1.45, 0.33333333333333
67354, 0.5625, 1.4666666666667, 0.33333333333333
67355, 0.58333333333333, 1.4666666666667, 0.3125
67356, 0.58333333333333, 1.4833333333333, 0.33333333333333
67357, 0.58333333333333, 1.4166666666667, 0.375
67358, 0.5625, 1.4333333333333, 0.375
67359, 0.58333333333333, 1.4333333333333, 0.35416666666667
67360, 0.58333333333333, 1.45, 0.375
67361, 0.5625, 1.4666666666667, 0.375
67362, 0.58333333333333, 1.4666666666667, 0.35416666666667
67363, 0.58333333333333, 1.4833333333333, 0.375
67364, 0.58333333333333, 1.4166666666667, 0.41666666666667
67365, 0.5625, 1.4333333333333, 0.41666666666667
67366, 0.58333333333333, 1.4333333333333, 0.39583333333333
67367, 0.58333333333333, 1.45, 0.41666666666667
67368, 0.5625, 1.4666666666667, 0.41666666666667
67369, 0.58333333333333, 1.4666666666667, 0.39583333333333
67370, 0.58333333333333, 1.4833333333333, 0.41666666666667
67371, 0.58333333333333, 1.4166666666667, 0.45833333333333
67372, 0.5625, 1.4333333333333, 0.45833333333333
67373, 0.58333333333333, 1.4333333333333, 0.4375
67374, 0.58333333333333, 1.45, 0.45833333333333
67375, 0.5625, 1.4666666666667, 0.45833333333333
67376, 0.58333333333333, 1.4666666666667, 0.4375
67377, 0.58333333333333, 1.4833333333333, 0.45833333333333
67378, 0.58333333333333, 1.4333333333333, 0.47916666666667
67379, 0.58333333333333, 1.4666666666667, 0.47916666666667
67380, 0.625, 1.4166666666667, 0.041666666666667
67381, 0.60416666666667, 1.4333333333333, 0.041666666666667
67382, 0.625, 1.4333333333333, 0.020833333333333
67383, 0.625, 1.45, 0.041666666666667
67384, 0.60416666666667, 1.4666666666667, 0.041666666666667
67385, 0.625, 1.4666666666667, 0.020833333333333
67386, 0.625, 1.4833333333333, 0.041666666666667
67387, 0.625, 1.4166666666667, 0.083333333333333
67388, 0.60416666666667, 1.4333333333333, 0.083333333333333
67389, 0.625, 1.4333333333333, 0.0625
67390, 0.625, 1.45, 0.083333333333333
67391, 0.60416666666667, 1.4666666666667, 0.083333333333333
67392, 0.625, 1.4666666666667, 0.0625
67393, 0.625, 1.4833333333333, 0.083333333333333
67394, 0.625, 1.4166666666667, 0.125
67395, 0.60416666666667, 1.4333333333333, 0.125
67396, 0.625, 1.4333333333333, 0.10416666666667
67397, 0.625, 1.45, 0.125
67398, 0.60416666666667, 1.4666666666667, 0.125
67399, 0.625, 1.4666666666667, 0.10416666666667
67400, 0.625, 1.4833333333333, 0.125
67401, 0.625, 1.4166666666667, 0.16666666666667
67402, 0.60416666666667, 1.4333333333333, 0.16666666666667
67403, 0.625, 1.4333333333333, 0.14583333333333
67404, 0.625, 1.45, 0.16666666666667
67405, 0.60416666666667, 1.4666666666667, 0.16666666666667
67406, 0.625, 1.4666666666667, 0.14583333333333
67407, 0.625, 1.4833333333333, 0.16666666666667
67408, 0.625, 1.4166666666667, 0.20833333333333
67409, 0.60416666666667, 1.4333333333333, 0.20833333333333
67410, 0.625, 1.4333333333333, 0.1875
67411, 0.625, 1.45, 0.20833333333333
67412, 0.60416666666667, 1.4666666666667, 0.20833333333333
67413, 0.625, 1.4666666666667, 0.1875
67414, 0.625, 1.4833333333333, 0.20833333333333
67415, 0.625, 1.4166666666667, 0.25
67416, 0.60416666666667, 1.4333333333333, 0.25
67417, 0.625, 1.4333333333333, 0.22916666666667
67418, 0.625, 1.45, 0.25
67419, 0.60416666666667, 1.4666666666667, 0.25
67420, 0.625, 1.4666666666667, 0.22916666666667
67421, 0.625, 1.4833333333333, 0.25
67422, 0.625, 1.4166666666667, 0.29166666666667
67423, 0.60416666666667, 1.4333333333333, 0.29166666666667
67424, 0.625, 1.4333333333333, 0.27083333333333
67425, 0.625, 1.45, 0.29166666666667
67426, 0.60416666666667, 1.4666666666667, 0.29166666666667
67427, 0.625, 1.4666666666667, 0.27083333333333
67428, 0.625, 1.4833333333333, 0.29166666666667
67429, 0.625, 1.4166666666667, 0.33333333333333
67430, 0.60416666666667, 1.4333333333333, 0.33333333333333
67431, 0.625, 1.4333333333333, 0.3125
67432, 0.625, 1.45, 0.33333333333333
67433, 0.60416666666667, 1.4666666666667, 0.33333333333333
67434, 0.625, 1.4666666666667, 0.3125
67435, 0.625, 1.4833333333333, 0.33333333333333
67436, 0.625, 1.4166666666667, 0.375
67437, 0.60416666666667, 1.4333333333333, 0.375
67438, 0.625, 1.4333333333333, 0.35416666666667
67439, 0.625, 1.45, 0.375
67440, 0.60416666666667, 1.4666666666667, 0.375
67441, 0.625, 1.4666666666667, 0.35416666666667
67442, 0.625, 1.4833333333333, 0.375
67443, 0.625, 1.4166666666667, 0.41666666666667
67444, 0.60416666666667, 1.4333333333333, 0.41666666666667
67445, 0.625, 1.4333333333333, 0.39583333333333
67446, 0.625, 1.45, 0.41666666666667
67447, 0.60416666666667, 1.4666666666667, 0.41666666666667
67448, 0.625, 1.4666666666667, 0.39583333333333
67449, 0.625, 1.4833333333333, 0.41666666666667
67450, 0.625, 1.4166666666667, 0.45833333333333
67451, 0.60416666666667, 1.4333333333333, 0.45833333333333
67452, 0.625, 1.4333333333333, 0.4375
67453, 0.625, 1.45, 0.45833333333333
67454, 0.60416666666667, 1.4666666666667, 0.45833333333333
67455, 0.625, 1.4666666666667, 0.4375
67456, 0.625, 1.4833333333333, 0.45833333333333
67457, 0.625, 1.4333333333333, 0.47916666666667
67458, 0.625, 1.4666666666667, 0.47916666666667
67459, 0.66666666666667, 1.4166666666667, 0.041666666666667
67460, 0.64583333333333, 1.4333333333333, 0.041666666666667
67461, 0.66666666666667, 1.4333333333333, 0.020833333333333
67462, 0.66666666666667, 1.45, 0.041666666666667
67463, 0.64583333333333, 1.4666666666667, 0.041666666666667
67464, 0.66666666666667, 1.4666666666667, 0.020833333333333
67465, 0.66666666666667, 1.4833333333333, 0.041666666666667
67466, 0.66666666666667, 1.4166666666667, 0.083333333333333
67467, 0.64583333333333, 1.4333333333333, 0.083333333333333
67468, 0.66666666666667, 1.4333333333333, 0.0625
67469, 0.66666666666667, 1.45, 0.083333333333333
67470, 0.64583333333333, 1.4666666666667, 0.083333333333333
67471, 0.66666666666667, 1.4666666666667, 0.0625
67472, 0.66666666666667, 1.4833333333333, 0.083333333333333
67473, 0.66666666666667, 1.4166666666667, 0.125
67474, 0.64583333333333, 1.4333333333333, 0.125
67475, 0.66666666666667, 1.4333333333333, 0.10416666666667
67476, 0.66666666666667, 1.45, 0.125
67477, 0.64583333333333, 1.4666666666667, 0.125
67478, 0.66666666666667, 1.4666666666667, 0.10416666666667
67479, 0.66666666666667, 1.4833333333333, 0.125
67480, 0.66666666666667, 1.4166666666667, 0.16666666666667
67481, 0.64583333333333, 1.4333333333333, 0.16666666666667
67482, 0.66666666666667, 1.4333333333333, 0.14583333333333
67483, 0.66666666666667, 1.45, 0.16666666666667
67484, 0.64583333333333, 1.4666666666667, 0.16666666666667
67485, 0.66666666666667, 1.4666666666667, 0.14583333333333
67486, 0.66666666666667, 1.4833333333333, 0.16666666666667
67487, 0.66666666666667, 1.4166666666667, 0.20833333333333
67488, 0.64583333333333, 1.4333333333333, 0.20833333333333
67489, 0.66666666666667, 1.4333333333333, 0.1875
67490, 0.66666666666667, 1.45, 0.20833333333333
67491, 0.64583333333333, 1.4666666666667, 0.20833333333333
67492, 0.66666666666667, 1.4666666666667, 0.1875
67493, 0.66666666666667, 1.4833333333333, 0.20833333333333
67494, 0.66666666666667, 1.4166666666667, 0.25
67495, 0.64583333333333, 1.4333333333333, 0.25
67496, 0.66666666666667, 1.4333333333333, 0.22916666666667
67497, 0.66666666666667, 1.45, 0.25
67498, 0.64583333333333, 1.4666666666667, 0.25
67499, 0.66666666666667, 1.4666666666667, 0.22916666666667
67500, 0.66666666666667, 1.4833333333333, 0.25
67501, 0.66666666666667, 1.4166666666667, 0.29166666666667
67502, 0.64583333333333, 1.4333333333333, 0.29166666666667
67503, 0.66666666666667, 1.4333333333333, 0.27083333333333
67504, 0.66666666666667, 1.45, 0.29166666666667
67505, 0.64583333333333, 1.4666666666667, 0.29166666666667
67506, 0.66666666666667, 1.4666666666667, 0.27083333333333
67507, 0.66666666666667, 1.4833333333333, 0.29166666666667
67508, 0.66666666666667, 1.4166666666667, 0.33333333333333
67509, 0.64583333333333, 1.4333333333333, 0.33333333333333
67510, 0.66666666666667, 1.4333333333333, 0.3125
67511, 0.66666666666667, 1.45, 0.33333333333333
67512, 0.64583333333333, 1.4666666666667, 0.33333333333333
67513, 0.66666666666667, 1.4666666666667, 0.3125
67514, 0.66666666666667, 1.4833333333333, 0.33333333333333
67515, 0.66666666666667, 1.4166666666667, 0.375
67516, 0.64583333333333, 1.4333333333333, 0.375
67517, 0.66666666666667, 1.4333333333333, 0.35416666666667
67518, 0.66666666666667, 1.45, 0.375
67519, 0.64583333333333, 1.4666666666667, 0.375
67520, 0.66666666666667, 1.4666666666667, 0.35416666666667
67521, 0.66666666666667, 1.4833333333333, 0.375
67522, 0.66666666666667, 1.4166666666667, 0.41666666666667
67523, 0.64583333333333, 1.4333333333333, 0.41666666666667
67524, 0.66666666666667, 1.4333333333333, 0.39583333333333
67525, 0.66666666666667, 1.45, 0.41666666666667
67526, 0.64583333333333, 1.4666666666667, 0.41666666666667
67527, 0.66666666666667, 1.4666666666667, 0.39583333333333
67528, 0.66666666666667, 1.4833333333333, 0.41666666666667
67529, 0.66666666666667, 1.4166666666667, 0.45833333333333
67530, 0.64583333333333, 1.4333333333333, 0.45833333333333
67531, 0.66666666666667, 1.4333333333333, 0.4375
67532, 0.66666666666667, 1.45, 0.45833333333333
67533, 0.64583333333333, 1.4666666666667, 0.45833333333333
67534, 0.66666666666667, 1.4666666666667, 0.4375
67535, 0.66666666666667, 1.4833333333333, 0.45833333333333
67536, 0.66666666666667, 1.4333333333333, 0.47916666666667
67537, 0.66666666666667, 1.4666666666667, 0.47916666666667
67538, 0.70833333333333, 1.4166666666667, 0.041666666666667
67539, 0.6875, 1.4333333333333, 0.041666666666667
67540, 0.70833333333333, 1.4333333333333, 0.020833333333333
67541, 0.70833333333333, 1.45, 0.041666666666667
67542, 0.6875, 1.4666666666667, 0.041666666666667
67543, 0.70833333333333, 1.4666666666667, 0.020833333333333
67544, 0.70833333333333, 1.4833333333333, 0.041666666666667
67545, 0.70833333333333, 1.4166666666667, 0.083333333333333
67546, 0.6875, 1.4333333333333, 0.083333333333333
67547, 0.70833333333333, 1.4333333333333, 0.0625
67548, 0.70833333333333, 1.45, 0.083333333333333
67549, 0.6875, 1.4666666666667, 0.083333333333333
67550, 0.70833333333333, 1.4666666666667, 0.0625
67551, 0.70833333333333, 1.4833333333333, 0.083333333333333
67552, 0.70833333333333, 1.4166666666667, 0.125
67553, 0.6875, 1.4333333333333, 0.125
67554, 0.70833333333333, 1.4333333333333, 0.10416666666667
67555, 0.70833333333333, 1.45, 0.125
67556, 0.6875, 1.4666666666667, 0.125
67557, 0.70833333333333, 1.4666666666667, 0.10416666666667
67558, 0.70833333333333, 1.4833333333333, 0.125
67559, 0.70833333333333, 1.4166666666667, 0.16666666666667
67560, 0.6875, 1.4333333333333, 0.16666666666667
67561, 0.70833333333333, 1.4333333333333, 0.14583333333333
67562, 0.70833333333333, 1.45, 0.16666666666667
67563, 0.6875, 1.4666666666667, 0.16666666666667
67564, 0.70833333333333, 1.4666666666667, 0.14583333333333
67565, 0.70833333333333, 1.4833333333333, 0.16666666666667
67566, 0.70833333333333, 1.4166666666667, 0.20833333333333
67567, 0.6875, 1.4333333333333, 0.20833333333333
67568, 0.70833333333333, 1.4333333333333, 0.1875
67569, 0.70833333333333, 1.45, 0.20833333333333
67570, 0.6875, 1.4666666666667, 0.20833333333333
67571, 0.70833333333333, 1.4666666666667, 0.1875
67572, 0.70833333333333, 1.4833333333333, 0.20833333333333
67573, 0.70833333333333, 1.4166666666667, 0.25
67574, 0.6875, 1.4333333333333, 0.25
67575, 0.70833333333333, 1.4333333333333, 0.22916666666667
67576, 0.70833333333333, 1.45, 0.25
67577, 0.6875, 1.4666666666667, 0.25
67578, 0.70833333333333, 1.4666666666667, 0.22916666666667
67579, 0.70833333333333, 1.4833333333333, 0.25
67580, 0.70833333333333, 1.4166666666667, 0.29166666666667
67581, 0.6875, 1.4333333333333, 0.29166666666667
67582, 0.70833333333333, 1.4333333333333, 0.27083333333333
67583, 0.70833333333333, 1.45, 0.29166666666667
67584, 0.6875, 1.4666666666667, 0.29166666666667
67585, 0.70833333333333, 1.4666666666667, 0.27083333333333
67586, 0.70833333333333, 1.4833333333333, 0.29166666666667
67587, 0.70833333333333, 1.4166666666667, 0.33333333333333
67588, 0.6875, 1.4333333333333, 0.33333333333333
67589, 0.70833333333333, 1.4333333333333, 0.3125
67590, 0.70833333333333, 1.45, 0.33333333333333
67591, 0.6875, 1.4666666666667, 0.33333333333333
67592, 0.70833333333333, 1.4666666666667, 0.3125
67593, 0.70833333333333, 1.4833333333333, 0.33333333333333
67594, 0.70833333333333, 1.4166666666667, 0.375
67595, 0.6875, 1.4333333333333, 0.375
67596, 0.70833333333333, 1.4333333333333, 0.35416666666667
67597, 0.70833333333333, 1.45, 0.375
67598, 0.6875, 1.4666666666667, 0.375
67599, 0.70833333333333, 1.4666666666667, 0.35416666666667
67600, 0.70833333333333, 1.4833333333333, 0.375
67601, 0.70833333333333, 1.4166666666667, 0.41666666666667
67602, 0.6875, 1.4333333333333, 0.41666666666667
67603, 0.70833333333333, 1.4333333333333, 0.39583333333333
67604, 0.70833333333333, 1.45, 0.41666666666667
67605, 0.6875, 1.4666666666667, 0.41666666666667
67606, 0.70833333333333, 1.4666666666667, 0.39583333333333
67607, 0.70833333333333, 1.4833333333333, 0.41666666666667
67608, 0.70833333333333, 1.4166666666667, 0.45833333333333
67609, 0.6875, 1.4333333333333, 0.45833333333333
67610, 0.70833333333333, 1.4333333333333, 0.4375
67611, 0.70833333333333, 1.45, 0.45833333333333
67612, 0.6875, 1.4666666666667, 0.45833333333333
67613, 0.70833333333333, 1.4666666666667, 0.4375
67614, 0.70833333333333, 1.4833333333333, 0.45833333333333
67615, 0.70833333333333, 1.4333333333333, 0.47916666666667
67616, 0.70833333333333, 1.4666666666667, 0.47916666666667
67617, 0.75, 1.4166666666667, 0.041666666666667
67618, 0.72916666666667, 1.4333333333333, 0.041666666666667
67619, 0.75, 1.4333333333333, 0.020833333333333
67620, 0.75, 1.45, 0.041666666666667
67621, 0.72916666666667, 1.4666666666667, 0.041666666666667
67622, 0.75, 1.4666666666667, 0.020833333333333
67623, 0.75, 1.4833333333333, 0.041666666666667
67624, 0.75, 1.4166666666667, 0.083333333333333
67625, 0.72916666666667, 1.4333333333333, 0.083333333333333
67626, 0.75, 1.4333333333333, 0.0625
67627, 0.75, 1.45, 0.083333333333333
67628, 0.72916666666667, 1.4666666666667, 0.083333333333333
67629, 0.75, 1.4666666666667, 0.0625
67630, 0.75, 1.4833333333333, 0.083333333333333
67631, 0.75, 1.4166666666667, 0.125
67632, 0.72916666666667, 1.4333333333333, 0.125
67633, 0.75, 1.4333333333333, 0.10416666666667
67634, 0.75, 1.45, 0.125
67635, 0.72916666666667, 1.4666666666667, 0.125
67636, 0.75, 1.4666666666667, 0.10416666666667
67637, 0.75, 1.4833333333333, 0.125
67638, 0.75, 1.4166666666667, 0.16666666666667
67639, 0.72916666666667, 1.4333333333333, 0.16666666666667
67640, 0.75, 1.4333333333333, 0.14583333333333
67641, 0.75, 1.45, 0.16666666666667
67642, 0.72916666666667, 1.4666666666667, 0.16666666666667
67643, 0.75, 1.4666666666667, 0.14583333333333
67644, 0.75, 1.4833333333333, 0.16666666666667
67645, 0.75, 1.4166666666667, 0.20833333333333
67646, 0.72916666666667, 1.4333333333333, 0.20833333333333
67647, 0.75, 1.4333333333333, 0.1875
67648, 0.75, 1.45, 0.20833333333333
67649, 0.72916666666667, 1.4666666666667, 0.20833333333333
67650, 0.75, 1.4666666666667, 0.1875
67651, 0.75, 1.4833333333333, 0.20833333333333
67652, 0.75, 1.4166666666667, 0.25
67653, 0.72916666666667, 1.4333333333333, 0.25
67654, 0.75, 1.4333333333333, 0.22916666666667
67655, 0.75, 1.45, 0.25
67656, 0.72916666666667, 1.4666666666667, 0.25
67657, 0.75, 1.4666666666667, 0.22916666666667
67658, 0.75, 1.4833333333333, 0.25
67659, 0.75, 1.4166666666667, 0.29166666666667
67660, 0.72916666666667, 1.4333333333333, 0.29166666666667
67661, 0.75, 1.4333333333333, 0.27083333333333
67662, 0.75, 1.45, 0.29166666666667
67663, 0.72916666666667, 1.4666666666667, 0.29166666666667
67664, 0.75, 1.4666666666667, 0.27083333333333
67665, 0.75, 1.4833333333333, 0.29166666666667
67666, 0.75, 1.4166666666667, 0.33333333333333
67667, 0.72916666666667, 1.4333333333333, 0.33333333333333
67668, 0.75, 1.4333333333333, 0.3125
67669, 0.75, 1.45, 0.33333333333333
67670, 0.72916666666667, 1.4666666666667, 0.33333333333333
67671, 0.75, 1.4666666666667, 0.3125
67672, 0.75, 1.4833333333333, 0.33333333333333
67673, 0.75, 1.4166666666667, 0.375
67674, 0.72916666666667, 1.4333333333333, 0.375
67675, 0.75, 1.4333333333333, 0.35416666666667
67676, 0.75, 1.45, 0.375
67677, 0.72916666666667, 1.4666666666667, 0.375
67678, 0.75, 1.4666666666667, 0.35416666666667
67679, 0.75, 1.4833333333333, 0.375
67680, 0.75, 1.4166666666667, 0.41666666666667
67681, 0.72916666666667, 1.4333333333333, 0.41666666666667
67682, 0.75, 1.4333333333333, 0.39583333333333
67683, 0.75, 1.45, 0.41666666666667
67684, 0.72916666666667, 1.4666666666667, 0.41666666666667
67685, 0.75, 1.4666666666667, 0.39583333333333
67686, 0.75, 1.4833333333333, 0.41666666666667
67687, 0.75, 1.4166666666667, 0.45833333333333
67688, 0.72916666666667, 1.4333333333333, 0.45833333333333
67689, 0.75, 1.4333333333333, 0.4375
67690, 0.75, 1.45, 0.45833333333333
67691, 0.72916666666667, 1.4666666666667, 0.45833333333333
67692, 0.75, 1.4666666666667, 0.4375
67693, 0.75, 1.4833333333333, 0.45833333333333
67694, 0.75, 1.4333333333333, 0.47916666666667
67695, 0.75, 1.4666666666667, 0.47916666666667
67696, 0.79166666666667, 1.4166666666667, 0.041666666666667
67697, 0.77083333333333, 1.4333333333333, 0.041666666666667
67698, 0.79166666666667, 1.4333333333333, 0.020833333333333
67699, 0.79166666666667, 1.45, 0.041666666666667
67700, 0.77083333333333, 1.4666666666667, 0.041666666666667
67701, 0.79166666666667, 1.4666666666667, 0.020833333333333
67702, 0.79166666666667, 1.4833333333333, 0.041666666666667
67703, 0.79166666666667, 1.4166666666667, 0.083333333333333
67704, 0.77083333333333, 1.4333333333333, 0.083333333333333
67705, 0.79166666666667, 1.4333333333333, 0.0625
67706, 0.79166666666667, 1.45, 0.083333333333333
67707, 0.77083333333333, 1.4666666666667, 0.083333333333333
67708, 0.79166666666667, 1.4666666666667, 0.0625
67709, 0.79166666666667, 1.4833333333333, 0.083333333333333
67710, 0.79166666666667, 1.4166666666667, 0.125
67711, 0.77083333333333, 1.4333333333333, 0.125
67712, 0.79166666666667, 1.4333333333333, 0.10416666666667
67713, 0.79166666666667, 1.45, 0.125
67714, 0.77083333333333, 1.4666666666667, 0.125
67715, 0.79166666666667, 1.4666666666667, 0.10416666666667
67716, 0.79166666666667, 1.4833333333333, 0.125
67717, 0.79166666666667, 1.4166666666667, 0.16666666666667
67718, 0.77083333333333, 1.4333333333333, 0.16666666666667
67719, 0.79166666666667, 1.4333333333333, 0.14583333333333
67720, 0.79166666666667, 1.45, 0.16666666666667
67721, 0.77083333333333, 1.4666666666667, 0.16666666666667
67722, 0.79166666666667, 1.4666666666667, 0.14583333333333
67723, 0.79166666666667, 1.4833333333333, 0.16666666666667
67724, 0.79166666666667, 1.4166666666667, 0.20833333333333
67725, 0.77083333333333, 1.4333333333333, 0.20833333333333
67726, 0.79166666666667, 1.4333333333333, 0.1875
67727, 0.79166666666667, 1.45, 0.20833333333333
67728, 0.77083333333333, 1.4666666666667, 0.20833333333333
67729, 0.79166666666667, 1.4666666666667, 0.1875
67730, 0.79166666666667, 1.4833333333333, 0.20833333333333
67731, 0.79166666666667, 1.4166666666667, 0.25
67732, 0.77083333333333, 1.4333333333333, 0.25
67733, 0.79166666666667, 1.4333333333333, 0.22916666666667
67734, 0.79166666666667, 1.45, 0.25
67735, 0.77083333333333, 1.4666666666667, 0.25
67736, 0.79166666666667, 1.4666666666667, 0.22916666666667
67737, 0.79166666666667, 1.4833333333333, 0.25
67738, 0.79166666666667, 1.4166666666667, 0.29166666666667
67739, 0.77083333333333, 1.4333333333333, 0.29166666666667
67740, 0.79166666666667, 1.4333333333333, 0.27083333333333
67741, 0.79166666666667, 1.45, 0.29166666666667
67742, 0.77083333333333, 1.4666666666667, 0.29166666666667
67743, 0.79166666666667, 1.4666666666667, 0.27083333333333
67744, 0.79166666666667, 1.4833333333333, 0.29166666666667
67745, 0.79166666666667, 1.4166666666667, 0.33333333333333
67746, 0.77083333333333, 1.4333333333333, 0.33333333333333
67747, 0.79166666666667, 1.4333333333333, 0.3125
67748, 0.79166666666667, 1.45, 0.33333333333333
67749, 0.77083333333333, 1.4666666666667, 0.33333333333333
67750, 0.79166666666667, 1.4666666666667, 0.3125
67751, 0.79166666666667, 1.4833333333333, 0.33333333333333
67752, 0.79166666666667, 1.4166666666667, 0.375
67753, 0.77083333333333, 1.4333333333333, 0.375
67754, 0.79166666666667, 1.4333333333333, 0.35416666666667
67755, 0.79166666666667, 1.45, 0.375
67756, 0.77083333333333, 1.4666666666667, 0.375
67757, 0.79166666666667, 1.4666666666667, 0.35416666666667
67758, 0.79166666666667, 1.4833333333333, 0.375
67759, 0.79166666666667, 1.4166666666667, 0.41666666666667
67760, 0.77083333333333, 1.4333333333333, 0.41666666666667
67761, 0.79166666666667, 1.4333333333333, 0.39583333333333
67762, 0.79166666666667, 1.45, 0.41666666666667
67763, 0.77083333333333, 1.4666666666667, 0.41666666666667
67764, 0.79166666666667, 1.4666666666667, 0.39583333333333
67765, 0.79166666666667, 1.4833333333333, 0.41666666666667
67766, 0.79166666666667, 1.4166666666667, 0.45833333333333
67767, 0.77083333333333, 1.4333333333333, 0.45833333333333
67768, 0.79166666666667, 1.4333333333333, 0.4375
67769, 0.79166666666667, 1.45, 0.45833333333333
67770, 0.77083333333333, 1.4666666666667, 0.45833333333333
67771, 0.79166666666667, 1.4666666666667, 0.4375
67772, 0.79166666666667, 1.4833333333333, 0.45833333333333
67773, 0.79166666666667, 1.4333333333333, 0.47916666666667
67774, 0.79166666666667, 1.4666666666667, 0.47916666666667
67775, 0.83333333333333, 1.4166666666667, 0.041666666666667
67776, 0.8125, 1.4333333333333, 0.041666666666667
67777, 0.83333333333333, 1.4333333333333, 0.020833333333333
67778, 0.83333333333333, 1.45, 0.041666666666667
67779, 0.8125, 1.4666666666667, 0.041666666666667
67780, 0.83333333333333, 1.4666666666667, 0.020833333333333
67781, 0.83333333333333, 1.4833333333333, 0.041666666666667
67782, 0.83333333333333, 1.4166666666667, 0.083333333333333
67783, 0.8125, 1.4333333333333, 0.083333333333333
67784, 0.83333333333333, 1.4333333333333, 0.0625
67785, 0.83333333333333, 1.45, 0.083333333333333
67786, 0.8125, 1.4666666666667, 0.083333333333333
67787, 0.83333333333333, 1.4666666666667, 0.0625
67788, 0.83333333333333, 1.4833333333333, 0.083333333333333
67789, 0.83333333333333, 1.4166666666667, 0.125
67790, 0.8125, 1.4333333333333, 0.125
67791, 0.83333333333333, 1.4333333333333, 0.10416666666667
67792, 0.83333333333333, 1.45, 0.125
67793, 0.8125, 1.4666666666667, 0.125
67794, 0.83333333333333, 1.4666666666667, 0.10416666666667
67795, 0.83333333333333, 1.4833333333333, 0.125
67796, 0.83333333333333, 1.4166666666667, 0.16666666666667
67797, 0.8125, 1.4333333333333, 0.16666666666667
67798, 0.83333333333333, 1.4333333333333, 0.14583333333333
67799, 0.83333333333333, 1.45, 0.16666666666667
67800, 0.8125, 1.4666666666667, 0.16666666666667
67801, 0.83333333333333, 1.4666666666667, 0.14583333333333
67802, 0.83333333333333, 1.4833333333333, 0.16666666666667
67803, 0.83333333333333, 1.4166666666667, 0.20833333333333
67804, 0.8125, 1.4333333333333, 0.20833333333333
67805, 0.83333333333333, 1.4333333333333, 0.1875
67806, 0.83333333333333, 1.45, 0.20833333333333
67807, 0.8125, 1.4666666666667, 0.20833333333333
67808, 0.83333333333333, 1.4666666666667, 0.1875
67809, 0.83333333333333, 1.4833333333333, 0.20833333333333
67810, 0.83333333333333, 1.4166666666667, 0.25
67811, 0.8125, 1.4333333333333, 0.25
67812, 0.83333333333333, 1.4333333333333, 0.22916666666667
67813, 0.83333333333333, 1.45, 0.25
67814, 0.8125, 1.4666666666667, 0.25
67815, 0.83333333333333, 1.4666666666667, 0.22916666666667
67816, 0.83333333333333, 1.4833333333333, 0.25
67817, 0.83333333333333, 1.4166666666667, 0.29166666666667
67818, 0.8125, 1.4333333333333, 0.29166666666667
67819, 0.83333333333333, 1.4333333333333, 0.27083333333333
67820, 0.83333333333333, 1.45, 0.29166666666667
67821, 0.8125, 1.4666666666667, 0.29166666666667
67822, 0.83333333333333, 1.4666666666667, 0.27083333333333
67823, 0.83333333333333, 1.4833333333333, 0.29166666666667
67824, 0.83333333333333, 1.4166666666667, 0.33333333333333
67825, 0.8125, 1.4333333333333, 0.33333333333333
67826, 0.83333333333333, 1.4333333333333, 0.3125
67827, 0.83333333333333, 1.45, 0.33333333333333
67828, 0.8125, 1.4666666666667, 0.33333333333333
67829, 0.83333333333333, 1.4666666666667, 0.3125
67830, 0.83333333333333, 1.4833333333333, 0.33333333333333
67831, 0.83333333333333, 1.4166666666667, 0.375
67832, 0.8125, 1.4333333333333, 0.375
67833, 0.83333333333333, 1.4333333333333, 0.35416666666667
67834, 0.83333333333333, 1.45, 0.375
67835, 0.8125, 1.4666666666667, 0.375
67836, 0.83333333333333, 1.4666666666667, 0.35416666666667
67837, 0.83333333333333, 1.4833333333333, 0.375
67838, 0.83333333333333, 1.4166666666667, 0.41666666666667
67839, 0.8125, 1.4333333333333, 0.41666666666667
67840, 0.83333333333333, 1.4333333333333, 0.39583333333333
67841, 0.83333333333333, 1.45, 0.41666666666667
67842, 0.8125, 1.4666666666667, 0.41666666666667
67843, 0.83333333333333, 1.4666666666667, 0.39583333333333
67844, 0.83333333333333, 1.4833333333333, 0.41666666666667
67845, 0.83333333333333, 1.4166666666667, 0.45833333333333
67846, 0.8125, 1.4333333333333, 0.45833333333333
67847, 0.83333333333333, 1.4333333333333, 0.4375
67848, 0.83333333333333, 1.45, 0.45833333333333
67849, 0.8125, 1.4666666666667, 0.45833333333333
67850, 0.83333333333333, 1.4666666666667, 0.4375
67851, 0.83333333333333, 1.4833333333333, 0.45833333333333
67852, 0.83333333333333, 1.4333333333333, 0.47916666666667
67853, 0.83333333333333, 1.4666666666667, 0.47916666666667
67854, 0.875, 1.4166666666667, 0.041666666666667
67855, 0.85416666666667, 1.4333333333333, 0.041666666666667
67856, 0.875, 1.4333333333333, 0.020833333333333
67857, 0.875, 1.45, 0.041666666666667
67858, 0.85416666666667, 1.4666666666667, 0.041666666666667
67859, 0.875, 1.4666666666667, 0.020833333333333
67860, 0.875, 1.4833333333333, 0.041666666666667
67861, 0.875, 1.4166666666667, 0.083333333333333
67862, 0.85416666666667, 1.4333333333333, 0.083333333333333
67863, 0.875, 1.4333333333333, 0.0625
67864, 0.875, 1.45, 0.083333333333333
67865, 0.85416666666667, 1.4666666666667, 0.083333333333333
67866, 0.875, 1.4666666666667, 0.0625
67867, 0.875, 1.4833333333333, 0.083333333333333
67868, 0.875, 1.4166666666667, 0.125
67869, 0.85416666666667, 1.4333333333333, 0.125
67870, 0.875, 1.4333333333333, 0.10416666666667
67871, 0.875, 1.45, 0.125
67872, 0.85416666666667, 1.4666666666667, 0.125
67873, 0.875, 1.4666666666667, 0.10416666666667
67874, 0.875, 1.4833333333333, 0.125
67875, 0.875, 1.4166666666667, 0.16666666666667
67876, 0.85416666666667, 1.4333333333333, 0.16666666666667
67877, 0.875, 1.4333333333333, 0.14583333333333
67878, 0.875, 1.45, 0.16666666666667
67879, 0.85416666666667, 1.4666666666667, 0.16666666666667
67880, 0.875, 1.4666666666667, 0.14583333333333
67881, 0.875, 1.4833333333333, 0.16666666666667
67882, 0.875, 1.4166666666667, 0.20833333333333
67883, 0.85416666666667, 1.4333333333333, 0.20833333333333
67884, 0.875, 1.4333333333333, 0.1875
67885, 0.875, 1.45, 0.20833333333333
67886, 0.85416666666667, 1.4666666666667, 0.20833333333333
67887, 0.875, 1.4666666666667, 0.1875
67888, 0.875, 1.4833333333333, 0.20833333333333
67889, 0.875, 1.4166666666667, 0.25
67890, 0.85416666666667, 1.4333333333333, 0.25
67891, 0.875, 1.4333333333333, 0.22916666666667
67892, 0.875, 1.45, 0.25
67893, 0.85416666666667, 1.4666666666667, 0.25
67894, 0.875, 1.4666666666667, 0.22916666666667
67895, 0.875, 1.4833333333333, 0.25
67896, 0.875, 1.4166666666667, 0.29166666666667
67897, 0.85416666666667, 1.4333333333333, 0.29166666666667
67898, 0.875, 1.4333333333333, 0.27083333333333
67899, 0.875, 1.45, 0.29166666666667
67900, 0.85416666666667, 1.4666666666667, 0.29166666666667
67901, 0.875, 1.4666666666667, 0.27083333333333
67902, 0.875, 1.4833333333333, 0.29166666666667
67903, 0.875, 1.4166666666667, 0.33333333333333
67904, 0.85416666666667, 1.4333333333333, 0.33333333333333
67905, 0.875, 1.4333333333333, 0.3125
67906, 0.875, 1.45, 0.33333333333333
67907, 0.85416666666667, 1.4666666666667, 0.33333333333333
67908, 0.875, 1.4666666666667, 0.3125
67909, 0.875, 1.4833333333333, 0.33333333333333
67910, 0.875, 1.4166666666667, 0.375
67911, 0.85416666666667, 1.4333333333333, 0.375
67912, 0.875, 1.4333333333333, 0.35416666666667
67913, 0.875, 1.45, 0.375
67914, 0.85416666666667, 1.4666666666667, 0.375
67915, 0.875, 1.4666666666667, 0.35416666666667
67916, 0.875, 1.4833333333333, 0.375
67917, 0.875, 1.4166666666667, 0.41666666666667
67918, 0.85416666666667, 1.4333333333333, 0.41666666666667
67919, 0.875, 1.4333333333333, 0.39583333333333
67920, 0.875, 1.45, 0.41666666666667
67921, 0.85416666666667, 1.4666666666667, 0.41666666666667
67922, 0.875, 1.4666666666667, 0.39583333333333
67923, 0.875, 1.4833333333333, 0.41666666666667
67924, 0.875, 1.4166666666667, 0.45833333333333
67925, 0.85416666666667, 1.4333333333333, 0.45833333333333
67926, 0.875, 1.4333333333333, 0.4375
67927, 0.875, 1.45, 0.45833333333333
67928, 0.85416666666667, 1.4666666666667, 0.45833333333333
67929, 0.875, 1.4666666666667, 0.4375
67930, 0.875, 1.4833333333333, 0.45833333333333
67931, 0.875, 1.4333333333333, 0.47916666666667
67932, 0.875, 1.4666666666667, 0.47916666666667
67933, 0.91666666666667, 1.4166666666667, 0.041666666666667
67934, 0.89583333333333, 1.4333333333333, 0.041666666666667
67935, 0.91666666666667, 1.4333333333333, 0.020833333333333
67936, 0.91666666666667, 1.45, 0.041666666666667
67937, 0.89583333333333, 1.4666666666667, 0.041666666666667
67938, 0.91666666666667, 1.4666666666667, 0.020833333333333
67939, 0.91666666666667, 1.4833333333333, 0.041666666666667
67940, 0.91666666666667, 1.4166666666667, 0.083333333333333
67941, 0.89583333333333, 1.4333333333333, 0.083333333333333
67942, 0.91666666666667, 1.4333333333333, 0.0625
67943, 0.91666666666667, 1.45, 0.083333333333333
67944, 0.89583333333333, 1.4666666666667, 0.083333333333333
67945, 0.91666666666667, 1.4666666666667, 0.0625
67946, 0.91666666666667, 1.4833333333333, 0.083333333333333
67947, 0.91666666666667, 1.4166666666667, 0.125
67948, 0.89583333333333, 1.4333333333333, 0.125
67949, 0.91666666666667, 1.4333333333333, 0.10416666666667
67950, 0.91666666666667, 1.45, 0.125
67951, 0.89583333333333, 1.4666666666667, 0.125
67952, 0.91666666666667, 1.4666666666667, 0.10416666666667
67953, 0.91666666666667, 1.4833333333333, 0.125
67954, 0.91666666666667, 1.4166666666667, 0.16666666666667
67955, 0.89583333333333, 1.4333333333333, 0.16666666666667
67956, 0.91666666666667, 1.4333333333333, 0.14583333333333
67957, 0.91666666666667, 1.45, 0.16666666666667
67958, 0.89583333333333, 1.4666666666667, 0.16666666666667
67959, 0.91666666666667, 1.4666666666667, 0.14583333333333
67960, 0.91666666666667, 1.4833333333333, 0.16666666666667
67961, 0.91666666666667, 1.4166666666667, 0.20833333333333
67962, 0.89583333333333, 1.4333333333333, 0.20833333333333
67963, 0.91666666666667, 1.4333333333333, 0.1875
67964, 0.91666666666667, 1.45, 0.20833333333333
67965, 0.89583333333333, 1.4666666666667, 0.20833333333333
67966, 0.91666666666667, 1.4666666666667, 0.1875
67967, 0.91666666666667, 1.4833333333333, 0.20833333333333
67968, 0.91666666666667, 1.4166666666667, 0.25
67969, 0.89583333333333, 1.4333333333333, 0.25
67970, 0.91666666666667, 1.4333333333333, 0.22916666666667
67971, 0.91666666666667, 1.45, 0.25
67972, 0.89583333333333, 1.4666666666667, 0.25
67973, 0.91666666666667, 1.4666666666667, 0.22916666666667
67974, 0.91666666666667, 1.4833333333333, 0.25
67975, 0.91666666666667, 1.4166666666667, 0.29166666666667
67976, 0.89583333333333, 1.4333333333333, 0.29166666666667
67977, 0.91666666666667, 1.4333333333333, 0.27083333333333
67978, 0.91666666666667, 1.45, 0.29166666666667
67979, 0.89583333333333, 1.4666666666667, 0.29166666666667
67980, 0.91666666666667, 1.4666666666667, 0.27083333333333
67981, 0.91666666666667, 1.4833333333333, 0.29166666666667
67982, 0.91666666666667, 1.4166666666667, 0.33333333333333
67983, 0.89583333333333, 1.4333333333333, 0.33333333333333
67984, 0.91666666666667, 1.4333333333333, 0.3125
67985, 0.91666666666667, 1.45, 0.33333333333333
67986, 0.89583333333333, 1.4666666666667, 0.33333333333333
67987, 0.91666666666667, 1.4666666666667, 0.3125
67988, 0.91666666666667, 1.4833333333333, 0.33333333333333
67989, 0.91666666666667, 1.4166666666667, 0.375
67990, 0.89583333333333, 1.4333333333333, 0.375
67991, 0.91666666666667, 1.4333333333333, 0.35416666666667
67992, 0.91666666666667, 1.45, 0.375
67993, 0.89583333333333, 1.4666666666667, 0.375
67994, 0.91666666666667, 1.4666666666667, 0.35416666666667
67995, 0.91666666666667, 1.4833333333333, 0.375
67996, 0.91666666666667, 1.4166666666667, 0.41666666666667
67997, 0.89583333333333, 1.4333333333333, 0.41666666666667
67998, 0.91666666666667, 1.4333333333333, 0.39583333333333
67999, 0.91666666666667, 1.45, 0.41666666666667
68000, 0.89583333333333, 1.4666666666667, 0.41666666666667
68001, 0.91666666666667, 1.4666666666667, 0.39583333333333
68002, 0.91666666666667, 1.4833333333333, 0.41666666666667
68003, 0.91666666666667, 1.4166666666667, 0.45833333333333
68004, 0.89583333333333, 1.4333333333333, 0.45833333333333
68005, 0.91666666666667, 1.4333333333333, 0.4375
68006, 0.91666666666667, 1.45, 0.45833333333333
68007, 0.89583333333333, 1.4666666666667, 0.45833333333333
68008, 0.91666666666667, 1.4666666666667, 0.4375
68009, 0.91666666666667, 1.4833333333333, 0.45833333333333
68010, 0.91666666666667, 1.4333333333333, 0.47916666666667
68011, 0.91666666666667, 1.4666666666667, 0.47916666666667
68012, 0.95833333333333, 1.4166666666667, 0.041666666666667
68013, 0.9375, 1.4333333333333, 0.041666666666667
68014, 0.95833333333333, 1.4333333333333, 0.020833333333333
68015, 0.95833333333333, 1.45, 0.041666666666667
68016, 0.9375, 1.4666666666667, 0.041666666666667
68017, 0.95833333333333, 1.4666666666667, 0.020833333333333
68018, 0.95833333333333, 1.4833333333333, 0.041666666666667
68019, 0.95833333333333, 1.4166666666667, 0.083333333333333
68020, 0.9375, 1.4333333333333, 0.083333333333333
68021, 0.95833333333333, 1.4333333333333, 0.0625
68022, 0.95833333333333, 1.45, 0.083333333333333
68023, 0.9375, 1.4666666666667, 0.083333333333333
68024, 0.95833333333333, 1.4666666666667, 0.0625
68025, 0.95833333333333, 1.4833333333333, 0.083333333333333
68026, 0.95833333333333, 1.4166666666667, 0.125
68027, 0.9375, 1.4333333333333, 0.125
68028, 0.95833333333333, 1.4333333333333, 0.10416666666667
68029, 0.95833333333333, 1.45, 0.125
68030, 0.9375, 1.4666666666667, 0.125
68031, 0.95833333333333, 1.4666666666667, 0.10416666666667
68032, 0.95833333333333, 1.4833333333333, 0.125
68033, 0.95833333333333, 1.4166666666667, 0.16666666666667
68034, 0.9375, 1.4333333333333, 0.16666666666667
68035, 0.95833333333333, 1.4333333333333, 0.14583333333333
68036, 0.95833333333333, 1.45, 0.16666666666667
68037, 0.9375, 1.4666666666667, 0.16666666666667
68038, 0.95833333333333, 1.4666666666667, 0.14583333333333
68039, 0.95833333333333, 1.4833333333333, 0.16666666666667
68040, 0.95833333333333, 1.4166666666667, 0.20833333333333
68041, 0.9375, 1.4333333333333, 0.20833333333333
68042, 0.95833333333333, 1.4333333333333, 0.1875
68043, 0.95833333333333, 1.45, 0.20833333333333
68044, 0.9375, 1.4666666666667, 0.20833333333333
68045, 0.95833333333333, 1.4666666666667, 0.1875
68046, 0.95833333333333, 1.4833333333333, 0.20833333333333
68047, 0.95833333333333, 1.4166666666667, 0.25
68048, 0.9375, 1.4333333333333, 0.25
68049, 0.95833333333333, 1.4333333333333, 0.22916666666667
68050, 0.95833333333333, 1.45, 0.25
68051, 0.9375, 1.4666666666667, 0.25
68052, 0.95833333333333, 1.4666666666667, 0.22916666666667
68053, 0.95833333333333, 1.4833333333333, 0.25
68054, 0.95833333333333, 1.4166666666667, 0.29166666666667
68055, 0.9375, 1.4333333333333, 0.29166666666667
68056, 0.95833333333333, 1.4333333333333, 0.27083333333333
68057, 0.95833333333333, 1.45, 0.29166666666667
68058, 0.9375, 1.4666666666667, 0.29166666666667
68059, 0.95833333333333, 1.4666666666667, 0.27083333333333
68060, 0.95833333333333, 1.4833333333333, 0.29166666666667
68061, 0.95833333333333, 1.4166666666667, 0.33333333333333
68062, 0.9375, 1.4333333333333, 0.33333333333333
68063, 0.95833333333333, 1.4333333333333, 0.3125
68064, 0.95833333333333, 1.45, 0.33333333333333
68065, 0.9375, 1.4666666666667, 0.33333333333333
68066, 0.95833333333333, 1.4666666666667, 0.3125
68067, 0.95833333333333, 1.4833333333333, 0.33333333333333
68068, 0.95833333333333, 1.4166666666667, 0.375
68069, 0.9375, 1.4333333333333, 0.375
68070, 0.95833333333333, 1.4333333333333, 0.35416666666667
68071, 0.95833333333333, 1.45, 0.375
68072, 0.9375, 1.4666666666667, 0.375
68073, 0.95833333333333, 1.4666666666667, 0.35416666666667
68074, 0.95833333333333, 1.4833333333333, 0.375
68075, 0.95833333333333, 1.4166666666667, 0.41666666666667
68076, 0.9375, 1.4333333333333, 0.41666666666667
68077, 0.95833333333333, 1.4333333333333, 0.39583333333333
68078, 0.95833333333333, 1.45, 0.41666666666667
68079, 0.9375, 1.4666666666667, 0.41666666666667
68080, 0.95833333333333, 1.4666666666667, 0.39583333333333
68081, 0.95833333333333, 1.4833333333333, 0.41666666666667
68082, 0.95833333333333, 1.4166666666667, 0.45833333333333
68083, 0.9375, 1.4333333333333, 0.45833333333333
68084, 0.95833333333333, 1.4333333333333, 0.4375
68085, 0.95833333333333, 1.45, 0.45833333333333
68086, 0.9375, 1.4666666666667, 0.45833333333333
68087, 0.95833333333333, 1.4666666666667, 0.4375
68088, 0.95833333333333, 1.4833333333333, 0.45833333333333
68089, 0.95833333333333, 1.4333333333333, 0.47916666666667
68090, 0.95833333333333, 1.4666666666667, 0.47916666666667
68091, 0.97916666666667, 1.4333333333333, 0.041666666666667
68092, 0.97916666666667, 1.4666666666667, 0.041666666666667
68093, 0.97916666666667, 1.4333333333333, 0.083333333333333
68094, 0.97916666666667, 1.4666666666667, 0.083333333333333
68095, 0.97916666666667, 1.4333333333333, 0.125
68096, 0.97916666666667, 1.4666666666667, 0.125
68097, 0.97916666666667, 1.4333333333333, 0.16666666666667
68098, 0.97916666666667, 1.4666666666667, 0.16666666666667
68099, 0.97916666666667, 1.4333333333333, 0.20833333333333
68100, 0.97916666666667, 1.4666666666667, 0.20833333333333
68101, 0.97916666666667, 1.4333333333333, 0.25
68102, 0.97916666666667, 1.4666666666667, 0.25
68103, 0.97916666666667, 1.4333333333333, 0.29166666666667
68104, 0.97916666666667, 1.4666666666667, 0.29166666666667
68105, 0.97916666666667, 1.4333333333333, 0.33333333333333
68106, 0.97916666666667, 1.4666666666667, 0.33333333333333
68107, 0.97916666666667, 1.4333333333333, 0.375
68108, 0.97916666666667, 1.4666666666667, 0.375
68109, 0.97916666666667, 1.4333333333333, 0.41666666666667
68110, 0.97916666666667, 1.4666666666667, 0.41666666666667
68111, 0.97916666666667, 1.4333333333333, 0.45833333333333
68112, 0.97916666666667, 1.4666666666667, 0.45833333333333
68113, 1.04, 1.4333333333333, 0.041666666666667
68114, 1.08, 1.4333333333333, 0.041666666666667
68115, 1.12, 1.4333333333333, 0.041666666666667
68116, 1.16, 1.4333333333333, 0.041666666666667
68117, 1.04, 1.4666666666667, 0.041666666666667
68118, 1.08, 1.4666666666667, 0.041666666666667
68119, 1.12, 1.4666666666667, 0.041666666666667
68120, 1.16, 1.4666666666667, 0.041666666666667
68121, 1.04, 1.4333333333333, 0.083333333333333
68122, 1.08, 1.4333333333333, 0.083333333333333
68123, 1.12, 1.4333333333333, 0.083333333333333
68124, 1.16, 1.4333333333333, 0.083333333333333
68125, 1.04, 1.4666666666667, 0.083333333333333
68126, 1.08, 1.4666666666667, 0.083333333333333
68127, 1.12, 1.4666666666667, 0.083333333333333
68128, 1.16, 1.4666666666667, 0.083333333333333
68129, 1.04, 1.4333333333333, 0.125
68130, 1.08, 1.4333333333333, 0.125
68131, 1.12, 1.4333333333333, 0.125
68132, 1.16, 1.4333333333333, 0.125
68133, 1.04, 1.4666666666667, 0.125
68134, 1.08, 1.4666666666667, 0.125
68135, 1.12, 1.4666666666667, 0.125
68136, 1.16, 1.4666666666667, 0.125
68137, 1.04, 1.4333333333333, 0.16666666666667
68138, 1.08, 1.4333333333333, 0.16666666666667
68139, 1.12, 1.4333333333333, 0.16666666666667
68140, 1.16, 1.4333333333333, 0.16666666666667
68141, 1.04, 1.4666666666667, 0.16666666666667
68142, 1.08, 1.4666666666667, 0.16666666666667
68143, 1.12, 1.4666666666667, 0.16666666666667
68144, 1.16, 1.4666666666667, 0.16666666666667
68145, 1.04, 1.4333333333333, 0.20833333333333
68146, 1.08, 1.4333333333333, 0.20833333333333
68147, 1.12, 1.4333333333333, 0.20833333333333
68148, 1.16, 1.4333333333333, 0.20833333333333
68149, 1.04, 1.4666666666667, 0.20833333333333
68150, 1.08, 1.4666666666667, 0.20833333333333
68151, 1.12, 1.4666666666667, 0.20833333333333
68152, 1.16, 1.4666666666667, 0.20833333333333
68153, 1.04, 1.4333333333333, 0.25
68154, 1.08, 1.4333333333333, 0.25
68155, 1.12, 1.4333333333333, 0.25
68156, 1.16, 1.4333333333333, 0.25
68157, 1.04, 1.4666666666667, 0.25
68158, 1.08, 1.4666666666667, 0.25
68159, 1.12, 1.4666666666667, 0.25
68160, 1.16, 1.4666666666667, 0.25
68161, 1.04, 1.4333333333333, 0.29166666666667
68162, 1.08, 1.4333333333333, 0.29166666666667
68163, 1.12, 1.4333333333333, 0.29166666666667
68164, 1.16, 1.4333333333333, 0.29166666666667
68165, 1.04, 1.4666666666667, 0.29166666666667
68166, 1.08, 1.4666666666667, 0.29166666666667
68167, 1.12, 1.4666666666667, 0.29166666666667
68168, 1.16, 1.4666666666667, 0.29166666666667
68169, 1.04, 1.4333333333333, 0.33333333333333
68170, 1.08, 1.4333333333333, 0.33333333333333
68171, 1.12, 1.4333333333333, 0.33333333333333
68172, 1.16, 1.4333333333333, 0.33333333333333
68173, 1.04, 1.4666666666667, 0.33333333333333
68174, 1.08, 1.4666666666667, 0.33333333333333
68175, 1.12, 1.4666666666667, 0.33333333333333
68176, 1.16, 1.4666666666667, 0.33333333333333
68177, 1.04, 1.4333333333333, 0.375
68178, 1.08, 1.4333333333333, 0.375
68179, 1.12, 1.4333333333333, 0.375
68180, 1.16, 1.4333333333333, 0.375
68181, 1.04, 1.4666666666667, 0.375
68182, 1.08, 1.4666666666667, 0.375
68183, 1.12, 1.4666666666667, 0.375
68184, 1.16, 1.4666666666667, 0.375
68185, 1.04, 1.4333333333333, 0.41666666666667
68186, 1.08, 1.4333333333333, 0.41666666666667
68187, 1.12, 1.4333333333333, 0.41666666666667
68188, 1.16, 1.4333333333333, 0.41666666666667
68189, 1.04, 1.4666666666667, 0.41666666666667
68190, 1.08, 1.4666666666667, 0.41666666666667
68191, 1.12, 1.4666666666667, 0.41666666666667
68192, 1.16, 1.4666666666667, 0.41666666666667
68193, 1.04, 1.4333333333333, 0.45833333333333
68194, 1.08, 1.4333333333333, 0.45833333333333
68195, 1.12, 1.4333333333333, 0.45833333333333
68196, 1.16, 1.4333333333333, 0.45833333333333
68197, 1.04, 1.4666666666667, 0.45833333333333
68198, 1.08, 1.4666666666667, 0.45833333333333
68199, 1.12, 1.4666666666667, 0.45833333333333
68200, 1.16, 1.4666666666667, 0.45833333333333
68201, 1.02, 1.4333333333333, 0.041666666666667
68202, 1.04, 1.4333333333333, 0.020833333333333
68203, 1.04, 1.4166666666667, 0.041666666666667
68204, 1.06, 1.4333333333333, 0.041666666666667
68205, 1.08, 1.4333333333333, 0.020833333333333
68206, 1.08, 1.4166666666667, 0.041666666666667
68207, 1.1, 1.4333333333333, 0.041666666666667
68208, 1.12, 1.4333333333333, 0.020833333333333
68209, 1.12, 1.4166666666667, 0.041666666666667
68210, 1.14, 1.4333333333333, 0.041666666666667
68211, 1.16, 1.4333333333333, 0.020833333333333
68212, 1.16, 1.4166666666667, 0.041666666666667
68213, 1.18, 1.4333333333333, 0.041666666666667
68214, 1.02, 1.4666666666667, 0.041666666666667
68215, 1.04, 1.4666666666667, 0.020833333333333
68216, 1.04, 1.45, 0.041666666666667
68217, 1.06, 1.4666666666667, 0.041666666666667
68218, 1.08, 1.4666666666667, 0.020833333333333
68219, 1.08, 1.45, 0.041666666666667
68220, 1.1, 1.4666666666667, 0.041666666666667
68221, 1.12, 1.4666666666667, 0.020833333333333
68222, 1.12, 1.45, 0.041666666666667
68223, 1.14, 1.4666666666667, 0.041666666666667
68224, 1.16, 1.4666666666667, 0.020833333333333
68225, 1.16, 1.45, 0.041666666666667
68226, 1.18, 1.4666666666667, 0.041666666666667
68227, 1.04, 1.4833333333333, 0.041666666666667
68228, 1.08, 1.4833333333333, 0.041666666666667
68229, 1.12, 1.4833333333333, 0.041666666666667
68230, 1.16, 1.4833333333333, 0.041666666666667
68231, 1.02, 1.4333333333333, 0.083333333333333
68232, 1.04, 1.4333333333333, 0.0625
68233, 1.04, 1.4166666666667, 0.083333333333333
68234, 1.06, 1.4333333333333, 0.083333333333333
68235, 1.08, 1.4333333333333, 0.0625
68236, 1.08, 1.4166666666667, 0.083333333333333
68237, 1.1, 1.4333333333333, 0.083333333333333
68238, 1.12, 1.4333333333333, 0.0625
68239, 1.12, 1.4166666666667, 0.083333333333333
68240, 1.14, 1.4333333333333, 0.083333333333333
68241, 1.16, 1.4333333333333, 0.0625
68242, 1.16, 1.4166666666667, 0.083333333333333
68243, 1.18, 1.4333333333333, 0.083333333333333
68244, 1.02, 1.4666666666667, 0.083333333333333
68245, 1.04, 1.4666666666667, 0.0625
68246, 1.04, 1.45, 0.083333333333333
68247, 1.06, 1.4666666666667, 0.083333333333333
68248, 1.08, 1.4666666666667, 0.0625
68249, 1.08, 1.45, 0.083333333333333
68250, 1.1, 1.4666666666667, 0.083333333333333
68251, 1.12, 1.4666666666667, 0.0625
68252, 1.12, 1.45, 0.083333333333333
68253, 1.14, 1.4666666666667, 0.083333333333333
68254, 1.16, 1.4666666666667, 0.0625
68255, 1.16, 1.45, 0.083333333333333
68256, 1.18, 1.4666666666667, 0.083333333333333
68257, 1.04, 1.4833333333333, 0.083333333333333
68258, 1.08, 1.4833333333333, 0.083333333333333
68259, 1.12, 1.4833333333333, 0.083333333333333
68260, 1.16, 1.4833333333333, 0.083333333333333
68261, 1.02, 1.4333333333333, 0.125
68262, 1.04, 1.4333333333333, 0.10416666666667
68263, 1.04, 1.4166666666667, 0.125
68264, 1.06, 1.4333333333333, 0.125
68265, 1.08, 1.4333333333333, 0.10416666666667
68266, 1.08, 1.4166666666667, 0.125
68267, 1.1, 1.4333333333333, 0.125
68268, 1.12, 1.4333333333333, 0.10416666666667
68269, 1.12, 1.4166666666667, 0.125
68270, 1.14, 1.4333333333333, 0.125
68271, 1.16, 1.4333333333333, 0.10416666666667
68272, 1.16, 1.4166666666667, 0.125
68273, 1.18, 1.4333333333333, 0.125
68274, 1.02, 1.4666666666667, 0.125
68275, 1.04, 1.4666666666667, 0.10416666666667
68276, 1.04, 1.45, 0.125
68277, 1.06, 1.4666666666667, 0.125
68278, 1.08, 1.4666666666667, 0.10416666666667
68279, 1.08, 1.45, 0.125
68280, 1.1, 1.4666666666667, 0.125
68281, 1.12, 1.4666666666667, 0.10416666666667
68282, 1.12, 1.45, 0.125
68283, 1.14, 1.4666666666667, 0.125
68284, 1.16, 1.4666666666667, 0.10416666666667
68285, 1.16, 1.45, 0.125
68286, 1.18, 1.4666666666667, 0.125
68287, 1.04, 1.4833333333333, 0.125
68288, 1.08, 1.4833333333333, 0.125
68289, 1.12, 1.4833333333333, 0.125
68290, 1.16, 1.4833333333333, 0.125
68291, 1.02, 1.4333333333333, 0.16666666666667
68292, 1.04, 1.4333333333333, 0.14583333333333
68293, 1.04, 1.4166666666667, 0.16666666666667
68294, 1.06, 1.4333333333333, 0.16666666666667
68295, 1.08, 1.4333333333333, 0.14583333333333
68296, 1.08, 1.4166666666667, 0.16666666666667
68297, 1.1, 1.4333333333333, 0.16666666666667
68298, 1.12, 1.4333333333333, 0.14583333333333
68299, 1.12, 1.4166666666667, 0.16666666666667
68300, 1.14, 1.4333333333333, 0.16666666666667
68301, 1.16, 1.4333333333333, 0.14583333333333
68302, 1.16, 1.4166666666667, 0.16666666666667
68303, 1.18, 1.4333333333333, 0.16666666666667
68304, 1.02, 1.4666666666667, 0.16666666666667
68305, 1.04, 1.4666666666667, 0.14583333333333
68306, 1.04, 1.45, 0.16666666666667
68307, 1.06, 1.4666666666667, 0.16666666666667
68308, 1.08, 1.4666666666667, 0.14583333333333
68309, 1.08, 1.45, 0.16666666666667
68310, 1.1, 1.4666666666667, 0.16666666666667
68311, 1.12, 1.4666666666667, 0.14583333333333
68312, 1.12, 1.45, 0.16666666666667
68313, 1.14, 1.4666666666667, 0.16666666666667
68314, 1.16, 1.4666666666667, 0.14583333333333
68315, 1.16, 1.45, 0.16666666666667
68316, 1.18, 1.4666666666667, 0.16666666666667
68317, 1.04, 1.4833333333333, 0.16666666666667
68318, 1.08, 1.4833333333333, 0.16666666666667
68319, 1.12, 1.4833333333333, 0.16666666666667
68320, 1.16, 1.4833333333333, 0.16666666666667
68321, 1.02, 1.4333333333333, 0.20833333333333
68322, 1.04, 1.4333333333333, 0.1875
68323, 1.04, 1.4166666666667, 0.20833333333333
68324, 1.06, 1.4333333333333, 0.20833333333333
68325, 1.08, 1.4333333333333, 0.1875
68326, 1.08, 1.4166666666667, 0.20833333333333
68327, 1.1, 1.4333333333333, 0.20833333333333
68328, 1.12, 1.4333333333333, 0.1875
68329, 1.12, 1.4166666666667, 0.20833333333333
68330, 1.14, 1.4333333333333, 0.20833333333333
68331, 1.16, 1.4333333333333, 0.1875
68332, 1.16, 1.4166666666667, 0.20833333333333
68333, 1.18, 1.4333333333333, 0.20833333333333
