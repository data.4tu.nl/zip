75145, 1.7833333333333, 1, 0.33333333333333
75146, 1.7833333333333, 0.95, 0.33333333333333
75147, 1.7833333333333, 0.9, 0.33333333333333
75148, 1.7833333333333, 0.85, 0.33333333333333
75149, 1.7833333333333, 0.8, 0.33333333333333
75150, 1.7833333333333, 0.75, 0.33333333333333
75151, 1.7833333333333, 0.7, 0.33333333333333
75152, 1.7833333333333, 0.65, 0.33333333333333
75153, 1.7833333333333, 0.6, 0.33333333333333
75154, 1.7833333333333, 0.55, 0.33333333333333
75155, 1.7833333333333, 0.5, 0.33333333333333
75156, 1.7833333333333, 0.45, 0.33333333333333
75157, 1.7833333333333, 0.4, 0.33333333333333
75158, 1.7833333333333, 0.35, 0.33333333333333
75159, 1.7833333333333, 0.3, 0.33333333333333
75160, 1.7833333333333, 0.25, 0.33333333333333
75161, 1.7833333333333, 0.2, 0.33333333333333
75162, 1.825, 1.3, 0.33333333333333
75163, 1.825, 1.25, 0.33333333333333
75164, 1.825, 1.2, 0.33333333333333
75165, 1.825, 1.15, 0.33333333333333
75166, 1.825, 1.1, 0.33333333333333
75167, 1.825, 1.05, 0.33333333333333
75168, 1.825, 1, 0.33333333333333
75169, 1.825, 0.95, 0.33333333333333
75170, 1.825, 0.9, 0.33333333333333
75171, 1.825, 0.85, 0.33333333333333
75172, 1.825, 0.8, 0.33333333333333
75173, 1.825, 0.75, 0.33333333333333
75174, 1.825, 0.7, 0.33333333333333
75175, 1.825, 0.65, 0.33333333333333
75176, 1.825, 0.6, 0.33333333333333
75177, 1.825, 0.55, 0.33333333333333
75178, 1.825, 0.5, 0.33333333333333
75179, 1.825, 0.45, 0.33333333333333
75180, 1.825, 0.4, 0.33333333333333
75181, 1.825, 0.35, 0.33333333333333
75182, 1.825, 0.3, 0.33333333333333
75183, 1.825, 0.25, 0.33333333333333
75184, 1.825, 0.2, 0.33333333333333
75185, 1.8666666666667, 1.3, 0.33333333333333
75186, 1.8666666666667, 1.25, 0.33333333333333
75187, 1.8666666666667, 1.2, 0.33333333333333
75188, 1.8666666666667, 1.15, 0.33333333333333
75189, 1.8666666666667, 1.1, 0.33333333333333
75190, 1.8666666666667, 1.05, 0.33333333333333
75191, 1.8666666666667, 1, 0.33333333333333
75192, 1.8666666666667, 0.95, 0.33333333333333
75193, 1.8666666666667, 0.9, 0.33333333333333
75194, 1.8666666666667, 0.85, 0.33333333333333
75195, 1.8666666666667, 0.8, 0.33333333333333
75196, 1.8666666666667, 0.75, 0.33333333333333
75197, 1.8666666666667, 0.7, 0.33333333333333
75198, 1.8666666666667, 0.65, 0.33333333333333
75199, 1.8666666666667, 0.6, 0.33333333333333
75200, 1.8666666666667, 0.55, 0.33333333333333
75201, 1.8666666666667, 0.5, 0.33333333333333
75202, 1.8666666666667, 0.45, 0.33333333333333
75203, 1.8666666666667, 0.4, 0.33333333333333
75204, 1.8666666666667, 0.35, 0.33333333333333
75205, 1.8666666666667, 0.3, 0.33333333333333
75206, 1.8666666666667, 0.25, 0.33333333333333
75207, 1.8666666666667, 0.2, 0.33333333333333
75208, 1.9083333333333, 1.3, 0.33333333333333
75209, 1.9083333333333, 1.25, 0.33333333333333
75210, 1.9083333333333, 1.2, 0.33333333333333
75211, 1.9083333333333, 1.15, 0.33333333333333
75212, 1.9083333333333, 1.1, 0.33333333333333
75213, 1.9083333333333, 1.05, 0.33333333333333
75214, 1.9083333333333, 1, 0.33333333333333
75215, 1.9083333333333, 0.95, 0.33333333333333
75216, 1.9083333333333, 0.9, 0.33333333333333
75217, 1.9083333333333, 0.85, 0.33333333333333
75218, 1.9083333333333, 0.8, 0.33333333333333
75219, 1.9083333333333, 0.75, 0.33333333333333
75220, 1.9083333333333, 0.7, 0.33333333333333
75221, 1.9083333333333, 0.65, 0.33333333333333
75222, 1.9083333333333, 0.6, 0.33333333333333
75223, 1.9083333333333, 0.55, 0.33333333333333
75224, 1.9083333333333, 0.5, 0.33333333333333
75225, 1.9083333333333, 0.45, 0.33333333333333
75226, 1.9083333333333, 0.4, 0.33333333333333
75227, 1.9083333333333, 0.35, 0.33333333333333
75228, 1.9083333333333, 0.3, 0.33333333333333
75229, 1.9083333333333, 0.25, 0.33333333333333
75230, 1.9083333333333, 0.2, 0.33333333333333
75231, 1.95, 1.3, 0.33333333333333
75232, 1.95, 1.25, 0.33333333333333
75233, 1.95, 1.2, 0.33333333333333
75234, 1.95, 1.15, 0.33333333333333
75235, 1.95, 1.1, 0.33333333333333
75236, 1.95, 1.05, 0.33333333333333
75237, 1.95, 1, 0.33333333333333
75238, 1.95, 0.95, 0.33333333333333
75239, 1.95, 0.9, 0.33333333333333
75240, 1.95, 0.85, 0.33333333333333
75241, 1.95, 0.8, 0.33333333333333
75242, 1.95, 0.75, 0.33333333333333
75243, 1.95, 0.7, 0.33333333333333
75244, 1.95, 0.65, 0.33333333333333
75245, 1.95, 0.6, 0.33333333333333
75246, 1.95, 0.55, 0.33333333333333
75247, 1.95, 0.5, 0.33333333333333
75248, 1.95, 0.45, 0.33333333333333
75249, 1.95, 0.4, 0.33333333333333
75250, 1.95, 0.35, 0.33333333333333
75251, 1.95, 0.3, 0.33333333333333
75252, 1.95, 0.25, 0.33333333333333
75253, 1.95, 0.2, 0.33333333333333
75254, 1.9916666666667, 1.3, 0.33333333333333
75255, 1.9916666666667, 1.25, 0.33333333333333
75256, 1.9916666666667, 1.2, 0.33333333333333
75257, 1.9916666666667, 1.15, 0.33333333333333
75258, 1.9916666666667, 1.1, 0.33333333333333
75259, 1.9916666666667, 1.05, 0.33333333333333
75260, 1.9916666666667, 1, 0.33333333333333
75261, 1.9916666666667, 0.95, 0.33333333333333
75262, 1.9916666666667, 0.9, 0.33333333333333
75263, 1.9916666666667, 0.85, 0.33333333333333
75264, 1.9916666666667, 0.8, 0.33333333333333
75265, 1.9916666666667, 0.75, 0.33333333333333
75266, 1.9916666666667, 0.7, 0.33333333333333
75267, 1.9916666666667, 0.65, 0.33333333333333
75268, 1.9916666666667, 0.6, 0.33333333333333
75269, 1.9916666666667, 0.55, 0.33333333333333
75270, 1.9916666666667, 0.5, 0.33333333333333
75271, 1.9916666666667, 0.45, 0.33333333333333
75272, 1.9916666666667, 0.4, 0.33333333333333
75273, 1.9916666666667, 0.35, 0.33333333333333
75274, 1.9916666666667, 0.3, 0.33333333333333
75275, 1.9916666666667, 0.25, 0.33333333333333
75276, 1.9916666666667, 0.2, 0.33333333333333
75277, 2.0333333333333, 1.3, 0.33333333333333
75278, 2.0333333333333, 1.25, 0.33333333333333
75279, 2.0333333333333, 1.2, 0.33333333333333
75280, 2.0333333333333, 1.15, 0.33333333333333
75281, 2.0333333333333, 1.1, 0.33333333333333
75282, 2.0333333333333, 1.05, 0.33333333333333
75283, 2.0333333333333, 1, 0.33333333333333
75284, 2.0333333333333, 0.95, 0.33333333333333
75285, 2.0333333333333, 0.9, 0.33333333333333
75286, 2.0333333333333, 0.85, 0.33333333333333
75287, 2.0333333333333, 0.8, 0.33333333333333
75288, 2.0333333333333, 0.75, 0.33333333333333
75289, 2.0333333333333, 0.7, 0.33333333333333
75290, 2.0333333333333, 0.65, 0.33333333333333
75291, 2.0333333333333, 0.6, 0.33333333333333
75292, 2.0333333333333, 0.55, 0.33333333333333
75293, 2.0333333333333, 0.5, 0.33333333333333
75294, 2.0333333333333, 0.45, 0.33333333333333
75295, 2.0333333333333, 0.4, 0.33333333333333
75296, 2.0333333333333, 0.35, 0.33333333333333
75297, 2.0333333333333, 0.3, 0.33333333333333
75298, 2.0333333333333, 0.25, 0.33333333333333
75299, 2.0333333333333, 0.2, 0.33333333333333
75300, 2.075, 1.3, 0.33333333333333
75301, 2.075, 1.25, 0.33333333333333
75302, 2.075, 1.2, 0.33333333333333
75303, 2.075, 1.15, 0.33333333333333
75304, 2.075, 1.1, 0.33333333333333
75305, 2.075, 1.05, 0.33333333333333
75306, 2.075, 1, 0.33333333333333
75307, 2.075, 0.95, 0.33333333333333
75308, 2.075, 0.9, 0.33333333333333
75309, 2.075, 0.85, 0.33333333333333
75310, 2.075, 0.8, 0.33333333333333
75311, 2.075, 0.75, 0.33333333333333
75312, 2.075, 0.7, 0.33333333333333
75313, 2.075, 0.65, 0.33333333333333
75314, 2.075, 0.6, 0.33333333333333
75315, 2.075, 0.55, 0.33333333333333
75316, 2.075, 0.5, 0.33333333333333
75317, 2.075, 0.45, 0.33333333333333
75318, 2.075, 0.4, 0.33333333333333
75319, 2.075, 0.35, 0.33333333333333
75320, 2.075, 0.3, 0.33333333333333
75321, 2.075, 0.25, 0.33333333333333
75322, 2.075, 0.2, 0.33333333333333
75323, 2.1166666666667, 1.3, 0.33333333333333
75324, 2.1166666666667, 1.25, 0.33333333333333
75325, 2.1166666666667, 1.2, 0.33333333333333
75326, 2.1166666666667, 1.15, 0.33333333333333
75327, 2.1166666666667, 1.1, 0.33333333333333
75328, 2.1166666666667, 1.05, 0.33333333333333
75329, 2.1166666666667, 1, 0.33333333333333
75330, 2.1166666666667, 0.95, 0.33333333333333
75331, 2.1166666666667, 0.9, 0.33333333333333
75332, 2.1166666666667, 0.85, 0.33333333333333
75333, 2.1166666666667, 0.8, 0.33333333333333
75334, 2.1166666666667, 0.75, 0.33333333333333
75335, 2.1166666666667, 0.7, 0.33333333333333
75336, 2.1166666666667, 0.65, 0.33333333333333
75337, 2.1166666666667, 0.6, 0.33333333333333
75338, 2.1166666666667, 0.55, 0.33333333333333
75339, 2.1166666666667, 0.5, 0.33333333333333
75340, 2.1166666666667, 0.45, 0.33333333333333
75341, 2.1166666666667, 0.4, 0.33333333333333
75342, 2.1166666666667, 0.35, 0.33333333333333
75343, 2.1166666666667, 0.3, 0.33333333333333
75344, 2.1166666666667, 0.25, 0.33333333333333
75345, 2.1166666666667, 0.2, 0.33333333333333
75346, 2.1583333333333, 1.3, 0.33333333333333
75347, 2.1583333333333, 1.25, 0.33333333333333
75348, 2.1583333333333, 1.2, 0.33333333333333
75349, 2.1583333333333, 1.15, 0.33333333333333
75350, 2.1583333333333, 1.1, 0.33333333333333
75351, 2.1583333333333, 1.05, 0.33333333333333
75352, 2.1583333333333, 1, 0.33333333333333
75353, 2.1583333333333, 0.95, 0.33333333333333
75354, 2.1583333333333, 0.9, 0.33333333333333
75355, 2.1583333333333, 0.85, 0.33333333333333
75356, 2.1583333333333, 0.8, 0.33333333333333
75357, 2.1583333333333, 0.75, 0.33333333333333
75358, 2.1583333333333, 0.7, 0.33333333333333
75359, 2.1583333333333, 0.65, 0.33333333333333
75360, 2.1583333333333, 0.6, 0.33333333333333
75361, 2.1583333333333, 0.55, 0.33333333333333
75362, 2.1583333333333, 0.5, 0.33333333333333
75363, 2.1583333333333, 0.45, 0.33333333333333
75364, 2.1583333333333, 0.4, 0.33333333333333
75365, 2.1583333333333, 0.35, 0.33333333333333
75366, 2.1583333333333, 0.3, 0.33333333333333
75367, 2.1583333333333, 0.25, 0.33333333333333
75368, 2.1583333333333, 0.2, 0.33333333333333
75369, 1.2416666666667, 1.3, 0.375
75370, 1.2416666666667, 1.25, 0.375
75371, 1.2416666666667, 1.2, 0.375
75372, 1.2416666666667, 1.15, 0.375
75373, 1.2416666666667, 1.1, 0.375
75374, 1.2416666666667, 1.05, 0.375
75375, 1.2416666666667, 1, 0.375
75376, 1.2416666666667, 0.95, 0.375
75377, 1.2416666666667, 0.9, 0.375
75378, 1.2416666666667, 0.85, 0.375
75379, 1.2416666666667, 0.8, 0.375
75380, 1.2416666666667, 0.75, 0.375
75381, 1.2416666666667, 0.7, 0.375
75382, 1.2416666666667, 0.65, 0.375
75383, 1.2416666666667, 0.6, 0.375
75384, 1.2416666666667, 0.55, 0.375
75385, 1.2416666666667, 0.5, 0.375
75386, 1.2416666666667, 0.45, 0.375
75387, 1.2416666666667, 0.4, 0.375
75388, 1.2416666666667, 0.35, 0.375
75389, 1.2416666666667, 0.3, 0.375
75390, 1.2416666666667, 0.25, 0.375
75391, 1.2416666666667, 0.2, 0.375
75392, 1.2833333333333, 1.3, 0.375
75393, 1.2833333333333, 1.25, 0.375
75394, 1.2833333333333, 1.2, 0.375
75395, 1.2833333333333, 1.15, 0.375
75396, 1.2833333333333, 1.1, 0.375
75397, 1.2833333333333, 1.05, 0.375
75398, 1.2833333333333, 1, 0.375
75399, 1.2833333333333, 0.95, 0.375
75400, 1.2833333333333, 0.9, 0.375
75401, 1.2833333333333, 0.85, 0.375
75402, 1.2833333333333, 0.8, 0.375
75403, 1.2833333333333, 0.75, 0.375
75404, 1.2833333333333, 0.7, 0.375
75405, 1.2833333333333, 0.65, 0.375
75406, 1.2833333333333, 0.6, 0.375
75407, 1.2833333333333, 0.55, 0.375
75408, 1.2833333333333, 0.5, 0.375
75409, 1.2833333333333, 0.45, 0.375
75410, 1.2833333333333, 0.4, 0.375
75411, 1.2833333333333, 0.35, 0.375
75412, 1.2833333333333, 0.3, 0.375
75413, 1.2833333333333, 0.25, 0.375
75414, 1.2833333333333, 0.2, 0.375
75415, 1.325, 1.3, 0.375
75416, 1.325, 1.25, 0.375
75417, 1.325, 1.2, 0.375
75418, 1.325, 1.15, 0.375
75419, 1.325, 1.1, 0.375
75420, 1.325, 1.05, 0.375
75421, 1.325, 1, 0.375
75422, 1.325, 0.95, 0.375
75423, 1.325, 0.9, 0.375
75424, 1.325, 0.85, 0.375
75425, 1.325, 0.8, 0.375
75426, 1.325, 0.75, 0.375
75427, 1.325, 0.7, 0.375
75428, 1.325, 0.65, 0.375
75429, 1.325, 0.6, 0.375
75430, 1.325, 0.55, 0.375
75431, 1.325, 0.5, 0.375
75432, 1.325, 0.45, 0.375
75433, 1.325, 0.4, 0.375
75434, 1.325, 0.35, 0.375
75435, 1.325, 0.3, 0.375
75436, 1.325, 0.25, 0.375
75437, 1.325, 0.2, 0.375
75438, 1.3666666666667, 1.3, 0.375
75439, 1.3666666666667, 1.25, 0.375
75440, 1.3666666666667, 1.2, 0.375
75441, 1.3666666666667, 1.15, 0.375
75442, 1.3666666666667, 1.1, 0.375
75443, 1.3666666666667, 1.05, 0.375
75444, 1.3666666666667, 1, 0.375
75445, 1.3666666666667, 0.95, 0.375
75446, 1.3666666666667, 0.9, 0.375
75447, 1.3666666666667, 0.85, 0.375
75448, 1.3666666666667, 0.8, 0.375
75449, 1.3666666666667, 0.75, 0.375
75450, 1.3666666666667, 0.7, 0.375
75451, 1.3666666666667, 0.65, 0.375
75452, 1.3666666666667, 0.6, 0.375
75453, 1.3666666666667, 0.55, 0.375
75454, 1.3666666666667, 0.5, 0.375
75455, 1.3666666666667, 0.45, 0.375
75456, 1.3666666666667, 0.4, 0.375
75457, 1.3666666666667, 0.35, 0.375
75458, 1.3666666666667, 0.3, 0.375
75459, 1.3666666666667, 0.25, 0.375
75460, 1.3666666666667, 0.2, 0.375
75461, 1.4083333333333, 1.3, 0.375
75462, 1.4083333333333, 1.25, 0.375
75463, 1.4083333333333, 1.2, 0.375
75464, 1.4083333333333, 1.15, 0.375
75465, 1.4083333333333, 1.1, 0.375
75466, 1.4083333333333, 1.05, 0.375
75467, 1.4083333333333, 1, 0.375
75468, 1.4083333333333, 0.95, 0.375
75469, 1.4083333333333, 0.9, 0.375
75470, 1.4083333333333, 0.85, 0.375
75471, 1.4083333333333, 0.8, 0.375
75472, 1.4083333333333, 0.75, 0.375
75473, 1.4083333333333, 0.7, 0.375
75474, 1.4083333333333, 0.65, 0.375
75475, 1.4083333333333, 0.6, 0.375
75476, 1.4083333333333, 0.55, 0.375
75477, 1.4083333333333, 0.5, 0.375
75478, 1.4083333333333, 0.45, 0.375
75479, 1.4083333333333, 0.4, 0.375
75480, 1.4083333333333, 0.35, 0.375
75481, 1.4083333333333, 0.3, 0.375
75482, 1.4083333333333, 0.25, 0.375
75483, 1.4083333333333, 0.2, 0.375
75484, 1.45, 1.3, 0.375
75485, 1.45, 1.25, 0.375
75486, 1.45, 1.2, 0.375
75487, 1.45, 1.15, 0.375
75488, 1.45, 1.1, 0.375
75489, 1.45, 1.05, 0.375
75490, 1.45, 1, 0.375
75491, 1.45, 0.95, 0.375
75492, 1.45, 0.9, 0.375
75493, 1.45, 0.85, 0.375
75494, 1.45, 0.8, 0.375
75495, 1.45, 0.75, 0.375
75496, 1.45, 0.7, 0.375
75497, 1.45, 0.65, 0.375
75498, 1.45, 0.6, 0.375
75499, 1.45, 0.55, 0.375
75500, 1.45, 0.5, 0.375
75501, 1.45, 0.45, 0.375
75502, 1.45, 0.4, 0.375
75503, 1.45, 0.35, 0.375
75504, 1.45, 0.3, 0.375
75505, 1.45, 0.25, 0.375
75506, 1.45, 0.2, 0.375
75507, 1.4916666666667, 1.3, 0.375
75508, 1.4916666666667, 1.25, 0.375
75509, 1.4916666666667, 1.2, 0.375
75510, 1.4916666666667, 1.15, 0.375
75511, 1.4916666666667, 1.1, 0.375
75512, 1.4916666666667, 1.05, 0.375
75513, 1.4916666666667, 1, 0.375
75514, 1.4916666666667, 0.95, 0.375
75515, 1.4916666666667, 0.9, 0.375
75516, 1.4916666666667, 0.85, 0.375
75517, 1.4916666666667, 0.8, 0.375
75518, 1.4916666666667, 0.75, 0.375
75519, 1.4916666666667, 0.7, 0.375
75520, 1.4916666666667, 0.65, 0.375
75521, 1.4916666666667, 0.6, 0.375
75522, 1.4916666666667, 0.55, 0.375
75523, 1.4916666666667, 0.5, 0.375
75524, 1.4916666666667, 0.45, 0.375
75525, 1.4916666666667, 0.4, 0.375
75526, 1.4916666666667, 0.35, 0.375
75527, 1.4916666666667, 0.3, 0.375
75528, 1.4916666666667, 0.25, 0.375
75529, 1.4916666666667, 0.2, 0.375
75530, 1.5333333333333, 1.3, 0.375
75531, 1.5333333333333, 1.25, 0.375
75532, 1.5333333333333, 1.2, 0.375
75533, 1.5333333333333, 1.15, 0.375
75534, 1.5333333333333, 1.1, 0.375
75535, 1.5333333333333, 1.05, 0.375
75536, 1.5333333333333, 1, 0.375
75537, 1.5333333333333, 0.95, 0.375
75538, 1.5333333333333, 0.9, 0.375
75539, 1.5333333333333, 0.85, 0.375
75540, 1.5333333333333, 0.8, 0.375
75541, 1.5333333333333, 0.75, 0.375
75542, 1.5333333333333, 0.7, 0.375
75543, 1.5333333333333, 0.65, 0.375
75544, 1.5333333333333, 0.6, 0.375
75545, 1.5333333333333, 0.55, 0.375
75546, 1.5333333333333, 0.5, 0.375
75547, 1.5333333333333, 0.45, 0.375
75548, 1.5333333333333, 0.4, 0.375
75549, 1.5333333333333, 0.35, 0.375
75550, 1.5333333333333, 0.3, 0.375
75551, 1.5333333333333, 0.25, 0.375
75552, 1.5333333333333, 0.2, 0.375
75553, 1.575, 1.3, 0.375
75554, 1.575, 1.25, 0.375
75555, 1.575, 1.2, 0.375
75556, 1.575, 1.15, 0.375
75557, 1.575, 1.1, 0.375
75558, 1.575, 1.05, 0.375
75559, 1.575, 1, 0.375
75560, 1.575, 0.95, 0.375
75561, 1.575, 0.9, 0.375
75562, 1.575, 0.85, 0.375
75563, 1.575, 0.8, 0.375
75564, 1.575, 0.75, 0.375
75565, 1.575, 0.7, 0.375
75566, 1.575, 0.65, 0.375
75567, 1.575, 0.6, 0.375
75568, 1.575, 0.55, 0.375
75569, 1.575, 0.5, 0.375
75570, 1.575, 0.45, 0.375
75571, 1.575, 0.4, 0.375
75572, 1.575, 0.35, 0.375
75573, 1.575, 0.3, 0.375
75574, 1.575, 0.25, 0.375
75575, 1.575, 0.2, 0.375
75576, 1.6166666666667, 1.3, 0.375
75577, 1.6166666666667, 1.25, 0.375
75578, 1.6166666666667, 1.2, 0.375
75579, 1.6166666666667, 1.15, 0.375
75580, 1.6166666666667, 1.1, 0.375
75581, 1.6166666666667, 1.05, 0.375
75582, 1.6166666666667, 1, 0.375
75583, 1.6166666666667, 0.95, 0.375
75584, 1.6166666666667, 0.9, 0.375
75585, 1.6166666666667, 0.85, 0.375
75586, 1.6166666666667, 0.8, 0.375
75587, 1.6166666666667, 0.75, 0.375
75588, 1.6166666666667, 0.7, 0.375
75589, 1.6166666666667, 0.65, 0.375
75590, 1.6166666666667, 0.6, 0.375
75591, 1.6166666666667, 0.55, 0.375
75592, 1.6166666666667, 0.5, 0.375
75593, 1.6166666666667, 0.45, 0.375
75594, 1.6166666666667, 0.4, 0.375
75595, 1.6166666666667, 0.35, 0.375
75596, 1.6166666666667, 0.3, 0.375
75597, 1.6166666666667, 0.25, 0.375
75598, 1.6166666666667, 0.2, 0.375
75599, 1.6583333333333, 1.3, 0.375
75600, 1.6583333333333, 1.25, 0.375
75601, 1.6583333333333, 1.2, 0.375
75602, 1.6583333333333, 1.15, 0.375
75603, 1.6583333333333, 1.1, 0.375
75604, 1.6583333333333, 1.05, 0.375
75605, 1.6583333333333, 1, 0.375
75606, 1.6583333333333, 0.95, 0.375
75607, 1.6583333333333, 0.9, 0.375
75608, 1.6583333333333, 0.85, 0.375
75609, 1.6583333333333, 0.8, 0.375
75610, 1.6583333333333, 0.75, 0.375
75611, 1.6583333333333, 0.7, 0.375
75612, 1.6583333333333, 0.65, 0.375
75613, 1.6583333333333, 0.6, 0.375
75614, 1.6583333333333, 0.55, 0.375
75615, 1.6583333333333, 0.5, 0.375
75616, 1.6583333333333, 0.45, 0.375
75617, 1.6583333333333, 0.4, 0.375
75618, 1.6583333333333, 0.35, 0.375
75619, 1.6583333333333, 0.3, 0.375
75620, 1.6583333333333, 0.25, 0.375
75621, 1.6583333333333, 0.2, 0.375
75622, 1.7, 1.3, 0.375
75623, 1.7, 1.25, 0.375
75624, 1.7, 1.2, 0.375
75625, 1.7, 1.15, 0.375
75626, 1.7, 1.1, 0.375
75627, 1.7, 1.05, 0.375
75628, 1.7, 1, 0.375
75629, 1.7, 0.95, 0.375
75630, 1.7, 0.9, 0.375
75631, 1.7, 0.85, 0.375
75632, 1.7, 0.8, 0.375
75633, 1.7, 0.75, 0.375
75634, 1.7, 0.7, 0.375
75635, 1.7, 0.65, 0.375
75636, 1.7, 0.6, 0.375
75637, 1.7, 0.55, 0.375
75638, 1.7, 0.5, 0.375
75639, 1.7, 0.45, 0.375
75640, 1.7, 0.4, 0.375
75641, 1.7, 0.35, 0.375
75642, 1.7, 0.3, 0.375
75643, 1.7, 0.25, 0.375
75644, 1.7, 0.2, 0.375
75645, 1.7416666666667, 1.3, 0.375
75646, 1.7416666666667, 1.25, 0.375
75647, 1.7416666666667, 1.2, 0.375
75648, 1.7416666666667, 1.15, 0.375
75649, 1.7416666666667, 1.1, 0.375
75650, 1.7416666666667, 1.05, 0.375
75651, 1.7416666666667, 1, 0.375
75652, 1.7416666666667, 0.95, 0.375
75653, 1.7416666666667, 0.9, 0.375
75654, 1.7416666666667, 0.85, 0.375
75655, 1.7416666666667, 0.8, 0.375
75656, 1.7416666666667, 0.75, 0.375
75657, 1.7416666666667, 0.7, 0.375
75658, 1.7416666666667, 0.65, 0.375
75659, 1.7416666666667, 0.6, 0.375
75660, 1.7416666666667, 0.55, 0.375
75661, 1.7416666666667, 0.5, 0.375
75662, 1.7416666666667, 0.45, 0.375
75663, 1.7416666666667, 0.4, 0.375
75664, 1.7416666666667, 0.35, 0.375
75665, 1.7416666666667, 0.3, 0.375
75666, 1.7416666666667, 0.25, 0.375
75667, 1.7416666666667, 0.2, 0.375
75668, 1.7833333333333, 1.3, 0.375
75669, 1.7833333333333, 1.25, 0.375
75670, 1.7833333333333, 1.2, 0.375
75671, 1.7833333333333, 1.15, 0.375
75672, 1.7833333333333, 1.1, 0.375
75673, 1.7833333333333, 1.05, 0.375
75674, 1.7833333333333, 1, 0.375
75675, 1.7833333333333, 0.95, 0.375
75676, 1.7833333333333, 0.9, 0.375
75677, 1.7833333333333, 0.85, 0.375
75678, 1.7833333333333, 0.8, 0.375
75679, 1.7833333333333, 0.75, 0.375
75680, 1.7833333333333, 0.7, 0.375
75681, 1.7833333333333, 0.65, 0.375
75682, 1.7833333333333, 0.6, 0.375
75683, 1.7833333333333, 0.55, 0.375
75684, 1.7833333333333, 0.5, 0.375
75685, 1.7833333333333, 0.45, 0.375
75686, 1.7833333333333, 0.4, 0.375
75687, 1.7833333333333, 0.35, 0.375
75688, 1.7833333333333, 0.3, 0.375
75689, 1.7833333333333, 0.25, 0.375
75690, 1.7833333333333, 0.2, 0.375
75691, 1.825, 1.3, 0.375
75692, 1.825, 1.25, 0.375
75693, 1.825, 1.2, 0.375
75694, 1.825, 1.15, 0.375
75695, 1.825, 1.1, 0.375
75696, 1.825, 1.05, 0.375
75697, 1.825, 1, 0.375
75698, 1.825, 0.95, 0.375
75699, 1.825, 0.9, 0.375
75700, 1.825, 0.85, 0.375
75701, 1.825, 0.8, 0.375
75702, 1.825, 0.75, 0.375
75703, 1.825, 0.7, 0.375
75704, 1.825, 0.65, 0.375
75705, 1.825, 0.6, 0.375
75706, 1.825, 0.55, 0.375
75707, 1.825, 0.5, 0.375
75708, 1.825, 0.45, 0.375
75709, 1.825, 0.4, 0.375
75710, 1.825, 0.35, 0.375
75711, 1.825, 0.3, 0.375
75712, 1.825, 0.25, 0.375
75713, 1.825, 0.2, 0.375
75714, 1.8666666666667, 1.3, 0.375
75715, 1.8666666666667, 1.25, 0.375
75716, 1.8666666666667, 1.2, 0.375
75717, 1.8666666666667, 1.15, 0.375
75718, 1.8666666666667, 1.1, 0.375
75719, 1.8666666666667, 1.05, 0.375
75720, 1.8666666666667, 1, 0.375
75721, 1.8666666666667, 0.95, 0.375
75722, 1.8666666666667, 0.9, 0.375
75723, 1.8666666666667, 0.85, 0.375
75724, 1.8666666666667, 0.8, 0.375
75725, 1.8666666666667, 0.75, 0.375
75726, 1.8666666666667, 0.7, 0.375
75727, 1.8666666666667, 0.65, 0.375
75728, 1.8666666666667, 0.6, 0.375
75729, 1.8666666666667, 0.55, 0.375
75730, 1.8666666666667, 0.5, 0.375
75731, 1.8666666666667, 0.45, 0.375
75732, 1.8666666666667, 0.4, 0.375
75733, 1.8666666666667, 0.35, 0.375
75734, 1.8666666666667, 0.3, 0.375
75735, 1.8666666666667, 0.25, 0.375
75736, 1.8666666666667, 0.2, 0.375
75737, 1.9083333333333, 1.3, 0.375
75738, 1.9083333333333, 1.25, 0.375
75739, 1.9083333333333, 1.2, 0.375
75740, 1.9083333333333, 1.15, 0.375
75741, 1.9083333333333, 1.1, 0.375
75742, 1.9083333333333, 1.05, 0.375
75743, 1.9083333333333, 1, 0.375
75744, 1.9083333333333, 0.95, 0.375
75745, 1.9083333333333, 0.9, 0.375
75746, 1.9083333333333, 0.85, 0.375
75747, 1.9083333333333, 0.8, 0.375
75748, 1.9083333333333, 0.75, 0.375
75749, 1.9083333333333, 0.7, 0.375
75750, 1.9083333333333, 0.65, 0.375
75751, 1.9083333333333, 0.6, 0.375
75752, 1.9083333333333, 0.55, 0.375
75753, 1.9083333333333, 0.5, 0.375
75754, 1.9083333333333, 0.45, 0.375
75755, 1.9083333333333, 0.4, 0.375
75756, 1.9083333333333, 0.35, 0.375
75757, 1.9083333333333, 0.3, 0.375
75758, 1.9083333333333, 0.25, 0.375
75759, 1.9083333333333, 0.2, 0.375
75760, 1.95, 1.3, 0.375
75761, 1.95, 1.25, 0.375
75762, 1.95, 1.2, 0.375
75763, 1.95, 1.15, 0.375
75764, 1.95, 1.1, 0.375
75765, 1.95, 1.05, 0.375
75766, 1.95, 1, 0.375
75767, 1.95, 0.95, 0.375
75768, 1.95, 0.9, 0.375
75769, 1.95, 0.85, 0.375
75770, 1.95, 0.8, 0.375
75771, 1.95, 0.75, 0.375
75772, 1.95, 0.7, 0.375
75773, 1.95, 0.65, 0.375
75774, 1.95, 0.6, 0.375
75775, 1.95, 0.55, 0.375
75776, 1.95, 0.5, 0.375
75777, 1.95, 0.45, 0.375
75778, 1.95, 0.4, 0.375
75779, 1.95, 0.35, 0.375
75780, 1.95, 0.3, 0.375
75781, 1.95, 0.25, 0.375
75782, 1.95, 0.2, 0.375
75783, 1.9916666666667, 1.3, 0.375
75784, 1.9916666666667, 1.25, 0.375
75785, 1.9916666666667, 1.2, 0.375
75786, 1.9916666666667, 1.15, 0.375
75787, 1.9916666666667, 1.1, 0.375
75788, 1.9916666666667, 1.05, 0.375
75789, 1.9916666666667, 1, 0.375
75790, 1.9916666666667, 0.95, 0.375
75791, 1.9916666666667, 0.9, 0.375
75792, 1.9916666666667, 0.85, 0.375
75793, 1.9916666666667, 0.8, 0.375
75794, 1.9916666666667, 0.75, 0.375
75795, 1.9916666666667, 0.7, 0.375
75796, 1.9916666666667, 0.65, 0.375
75797, 1.9916666666667, 0.6, 0.375
75798, 1.9916666666667, 0.55, 0.375
75799, 1.9916666666667, 0.5, 0.375
75800, 1.9916666666667, 0.45, 0.375
75801, 1.9916666666667, 0.4, 0.375
75802, 1.9916666666667, 0.35, 0.375
75803, 1.9916666666667, 0.3, 0.375
75804, 1.9916666666667, 0.25, 0.375
75805, 1.9916666666667, 0.2, 0.375
75806, 2.0333333333333, 1.3, 0.375
75807, 2.0333333333333, 1.25, 0.375
75808, 2.0333333333333, 1.2, 0.375
75809, 2.0333333333333, 1.15, 0.375
75810, 2.0333333333333, 1.1, 0.375
75811, 2.0333333333333, 1.05, 0.375
75812, 2.0333333333333, 1, 0.375
75813, 2.0333333333333, 0.95, 0.375
75814, 2.0333333333333, 0.9, 0.375
75815, 2.0333333333333, 0.85, 0.375
75816, 2.0333333333333, 0.8, 0.375
75817, 2.0333333333333, 0.75, 0.375
75818, 2.0333333333333, 0.7, 0.375
75819, 2.0333333333333, 0.65, 0.375
75820, 2.0333333333333, 0.6, 0.375
75821, 2.0333333333333, 0.55, 0.375
75822, 2.0333333333333, 0.5, 0.375
75823, 2.0333333333333, 0.45, 0.375
75824, 2.0333333333333, 0.4, 0.375
75825, 2.0333333333333, 0.35, 0.375
75826, 2.0333333333333, 0.3, 0.375
75827, 2.0333333333333, 0.25, 0.375
75828, 2.0333333333333, 0.2, 0.375
75829, 2.075, 1.3, 0.375
75830, 2.075, 1.25, 0.375
75831, 2.075, 1.2, 0.375
75832, 2.075, 1.15, 0.375
75833, 2.075, 1.1, 0.375
75834, 2.075, 1.05, 0.375
75835, 2.075, 1, 0.375
75836, 2.075, 0.95, 0.375
75837, 2.075, 0.9, 0.375
75838, 2.075, 0.85, 0.375
75839, 2.075, 0.8, 0.375
75840, 2.075, 0.75, 0.375
75841, 2.075, 0.7, 0.375
75842, 2.075, 0.65, 0.375
75843, 2.075, 0.6, 0.375
75844, 2.075, 0.55, 0.375
75845, 2.075, 0.5, 0.375
75846, 2.075, 0.45, 0.375
75847, 2.075, 0.4, 0.375
75848, 2.075, 0.35, 0.375
75849, 2.075, 0.3, 0.375
75850, 2.075, 0.25, 0.375
75851, 2.075, 0.2, 0.375
75852, 2.1166666666667, 1.3, 0.375
75853, 2.1166666666667, 1.25, 0.375
75854, 2.1166666666667, 1.2, 0.375
75855, 2.1166666666667, 1.15, 0.375
75856, 2.1166666666667, 1.1, 0.375
75857, 2.1166666666667, 1.05, 0.375
75858, 2.1166666666667, 1, 0.375
75859, 2.1166666666667, 0.95, 0.375
75860, 2.1166666666667, 0.9, 0.375
75861, 2.1166666666667, 0.85, 0.375
75862, 2.1166666666667, 0.8, 0.375
75863, 2.1166666666667, 0.75, 0.375
75864, 2.1166666666667, 0.7, 0.375
75865, 2.1166666666667, 0.65, 0.375
75866, 2.1166666666667, 0.6, 0.375
75867, 2.1166666666667, 0.55, 0.375
75868, 2.1166666666667, 0.5, 0.375
75869, 2.1166666666667, 0.45, 0.375
75870, 2.1166666666667, 0.4, 0.375
75871, 2.1166666666667, 0.35, 0.375
75872, 2.1166666666667, 0.3, 0.375
75873, 2.1166666666667, 0.25, 0.375
75874, 2.1166666666667, 0.2, 0.375
75875, 2.1583333333333, 1.3, 0.375
75876, 2.1583333333333, 1.25, 0.375
75877, 2.1583333333333, 1.2, 0.375
75878, 2.1583333333333, 1.15, 0.375
75879, 2.1583333333333, 1.1, 0.375
75880, 2.1583333333333, 1.05, 0.375
75881, 2.1583333333333, 1, 0.375
75882, 2.1583333333333, 0.95, 0.375
75883, 2.1583333333333, 0.9, 0.375
75884, 2.1583333333333, 0.85, 0.375
75885, 2.1583333333333, 0.8, 0.375
75886, 2.1583333333333, 0.75, 0.375
75887, 2.1583333333333, 0.7, 0.375
75888, 2.1583333333333, 0.65, 0.375
75889, 2.1583333333333, 0.6, 0.375
75890, 2.1583333333333, 0.55, 0.375
75891, 2.1583333333333, 0.5, 0.375
75892, 2.1583333333333, 0.45, 0.375
75893, 2.1583333333333, 0.4, 0.375
75894, 2.1583333333333, 0.35, 0.375
75895, 2.1583333333333, 0.3, 0.375
75896, 2.1583333333333, 0.25, 0.375
75897, 2.1583333333333, 0.2, 0.375
75898, 1.2416666666667, 1.3, 0.41666666666667
75899, 1.2416666666667, 1.25, 0.41666666666667
75900, 1.2416666666667, 1.2, 0.41666666666667
75901, 1.2416666666667, 1.15, 0.41666666666667
75902, 1.2416666666667, 1.1, 0.41666666666667
75903, 1.2416666666667, 1.05, 0.41666666666667
75904, 1.2416666666667, 1, 0.41666666666667
75905, 1.2416666666667, 0.95, 0.41666666666667
75906, 1.2416666666667, 0.9, 0.41666666666667
75907, 1.2416666666667, 0.85, 0.41666666666667
75908, 1.2416666666667, 0.8, 0.41666666666667
75909, 1.2416666666667, 0.75, 0.41666666666667
75910, 1.2416666666667, 0.7, 0.41666666666667
75911, 1.2416666666667, 0.65, 0.41666666666667
75912, 1.2416666666667, 0.6, 0.41666666666667
75913, 1.2416666666667, 0.55, 0.41666666666667
75914, 1.2416666666667, 0.5, 0.41666666666667
75915, 1.2416666666667, 0.45, 0.41666666666667
75916, 1.2416666666667, 0.4, 0.41666666666667
75917, 1.2416666666667, 0.35, 0.41666666666667
75918, 1.2416666666667, 0.3, 0.41666666666667
75919, 1.2416666666667, 0.25, 0.41666666666667
75920, 1.2416666666667, 0.2, 0.41666666666667
75921, 1.2833333333333, 1.3, 0.41666666666667
75922, 1.2833333333333, 1.25, 0.41666666666667
75923, 1.2833333333333, 1.2, 0.41666666666667
75924, 1.2833333333333, 1.15, 0.41666666666667
75925, 1.2833333333333, 1.1, 0.41666666666667
75926, 1.2833333333333, 1.05, 0.41666666666667
75927, 1.2833333333333, 1, 0.41666666666667
75928, 1.2833333333333, 0.95, 0.41666666666667
75929, 1.2833333333333, 0.9, 0.41666666666667
75930, 1.2833333333333, 0.85, 0.41666666666667
75931, 1.2833333333333, 0.8, 0.41666666666667
75932, 1.2833333333333, 0.75, 0.41666666666667
75933, 1.2833333333333, 0.7, 0.41666666666667
75934, 1.2833333333333, 0.65, 0.41666666666667
75935, 1.2833333333333, 0.6, 0.41666666666667
75936, 1.2833333333333, 0.55, 0.41666666666667
75937, 1.2833333333333, 0.5, 0.41666666666667
75938, 1.2833333333333, 0.45, 0.41666666666667
75939, 1.2833333333333, 0.4, 0.41666666666667
75940, 1.2833333333333, 0.35, 0.41666666666667
75941, 1.2833333333333, 0.3, 0.41666666666667
75942, 1.2833333333333, 0.25, 0.41666666666667
75943, 1.2833333333333, 0.2, 0.41666666666667
75944, 1.325, 1.3, 0.41666666666667
75945, 1.325, 1.25, 0.41666666666667
75946, 1.325, 1.2, 0.41666666666667
75947, 1.325, 1.15, 0.41666666666667
75948, 1.325, 1.1, 0.41666666666667
75949, 1.325, 1.05, 0.41666666666667
75950, 1.325, 1, 0.41666666666667
75951, 1.325, 0.95, 0.41666666666667
75952, 1.325, 0.9, 0.41666666666667
75953, 1.325, 0.85, 0.41666666666667
75954, 1.325, 0.8, 0.41666666666667
75955, 1.325, 0.75, 0.41666666666667
75956, 1.325, 0.7, 0.41666666666667
75957, 1.325, 0.65, 0.41666666666667
75958, 1.325, 0.6, 0.41666666666667
75959, 1.325, 0.55, 0.41666666666667
75960, 1.325, 0.5, 0.41666666666667
75961, 1.325, 0.45, 0.41666666666667
75962, 1.325, 0.4, 0.41666666666667
75963, 1.325, 0.35, 0.41666666666667
75964, 1.325, 0.3, 0.41666666666667
75965, 1.325, 0.25, 0.41666666666667
75966, 1.325, 0.2, 0.41666666666667
75967, 1.3666666666667, 1.3, 0.41666666666667
75968, 1.3666666666667, 1.25, 0.41666666666667
75969, 1.3666666666667, 1.2, 0.41666666666667
75970, 1.3666666666667, 1.15, 0.41666666666667
75971, 1.3666666666667, 1.1, 0.41666666666667
75972, 1.3666666666667, 1.05, 0.41666666666667
75973, 1.3666666666667, 1, 0.41666666666667
75974, 1.3666666666667, 0.95, 0.41666666666667
75975, 1.3666666666667, 0.9, 0.41666666666667
75976, 1.3666666666667, 0.85, 0.41666666666667
75977, 1.3666666666667, 0.8, 0.41666666666667
75978, 1.3666666666667, 0.75, 0.41666666666667
75979, 1.3666666666667, 0.7, 0.41666666666667
75980, 1.3666666666667, 0.65, 0.41666666666667
75981, 1.3666666666667, 0.6, 0.41666666666667
75982, 1.3666666666667, 0.55, 0.41666666666667
75983, 1.3666666666667, 0.5, 0.41666666666667
75984, 1.3666666666667, 0.45, 0.41666666666667
75985, 1.3666666666667, 0.4, 0.41666666666667
75986, 1.3666666666667, 0.35, 0.41666666666667
75987, 1.3666666666667, 0.3, 0.41666666666667
75988, 1.3666666666667, 0.25, 0.41666666666667
75989, 1.3666666666667, 0.2, 0.41666666666667
75990, 1.4083333333333, 1.3, 0.41666666666667
75991, 1.4083333333333, 1.25, 0.41666666666667
75992, 1.4083333333333, 1.2, 0.41666666666667
75993, 1.4083333333333, 1.15, 0.41666666666667
75994, 1.4083333333333, 1.1, 0.41666666666667
75995, 1.4083333333333, 1.05, 0.41666666666667
75996, 1.4083333333333, 1, 0.41666666666667
75997, 1.4083333333333, 0.95, 0.41666666666667
75998, 1.4083333333333, 0.9, 0.41666666666667
75999, 1.4083333333333, 0.85, 0.41666666666667
76000, 1.4083333333333, 0.8, 0.41666666666667
76001, 1.4083333333333, 0.75, 0.41666666666667
76002, 1.4083333333333, 0.7, 0.41666666666667
76003, 1.4083333333333, 0.65, 0.41666666666667
76004, 1.4083333333333, 0.6, 0.41666666666667
76005, 1.4083333333333, 0.55, 0.41666666666667
76006, 1.4083333333333, 0.5, 0.41666666666667
76007, 1.4083333333333, 0.45, 0.41666666666667
76008, 1.4083333333333, 0.4, 0.41666666666667
76009, 1.4083333333333, 0.35, 0.41666666666667
76010, 1.4083333333333, 0.3, 0.41666666666667
76011, 1.4083333333333, 0.25, 0.41666666666667
76012, 1.4083333333333, 0.2, 0.41666666666667
76013, 1.45, 1.3, 0.41666666666667
76014, 1.45, 1.25, 0.41666666666667
76015, 1.45, 1.2, 0.41666666666667
76016, 1.45, 1.15, 0.41666666666667
76017, 1.45, 1.1, 0.41666666666667
76018, 1.45, 1.05, 0.41666666666667
76019, 1.45, 1, 0.41666666666667
76020, 1.45, 0.95, 0.41666666666667
76021, 1.45, 0.9, 0.41666666666667
76022, 1.45, 0.85, 0.41666666666667
76023, 1.45, 0.8, 0.41666666666667
76024, 1.45, 0.75, 0.41666666666667
76025, 1.45, 0.7, 0.41666666666667
76026, 1.45, 0.65, 0.41666666666667
76027, 1.45, 0.6, 0.41666666666667
76028, 1.45, 0.55, 0.41666666666667
76029, 1.45, 0.5, 0.41666666666667
76030, 1.45, 0.45, 0.41666666666667
76031, 1.45, 0.4, 0.41666666666667
76032, 1.45, 0.35, 0.41666666666667
76033, 1.45, 0.3, 0.41666666666667
76034, 1.45, 0.25, 0.41666666666667
76035, 1.45, 0.2, 0.41666666666667
76036, 1.4916666666667, 1.3, 0.41666666666667
76037, 1.4916666666667, 1.25, 0.41666666666667
76038, 1.4916666666667, 1.2, 0.41666666666667
76039, 1.4916666666667, 1.15, 0.41666666666667
76040, 1.4916666666667, 1.1, 0.41666666666667
76041, 1.4916666666667, 1.05, 0.41666666666667
76042, 1.4916666666667, 1, 0.41666666666667
76043, 1.4916666666667, 0.95, 0.41666666666667
76044, 1.4916666666667, 0.9, 0.41666666666667
76045, 1.4916666666667, 0.85, 0.41666666666667
76046, 1.4916666666667, 0.8, 0.41666666666667
76047, 1.4916666666667, 0.75, 0.41666666666667
76048, 1.4916666666667, 0.7, 0.41666666666667
76049, 1.4916666666667, 0.65, 0.41666666666667
76050, 1.4916666666667, 0.6, 0.41666666666667
76051, 1.4916666666667, 0.55, 0.41666666666667
76052, 1.4916666666667, 0.5, 0.41666666666667
76053, 1.4916666666667, 0.45, 0.41666666666667
76054, 1.4916666666667, 0.4, 0.41666666666667
76055, 1.4916666666667, 0.35, 0.41666666666667
76056, 1.4916666666667, 0.3, 0.41666666666667
76057, 1.4916666666667, 0.25, 0.41666666666667
76058, 1.4916666666667, 0.2, 0.41666666666667
76059, 1.5333333333333, 1.3, 0.41666666666667
76060, 1.5333333333333, 1.25, 0.41666666666667
76061, 1.5333333333333, 1.2, 0.41666666666667
76062, 1.5333333333333, 1.15, 0.41666666666667
76063, 1.5333333333333, 1.1, 0.41666666666667
76064, 1.5333333333333, 1.05, 0.41666666666667
76065, 1.5333333333333, 1, 0.41666666666667
76066, 1.5333333333333, 0.95, 0.41666666666667
76067, 1.5333333333333, 0.9, 0.41666666666667
76068, 1.5333333333333, 0.85, 0.41666666666667
76069, 1.5333333333333, 0.8, 0.41666666666667
76070, 1.5333333333333, 0.75, 0.41666666666667
76071, 1.5333333333333, 0.7, 0.41666666666667
76072, 1.5333333333333, 0.65, 0.41666666666667
76073, 1.5333333333333, 0.6, 0.41666666666667
76074, 1.5333333333333, 0.55, 0.41666666666667
76075, 1.5333333333333, 0.5, 0.41666666666667
76076, 1.5333333333333, 0.45, 0.41666666666667
76077, 1.5333333333333, 0.4, 0.41666666666667
76078, 1.5333333333333, 0.35, 0.41666666666667
76079, 1.5333333333333, 0.3, 0.41666666666667
76080, 1.5333333333333, 0.25, 0.41666666666667
76081, 1.5333333333333, 0.2, 0.41666666666667
76082, 1.575, 1.3, 0.41666666666667
76083, 1.575, 1.25, 0.41666666666667
76084, 1.575, 1.2, 0.41666666666667
76085, 1.575, 1.15, 0.41666666666667
76086, 1.575, 1.1, 0.41666666666667
76087, 1.575, 1.05, 0.41666666666667
76088, 1.575, 1, 0.41666666666667
76089, 1.575, 0.95, 0.41666666666667
76090, 1.575, 0.9, 0.41666666666667
76091, 1.575, 0.85, 0.41666666666667
76092, 1.575, 0.8, 0.41666666666667
76093, 1.575, 0.75, 0.41666666666667
76094, 1.575, 0.7, 0.41666666666667
76095, 1.575, 0.65, 0.41666666666667
76096, 1.575, 0.6, 0.41666666666667
76097, 1.575, 0.55, 0.41666666666667
76098, 1.575, 0.5, 0.41666666666667
76099, 1.575, 0.45, 0.41666666666667
76100, 1.575, 0.4, 0.41666666666667
76101, 1.575, 0.35, 0.41666666666667
76102, 1.575, 0.3, 0.41666666666667
76103, 1.575, 0.25, 0.41666666666667
76104, 1.575, 0.2, 0.41666666666667
76105, 1.6166666666667, 1.3, 0.41666666666667
76106, 1.6166666666667, 1.25, 0.41666666666667
76107, 1.6166666666667, 1.2, 0.41666666666667
76108, 1.6166666666667, 1.15, 0.41666666666667
76109, 1.6166666666667, 1.1, 0.41666666666667
76110, 1.6166666666667, 1.05, 0.41666666666667
76111, 1.6166666666667, 1, 0.41666666666667
76112, 1.6166666666667, 0.95, 0.41666666666667
76113, 1.6166666666667, 0.9, 0.41666666666667
76114, 1.6166666666667, 0.85, 0.41666666666667
76115, 1.6166666666667, 0.8, 0.41666666666667
76116, 1.6166666666667, 0.75, 0.41666666666667
76117, 1.6166666666667, 0.7, 0.41666666666667
76118, 1.6166666666667, 0.65, 0.41666666666667
76119, 1.6166666666667, 0.6, 0.41666666666667
76120, 1.6166666666667, 0.55, 0.41666666666667
76121, 1.6166666666667, 0.5, 0.41666666666667
76122, 1.6166666666667, 0.45, 0.41666666666667
76123, 1.6166666666667, 0.4, 0.41666666666667
76124, 1.6166666666667, 0.35, 0.41666666666667
76125, 1.6166666666667, 0.3, 0.41666666666667
76126, 1.6166666666667, 0.25, 0.41666666666667
76127, 1.6166666666667, 0.2, 0.41666666666667
76128, 1.6583333333333, 1.3, 0.41666666666667
76129, 1.6583333333333, 1.25, 0.41666666666667
76130, 1.6583333333333, 1.2, 0.41666666666667
76131, 1.6583333333333, 1.15, 0.41666666666667
76132, 1.6583333333333, 1.1, 0.41666666666667
76133, 1.6583333333333, 1.05, 0.41666666666667
76134, 1.6583333333333, 1, 0.41666666666667
76135, 1.6583333333333, 0.95, 0.41666666666667
76136, 1.6583333333333, 0.9, 0.41666666666667
76137, 1.6583333333333, 0.85, 0.41666666666667
76138, 1.6583333333333, 0.8, 0.41666666666667
76139, 1.6583333333333, 0.75, 0.41666666666667
76140, 1.6583333333333, 0.7, 0.41666666666667
76141, 1.6583333333333, 0.65, 0.41666666666667
76142, 1.6583333333333, 0.6, 0.41666666666667
76143, 1.6583333333333, 0.55, 0.41666666666667
76144, 1.6583333333333, 0.5, 0.41666666666667
76145, 1.6583333333333, 0.45, 0.41666666666667
76146, 1.6583333333333, 0.4, 0.41666666666667
76147, 1.6583333333333, 0.35, 0.41666666666667
76148, 1.6583333333333, 0.3, 0.41666666666667
76149, 1.6583333333333, 0.25, 0.41666666666667
76150, 1.6583333333333, 0.2, 0.41666666666667
76151, 1.7, 1.3, 0.41666666666667
76152, 1.7, 1.25, 0.41666666666667
76153, 1.7, 1.2, 0.41666666666667
76154, 1.7, 1.15, 0.41666666666667
76155, 1.7, 1.1, 0.41666666666667
76156, 1.7, 1.05, 0.41666666666667
76157, 1.7, 1, 0.41666666666667
76158, 1.7, 0.95, 0.41666666666667
76159, 1.7, 0.9, 0.41666666666667
76160, 1.7, 0.85, 0.41666666666667
76161, 1.7, 0.8, 0.41666666666667
76162, 1.7, 0.75, 0.41666666666667
76163, 1.7, 0.7, 0.41666666666667
76164, 1.7, 0.65, 0.41666666666667
76165, 1.7, 0.6, 0.41666666666667
76166, 1.7, 0.55, 0.41666666666667
76167, 1.7, 0.5, 0.41666666666667
76168, 1.7, 0.45, 0.41666666666667
76169, 1.7, 0.4, 0.41666666666667
76170, 1.7, 0.35, 0.41666666666667
76171, 1.7, 0.3, 0.41666666666667
76172, 1.7, 0.25, 0.41666666666667
76173, 1.7, 0.2, 0.41666666666667
76174, 1.7416666666667, 1.3, 0.41666666666667
76175, 1.7416666666667, 1.25, 0.41666666666667
76176, 1.7416666666667, 1.2, 0.41666666666667
76177, 1.7416666666667, 1.15, 0.41666666666667
76178, 1.7416666666667, 1.1, 0.41666666666667
76179, 1.7416666666667, 1.05, 0.41666666666667
76180, 1.7416666666667, 1, 0.41666666666667
76181, 1.7416666666667, 0.95, 0.41666666666667
76182, 1.7416666666667, 0.9, 0.41666666666667
76183, 1.7416666666667, 0.85, 0.41666666666667
76184, 1.7416666666667, 0.8, 0.41666666666667
76185, 1.7416666666667, 0.75, 0.41666666666667
76186, 1.7416666666667, 0.7, 0.41666666666667
76187, 1.7416666666667, 0.65, 0.41666666666667
76188, 1.7416666666667, 0.6, 0.41666666666667
76189, 1.7416666666667, 0.55, 0.41666666666667
76190, 1.7416666666667, 0.5, 0.41666666666667
76191, 1.7416666666667, 0.45, 0.41666666666667
76192, 1.7416666666667, 0.4, 0.41666666666667
76193, 1.7416666666667, 0.35, 0.41666666666667
76194, 1.7416666666667, 0.3, 0.41666666666667
76195, 1.7416666666667, 0.25, 0.41666666666667
76196, 1.7416666666667, 0.2, 0.41666666666667
76197, 1.7833333333333, 1.3, 0.41666666666667
76198, 1.7833333333333, 1.25, 0.41666666666667
76199, 1.7833333333333, 1.2, 0.41666666666667
76200, 1.7833333333333, 1.15, 0.41666666666667
76201, 1.7833333333333, 1.1, 0.41666666666667
76202, 1.7833333333333, 1.05, 0.41666666666667
76203, 1.7833333333333, 1, 0.41666666666667
76204, 1.7833333333333, 0.95, 0.41666666666667
76205, 1.7833333333333, 0.9, 0.41666666666667
76206, 1.7833333333333, 0.85, 0.41666666666667
76207, 1.7833333333333, 0.8, 0.41666666666667
76208, 1.7833333333333, 0.75, 0.41666666666667
76209, 1.7833333333333, 0.7, 0.41666666666667
76210, 1.7833333333333, 0.65, 0.41666666666667
76211, 1.7833333333333, 0.6, 0.41666666666667
76212, 1.7833333333333, 0.55, 0.41666666666667
76213, 1.7833333333333, 0.5, 0.41666666666667
76214, 1.7833333333333, 0.45, 0.41666666666667
76215, 1.7833333333333, 0.4, 0.41666666666667
76216, 1.7833333333333, 0.35, 0.41666666666667
76217, 1.7833333333333, 0.3, 0.41666666666667
76218, 1.7833333333333, 0.25, 0.41666666666667
76219, 1.7833333333333, 0.2, 0.41666666666667
76220, 1.825, 1.3, 0.41666666666667
76221, 1.825, 1.25, 0.41666666666667
76222, 1.825, 1.2, 0.41666666666667
76223, 1.825, 1.15, 0.41666666666667
76224, 1.825, 1.1, 0.41666666666667
76225, 1.825, 1.05, 0.41666666666667
76226, 1.825, 1, 0.41666666666667
76227, 1.825, 0.95, 0.41666666666667
76228, 1.825, 0.9, 0.41666666666667
76229, 1.825, 0.85, 0.41666666666667
76230, 1.825, 0.8, 0.41666666666667
76231, 1.825, 0.75, 0.41666666666667
76232, 1.825, 0.7, 0.41666666666667
76233, 1.825, 0.65, 0.41666666666667
76234, 1.825, 0.6, 0.41666666666667
76235, 1.825, 0.55, 0.41666666666667
76236, 1.825, 0.5, 0.41666666666667
76237, 1.825, 0.45, 0.41666666666667
76238, 1.825, 0.4, 0.41666666666667
76239, 1.825, 0.35, 0.41666666666667
76240, 1.825, 0.3, 0.41666666666667
76241, 1.825, 0.25, 0.41666666666667
76242, 1.825, 0.2, 0.41666666666667
76243, 1.8666666666667, 1.3, 0.41666666666667
76244, 1.8666666666667, 1.25, 0.41666666666667
76245, 1.8666666666667, 1.2, 0.41666666666667
76246, 1.8666666666667, 1.15, 0.41666666666667
76247, 1.8666666666667, 1.1, 0.41666666666667
76248, 1.8666666666667, 1.05, 0.41666666666667
76249, 1.8666666666667, 1, 0.41666666666667
76250, 1.8666666666667, 0.95, 0.41666666666667
76251, 1.8666666666667, 0.9, 0.41666666666667
76252, 1.8666666666667, 0.85, 0.41666666666667
76253, 1.8666666666667, 0.8, 0.41666666666667
76254, 1.8666666666667, 0.75, 0.41666666666667
76255, 1.8666666666667, 0.7, 0.41666666666667
76256, 1.8666666666667, 0.65, 0.41666666666667
76257, 1.8666666666667, 0.6, 0.41666666666667
76258, 1.8666666666667, 0.55, 0.41666666666667
76259, 1.8666666666667, 0.5, 0.41666666666667
76260, 1.8666666666667, 0.45, 0.41666666666667
76261, 1.8666666666667, 0.4, 0.41666666666667
76262, 1.8666666666667, 0.35, 0.41666666666667
76263, 1.8666666666667, 0.3, 0.41666666666667
76264, 1.8666666666667, 0.25, 0.41666666666667
76265, 1.8666666666667, 0.2, 0.41666666666667
76266, 1.9083333333333, 1.3, 0.41666666666667
76267, 1.9083333333333, 1.25, 0.41666666666667
76268, 1.9083333333333, 1.2, 0.41666666666667
76269, 1.9083333333333, 1.15, 0.41666666666667
76270, 1.9083333333333, 1.1, 0.41666666666667
76271, 1.9083333333333, 1.05, 0.41666666666667
76272, 1.9083333333333, 1, 0.41666666666667
76273, 1.9083333333333, 0.95, 0.41666666666667
76274, 1.9083333333333, 0.9, 0.41666666666667
76275, 1.9083333333333, 0.85, 0.41666666666667
76276, 1.9083333333333, 0.8, 0.41666666666667
76277, 1.9083333333333, 0.75, 0.41666666666667
76278, 1.9083333333333, 0.7, 0.41666666666667
76279, 1.9083333333333, 0.65, 0.41666666666667
76280, 1.9083333333333, 0.6, 0.41666666666667
76281, 1.9083333333333, 0.55, 0.41666666666667
76282, 1.9083333333333, 0.5, 0.41666666666667
76283, 1.9083333333333, 0.45, 0.41666666666667
76284, 1.9083333333333, 0.4, 0.41666666666667
76285, 1.9083333333333, 0.35, 0.41666666666667
76286, 1.9083333333333, 0.3, 0.41666666666667
76287, 1.9083333333333, 0.25, 0.41666666666667
76288, 1.9083333333333, 0.2, 0.41666666666667
76289, 1.95, 1.3, 0.41666666666667
76290, 1.95, 1.25, 0.41666666666667
76291, 1.95, 1.2, 0.41666666666667
76292, 1.95, 1.15, 0.41666666666667
76293, 1.95, 1.1, 0.41666666666667
76294, 1.95, 1.05, 0.41666666666667
76295, 1.95, 1, 0.41666666666667
76296, 1.95, 0.95, 0.41666666666667
76297, 1.95, 0.9, 0.41666666666667
76298, 1.95, 0.85, 0.41666666666667
76299, 1.95, 0.8, 0.41666666666667
76300, 1.95, 0.75, 0.41666666666667
76301, 1.95, 0.7, 0.41666666666667
76302, 1.95, 0.65, 0.41666666666667
76303, 1.95, 0.6, 0.41666666666667
76304, 1.95, 0.55, 0.41666666666667
76305, 1.95, 0.5, 0.41666666666667
76306, 1.95, 0.45, 0.41666666666667
76307, 1.95, 0.4, 0.41666666666667
76308, 1.95, 0.35, 0.41666666666667
76309, 1.95, 0.3, 0.41666666666667
76310, 1.95, 0.25, 0.41666666666667
76311, 1.95, 0.2, 0.41666666666667
76312, 1.9916666666667, 1.3, 0.41666666666667
76313, 1.9916666666667, 1.25, 0.41666666666667
76314, 1.9916666666667, 1.2, 0.41666666666667
76315, 1.9916666666667, 1.15, 0.41666666666667
76316, 1.9916666666667, 1.1, 0.41666666666667
76317, 1.9916666666667, 1.05, 0.41666666666667
76318, 1.9916666666667, 1, 0.41666666666667
76319, 1.9916666666667, 0.95, 0.41666666666667
76320, 1.9916666666667, 0.9, 0.41666666666667
76321, 1.9916666666667, 0.85, 0.41666666666667
76322, 1.9916666666667, 0.8, 0.41666666666667
76323, 1.9916666666667, 0.75, 0.41666666666667
76324, 1.9916666666667, 0.7, 0.41666666666667
76325, 1.9916666666667, 0.65, 0.41666666666667
76326, 1.9916666666667, 0.6, 0.41666666666667
76327, 1.9916666666667, 0.55, 0.41666666666667
76328, 1.9916666666667, 0.5, 0.41666666666667
76329, 1.9916666666667, 0.45, 0.41666666666667
76330, 1.9916666666667, 0.4, 0.41666666666667
76331, 1.9916666666667, 0.35, 0.41666666666667
76332, 1.9916666666667, 0.3, 0.41666666666667
76333, 1.9916666666667, 0.25, 0.41666666666667
76334, 1.9916666666667, 0.2, 0.41666666666667
76335, 2.0333333333333, 1.3, 0.41666666666667
76336, 2.0333333333333, 1.25, 0.41666666666667
76337, 2.0333333333333, 1.2, 0.41666666666667
76338, 2.0333333333333, 1.15, 0.41666666666667
76339, 2.0333333333333, 1.1, 0.41666666666667
76340, 2.0333333333333, 1.05, 0.41666666666667
76341, 2.0333333333333, 1, 0.41666666666667
76342, 2.0333333333333, 0.95, 0.41666666666667
76343, 2.0333333333333, 0.9, 0.41666666666667
76344, 2.0333333333333, 0.85, 0.41666666666667
76345, 2.0333333333333, 0.8, 0.41666666666667
76346, 2.0333333333333, 0.75, 0.41666666666667
76347, 2.0333333333333, 0.7, 0.41666666666667
76348, 2.0333333333333, 0.65, 0.41666666666667
76349, 2.0333333333333, 0.6, 0.41666666666667
76350, 2.0333333333333, 0.55, 0.41666666666667
76351, 2.0333333333333, 0.5, 0.41666666666667
76352, 2.0333333333333, 0.45, 0.41666666666667
76353, 2.0333333333333, 0.4, 0.41666666666667
76354, 2.0333333333333, 0.35, 0.41666666666667
76355, 2.0333333333333, 0.3, 0.41666666666667
76356, 2.0333333333333, 0.25, 0.41666666666667
76357, 2.0333333333333, 0.2, 0.41666666666667
76358, 2.075, 1.3, 0.41666666666667
76359, 2.075, 1.25, 0.41666666666667
76360, 2.075, 1.2, 0.41666666666667
76361, 2.075, 1.15, 0.41666666666667
76362, 2.075, 1.1, 0.41666666666667
76363, 2.075, 1.05, 0.41666666666667
76364, 2.075, 1, 0.41666666666667
76365, 2.075, 0.95, 0.41666666666667
76366, 2.075, 0.9, 0.41666666666667
76367, 2.075, 0.85, 0.41666666666667
76368, 2.075, 0.8, 0.41666666666667
76369, 2.075, 0.75, 0.41666666666667
76370, 2.075, 0.7, 0.41666666666667
76371, 2.075, 0.65, 0.41666666666667
76372, 2.075, 0.6, 0.41666666666667
76373, 2.075, 0.55, 0.41666666666667
76374, 2.075, 0.5, 0.41666666666667
76375, 2.075, 0.45, 0.41666666666667
76376, 2.075, 0.4, 0.41666666666667
76377, 2.075, 0.35, 0.41666666666667
76378, 2.075, 0.3, 0.41666666666667
76379, 2.075, 0.25, 0.41666666666667
76380, 2.075, 0.2, 0.41666666666667
76381, 2.1166666666667, 1.3, 0.41666666666667
76382, 2.1166666666667, 1.25, 0.41666666666667
76383, 2.1166666666667, 1.2, 0.41666666666667
76384, 2.1166666666667, 1.15, 0.41666666666667
76385, 2.1166666666667, 1.1, 0.41666666666667
76386, 2.1166666666667, 1.05, 0.41666666666667
76387, 2.1166666666667, 1, 0.41666666666667
76388, 2.1166666666667, 0.95, 0.41666666666667
76389, 2.1166666666667, 0.9, 0.41666666666667
76390, 2.1166666666667, 0.85, 0.41666666666667
76391, 2.1166666666667, 0.8, 0.41666666666667
76392, 2.1166666666667, 0.75, 0.41666666666667
76393, 2.1166666666667, 0.7, 0.41666666666667
76394, 2.1166666666667, 0.65, 0.41666666666667
76395, 2.1166666666667, 0.6, 0.41666666666667
76396, 2.1166666666667, 0.55, 0.41666666666667
76397, 2.1166666666667, 0.5, 0.41666666666667
76398, 2.1166666666667, 0.45, 0.41666666666667
76399, 2.1166666666667, 0.4, 0.41666666666667
76400, 2.1166666666667, 0.35, 0.41666666666667
76401, 2.1166666666667, 0.3, 0.41666666666667
76402, 2.1166666666667, 0.25, 0.41666666666667
76403, 2.1166666666667, 0.2, 0.41666666666667
76404, 2.1583333333333, 1.3, 0.41666666666667
76405, 2.1583333333333, 1.25, 0.41666666666667
76406, 2.1583333333333, 1.2, 0.41666666666667
76407, 2.1583333333333, 1.15, 0.41666666666667
76408, 2.1583333333333, 1.1, 0.41666666666667
76409, 2.1583333333333, 1.05, 0.41666666666667
76410, 2.1583333333333, 1, 0.41666666666667
76411, 2.1583333333333, 0.95, 0.41666666666667
76412, 2.1583333333333, 0.9, 0.41666666666667
76413, 2.1583333333333, 0.85, 0.41666666666667
76414, 2.1583333333333, 0.8, 0.41666666666667
76415, 2.1583333333333, 0.75, 0.41666666666667
76416, 2.1583333333333, 0.7, 0.41666666666667
76417, 2.1583333333333, 0.65, 0.41666666666667
76418, 2.1583333333333, 0.6, 0.41666666666667
76419, 2.1583333333333, 0.55, 0.41666666666667
76420, 2.1583333333333, 0.5, 0.41666666666667
76421, 2.1583333333333, 0.45, 0.41666666666667
76422, 2.1583333333333, 0.4, 0.41666666666667
76423, 2.1583333333333, 0.35, 0.41666666666667
76424, 2.1583333333333, 0.3, 0.41666666666667
76425, 2.1583333333333, 0.25, 0.41666666666667
76426, 2.1583333333333, 0.2, 0.41666666666667
76427, 1.2416666666667, 1.3, 0.45833333333333
76428, 1.2416666666667, 1.25, 0.45833333333333
76429, 1.2416666666667, 1.2, 0.45833333333333
76430, 1.2416666666667, 1.15, 0.45833333333333
76431, 1.2416666666667, 1.1, 0.45833333333333
76432, 1.2416666666667, 1.05, 0.45833333333333
76433, 1.2416666666667, 1, 0.45833333333333
76434, 1.2416666666667, 0.95, 0.45833333333333
76435, 1.2416666666667, 0.9, 0.45833333333333
76436, 1.2416666666667, 0.85, 0.45833333333333
76437, 1.2416666666667, 0.8, 0.45833333333333
76438, 1.2416666666667, 0.75, 0.45833333333333
76439, 1.2416666666667, 0.7, 0.45833333333333
76440, 1.2416666666667, 0.65, 0.45833333333333
76441, 1.2416666666667, 0.6, 0.45833333333333
76442, 1.2416666666667, 0.55, 0.45833333333333
76443, 1.2416666666667, 0.5, 0.45833333333333
76444, 1.2416666666667, 0.45, 0.45833333333333
76445, 1.2416666666667, 0.4, 0.45833333333333
76446, 1.2416666666667, 0.35, 0.45833333333333
76447, 1.2416666666667, 0.3, 0.45833333333333
76448, 1.2416666666667, 0.25, 0.45833333333333
76449, 1.2416666666667, 0.2, 0.45833333333333
76450, 1.2833333333333, 1.3, 0.45833333333333
76451, 1.2833333333333, 1.25, 0.45833333333333
76452, 1.2833333333333, 1.2, 0.45833333333333
76453, 1.2833333333333, 1.15, 0.45833333333333
76454, 1.2833333333333, 1.1, 0.45833333333333
76455, 1.2833333333333, 1.05, 0.45833333333333
76456, 1.2833333333333, 1, 0.45833333333333
76457, 1.2833333333333, 0.95, 0.45833333333333
76458, 1.2833333333333, 0.9, 0.45833333333333
76459, 1.2833333333333, 0.85, 0.45833333333333
76460, 1.2833333333333, 0.8, 0.45833333333333
76461, 1.2833333333333, 0.75, 0.45833333333333
76462, 1.2833333333333, 0.7, 0.45833333333333
76463, 1.2833333333333, 0.65, 0.45833333333333
76464, 1.2833333333333, 0.6, 0.45833333333333
76465, 1.2833333333333, 0.55, 0.45833333333333
76466, 1.2833333333333, 0.5, 0.45833333333333
76467, 1.2833333333333, 0.45, 0.45833333333333
76468, 1.2833333333333, 0.4, 0.45833333333333
76469, 1.2833333333333, 0.35, 0.45833333333333
76470, 1.2833333333333, 0.3, 0.45833333333333
76471, 1.2833333333333, 0.25, 0.45833333333333
76472, 1.2833333333333, 0.2, 0.45833333333333
76473, 1.325, 1.3, 0.45833333333333
76474, 1.325, 1.25, 0.45833333333333
76475, 1.325, 1.2, 0.45833333333333
76476, 1.325, 1.15, 0.45833333333333
76477, 1.325, 1.1, 0.45833333333333
76478, 1.325, 1.05, 0.45833333333333
76479, 1.325, 1, 0.45833333333333
76480, 1.325, 0.95, 0.45833333333333
76481, 1.325, 0.9, 0.45833333333333
76482, 1.325, 0.85, 0.45833333333333
76483, 1.325, 0.8, 0.45833333333333
76484, 1.325, 0.75, 0.45833333333333
76485, 1.325, 0.7, 0.45833333333333
76486, 1.325, 0.65, 0.45833333333333
76487, 1.325, 0.6, 0.45833333333333
76488, 1.325, 0.55, 0.45833333333333
76489, 1.325, 0.5, 0.45833333333333
76490, 1.325, 0.45, 0.45833333333333
76491, 1.325, 0.4, 0.45833333333333
76492, 1.325, 0.35, 0.45833333333333
76493, 1.325, 0.3, 0.45833333333333
76494, 1.325, 0.25, 0.45833333333333
76495, 1.325, 0.2, 0.45833333333333
76496, 1.3666666666667, 1.3, 0.45833333333333
76497, 1.3666666666667, 1.25, 0.45833333333333
76498, 1.3666666666667, 1.2, 0.45833333333333
76499, 1.3666666666667, 1.15, 0.45833333333333
76500, 1.3666666666667, 1.1, 0.45833333333333
76501, 1.3666666666667, 1.05, 0.45833333333333
76502, 1.3666666666667, 1, 0.45833333333333
76503, 1.3666666666667, 0.95, 0.45833333333333
76504, 1.3666666666667, 0.9, 0.45833333333333
76505, 1.3666666666667, 0.85, 0.45833333333333
76506, 1.3666666666667, 0.8, 0.45833333333333
76507, 1.3666666666667, 0.75, 0.45833333333333
76508, 1.3666666666667, 0.7, 0.45833333333333
76509, 1.3666666666667, 0.65, 0.45833333333333
76510, 1.3666666666667, 0.6, 0.45833333333333
76511, 1.3666666666667, 0.55, 0.45833333333333
76512, 1.3666666666667, 0.5, 0.45833333333333
76513, 1.3666666666667, 0.45, 0.45833333333333
76514, 1.3666666666667, 0.4, 0.45833333333333
76515, 1.3666666666667, 0.35, 0.45833333333333
76516, 1.3666666666667, 0.3, 0.45833333333333
76517, 1.3666666666667, 0.25, 0.45833333333333
76518, 1.3666666666667, 0.2, 0.45833333333333
76519, 1.4083333333333, 1.3, 0.45833333333333
76520, 1.4083333333333, 1.25, 0.45833333333333
76521, 1.4083333333333, 1.2, 0.45833333333333
76522, 1.4083333333333, 1.15, 0.45833333333333
76523, 1.4083333333333, 1.1, 0.45833333333333
76524, 1.4083333333333, 1.05, 0.45833333333333
76525, 1.4083333333333, 1, 0.45833333333333
76526, 1.4083333333333, 0.95, 0.45833333333333
76527, 1.4083333333333, 0.9, 0.45833333333333
76528, 1.4083333333333, 0.85, 0.45833333333333
76529, 1.4083333333333, 0.8, 0.45833333333333
76530, 1.4083333333333, 0.75, 0.45833333333333
76531, 1.4083333333333, 0.7, 0.45833333333333
76532, 1.4083333333333, 0.65, 0.45833333333333
76533, 1.4083333333333, 0.6, 0.45833333333333
76534, 1.4083333333333, 0.55, 0.45833333333333
76535, 1.4083333333333, 0.5, 0.45833333333333
76536, 1.4083333333333, 0.45, 0.45833333333333
76537, 1.4083333333333, 0.4, 0.45833333333333
76538, 1.4083333333333, 0.35, 0.45833333333333
76539, 1.4083333333333, 0.3, 0.45833333333333
76540, 1.4083333333333, 0.25, 0.45833333333333
76541, 1.4083333333333, 0.2, 0.45833333333333
76542, 1.45, 1.3, 0.45833333333333
76543, 1.45, 1.25, 0.45833333333333
76544, 1.45, 1.2, 0.45833333333333
76545, 1.45, 1.15, 0.45833333333333
76546, 1.45, 1.1, 0.45833333333333
76547, 1.45, 1.05, 0.45833333333333
76548, 1.45, 1, 0.45833333333333
76549, 1.45, 0.95, 0.45833333333333
76550, 1.45, 0.9, 0.45833333333333
76551, 1.45, 0.85, 0.45833333333333
76552, 1.45, 0.8, 0.45833333333333
76553, 1.45, 0.75, 0.45833333333333
76554, 1.45, 0.7, 0.45833333333333
76555, 1.45, 0.65, 0.45833333333333
76556, 1.45, 0.6, 0.45833333333333
76557, 1.45, 0.55, 0.45833333333333
76558, 1.45, 0.5, 0.45833333333333
76559, 1.45, 0.45, 0.45833333333333
76560, 1.45, 0.4, 0.45833333333333
76561, 1.45, 0.35, 0.45833333333333
76562, 1.45, 0.3, 0.45833333333333
76563, 1.45, 0.25, 0.45833333333333
76564, 1.45, 0.2, 0.45833333333333
76565, 1.4916666666667, 1.3, 0.45833333333333
76566, 1.4916666666667, 1.25, 0.45833333333333
76567, 1.4916666666667, 1.2, 0.45833333333333
76568, 1.4916666666667, 1.15, 0.45833333333333
76569, 1.4916666666667, 1.1, 0.45833333333333
76570, 1.4916666666667, 1.05, 0.45833333333333
76571, 1.4916666666667, 1, 0.45833333333333
76572, 1.4916666666667, 0.95, 0.45833333333333
76573, 1.4916666666667, 0.9, 0.45833333333333
76574, 1.4916666666667, 0.85, 0.45833333333333
76575, 1.4916666666667, 0.8, 0.45833333333333
76576, 1.4916666666667, 0.75, 0.45833333333333
76577, 1.4916666666667, 0.7, 0.45833333333333
76578, 1.4916666666667, 0.65, 0.45833333333333
76579, 1.4916666666667, 0.6, 0.45833333333333
76580, 1.4916666666667, 0.55, 0.45833333333333
76581, 1.4916666666667, 0.5, 0.45833333333333
76582, 1.4916666666667, 0.45, 0.45833333333333
76583, 1.4916666666667, 0.4, 0.45833333333333
76584, 1.4916666666667, 0.35, 0.45833333333333
76585, 1.4916666666667, 0.3, 0.45833333333333
76586, 1.4916666666667, 0.25, 0.45833333333333
76587, 1.4916666666667, 0.2, 0.45833333333333
76588, 1.5333333333333, 1.3, 0.45833333333333
76589, 1.5333333333333, 1.25, 0.45833333333333
76590, 1.5333333333333, 1.2, 0.45833333333333
76591, 1.5333333333333, 1.15, 0.45833333333333
76592, 1.5333333333333, 1.1, 0.45833333333333
76593, 1.5333333333333, 1.05, 0.45833333333333
76594, 1.5333333333333, 1, 0.45833333333333
76595, 1.5333333333333, 0.95, 0.45833333333333
76596, 1.5333333333333, 0.9, 0.45833333333333
76597, 1.5333333333333, 0.85, 0.45833333333333
76598, 1.5333333333333, 0.8, 0.45833333333333
76599, 1.5333333333333, 0.75, 0.45833333333333
76600, 1.5333333333333, 0.7, 0.45833333333333
76601, 1.5333333333333, 0.65, 0.45833333333333
76602, 1.5333333333333, 0.6, 0.45833333333333
76603, 1.5333333333333, 0.55, 0.45833333333333
76604, 1.5333333333333, 0.5, 0.45833333333333
76605, 1.5333333333333, 0.45, 0.45833333333333
76606, 1.5333333333333, 0.4, 0.45833333333333
76607, 1.5333333333333, 0.35, 0.45833333333333
76608, 1.5333333333333, 0.3, 0.45833333333333
76609, 1.5333333333333, 0.25, 0.45833333333333
76610, 1.5333333333333, 0.2, 0.45833333333333
76611, 1.575, 1.3, 0.45833333333333
76612, 1.575, 1.25, 0.45833333333333
76613, 1.575, 1.2, 0.45833333333333
76614, 1.575, 1.15, 0.45833333333333
76615, 1.575, 1.1, 0.45833333333333
76616, 1.575, 1.05, 0.45833333333333
76617, 1.575, 1, 0.45833333333333
76618, 1.575, 0.95, 0.45833333333333
76619, 1.575, 0.9, 0.45833333333333
76620, 1.575, 0.85, 0.45833333333333
76621, 1.575, 0.8, 0.45833333333333
76622, 1.575, 0.75, 0.45833333333333
76623, 1.575, 0.7, 0.45833333333333
76624, 1.575, 0.65, 0.45833333333333
76625, 1.575, 0.6, 0.45833333333333
76626, 1.575, 0.55, 0.45833333333333
76627, 1.575, 0.5, 0.45833333333333
76628, 1.575, 0.45, 0.45833333333333
76629, 1.575, 0.4, 0.45833333333333
76630, 1.575, 0.35, 0.45833333333333
76631, 1.575, 0.3, 0.45833333333333
76632, 1.575, 0.25, 0.45833333333333
76633, 1.575, 0.2, 0.45833333333333
76634, 1.6166666666667, 1.3, 0.45833333333333
76635, 1.6166666666667, 1.25, 0.45833333333333
76636, 1.6166666666667, 1.2, 0.45833333333333
76637, 1.6166666666667, 1.15, 0.45833333333333
76638, 1.6166666666667, 1.1, 0.45833333333333
76639, 1.6166666666667, 1.05, 0.45833333333333
76640, 1.6166666666667, 1, 0.45833333333333
76641, 1.6166666666667, 0.95, 0.45833333333333
76642, 1.6166666666667, 0.9, 0.45833333333333
76643, 1.6166666666667, 0.85, 0.45833333333333
76644, 1.6166666666667, 0.8, 0.45833333333333
76645, 1.6166666666667, 0.75, 0.45833333333333
76646, 1.6166666666667, 0.7, 0.45833333333333
76647, 1.6166666666667, 0.65, 0.45833333333333
76648, 1.6166666666667, 0.6, 0.45833333333333
76649, 1.6166666666667, 0.55, 0.45833333333333
76650, 1.6166666666667, 0.5, 0.45833333333333
76651, 1.6166666666667, 0.45, 0.45833333333333
76652, 1.6166666666667, 0.4, 0.45833333333333
76653, 1.6166666666667, 0.35, 0.45833333333333
76654, 1.6166666666667, 0.3, 0.45833333333333
76655, 1.6166666666667, 0.25, 0.45833333333333
76656, 1.6166666666667, 0.2, 0.45833333333333
76657, 1.6583333333333, 1.3, 0.45833333333333
76658, 1.6583333333333, 1.25, 0.45833333333333
76659, 1.6583333333333, 1.2, 0.45833333333333
76660, 1.6583333333333, 1.15, 0.45833333333333
76661, 1.6583333333333, 1.1, 0.45833333333333
76662, 1.6583333333333, 1.05, 0.45833333333333
76663, 1.6583333333333, 1, 0.45833333333333
76664, 1.6583333333333, 0.95, 0.45833333333333
76665, 1.6583333333333, 0.9, 0.45833333333333
76666, 1.6583333333333, 0.85, 0.45833333333333
76667, 1.6583333333333, 0.8, 0.45833333333333
76668, 1.6583333333333, 0.75, 0.45833333333333
76669, 1.6583333333333, 0.7, 0.45833333333333
76670, 1.6583333333333, 0.65, 0.45833333333333
76671, 1.6583333333333, 0.6, 0.45833333333333
76672, 1.6583333333333, 0.55, 0.45833333333333
76673, 1.6583333333333, 0.5, 0.45833333333333
76674, 1.6583333333333, 0.45, 0.45833333333333
76675, 1.6583333333333, 0.4, 0.45833333333333
76676, 1.6583333333333, 0.35, 0.45833333333333
76677, 1.6583333333333, 0.3, 0.45833333333333
76678, 1.6583333333333, 0.25, 0.45833333333333
76679, 1.6583333333333, 0.2, 0.45833333333333
76680, 1.7, 1.3, 0.45833333333333
76681, 1.7, 1.25, 0.45833333333333
76682, 1.7, 1.2, 0.45833333333333
76683, 1.7, 1.15, 0.45833333333333
76684, 1.7, 1.1, 0.45833333333333
76685, 1.7, 1.05, 0.45833333333333
76686, 1.7, 1, 0.45833333333333
76687, 1.7, 0.95, 0.45833333333333
76688, 1.7, 0.9, 0.45833333333333
76689, 1.7, 0.85, 0.45833333333333
76690, 1.7, 0.8, 0.45833333333333
76691, 1.7, 0.75, 0.45833333333333
76692, 1.7, 0.7, 0.45833333333333
76693, 1.7, 0.65, 0.45833333333333
76694, 1.7, 0.6, 0.45833333333333
76695, 1.7, 0.55, 0.45833333333333
76696, 1.7, 0.5, 0.45833333333333
76697, 1.7, 0.45, 0.45833333333333
76698, 1.7, 0.4, 0.45833333333333
76699, 1.7, 0.35, 0.45833333333333
76700, 1.7, 0.3, 0.45833333333333
76701, 1.7, 0.25, 0.45833333333333
76702, 1.7, 0.2, 0.45833333333333
76703, 1.7416666666667, 1.3, 0.45833333333333
76704, 1.7416666666667, 1.25, 0.45833333333333
76705, 1.7416666666667, 1.2, 0.45833333333333
76706, 1.7416666666667, 1.15, 0.45833333333333
76707, 1.7416666666667, 1.1, 0.45833333333333
76708, 1.7416666666667, 1.05, 0.45833333333333
76709, 1.7416666666667, 1, 0.45833333333333
76710, 1.7416666666667, 0.95, 0.45833333333333
76711, 1.7416666666667, 0.9, 0.45833333333333
76712, 1.7416666666667, 0.85, 0.45833333333333
76713, 1.7416666666667, 0.8, 0.45833333333333
76714, 1.7416666666667, 0.75, 0.45833333333333
76715, 1.7416666666667, 0.7, 0.45833333333333
76716, 1.7416666666667, 0.65, 0.45833333333333
76717, 1.7416666666667, 0.6, 0.45833333333333
76718, 1.7416666666667, 0.55, 0.45833333333333
76719, 1.7416666666667, 0.5, 0.45833333333333
76720, 1.7416666666667, 0.45, 0.45833333333333
76721, 1.7416666666667, 0.4, 0.45833333333333
76722, 1.7416666666667, 0.35, 0.45833333333333
76723, 1.7416666666667, 0.3, 0.45833333333333
76724, 1.7416666666667, 0.25, 0.45833333333333
76725, 1.7416666666667, 0.2, 0.45833333333333
76726, 1.7833333333333, 1.3, 0.45833333333333
76727, 1.7833333333333, 1.25, 0.45833333333333
76728, 1.7833333333333, 1.2, 0.45833333333333
76729, 1.7833333333333, 1.15, 0.45833333333333
76730, 1.7833333333333, 1.1, 0.45833333333333
76731, 1.7833333333333, 1.05, 0.45833333333333
76732, 1.7833333333333, 1, 0.45833333333333
76733, 1.7833333333333, 0.95, 0.45833333333333
76734, 1.7833333333333, 0.9, 0.45833333333333
76735, 1.7833333333333, 0.85, 0.45833333333333
76736, 1.7833333333333, 0.8, 0.45833333333333
76737, 1.7833333333333, 0.75, 0.45833333333333
76738, 1.7833333333333, 0.7, 0.45833333333333
76739, 1.7833333333333, 0.65, 0.45833333333333
76740, 1.7833333333333, 0.6, 0.45833333333333
76741, 1.7833333333333, 0.55, 0.45833333333333
76742, 1.7833333333333, 0.5, 0.45833333333333
76743, 1.7833333333333, 0.45, 0.45833333333333
76744, 1.7833333333333, 0.4, 0.45833333333333
76745, 1.7833333333333, 0.35, 0.45833333333333
76746, 1.7833333333333, 0.3, 0.45833333333333
76747, 1.7833333333333, 0.25, 0.45833333333333
76748, 1.7833333333333, 0.2, 0.45833333333333
76749, 1.825, 1.3, 0.45833333333333
76750, 1.825, 1.25, 0.45833333333333
76751, 1.825, 1.2, 0.45833333333333
76752, 1.825, 1.15, 0.45833333333333
76753, 1.825, 1.1, 0.45833333333333
76754, 1.825, 1.05, 0.45833333333333
76755, 1.825, 1, 0.45833333333333
76756, 1.825, 0.95, 0.45833333333333
76757, 1.825, 0.9, 0.45833333333333
76758, 1.825, 0.85, 0.45833333333333
76759, 1.825, 0.8, 0.45833333333333
76760, 1.825, 0.75, 0.45833333333333
76761, 1.825, 0.7, 0.45833333333333
76762, 1.825, 0.65, 0.45833333333333
76763, 1.825, 0.6, 0.45833333333333
76764, 1.825, 0.55, 0.45833333333333
76765, 1.825, 0.5, 0.45833333333333
76766, 1.825, 0.45, 0.45833333333333
76767, 1.825, 0.4, 0.45833333333333
76768, 1.825, 0.35, 0.45833333333333
76769, 1.825, 0.3, 0.45833333333333
76770, 1.825, 0.25, 0.45833333333333
76771, 1.825, 0.2, 0.45833333333333
76772, 1.8666666666667, 1.3, 0.45833333333333
76773, 1.8666666666667, 1.25, 0.45833333333333
76774, 1.8666666666667, 1.2, 0.45833333333333
76775, 1.8666666666667, 1.15, 0.45833333333333
76776, 1.8666666666667, 1.1, 0.45833333333333
76777, 1.8666666666667, 1.05, 0.45833333333333
76778, 1.8666666666667, 1, 0.45833333333333
76779, 1.8666666666667, 0.95, 0.45833333333333
76780, 1.8666666666667, 0.9, 0.45833333333333
76781, 1.8666666666667, 0.85, 0.45833333333333
76782, 1.8666666666667, 0.8, 0.45833333333333
76783, 1.8666666666667, 0.75, 0.45833333333333
76784, 1.8666666666667, 0.7, 0.45833333333333
76785, 1.8666666666667, 0.65, 0.45833333333333
76786, 1.8666666666667, 0.6, 0.45833333333333
76787, 1.8666666666667, 0.55, 0.45833333333333
76788, 1.8666666666667, 0.5, 0.45833333333333
76789, 1.8666666666667, 0.45, 0.45833333333333
76790, 1.8666666666667, 0.4, 0.45833333333333
76791, 1.8666666666667, 0.35, 0.45833333333333
76792, 1.8666666666667, 0.3, 0.45833333333333
76793, 1.8666666666667, 0.25, 0.45833333333333
76794, 1.8666666666667, 0.2, 0.45833333333333
76795, 1.9083333333333, 1.3, 0.45833333333333
76796, 1.9083333333333, 1.25, 0.45833333333333
76797, 1.9083333333333, 1.2, 0.45833333333333
76798, 1.9083333333333, 1.15, 0.45833333333333
76799, 1.9083333333333, 1.1, 0.45833333333333
76800, 1.9083333333333, 1.05, 0.45833333333333
76801, 1.9083333333333, 1, 0.45833333333333
76802, 1.9083333333333, 0.95, 0.45833333333333
76803, 1.9083333333333, 0.9, 0.45833333333333
76804, 1.9083333333333, 0.85, 0.45833333333333
76805, 1.9083333333333, 0.8, 0.45833333333333
76806, 1.9083333333333, 0.75, 0.45833333333333
76807, 1.9083333333333, 0.7, 0.45833333333333
76808, 1.9083333333333, 0.65, 0.45833333333333
76809, 1.9083333333333, 0.6, 0.45833333333333
76810, 1.9083333333333, 0.55, 0.45833333333333
76811, 1.9083333333333, 0.5, 0.45833333333333
76812, 1.9083333333333, 0.45, 0.45833333333333
76813, 1.9083333333333, 0.4, 0.45833333333333
76814, 1.9083333333333, 0.35, 0.45833333333333
76815, 1.9083333333333, 0.3, 0.45833333333333
76816, 1.9083333333333, 0.25, 0.45833333333333
76817, 1.9083333333333, 0.2, 0.45833333333333
76818, 1.95, 1.3, 0.45833333333333
76819, 1.95, 1.25, 0.45833333333333
76820, 1.95, 1.2, 0.45833333333333
76821, 1.95, 1.15, 0.45833333333333
76822, 1.95, 1.1, 0.45833333333333
76823, 1.95, 1.05, 0.45833333333333
76824, 1.95, 1, 0.45833333333333
76825, 1.95, 0.95, 0.45833333333333
76826, 1.95, 0.9, 0.45833333333333
76827, 1.95, 0.85, 0.45833333333333
76828, 1.95, 0.8, 0.45833333333333
76829, 1.95, 0.75, 0.45833333333333
76830, 1.95, 0.7, 0.45833333333333
76831, 1.95, 0.65, 0.45833333333333
76832, 1.95, 0.6, 0.45833333333333
76833, 1.95, 0.55, 0.45833333333333
76834, 1.95, 0.5, 0.45833333333333
76835, 1.95, 0.45, 0.45833333333333
76836, 1.95, 0.4, 0.45833333333333
76837, 1.95, 0.35, 0.45833333333333
76838, 1.95, 0.3, 0.45833333333333
76839, 1.95, 0.25, 0.45833333333333
76840, 1.95, 0.2, 0.45833333333333
76841, 1.9916666666667, 1.3, 0.45833333333333
76842, 1.9916666666667, 1.25, 0.45833333333333
76843, 1.9916666666667, 1.2, 0.45833333333333
76844, 1.9916666666667, 1.15, 0.45833333333333
76845, 1.9916666666667, 1.1, 0.45833333333333
76846, 1.9916666666667, 1.05, 0.45833333333333
76847, 1.9916666666667, 1, 0.45833333333333
76848, 1.9916666666667, 0.95, 0.45833333333333
76849, 1.9916666666667, 0.9, 0.45833333333333
76850, 1.9916666666667, 0.85, 0.45833333333333
76851, 1.9916666666667, 0.8, 0.45833333333333
76852, 1.9916666666667, 0.75, 0.45833333333333
76853, 1.9916666666667, 0.7, 0.45833333333333
76854, 1.9916666666667, 0.65, 0.45833333333333
76855, 1.9916666666667, 0.6, 0.45833333333333
76856, 1.9916666666667, 0.55, 0.45833333333333
76857, 1.9916666666667, 0.5, 0.45833333333333
76858, 1.9916666666667, 0.45, 0.45833333333333
76859, 1.9916666666667, 0.4, 0.45833333333333
76860, 1.9916666666667, 0.35, 0.45833333333333
76861, 1.9916666666667, 0.3, 0.45833333333333
76862, 1.9916666666667, 0.25, 0.45833333333333
76863, 1.9916666666667, 0.2, 0.45833333333333
76864, 2.0333333333333, 1.3, 0.45833333333333
76865, 2.0333333333333, 1.25, 0.45833333333333
76866, 2.0333333333333, 1.2, 0.45833333333333
76867, 2.0333333333333, 1.15, 0.45833333333333
76868, 2.0333333333333, 1.1, 0.45833333333333
76869, 2.0333333333333, 1.05, 0.45833333333333
76870, 2.0333333333333, 1, 0.45833333333333
76871, 2.0333333333333, 0.95, 0.45833333333333
76872, 2.0333333333333, 0.9, 0.45833333333333
76873, 2.0333333333333, 0.85, 0.45833333333333
76874, 2.0333333333333, 0.8, 0.45833333333333
76875, 2.0333333333333, 0.75, 0.45833333333333
76876, 2.0333333333333, 0.7, 0.45833333333333
76877, 2.0333333333333, 0.65, 0.45833333333333
76878, 2.0333333333333, 0.6, 0.45833333333333
76879, 2.0333333333333, 0.55, 0.45833333333333
76880, 2.0333333333333, 0.5, 0.45833333333333
76881, 2.0333333333333, 0.45, 0.45833333333333
76882, 2.0333333333333, 0.4, 0.45833333333333
76883, 2.0333333333333, 0.35, 0.45833333333333
76884, 2.0333333333333, 0.3, 0.45833333333333
76885, 2.0333333333333, 0.25, 0.45833333333333
76886, 2.0333333333333, 0.2, 0.45833333333333
76887, 2.075, 1.3, 0.45833333333333
76888, 2.075, 1.25, 0.45833333333333
76889, 2.075, 1.2, 0.45833333333333
76890, 2.075, 1.15, 0.45833333333333
76891, 2.075, 1.1, 0.45833333333333
76892, 2.075, 1.05, 0.45833333333333
76893, 2.075, 1, 0.45833333333333
76894, 2.075, 0.95, 0.45833333333333
76895, 2.075, 0.9, 0.45833333333333
76896, 2.075, 0.85, 0.45833333333333
76897, 2.075, 0.8, 0.45833333333333
76898, 2.075, 0.75, 0.45833333333333
76899, 2.075, 0.7, 0.45833333333333
76900, 2.075, 0.65, 0.45833333333333
76901, 2.075, 0.6, 0.45833333333333
76902, 2.075, 0.55, 0.45833333333333
76903, 2.075, 0.5, 0.45833333333333
76904, 2.075, 0.45, 0.45833333333333
76905, 2.075, 0.4, 0.45833333333333
76906, 2.075, 0.35, 0.45833333333333
76907, 2.075, 0.3, 0.45833333333333
76908, 2.075, 0.25, 0.45833333333333
76909, 2.075, 0.2, 0.45833333333333
76910, 2.1166666666667, 1.3, 0.45833333333333
76911, 2.1166666666667, 1.25, 0.45833333333333
76912, 2.1166666666667, 1.2, 0.45833333333333
76913, 2.1166666666667, 1.15, 0.45833333333333
76914, 2.1166666666667, 1.1, 0.45833333333333
76915, 2.1166666666667, 1.05, 0.45833333333333
76916, 2.1166666666667, 1, 0.45833333333333
76917, 2.1166666666667, 0.95, 0.45833333333333
76918, 2.1166666666667, 0.9, 0.45833333333333
76919, 2.1166666666667, 0.85, 0.45833333333333
76920, 2.1166666666667, 0.8, 0.45833333333333
76921, 2.1166666666667, 0.75, 0.45833333333333
76922, 2.1166666666667, 0.7, 0.45833333333333
76923, 2.1166666666667, 0.65, 0.45833333333333
76924, 2.1166666666667, 0.6, 0.45833333333333
76925, 2.1166666666667, 0.55, 0.45833333333333
76926, 2.1166666666667, 0.5, 0.45833333333333
76927, 2.1166666666667, 0.45, 0.45833333333333
76928, 2.1166666666667, 0.4, 0.45833333333333
76929, 2.1166666666667, 0.35, 0.45833333333333
76930, 2.1166666666667, 0.3, 0.45833333333333
76931, 2.1166666666667, 0.25, 0.45833333333333
76932, 2.1166666666667, 0.2, 0.45833333333333
76933, 2.1583333333333, 1.3, 0.45833333333333
76934, 2.1583333333333, 1.25, 0.45833333333333
76935, 2.1583333333333, 1.2, 0.45833333333333
76936, 2.1583333333333, 1.15, 0.45833333333333
76937, 2.1583333333333, 1.1, 0.45833333333333
76938, 2.1583333333333, 1.05, 0.45833333333333
76939, 2.1583333333333, 1, 0.45833333333333
76940, 2.1583333333333, 0.95, 0.45833333333333
76941, 2.1583333333333, 0.9, 0.45833333333333
76942, 2.1583333333333, 0.85, 0.45833333333333
76943, 2.1583333333333, 0.8, 0.45833333333333
76944, 2.1583333333333, 0.75, 0.45833333333333
76945, 2.1583333333333, 0.7, 0.45833333333333
76946, 2.1583333333333, 0.65, 0.45833333333333
76947, 2.1583333333333, 0.6, 0.45833333333333
76948, 2.1583333333333, 0.55, 0.45833333333333
76949, 2.1583333333333, 0.5, 0.45833333333333
76950, 2.1583333333333, 0.45, 0.45833333333333
76951, 2.1583333333333, 0.4, 0.45833333333333
76952, 2.1583333333333, 0.35, 0.45833333333333
76953, 2.1583333333333, 0.3, 0.45833333333333
76954, 2.1583333333333, 0.25, 0.45833333333333
76955, 2.1583333333333, 0.2, 0.45833333333333
76956, 1.2416666666667, 1.325, 0.041666666666667
76957, 1.2416666666667, 1.3, 0.020833333333333
76958, 1.2208333333333, 1.3, 0.041666666666667
76959, 1.2416666666667, 1.275, 0.041666666666667
76960, 1.2416666666667, 1.25, 0.020833333333333
76961, 1.2208333333333, 1.25, 0.041666666666667
76962, 1.2416666666667, 1.225, 0.041666666666667
76963, 1.2416666666667, 1.2, 0.020833333333333
76964, 1.2208333333333, 1.2, 0.041666666666667
76965, 1.2416666666667, 1.175, 0.041666666666667
76966, 1.2416666666667, 1.15, 0.020833333333333
76967, 1.2208333333333, 1.15, 0.041666666666667
76968, 1.2416666666667, 1.125, 0.041666666666667
76969, 1.2416666666667, 1.1, 0.020833333333333
76970, 1.2208333333333, 1.1, 0.041666666666667
76971, 1.2416666666667, 1.075, 0.041666666666667
76972, 1.2416666666667, 1.05, 0.020833333333333
76973, 1.2208333333333, 1.05, 0.041666666666667
76974, 1.2416666666667, 1.025, 0.041666666666667
76975, 1.2416666666667, 1, 0.020833333333333
76976, 1.2208333333333, 1, 0.041666666666667
76977, 1.2416666666667, 0.975, 0.041666666666667
76978, 1.2416666666667, 0.95, 0.020833333333333
76979, 1.2208333333333, 0.95, 0.041666666666667
76980, 1.2416666666667, 0.925, 0.041666666666667
76981, 1.2416666666667, 0.9, 0.020833333333333
76982, 1.2208333333333, 0.9, 0.041666666666667
76983, 1.2416666666667, 0.875, 0.041666666666667
76984, 1.2416666666667, 0.85, 0.020833333333333
76985, 1.2208333333333, 0.85, 0.041666666666667
76986, 1.2416666666667, 0.825, 0.041666666666667
76987, 1.2416666666667, 0.8, 0.020833333333333
76988, 1.2208333333333, 0.8, 0.041666666666667
76989, 1.2416666666667, 0.775, 0.041666666666667
76990, 1.2416666666667, 0.75, 0.020833333333333
76991, 1.2208333333333, 0.75, 0.041666666666667
76992, 1.2416666666667, 0.725, 0.041666666666667
76993, 1.2416666666667, 0.7, 0.020833333333333
76994, 1.2208333333333, 0.7, 0.041666666666667
76995, 1.2416666666667, 0.675, 0.041666666666667
76996, 1.2416666666667, 0.65, 0.020833333333333
76997, 1.2208333333333, 0.65, 0.041666666666667
76998, 1.2416666666667, 0.625, 0.041666666666667
76999, 1.2416666666667, 0.6, 0.020833333333333
77000, 1.2208333333333, 0.6, 0.041666666666667
77001, 1.2416666666667, 0.575, 0.041666666666667
77002, 1.2416666666667, 0.55, 0.020833333333333
77003, 1.2208333333333, 0.55, 0.041666666666667
77004, 1.2416666666667, 0.525, 0.041666666666667
77005, 1.2416666666667, 0.5, 0.020833333333333
77006, 1.2208333333333, 0.5, 0.041666666666667
77007, 1.2416666666667, 0.475, 0.041666666666667
77008, 1.2416666666667, 0.45, 0.020833333333333
77009, 1.2208333333333, 0.45, 0.041666666666667
77010, 1.2416666666667, 0.425, 0.041666666666667
77011, 1.2416666666667, 0.4, 0.020833333333333
77012, 1.2208333333333, 0.4, 0.041666666666667
77013, 1.2416666666667, 0.375, 0.041666666666667
77014, 1.2416666666667, 0.35, 0.020833333333333
77015, 1.2208333333333, 0.35, 0.041666666666667
77016, 1.2416666666667, 0.325, 0.041666666666667
77017, 1.2416666666667, 0.3, 0.020833333333333
77018, 1.2208333333333, 0.3, 0.041666666666667
77019, 1.2416666666667, 0.275, 0.041666666666667
77020, 1.2416666666667, 0.25, 0.020833333333333
77021, 1.2208333333333, 0.25, 0.041666666666667
77022, 1.2416666666667, 0.225, 0.041666666666667
77023, 1.2416666666667, 0.2, 0.020833333333333
77024, 1.2208333333333, 0.2, 0.041666666666667
77025, 1.2416666666667, 0.175, 0.041666666666667
77026, 1.2833333333333, 1.325, 0.041666666666667
77027, 1.2833333333333, 1.3, 0.020833333333333
77028, 1.2625, 1.3, 0.041666666666667
77029, 1.2833333333333, 1.275, 0.041666666666667
77030, 1.2833333333333, 1.25, 0.020833333333333
77031, 1.2625, 1.25, 0.041666666666667
77032, 1.2833333333333, 1.225, 0.041666666666667
77033, 1.2833333333333, 1.2, 0.020833333333333
77034, 1.2625, 1.2, 0.041666666666667
77035, 1.2833333333333, 1.175, 0.041666666666667
77036, 1.2833333333333, 1.15, 0.020833333333333
77037, 1.2625, 1.15, 0.041666666666667
77038, 1.2833333333333, 1.125, 0.041666666666667
77039, 1.2833333333333, 1.1, 0.020833333333333
77040, 1.2625, 1.1, 0.041666666666667
77041, 1.2833333333333, 1.075, 0.041666666666667
77042, 1.2833333333333, 1.05, 0.020833333333333
77043, 1.2625, 1.05, 0.041666666666667
77044, 1.2833333333333, 1.025, 0.041666666666667
77045, 1.2833333333333, 1, 0.020833333333333
77046, 1.2625, 1, 0.041666666666667
77047, 1.2833333333333, 0.975, 0.041666666666667
77048, 1.2833333333333, 0.95, 0.020833333333333
77049, 1.2625, 0.95, 0.041666666666667
77050, 1.2833333333333, 0.925, 0.041666666666667
77051, 1.2833333333333, 0.9, 0.020833333333333
77052, 1.2625, 0.9, 0.041666666666667
77053, 1.2833333333333, 0.875, 0.041666666666667
77054, 1.2833333333333, 0.85, 0.020833333333333
77055, 1.2625, 0.85, 0.041666666666667
77056, 1.2833333333333, 0.825, 0.041666666666667
77057, 1.2833333333333, 0.8, 0.020833333333333
77058, 1.2625, 0.8, 0.041666666666667
77059, 1.2833333333333, 0.775, 0.041666666666667
77060, 1.2833333333333, 0.75, 0.020833333333333
77061, 1.2625, 0.75, 0.041666666666667
77062, 1.2833333333333, 0.725, 0.041666666666667
77063, 1.2833333333333, 0.7, 0.020833333333333
77064, 1.2625, 0.7, 0.041666666666667
77065, 1.2833333333333, 0.675, 0.041666666666667
77066, 1.2833333333333, 0.65, 0.020833333333333
77067, 1.2625, 0.65, 0.041666666666667
77068, 1.2833333333333, 0.625, 0.041666666666667
77069, 1.2833333333333, 0.6, 0.020833333333333
77070, 1.2625, 0.6, 0.041666666666667
77071, 1.2833333333333, 0.575, 0.041666666666667
77072, 1.2833333333333, 0.55, 0.020833333333333
77073, 1.2625, 0.55, 0.041666666666667
77074, 1.2833333333333, 0.525, 0.041666666666667
77075, 1.2833333333333, 0.5, 0.020833333333333
77076, 1.2625, 0.5, 0.041666666666667
77077, 1.2833333333333, 0.475, 0.041666666666667
77078, 1.2833333333333, 0.45, 0.020833333333333
77079, 1.2625, 0.45, 0.041666666666667
77080, 1.2833333333333, 0.425, 0.041666666666667
77081, 1.2833333333333, 0.4, 0.020833333333333
77082, 1.2625, 0.4, 0.041666666666667
77083, 1.2833333333333, 0.375, 0.041666666666667
77084, 1.2833333333333, 0.35, 0.020833333333333
77085, 1.2625, 0.35, 0.041666666666667
77086, 1.2833333333333, 0.325, 0.041666666666667
77087, 1.2833333333333, 0.3, 0.020833333333333
77088, 1.2625, 0.3, 0.041666666666667
77089, 1.2833333333333, 0.275, 0.041666666666667
77090, 1.2833333333333, 0.25, 0.020833333333333
77091, 1.2625, 0.25, 0.041666666666667
77092, 1.2833333333333, 0.225, 0.041666666666667
77093, 1.2833333333333, 0.2, 0.020833333333333
77094, 1.2625, 0.2, 0.041666666666667
77095, 1.2833333333333, 0.175, 0.041666666666667
77096, 1.325, 1.325, 0.041666666666667
77097, 1.325, 1.3, 0.020833333333333
77098, 1.3041666666667, 1.3, 0.041666666666667
77099, 1.325, 1.275, 0.041666666666667
77100, 1.325, 1.25, 0.020833333333333
77101, 1.3041666666667, 1.25, 0.041666666666667
77102, 1.325, 1.225, 0.041666666666667
77103, 1.325, 1.2, 0.020833333333333
77104, 1.3041666666667, 1.2, 0.041666666666667
77105, 1.325, 1.175, 0.041666666666667
77106, 1.325, 1.15, 0.020833333333333
77107, 1.3041666666667, 1.15, 0.041666666666667
77108, 1.325, 1.125, 0.041666666666667
77109, 1.325, 1.1, 0.020833333333333
77110, 1.3041666666667, 1.1, 0.041666666666667
77111, 1.325, 1.075, 0.041666666666667
77112, 1.325, 1.05, 0.020833333333333
77113, 1.3041666666667, 1.05, 0.041666666666667
77114, 1.325, 1.025, 0.041666666666667
77115, 1.325, 1, 0.020833333333333
77116, 1.3041666666667, 1, 0.041666666666667
77117, 1.325, 0.975, 0.041666666666667
77118, 1.325, 0.95, 0.020833333333333
77119, 1.3041666666667, 0.95, 0.041666666666667
77120, 1.325, 0.925, 0.041666666666667
77121, 1.325, 0.9, 0.020833333333333
77122, 1.3041666666667, 0.9, 0.041666666666667
77123, 1.325, 0.875, 0.041666666666667
77124, 1.325, 0.85, 0.020833333333333
77125, 1.3041666666667, 0.85, 0.041666666666667
77126, 1.325, 0.825, 0.041666666666667
77127, 1.325, 0.8, 0.020833333333333
77128, 1.3041666666667, 0.8, 0.041666666666667
77129, 1.325, 0.775, 0.041666666666667
77130, 1.325, 0.75, 0.020833333333333
77131, 1.3041666666667, 0.75, 0.041666666666667
77132, 1.325, 0.725, 0.041666666666667
77133, 1.325, 0.7, 0.020833333333333
77134, 1.3041666666667, 0.7, 0.041666666666667
77135, 1.325, 0.675, 0.041666666666667
77136, 1.325, 0.65, 0.020833333333333
77137, 1.3041666666667, 0.65, 0.041666666666667
77138, 1.325, 0.625, 0.041666666666667
77139, 1.325, 0.6, 0.020833333333333
77140, 1.3041666666667, 0.6, 0.041666666666667
77141, 1.325, 0.575, 0.041666666666667
77142, 1.325, 0.55, 0.020833333333333
77143, 1.3041666666667, 0.55, 0.041666666666667
77144, 1.325, 0.525, 0.041666666666667
77145, 1.325, 0.5, 0.020833333333333
77146, 1.3041666666667, 0.5, 0.041666666666667
77147, 1.325, 0.475, 0.041666666666667
77148, 1.325, 0.45, 0.020833333333333
77149, 1.3041666666667, 0.45, 0.041666666666667
77150, 1.325, 0.425, 0.041666666666667
77151, 1.325, 0.4, 0.020833333333333
77152, 1.3041666666667, 0.4, 0.041666666666667
77153, 1.325, 0.375, 0.041666666666667
77154, 1.325, 0.35, 0.020833333333333
77155, 1.3041666666667, 0.35, 0.041666666666667
77156, 1.325, 0.325, 0.041666666666667
77157, 1.325, 0.3, 0.020833333333333
77158, 1.3041666666667, 0.3, 0.041666666666667
77159, 1.325, 0.275, 0.041666666666667
77160, 1.325, 0.25, 0.020833333333333
77161, 1.3041666666667, 0.25, 0.041666666666667
77162, 1.325, 0.225, 0.041666666666667
77163, 1.325, 0.2, 0.020833333333333
77164, 1.3041666666667, 0.2, 0.041666666666667
77165, 1.325, 0.175, 0.041666666666667
77166, 1.3666666666667, 1.325, 0.041666666666667
77167, 1.3666666666667, 1.3, 0.020833333333333
77168, 1.3458333333333, 1.3, 0.041666666666667
77169, 1.3666666666667, 1.275, 0.041666666666667
77170, 1.3666666666667, 1.25, 0.020833333333333
77171, 1.3458333333333, 1.25, 0.041666666666667
77172, 1.3666666666667, 1.225, 0.041666666666667
77173, 1.3666666666667, 1.2, 0.020833333333333
77174, 1.3458333333333, 1.2, 0.041666666666667
77175, 1.3666666666667, 1.175, 0.041666666666667
77176, 1.3666666666667, 1.15, 0.020833333333333
77177, 1.3458333333333, 1.15, 0.041666666666667
77178, 1.3666666666667, 1.125, 0.041666666666667
77179, 1.3666666666667, 1.1, 0.020833333333333
77180, 1.3458333333333, 1.1, 0.041666666666667
77181, 1.3666666666667, 1.075, 0.041666666666667
77182, 1.3666666666667, 1.05, 0.020833333333333
77183, 1.3458333333333, 1.05, 0.041666666666667
77184, 1.3666666666667, 1.025, 0.041666666666667
77185, 1.3666666666667, 1, 0.020833333333333
77186, 1.3458333333333, 1, 0.041666666666667
77187, 1.3666666666667, 0.975, 0.041666666666667
77188, 1.3666666666667, 0.95, 0.020833333333333
77189, 1.3458333333333, 0.95, 0.041666666666667
77190, 1.3666666666667, 0.925, 0.041666666666667
77191, 1.3666666666667, 0.9, 0.020833333333333
77192, 1.3458333333333, 0.9, 0.041666666666667
77193, 1.3666666666667, 0.875, 0.041666666666667
77194, 1.3666666666667, 0.85, 0.020833333333333
77195, 1.3458333333333, 0.85, 0.041666666666667
77196, 1.3666666666667, 0.825, 0.041666666666667
77197, 1.3666666666667, 0.8, 0.020833333333333
77198, 1.3458333333333, 0.8, 0.041666666666667
77199, 1.3666666666667, 0.775, 0.041666666666667
77200, 1.3666666666667, 0.75, 0.020833333333333
77201, 1.3458333333333, 0.75, 0.041666666666667
77202, 1.3666666666667, 0.725, 0.041666666666667
77203, 1.3666666666667, 0.7, 0.020833333333333
77204, 1.3458333333333, 0.7, 0.041666666666667
77205, 1.3666666666667, 0.675, 0.041666666666667
77206, 1.3666666666667, 0.65, 0.020833333333333
77207, 1.3458333333333, 0.65, 0.041666666666667
77208, 1.3666666666667, 0.625, 0.041666666666667
77209, 1.3666666666667, 0.6, 0.020833333333333
77210, 1.3458333333333, 0.6, 0.041666666666667
77211, 1.3666666666667, 0.575, 0.041666666666667
77212, 1.3666666666667, 0.55, 0.020833333333333
77213, 1.3458333333333, 0.55, 0.041666666666667
77214, 1.3666666666667, 0.525, 0.041666666666667
77215, 1.3666666666667, 0.5, 0.020833333333333
77216, 1.3458333333333, 0.5, 0.041666666666667
77217, 1.3666666666667, 0.475, 0.041666666666667
77218, 1.3666666666667, 0.45, 0.020833333333333
77219, 1.3458333333333, 0.45, 0.041666666666667
77220, 1.3666666666667, 0.425, 0.041666666666667
77221, 1.3666666666667, 0.4, 0.020833333333333
77222, 1.3458333333333, 0.4, 0.041666666666667
77223, 1.3666666666667, 0.375, 0.041666666666667
77224, 1.3666666666667, 0.35, 0.020833333333333
77225, 1.3458333333333, 0.35, 0.041666666666667
77226, 1.3666666666667, 0.325, 0.041666666666667
77227, 1.3666666666667, 0.3, 0.020833333333333
77228, 1.3458333333333, 0.3, 0.041666666666667
77229, 1.3666666666667, 0.275, 0.041666666666667
77230, 1.3666666666667, 0.25, 0.020833333333333
77231, 1.3458333333333, 0.25, 0.041666666666667
77232, 1.3666666666667, 0.225, 0.041666666666667
77233, 1.3666666666667, 0.2, 0.020833333333333
77234, 1.3458333333333, 0.2, 0.041666666666667
77235, 1.3666666666667, 0.175, 0.041666666666667
77236, 1.4083333333333, 1.325, 0.041666666666667
77237, 1.4083333333333, 1.3, 0.020833333333333
77238, 1.3875, 1.3, 0.041666666666667
77239, 1.4083333333333, 1.275, 0.041666666666667
77240, 1.4083333333333, 1.25, 0.020833333333333
77241, 1.3875, 1.25, 0.041666666666667
77242, 1.4083333333333, 1.225, 0.041666666666667
77243, 1.4083333333333, 1.2, 0.020833333333333
77244, 1.3875, 1.2, 0.041666666666667
77245, 1.4083333333333, 1.175, 0.041666666666667
77246, 1.4083333333333, 1.15, 0.020833333333333
77247, 1.3875, 1.15, 0.041666666666667
77248, 1.4083333333333, 1.125, 0.041666666666667
77249, 1.4083333333333, 1.1, 0.020833333333333
77250, 1.3875, 1.1, 0.041666666666667
77251, 1.4083333333333, 1.075, 0.041666666666667
77252, 1.4083333333333, 1.05, 0.020833333333333
77253, 1.3875, 1.05, 0.041666666666667
77254, 1.4083333333333, 1.025, 0.041666666666667
77255, 1.4083333333333, 1, 0.020833333333333
77256, 1.3875, 1, 0.041666666666667
77257, 1.4083333333333, 0.975, 0.041666666666667
77258, 1.4083333333333, 0.95, 0.020833333333333
77259, 1.3875, 0.95, 0.041666666666667
77260, 1.4083333333333, 0.925, 0.041666666666667
77261, 1.4083333333333, 0.9, 0.020833333333333
77262, 1.3875, 0.9, 0.041666666666667
77263, 1.4083333333333, 0.875, 0.041666666666667
77264, 1.4083333333333, 0.85, 0.020833333333333
77265, 1.3875, 0.85, 0.041666666666667
77266, 1.4083333333333, 0.825, 0.041666666666667
77267, 1.4083333333333, 0.8, 0.020833333333333
77268, 1.3875, 0.8, 0.041666666666667
77269, 1.4083333333333, 0.775, 0.041666666666667
77270, 1.4083333333333, 0.75, 0.020833333333333
77271, 1.3875, 0.75, 0.041666666666667
77272, 1.4083333333333, 0.725, 0.041666666666667
77273, 1.4083333333333, 0.7, 0.020833333333333
77274, 1.3875, 0.7, 0.041666666666667
77275, 1.4083333333333, 0.675, 0.041666666666667
77276, 1.4083333333333, 0.65, 0.020833333333333
77277, 1.3875, 0.65, 0.041666666666667
77278, 1.4083333333333, 0.625, 0.041666666666667
77279, 1.4083333333333, 0.6, 0.020833333333333
77280, 1.3875, 0.6, 0.041666666666667
77281, 1.4083333333333, 0.575, 0.041666666666667
77282, 1.4083333333333, 0.55, 0.020833333333333
77283, 1.3875, 0.55, 0.041666666666667
77284, 1.4083333333333, 0.525, 0.041666666666667
77285, 1.4083333333333, 0.5, 0.020833333333333
77286, 1.3875, 0.5, 0.041666666666667
77287, 1.4083333333333, 0.475, 0.041666666666667
77288, 1.4083333333333, 0.45, 0.020833333333333
77289, 1.3875, 0.45, 0.041666666666667
77290, 1.4083333333333, 0.425, 0.041666666666667
77291, 1.4083333333333, 0.4, 0.020833333333333
77292, 1.3875, 0.4, 0.041666666666667
77293, 1.4083333333333, 0.375, 0.041666666666667
77294, 1.4083333333333, 0.35, 0.020833333333333
77295, 1.3875, 0.35, 0.041666666666667
77296, 1.4083333333333, 0.325, 0.041666666666667
77297, 1.4083333333333, 0.3, 0.020833333333333
77298, 1.3875, 0.3, 0.041666666666667
77299, 1.4083333333333, 0.275, 0.041666666666667
77300, 1.4083333333333, 0.25, 0.020833333333333
77301, 1.3875, 0.25, 0.041666666666667
77302, 1.4083333333333, 0.225, 0.041666666666667
77303, 1.4083333333333, 0.2, 0.020833333333333
77304, 1.3875, 0.2, 0.041666666666667
77305, 1.4083333333333, 0.175, 0.041666666666667
77306, 1.45, 1.325, 0.041666666666667
77307, 1.45, 1.3, 0.020833333333333
77308, 1.4291666666667, 1.3, 0.041666666666667
77309, 1.45, 1.275, 0.041666666666667
77310, 1.45, 1.25, 0.020833333333333
77311, 1.4291666666667, 1.25, 0.041666666666667
77312, 1.45, 1.225, 0.041666666666667
77313, 1.45, 1.2, 0.020833333333333
77314, 1.4291666666667, 1.2, 0.041666666666667
77315, 1.45, 1.175, 0.041666666666667
77316, 1.45, 1.15, 0.020833333333333
77317, 1.4291666666667, 1.15, 0.041666666666667
77318, 1.45, 1.125, 0.041666666666667
77319, 1.45, 1.1, 0.020833333333333
77320, 1.4291666666667, 1.1, 0.041666666666667
77321, 1.45, 1.075, 0.041666666666667
77322, 1.45, 1.05, 0.020833333333333
77323, 1.4291666666667, 1.05, 0.041666666666667
77324, 1.45, 1.025, 0.041666666666667
77325, 1.45, 1, 0.020833333333333
77326, 1.4291666666667, 1, 0.041666666666667
77327, 1.45, 0.975, 0.041666666666667
77328, 1.45, 0.95, 0.020833333333333
77329, 1.4291666666667, 0.95, 0.041666666666667
77330, 1.45, 0.925, 0.041666666666667
77331, 1.45, 0.9, 0.020833333333333
77332, 1.4291666666667, 0.9, 0.041666666666667
77333, 1.45, 0.875, 0.041666666666667
77334, 1.45, 0.85, 0.020833333333333
77335, 1.4291666666667, 0.85, 0.041666666666667
77336, 1.45, 0.825, 0.041666666666667
77337, 1.45, 0.8, 0.020833333333333
77338, 1.4291666666667, 0.8, 0.041666666666667
77339, 1.45, 0.775, 0.041666666666667
77340, 1.45, 0.75, 0.020833333333333
77341, 1.4291666666667, 0.75, 0.041666666666667
77342, 1.45, 0.725, 0.041666666666667
77343, 1.45, 0.7, 0.020833333333333
77344, 1.4291666666667, 0.7, 0.041666666666667
77345, 1.45, 0.675, 0.041666666666667
77346, 1.45, 0.65, 0.020833333333333
77347, 1.4291666666667, 0.65, 0.041666666666667
77348, 1.45, 0.625, 0.041666666666667
77349, 1.45, 0.6, 0.020833333333333
77350, 1.4291666666667, 0.6, 0.041666666666667
77351, 1.45, 0.575, 0.041666666666667
77352, 1.45, 0.55, 0.020833333333333
77353, 1.4291666666667, 0.55, 0.041666666666667
77354, 1.45, 0.525, 0.041666666666667
77355, 1.45, 0.5, 0.020833333333333
77356, 1.4291666666667, 0.5, 0.041666666666667
77357, 1.45, 0.475, 0.041666666666667
77358, 1.45, 0.45, 0.020833333333333
77359, 1.4291666666667, 0.45, 0.041666666666667
77360, 1.45, 0.425, 0.041666666666667
77361, 1.45, 0.4, 0.020833333333333
77362, 1.4291666666667, 0.4, 0.041666666666667
77363, 1.45, 0.375, 0.041666666666667
77364, 1.45, 0.35, 0.020833333333333
77365, 1.4291666666667, 0.35, 0.041666666666667
77366, 1.45, 0.325, 0.041666666666667
77367, 1.45, 0.3, 0.020833333333333
77368, 1.4291666666667, 0.3, 0.041666666666667
77369, 1.45, 0.275, 0.041666666666667
77370, 1.45, 0.25, 0.020833333333333
77371, 1.4291666666667, 0.25, 0.041666666666667
77372, 1.45, 0.225, 0.041666666666667
77373, 1.45, 0.2, 0.020833333333333
77374, 1.4291666666667, 0.2, 0.041666666666667
77375, 1.45, 0.175, 0.041666666666667
77376, 1.4916666666667, 1.325, 0.041666666666667
77377, 1.4916666666667, 1.3, 0.020833333333333
77378, 1.4708333333333, 1.3, 0.041666666666667
77379, 1.4916666666667, 1.275, 0.041666666666667
77380, 1.4916666666667, 1.25, 0.020833333333333
77381, 1.4708333333333, 1.25, 0.041666666666667
77382, 1.4916666666667, 1.225, 0.041666666666667
77383, 1.4916666666667, 1.2, 0.020833333333333
77384, 1.4708333333333, 1.2, 0.041666666666667
77385, 1.4916666666667, 1.175, 0.041666666666667
77386, 1.4916666666667, 1.15, 0.020833333333333
77387, 1.4708333333333, 1.15, 0.041666666666667
77388, 1.4916666666667, 1.125, 0.041666666666667
77389, 1.4916666666667, 1.1, 0.020833333333333
77390, 1.4708333333333, 1.1, 0.041666666666667
77391, 1.4916666666667, 1.075, 0.041666666666667
77392, 1.4916666666667, 1.05, 0.020833333333333
77393, 1.4708333333333, 1.05, 0.041666666666667
77394, 1.4916666666667, 1.025, 0.041666666666667
77395, 1.4916666666667, 1, 0.020833333333333
77396, 1.4708333333333, 1, 0.041666666666667
77397, 1.4916666666667, 0.975, 0.041666666666667
77398, 1.4916666666667, 0.95, 0.020833333333333
77399, 1.4708333333333, 0.95, 0.041666666666667
77400, 1.4916666666667, 0.925, 0.041666666666667
77401, 1.4916666666667, 0.9, 0.020833333333333
77402, 1.4708333333333, 0.9, 0.041666666666667
77403, 1.4916666666667, 0.875, 0.041666666666667
77404, 1.4916666666667, 0.85, 0.020833333333333
77405, 1.4708333333333, 0.85, 0.041666666666667
77406, 1.4916666666667, 0.825, 0.041666666666667
77407, 1.4916666666667, 0.8, 0.020833333333333
77408, 1.4708333333333, 0.8, 0.041666666666667
77409, 1.4916666666667, 0.775, 0.041666666666667
77410, 1.4916666666667, 0.75, 0.020833333333333
77411, 1.4708333333333, 0.75, 0.041666666666667
77412, 1.4916666666667, 0.725, 0.041666666666667
77413, 1.4916666666667, 0.7, 0.020833333333333
77414, 1.4708333333333, 0.7, 0.041666666666667
77415, 1.4916666666667, 0.675, 0.041666666666667
77416, 1.4916666666667, 0.65, 0.020833333333333
77417, 1.4708333333333, 0.65, 0.041666666666667
77418, 1.4916666666667, 0.625, 0.041666666666667
77419, 1.4916666666667, 0.6, 0.020833333333333
77420, 1.4708333333333, 0.6, 0.041666666666667
77421, 1.4916666666667, 0.575, 0.041666666666667
77422, 1.4916666666667, 0.55, 0.020833333333333
77423, 1.4708333333333, 0.55, 0.041666666666667
77424, 1.4916666666667, 0.525, 0.041666666666667
77425, 1.4916666666667, 0.5, 0.020833333333333
77426, 1.4708333333333, 0.5, 0.041666666666667
77427, 1.4916666666667, 0.475, 0.041666666666667
77428, 1.4916666666667, 0.45, 0.020833333333333
77429, 1.4708333333333, 0.45, 0.041666666666667
77430, 1.4916666666667, 0.425, 0.041666666666667
77431, 1.4916666666667, 0.4, 0.020833333333333
77432, 1.4708333333333, 0.4, 0.041666666666667
77433, 1.4916666666667, 0.375, 0.041666666666667
77434, 1.4916666666667, 0.35, 0.020833333333333
77435, 1.4708333333333, 0.35, 0.041666666666667
77436, 1.4916666666667, 0.325, 0.041666666666667
77437, 1.4916666666667, 0.3, 0.020833333333333
77438, 1.4708333333333, 0.3, 0.041666666666667
77439, 1.4916666666667, 0.275, 0.041666666666667
77440, 1.4916666666667, 0.25, 0.020833333333333
77441, 1.4708333333333, 0.25, 0.041666666666667
77442, 1.4916666666667, 0.225, 0.041666666666667
77443, 1.4916666666667, 0.2, 0.020833333333333
77444, 1.4708333333333, 0.2, 0.041666666666667
77445, 1.4916666666667, 0.175, 0.041666666666667
77446, 1.5333333333333, 1.325, 0.041666666666667
77447, 1.5333333333333, 1.3, 0.020833333333333
77448, 1.5125, 1.3, 0.041666666666667
77449, 1.5333333333333, 1.275, 0.041666666666667
77450, 1.5333333333333, 1.25, 0.020833333333333
77451, 1.5125, 1.25, 0.041666666666667
77452, 1.5333333333333, 1.225, 0.041666666666667
77453, 1.5333333333333, 1.2, 0.020833333333333
77454, 1.5125, 1.2, 0.041666666666667
77455, 1.5333333333333, 1.175, 0.041666666666667
77456, 1.5333333333333, 1.15, 0.020833333333333
77457, 1.5125, 1.15, 0.041666666666667
77458, 1.5333333333333, 1.125, 0.041666666666667
77459, 1.5333333333333, 1.1, 0.020833333333333
77460, 1.5125, 1.1, 0.041666666666667
77461, 1.5333333333333, 1.075, 0.041666666666667
77462, 1.5333333333333, 1.05, 0.020833333333333
77463, 1.5125, 1.05, 0.041666666666667
77464, 1.5333333333333, 1.025, 0.041666666666667
77465, 1.5333333333333, 1, 0.020833333333333
77466, 1.5125, 1, 0.041666666666667
77467, 1.5333333333333, 0.975, 0.041666666666667
77468, 1.5333333333333, 0.95, 0.020833333333333
77469, 1.5125, 0.95, 0.041666666666667
77470, 1.5333333333333, 0.925, 0.041666666666667
77471, 1.5333333333333, 0.9, 0.020833333333333
77472, 1.5125, 0.9, 0.041666666666667
77473, 1.5333333333333, 0.875, 0.041666666666667
77474, 1.5333333333333, 0.85, 0.020833333333333
77475, 1.5125, 0.85, 0.041666666666667
77476, 1.5333333333333, 0.825, 0.041666666666667
77477, 1.5333333333333, 0.8, 0.020833333333333
77478, 1.5125, 0.8, 0.041666666666667
77479, 1.5333333333333, 0.775, 0.041666666666667
77480, 1.5333333333333, 0.75, 0.020833333333333
77481, 1.5125, 0.75, 0.041666666666667
77482, 1.5333333333333, 0.725, 0.041666666666667
77483, 1.5333333333333, 0.7, 0.020833333333333
77484, 1.5125, 0.7, 0.041666666666667
77485, 1.5333333333333, 0.675, 0.041666666666667
77486, 1.5333333333333, 0.65, 0.020833333333333
77487, 1.5125, 0.65, 0.041666666666667
77488, 1.5333333333333, 0.625, 0.041666666666667
77489, 1.5333333333333, 0.6, 0.020833333333333
77490, 1.5125, 0.6, 0.041666666666667
77491, 1.5333333333333, 0.575, 0.041666666666667
77492, 1.5333333333333, 0.55, 0.020833333333333
77493, 1.5125, 0.55, 0.041666666666667
77494, 1.5333333333333, 0.525, 0.041666666666667
77495, 1.5333333333333, 0.5, 0.020833333333333
77496, 1.5125, 0.5, 0.041666666666667
77497, 1.5333333333333, 0.475, 0.041666666666667
77498, 1.5333333333333, 0.45, 0.020833333333333
77499, 1.5125, 0.45, 0.041666666666667
77500, 1.5333333333333, 0.425, 0.041666666666667
77501, 1.5333333333333, 0.4, 0.020833333333333
77502, 1.5125, 0.4, 0.041666666666667
77503, 1.5333333333333, 0.375, 0.041666666666667
77504, 1.5333333333333, 0.35, 0.020833333333333
77505, 1.5125, 0.35, 0.041666666666667
77506, 1.5333333333333, 0.325, 0.041666666666667
77507, 1.5333333333333, 0.3, 0.020833333333333
77508, 1.5125, 0.3, 0.041666666666667
77509, 1.5333333333333, 0.275, 0.041666666666667
77510, 1.5333333333333, 0.25, 0.020833333333333
77511, 1.5125, 0.25, 0.041666666666667
77512, 1.5333333333333, 0.225, 0.041666666666667
77513, 1.5333333333333, 0.2, 0.020833333333333
77514, 1.5125, 0.2, 0.041666666666667
77515, 1.5333333333333, 0.175, 0.041666666666667
77516, 1.575, 1.325, 0.041666666666667
77517, 1.575, 1.3, 0.020833333333333
77518, 1.5541666666667, 1.3, 0.041666666666667
77519, 1.575, 1.275, 0.041666666666667
77520, 1.575, 1.25, 0.020833333333333
77521, 1.5541666666667, 1.25, 0.041666666666667
77522, 1.575, 1.225, 0.041666666666667
77523, 1.575, 1.2, 0.020833333333333
77524, 1.5541666666667, 1.2, 0.041666666666667
77525, 1.575, 1.175, 0.041666666666667
77526, 1.575, 1.15, 0.020833333333333
77527, 1.5541666666667, 1.15, 0.041666666666667
77528, 1.575, 1.125, 0.041666666666667
77529, 1.575, 1.1, 0.020833333333333
77530, 1.5541666666667, 1.1, 0.041666666666667
77531, 1.575, 1.075, 0.041666666666667
77532, 1.575, 1.05, 0.020833333333333
77533, 1.5541666666667, 1.05, 0.041666666666667
77534, 1.575, 1.025, 0.041666666666667
77535, 1.575, 1, 0.020833333333333
77536, 1.5541666666667, 1, 0.041666666666667
77537, 1.575, 0.975, 0.041666666666667
77538, 1.575, 0.95, 0.020833333333333
77539, 1.5541666666667, 0.95, 0.041666666666667
77540, 1.575, 0.925, 0.041666666666667
77541, 1.575, 0.9, 0.020833333333333
77542, 1.5541666666667, 0.9, 0.041666666666667
77543, 1.575, 0.875, 0.041666666666667
77544, 1.575, 0.85, 0.020833333333333
77545, 1.5541666666667, 0.85, 0.041666666666667
77546, 1.575, 0.825, 0.041666666666667
77547, 1.575, 0.8, 0.020833333333333
77548, 1.5541666666667, 0.8, 0.041666666666667
77549, 1.575, 0.775, 0.041666666666667
77550, 1.575, 0.75, 0.020833333333333
77551, 1.5541666666667, 0.75, 0.041666666666667
77552, 1.575, 0.725, 0.041666666666667
77553, 1.575, 0.7, 0.020833333333333
77554, 1.5541666666667, 0.7, 0.041666666666667
77555, 1.575, 0.675, 0.041666666666667
77556, 1.575, 0.65, 0.020833333333333
77557, 1.5541666666667, 0.65, 0.041666666666667
77558, 1.575, 0.625, 0.041666666666667
77559, 1.575, 0.6, 0.020833333333333
77560, 1.5541666666667, 0.6, 0.041666666666667
77561, 1.575, 0.575, 0.041666666666667
77562, 1.575, 0.55, 0.020833333333333
77563, 1.5541666666667, 0.55, 0.041666666666667
77564, 1.575, 0.525, 0.041666666666667
77565, 1.575, 0.5, 0.020833333333333
77566, 1.5541666666667, 0.5, 0.041666666666667
77567, 1.575, 0.475, 0.041666666666667
77568, 1.575, 0.45, 0.020833333333333
77569, 1.5541666666667, 0.45, 0.041666666666667
77570, 1.575, 0.425, 0.041666666666667
77571, 1.575, 0.4, 0.020833333333333
77572, 1.5541666666667, 0.4, 0.041666666666667
