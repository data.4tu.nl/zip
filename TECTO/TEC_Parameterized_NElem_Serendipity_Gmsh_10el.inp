37159, 100477, 100481, 100525, 100521, 32348, 32349, 32360, 32359, 103427, 103573, 103574, 103560, 32827, 32849, 32850, 
32847, 103415, 103428, 103575, 103562
37160, 14114, 14115, 14126, 14125, 100478, 100482, 100526, 100522, 14594, 14616, 14617, 14614, 103431, 103577, 103578, 
103564, 103416, 103429, 103576, 103563
37161, 100478, 100482, 100526, 100522, 100479, 100483, 100527, 100523, 103431, 103577, 103578, 103564, 103434, 103580, 103581, 
103567, 103419, 103432, 103579, 103566
37162, 100479, 100483, 100527, 100523, 100480, 100484, 100528, 100524, 103434, 103580, 103581, 103567, 103437, 103583, 103584, 
103570, 103422, 103435, 103582, 103569
37163, 100480, 100484, 100528, 100524, 100481, 100485, 100529, 100525, 103437, 103583, 103584, 103570, 103440, 103586, 103587, 
103573, 103425, 103438, 103585, 103572
37164, 100481, 100485, 100529, 100525, 32349, 32350, 32361, 32360, 103440, 103586, 103587, 103573, 32829, 32851, 32852, 
32849, 103428, 103441, 103588, 103575
37165, 14115, 14116, 14127, 14126, 100482, 100486, 100530, 100526, 14596, 14618, 14619, 14616, 103444, 103590, 103591, 
103577, 103429, 103442, 103589, 103576
37166, 100482, 100486, 100530, 100526, 100483, 100487, 100531, 100527, 103444, 103590, 103591, 103577, 103447, 103593, 103594, 
103580, 103432, 103445, 103592, 103579
37167, 100483, 100487, 100531, 100527, 100484, 100488, 100532, 100528, 103447, 103593, 103594, 103580, 103450, 103596, 103597, 
103583, 103435, 103448, 103595, 103582
37168, 100484, 100488, 100532, 100528, 100485, 100489, 100533, 100529, 103450, 103596, 103597, 103583, 103453, 103599, 103600, 
103586, 103438, 103451, 103598, 103585
37169, 100485, 100489, 100533, 100529, 32350, 32351, 32362, 32361, 103453, 103599, 103600, 103586, 32831, 32853, 32854, 
32851, 103441, 103454, 103601, 103588
37170, 14116, 1121, 1122, 14127, 100486, 31765, 31769, 100530, 14597, 1145, 14620, 14618, 103455, 31957, 103602, 
103590, 103442, 31947, 31956, 103589
37171, 100486, 31765, 31769, 100530, 100487, 31766, 31770, 100531, 103455, 31957, 103602, 103590, 103456, 31959, 103603, 
103593, 103445, 31949, 31958, 103592
37172, 100487, 31766, 31770, 100531, 100488, 31767, 31771, 100532, 103456, 31959, 103603, 103593, 103457, 31961, 103604, 
103596, 103448, 31951, 31960, 103595
37173, 100488, 31767, 31771, 100532, 100489, 31768, 31772, 100533, 103457, 31961, 103604, 103596, 103458, 31963, 103605, 
103599, 103451, 31953, 31962, 103598
37174, 100489, 31768, 31772, 100533, 32351, 3303, 3304, 32362, 103458, 31963, 103605, 103599, 32832, 3327, 32855, 
32853, 103454, 31955, 31964, 103601
37175, 1042, 14117, 14128, 1043, 31319, 100490, 100534, 31323, 14599, 14621, 14622, 1066, 103461, 103607, 103608, 
31515, 31507, 103459, 103606, 31516
37176, 31319, 100490, 100534, 31323, 31320, 100491, 100535, 31324, 103461, 103607, 103608, 31515, 103464, 103610, 103611, 
31517, 31509, 103462, 103609, 31518
37177, 31320, 100491, 100535, 31324, 31321, 100492, 100536, 31325, 103464, 103610, 103611, 31517, 103467, 103613, 103614, 
31519, 31511, 103465, 103612, 31520
37178, 31321, 100492, 100536, 31325, 31322, 100493, 100537, 31326, 103467, 103613, 103614, 31519, 103470, 103616, 103617, 
31521, 31513, 103468, 103615, 31522
37179, 31322, 100493, 100537, 31326, 3216, 32352, 32363, 3217, 103470, 103616, 103617, 31521, 32834, 32856, 32857, 
3240, 31514, 103471, 103618, 31523
37180, 14117, 14118, 14129, 14128, 100490, 100494, 100538, 100534, 14601, 14623, 14624, 14621, 103474, 103620, 103621, 
103607, 103459, 103472, 103619, 103606
37181, 100490, 100494, 100538, 100534, 100491, 100495, 100539, 100535, 103474, 103620, 103621, 103607, 103477, 103623, 103624, 
103610, 103462, 103475, 103622, 103609
37182, 100491, 100495, 100539, 100535, 100492, 100496, 100540, 100536, 103477, 103623, 103624, 103610, 103480, 103626, 103627, 
103613, 103465, 103478, 103625, 103612
37183, 100492, 100496, 100540, 100536, 100493, 100497, 100541, 100537, 103480, 103626, 103627, 103613, 103483, 103629, 103630, 
103616, 103468, 103481, 103628, 103615
37184, 100493, 100497, 100541, 100537, 32352, 32353, 32364, 32363, 103483, 103629, 103630, 103616, 32836, 32858, 32859, 
32856, 103471, 103484, 103631, 103618
37185, 14118, 14119, 14130, 14129, 100494, 100498, 100542, 100538, 14603, 14625, 14626, 14623, 103487, 103633, 103634, 
103620, 103472, 103485, 103632, 103619
37186, 100494, 100498, 100542, 100538, 100495, 100499, 100543, 100539, 103487, 103633, 103634, 103620, 103490, 103636, 103637, 
103623, 103475, 103488, 103635, 103622
37187, 100495, 100499, 100543, 100539, 100496, 100500, 100544, 100540, 103490, 103636, 103637, 103623, 103493, 103639, 103640, 
103626, 103478, 103491, 103638, 103625
37188, 100496, 100500, 100544, 100540, 100497, 100501, 100545, 100541, 103493, 103639, 103640, 103626, 103496, 103642, 103643, 
103629, 103481, 103494, 103641, 103628
37189, 100497, 100501, 100545, 100541, 32353, 32354, 32365, 32364, 103496, 103642, 103643, 103629, 32838, 32860, 32861, 
32858, 103484, 103497, 103644, 103631
37190, 14119, 14120, 14131, 14130, 100498, 100502, 100546, 100542, 14605, 14627, 14628, 14625, 103500, 103646, 103647, 
103633, 103485, 103498, 103645, 103632
37191, 100498, 100502, 100546, 100542, 100499, 100503, 100547, 100543, 103500, 103646, 103647, 103633, 103503, 103649, 103650, 
103636, 103488, 103501, 103648, 103635
37192, 100499, 100503, 100547, 100543, 100500, 100504, 100548, 100544, 103503, 103649, 103650, 103636, 103506, 103652, 103653, 
103639, 103491, 103504, 103651, 103638
37193, 100500, 100504, 100548, 100544, 100501, 100505, 100549, 100545, 103506, 103652, 103653, 103639, 103509, 103655, 103656, 
103642, 103494, 103507, 103654, 103641
37194, 100501, 100505, 100549, 100545, 32354, 32355, 32366, 32365, 103509, 103655, 103656, 103642, 32840, 32862, 32863, 
32860, 103497, 103510, 103657, 103644
37195, 14120, 14121, 14132, 14131, 100502, 100506, 100550, 100546, 14607, 14629, 14630, 14627, 103513, 103659, 103660, 
103646, 103498, 103511, 103658, 103645
37196, 100502, 100506, 100550, 100546, 100503, 100507, 100551, 100547, 103513, 103659, 103660, 103646, 103516, 103662, 103663, 
103649, 103501, 103514, 103661, 103648
37197, 100503, 100507, 100551, 100547, 100504, 100508, 100552, 100548, 103516, 103662, 103663, 103649, 103519, 103665, 103666, 
103652, 103504, 103517, 103664, 103651
37198, 100504, 100508, 100552, 100548, 100505, 100509, 100553, 100549, 103519, 103665, 103666, 103652, 103522, 103668, 103669, 
103655, 103507, 103520, 103667, 103654
37199, 100505, 100509, 100553, 100549, 32355, 32356, 32367, 32366, 103522, 103668, 103669, 103655, 32842, 32864, 32865, 
32862, 103510, 103523, 103670, 103657
37200, 14121, 14122, 14133, 14132, 100506, 100510, 100554, 100550, 14609, 14631, 14632, 14629, 103526, 103672, 103673, 
103659, 103511, 103524, 103671, 103658
37201, 100506, 100510, 100554, 100550, 100507, 100511, 100555, 100551, 103526, 103672, 103673, 103659, 103529, 103675, 103676, 
103662, 103514, 103527, 103674, 103661
37202, 100507, 100511, 100555, 100551, 100508, 100512, 100556, 100552, 103529, 103675, 103676, 103662, 103532, 103678, 103679, 
103665, 103517, 103530, 103677, 103664
37203, 100508, 100512, 100556, 100552, 100509, 100513, 100557, 100553, 103532, 103678, 103679, 103665, 103535, 103681, 103682, 
103668, 103520, 103533, 103680, 103667
37204, 100509, 100513, 100557, 100553, 32356, 32357, 32368, 32367, 103535, 103681, 103682, 103668, 32844, 32866, 32867, 
32864, 103523, 103536, 103683, 103670
37205, 14122, 14123, 14134, 14133, 100510, 100514, 100558, 100554, 14611, 14633, 14634, 14631, 103539, 103685, 103686, 
103672, 103524, 103537, 103684, 103671
37206, 100510, 100514, 100558, 100554, 100511, 100515, 100559, 100555, 103539, 103685, 103686, 103672, 103542, 103688, 103689, 
103675, 103527, 103540, 103687, 103674
37207, 100511, 100515, 100559, 100555, 100512, 100516, 100560, 100556, 103542, 103688, 103689, 103675, 103545, 103691, 103692, 
103678, 103530, 103543, 103690, 103677
37208, 100512, 100516, 100560, 100556, 100513, 100517, 100561, 100557, 103545, 103691, 103692, 103678, 103548, 103694, 103695, 
103681, 103533, 103546, 103693, 103680
37209, 100513, 100517, 100561, 100557, 32357, 32358, 32369, 32368, 103548, 103694, 103695, 103681, 32846, 32868, 32869, 
32866, 103536, 103549, 103696, 103683
37210, 14123, 14124, 14135, 14134, 100514, 100518, 100562, 100558, 14613, 14635, 14636, 14633, 103552, 103698, 103699, 
103685, 103537, 103550, 103697, 103684
37211, 100514, 100518, 100562, 100558, 100515, 100519, 100563, 100559, 103552, 103698, 103699, 103685, 103555, 103701, 103702, 
103688, 103540, 103553, 103700, 103687
37212, 100515, 100519, 100563, 100559, 100516, 100520, 100564, 100560, 103555, 103701, 103702, 103688, 103558, 103704, 103705, 
103691, 103543, 103556, 103703, 103690
37213, 100516, 100520, 100564, 100560, 100517, 100521, 100565, 100561, 103558, 103704, 103705, 103691, 103561, 103707, 103708, 
103694, 103546, 103559, 103706, 103693
37214, 100517, 100521, 100565, 100561, 32358, 32359, 32370, 32369, 103561, 103707, 103708, 103694, 32848, 32870, 32871, 
32868, 103549, 103562, 103709, 103696
37215, 14124, 14125, 14136, 14135, 100518, 100522, 100566, 100562, 14615, 14637, 14638, 14635, 103565, 103711, 103712, 
103698, 103550, 103563, 103710, 103697
37216, 100518, 100522, 100566, 100562, 100519, 100523, 100567, 100563, 103565, 103711, 103712, 103698, 103568, 103714, 103715, 
103701, 103553, 103566, 103713, 103700
37217, 100519, 100523, 100567, 100563, 100520, 100524, 100568, 100564, 103568, 103714, 103715, 103701, 103571, 103717, 103718, 
103704, 103556, 103569, 103716, 103703
37218, 100520, 100524, 100568, 100564, 100521, 100525, 100569, 100565, 103571, 103717, 103718, 103704, 103574, 103720, 103721, 
103707, 103559, 103572, 103719, 103706
37219, 100521, 100525, 100569, 100565, 32359, 32360, 32371, 32370, 103574, 103720, 103721, 103707, 32850, 32872, 32873, 
32870, 103562, 103575, 103722, 103709
37220, 14125, 14126, 14137, 14136, 100522, 100526, 100570, 100566, 14617, 14639, 14640, 14637, 103578, 103724, 103725, 
103711, 103563, 103576, 103723, 103710
37221, 100522, 100526, 100570, 100566, 100523, 100527, 100571, 100567, 103578, 103724, 103725, 103711, 103581, 103727, 103728, 
103714, 103566, 103579, 103726, 103713
37222, 100523, 100527, 100571, 100567, 100524, 100528, 100572, 100568, 103581, 103727, 103728, 103714, 103584, 103730, 103731, 
103717, 103569, 103582, 103729, 103716
37223, 100524, 100528, 100572, 100568, 100525, 100529, 100573, 100569, 103584, 103730, 103731, 103717, 103587, 103733, 103734, 
103720, 103572, 103585, 103732, 103719
37224, 100525, 100529, 100573, 100569, 32360, 32361, 32372, 32371, 103587, 103733, 103734, 103720, 32852, 32874, 32875, 
32872, 103575, 103588, 103735, 103722
37225, 14126, 14127, 14138, 14137, 100526, 100530, 100574, 100570, 14619, 14641, 14642, 14639, 103591, 103737, 103738, 
103724, 103576, 103589, 103736, 103723
37226, 100526, 100530, 100574, 100570, 100527, 100531, 100575, 100571, 103591, 103737, 103738, 103724, 103594, 103740, 103741, 
103727, 103579, 103592, 103739, 103726
37227, 100527, 100531, 100575, 100571, 100528, 100532, 100576, 100572, 103594, 103740, 103741, 103727, 103597, 103743, 103744, 
103730, 103582, 103595, 103742, 103729
37228, 100528, 100532, 100576, 100572, 100529, 100533, 100577, 100573, 103597, 103743, 103744, 103730, 103600, 103746, 103747, 
103733, 103585, 103598, 103745, 103732
37229, 100529, 100533, 100577, 100573, 32361, 32362, 32373, 32372, 103600, 103746, 103747, 103733, 32854, 32876, 32877, 
32874, 103588, 103601, 103748, 103735
37230, 14127, 1122, 1123, 14138, 100530, 31769, 31773, 100574, 14620, 1146, 14643, 14641, 103602, 31966, 103749, 
103737, 103589, 31956, 31965, 103736
37231, 100530, 31769, 31773, 100574, 100531, 31770, 31774, 100575, 103602, 31966, 103749, 103737, 103603, 31968, 103750, 
103740, 103592, 31958, 31967, 103739
37232, 100531, 31770, 31774, 100575, 100532, 31771, 31775, 100576, 103603, 31968, 103750, 103740, 103604, 31970, 103751, 
103743, 103595, 31960, 31969, 103742
37233, 100532, 31771, 31775, 100576, 100533, 31772, 31776, 100577, 103604, 31970, 103751, 103743, 103605, 31972, 103752, 
103746, 103598, 31962, 31971, 103745
37234, 100533, 31772, 31776, 100577, 32362, 3304, 3305, 32373, 103605, 31972, 103752, 103746, 32855, 3328, 32878, 
32876, 103601, 31964, 31973, 103748
37235, 1043, 14128, 14139, 1044, 31323, 100534, 100578, 31327, 14622, 14644, 14645, 1067, 103608, 103754, 103755, 
31524, 31516, 103606, 103753, 31525
37236, 31323, 100534, 100578, 31327, 31324, 100535, 100579, 31328, 103608, 103754, 103755, 31524, 103611, 103757, 103758, 
31526, 31518, 103609, 103756, 31527
37237, 31324, 100535, 100579, 31328, 31325, 100536, 100580, 31329, 103611, 103757, 103758, 31526, 103614, 103760, 103761, 
31528, 31520, 103612, 103759, 31529
37238, 31325, 100536, 100580, 31329, 31326, 100537, 100581, 31330, 103614, 103760, 103761, 31528, 103617, 103763, 103764, 
31530, 31522, 103615, 103762, 31531
37239, 31326, 100537, 100581, 31330, 3217, 32363, 32374, 3218, 103617, 103763, 103764, 31530, 32857, 32879, 32880, 
3241, 31523, 103618, 103765, 31532
37240, 14128, 14129, 14140, 14139, 100534, 100538, 100582, 100578, 14624, 14646, 14647, 14644, 103621, 103767, 103768, 
103754, 103606, 103619, 103766, 103753
37241, 100534, 100538, 100582, 100578, 100535, 100539, 100583, 100579, 103621, 103767, 103768, 103754, 103624, 103770, 103771, 
103757, 103609, 103622, 103769, 103756
37242, 100535, 100539, 100583, 100579, 100536, 100540, 100584, 100580, 103624, 103770, 103771, 103757, 103627, 103773, 103774, 
103760, 103612, 103625, 103772, 103759
37243, 100536, 100540, 100584, 100580, 100537, 100541, 100585, 100581, 103627, 103773, 103774, 103760, 103630, 103776, 103777, 
103763, 103615, 103628, 103775, 103762
37244, 100537, 100541, 100585, 100581, 32363, 32364, 32375, 32374, 103630, 103776, 103777, 103763, 32859, 32881, 32882, 
32879, 103618, 103631, 103778, 103765
37245, 14129, 14130, 14141, 14140, 100538, 100542, 100586, 100582, 14626, 14648, 14649, 14646, 103634, 103780, 103781, 
103767, 103619, 103632, 103779, 103766
37246, 100538, 100542, 100586, 100582, 100539, 100543, 100587, 100583, 103634, 103780, 103781, 103767, 103637, 103783, 103784, 
103770, 103622, 103635, 103782, 103769
37247, 100539, 100543, 100587, 100583, 100540, 100544, 100588, 100584, 103637, 103783, 103784, 103770, 103640, 103786, 103787, 
103773, 103625, 103638, 103785, 103772
37248, 100540, 100544, 100588, 100584, 100541, 100545, 100589, 100585, 103640, 103786, 103787, 103773, 103643, 103789, 103790, 
103776, 103628, 103641, 103788, 103775
37249, 100541, 100545, 100589, 100585, 32364, 32365, 32376, 32375, 103643, 103789, 103790, 103776, 32861, 32883, 32884, 
32881, 103631, 103644, 103791, 103778
37250, 14130, 14131, 14142, 14141, 100542, 100546, 100590, 100586, 14628, 14650, 14651, 14648, 103647, 103793, 103794, 
103780, 103632, 103645, 103792, 103779
37251, 100542, 100546, 100590, 100586, 100543, 100547, 100591, 100587, 103647, 103793, 103794, 103780, 103650, 103796, 103797, 
103783, 103635, 103648, 103795, 103782
37252, 100543, 100547, 100591, 100587, 100544, 100548, 100592, 100588, 103650, 103796, 103797, 103783, 103653, 103799, 103800, 
103786, 103638, 103651, 103798, 103785
37253, 100544, 100548, 100592, 100588, 100545, 100549, 100593, 100589, 103653, 103799, 103800, 103786, 103656, 103802, 103803, 
103789, 103641, 103654, 103801, 103788
37254, 100545, 100549, 100593, 100589, 32365, 32366, 32377, 32376, 103656, 103802, 103803, 103789, 32863, 32885, 32886, 
32883, 103644, 103657, 103804, 103791
37255, 14131, 14132, 14143, 14142, 100546, 100550, 100594, 100590, 14630, 14652, 14653, 14650, 103660, 103806, 103807, 
103793, 103645, 103658, 103805, 103792
37256, 100546, 100550, 100594, 100590, 100547, 100551, 100595, 100591, 103660, 103806, 103807, 103793, 103663, 103809, 103810, 
103796, 103648, 103661, 103808, 103795
37257, 100547, 100551, 100595, 100591, 100548, 100552, 100596, 100592, 103663, 103809, 103810, 103796, 103666, 103812, 103813, 
103799, 103651, 103664, 103811, 103798
37258, 100548, 100552, 100596, 100592, 100549, 100553, 100597, 100593, 103666, 103812, 103813, 103799, 103669, 103815, 103816, 
103802, 103654, 103667, 103814, 103801
37259, 100549, 100553, 100597, 100593, 32366, 32367, 32378, 32377, 103669, 103815, 103816, 103802, 32865, 32887, 32888, 
32885, 103657, 103670, 103817, 103804
37260, 14132, 14133, 14144, 14143, 100550, 100554, 100598, 100594, 14632, 14654, 14655, 14652, 103673, 103819, 103820, 
103806, 103658, 103671, 103818, 103805
37261, 100550, 100554, 100598, 100594, 100551, 100555, 100599, 100595, 103673, 103819, 103820, 103806, 103676, 103822, 103823, 
103809, 103661, 103674, 103821, 103808
37262, 100551, 100555, 100599, 100595, 100552, 100556, 100600, 100596, 103676, 103822, 103823, 103809, 103679, 103825, 103826, 
103812, 103664, 103677, 103824, 103811
37263, 100552, 100556, 100600, 100596, 100553, 100557, 100601, 100597, 103679, 103825, 103826, 103812, 103682, 103828, 103829, 
103815, 103667, 103680, 103827, 103814
37264, 100553, 100557, 100601, 100597, 32367, 32368, 32379, 32378, 103682, 103828, 103829, 103815, 32867, 32889, 32890, 
32887, 103670, 103683, 103830, 103817
37265, 14133, 14134, 14145, 14144, 100554, 100558, 100602, 100598, 14634, 14656, 14657, 14654, 103686, 103832, 103833, 
103819, 103671, 103684, 103831, 103818
37266, 100554, 100558, 100602, 100598, 100555, 100559, 100603, 100599, 103686, 103832, 103833, 103819, 103689, 103835, 103836, 
103822, 103674, 103687, 103834, 103821
37267, 100555, 100559, 100603, 100599, 100556, 100560, 100604, 100600, 103689, 103835, 103836, 103822, 103692, 103838, 103839, 
103825, 103677, 103690, 103837, 103824
37268, 100556, 100560, 100604, 100600, 100557, 100561, 100605, 100601, 103692, 103838, 103839, 103825, 103695, 103841, 103842, 
103828, 103680, 103693, 103840, 103827
37269, 100557, 100561, 100605, 100601, 32368, 32369, 32380, 32379, 103695, 103841, 103842, 103828, 32869, 32891, 32892, 
32889, 103683, 103696, 103843, 103830
37270, 14134, 14135, 14146, 14145, 100558, 100562, 100606, 100602, 14636, 14658, 14659, 14656, 103699, 103845, 103846, 
103832, 103684, 103697, 103844, 103831
37271, 100558, 100562, 100606, 100602, 100559, 100563, 100607, 100603, 103699, 103845, 103846, 103832, 103702, 103848, 103849, 
103835, 103687, 103700, 103847, 103834
37272, 100559, 100563, 100607, 100603, 100560, 100564, 100608, 100604, 103702, 103848, 103849, 103835, 103705, 103851, 103852, 
103838, 103690, 103703, 103850, 103837
37273, 100560, 100564, 100608, 100604, 100561, 100565, 100609, 100605, 103705, 103851, 103852, 103838, 103708, 103854, 103855, 
103841, 103693, 103706, 103853, 103840
37274, 100561, 100565, 100609, 100605, 32369, 32370, 32381, 32380, 103708, 103854, 103855, 103841, 32871, 32893, 32894, 
32891, 103696, 103709, 103856, 103843
37275, 14135, 14136, 14147, 14146, 100562, 100566, 100610, 100606, 14638, 14660, 14661, 14658, 103712, 103858, 103859, 
103845, 103697, 103710, 103857, 103844
37276, 100562, 100566, 100610, 100606, 100563, 100567, 100611, 100607, 103712, 103858, 103859, 103845, 103715, 103861, 103862, 
103848, 103700, 103713, 103860, 103847
37277, 100563, 100567, 100611, 100607, 100564, 100568, 100612, 100608, 103715, 103861, 103862, 103848, 103718, 103864, 103865, 
103851, 103703, 103716, 103863, 103850
37278, 100564, 100568, 100612, 100608, 100565, 100569, 100613, 100609, 103718, 103864, 103865, 103851, 103721, 103867, 103868, 
103854, 103706, 103719, 103866, 103853
37279, 100565, 100569, 100613, 100609, 32370, 32371, 32382, 32381, 103721, 103867, 103868, 103854, 32873, 32895, 32896, 
32893, 103709, 103722, 103869, 103856
37280, 14136, 14137, 14148, 14147, 100566, 100570, 100614, 100610, 14640, 14662, 14663, 14660, 103725, 103871, 103872, 
103858, 103710, 103723, 103870, 103857
37281, 100566, 100570, 100614, 100610, 100567, 100571, 100615, 100611, 103725, 103871, 103872, 103858, 103728, 103874, 103875, 
103861, 103713, 103726, 103873, 103860
37282, 100567, 100571, 100615, 100611, 100568, 100572, 100616, 100612, 103728, 103874, 103875, 103861, 103731, 103877, 103878, 
103864, 103716, 103729, 103876, 103863
37283, 100568, 100572, 100616, 100612, 100569, 100573, 100617, 100613, 103731, 103877, 103878, 103864, 103734, 103880, 103881, 
103867, 103719, 103732, 103879, 103866
37284, 100569, 100573, 100617, 100613, 32371, 32372, 32383, 32382, 103734, 103880, 103881, 103867, 32875, 32897, 32898, 
32895, 103722, 103735, 103882, 103869
37285, 14137, 14138, 14149, 14148, 100570, 100574, 100618, 100614, 14642, 14664, 14665, 14662, 103738, 103884, 103885, 
103871, 103723, 103736, 103883, 103870
37286, 100570, 100574, 100618, 100614, 100571, 100575, 100619, 100615, 103738, 103884, 103885, 103871, 103741, 103887, 103888, 
103874, 103726, 103739, 103886, 103873
37287, 100571, 100575, 100619, 100615, 100572, 100576, 100620, 100616, 103741, 103887, 103888, 103874, 103744, 103890, 103891, 
103877, 103729, 103742, 103889, 103876
37288, 100572, 100576, 100620, 100616, 100573, 100577, 100621, 100617, 103744, 103890, 103891, 103877, 103747, 103893, 103894, 
103880, 103732, 103745, 103892, 103879
37289, 100573, 100577, 100621, 100617, 32372, 32373, 32384, 32383, 103747, 103893, 103894, 103880, 32877, 32899, 32900, 
32897, 103735, 103748, 103895, 103882
37290, 14138, 1123, 1124, 14149, 100574, 31773, 31777, 100618, 14643, 1147, 14666, 14664, 103749, 31975, 103896, 
103884, 103736, 31965, 31974, 103883
37291, 100574, 31773, 31777, 100618, 100575, 31774, 31778, 100619, 103749, 31975, 103896, 103884, 103750, 31977, 103897, 
103887, 103739, 31967, 31976, 103886
37292, 100575, 31774, 31778, 100619, 100576, 31775, 31779, 100620, 103750, 31977, 103897, 103887, 103751, 31979, 103898, 
103890, 103742, 31969, 31978, 103889
37293, 100576, 31775, 31779, 100620, 100577, 31776, 31780, 100621, 103751, 31979, 103898, 103890, 103752, 31981, 103899, 
103893, 103745, 31971, 31980, 103892
37294, 100577, 31776, 31780, 100621, 32373, 3305, 3306, 32384, 103752, 31981, 103899, 103893, 32878, 3329, 32901, 
32899, 103748, 31973, 31982, 103895
37295, 1044, 14139, 14150, 1045, 31327, 100578, 100622, 31331, 14645, 14667, 14668, 1068, 103755, 103901, 103902, 
31533, 31525, 103753, 103900, 31534
37296, 31327, 100578, 100622, 31331, 31328, 100579, 100623, 31332, 103755, 103901, 103902, 31533, 103758, 103904, 103905, 
31535, 31527, 103756, 103903, 31536
37297, 31328, 100579, 100623, 31332, 31329, 100580, 100624, 31333, 103758, 103904, 103905, 31535, 103761, 103907, 103908, 
31537, 31529, 103759, 103906, 31538
37298, 31329, 100580, 100624, 31333, 31330, 100581, 100625, 31334, 103761, 103907, 103908, 31537, 103764, 103910, 103911, 
31539, 31531, 103762, 103909, 31540
37299, 31330, 100581, 100625, 31334, 3218, 32374, 32385, 3219, 103764, 103910, 103911, 31539, 32880, 32902, 32903, 
3242, 31532, 103765, 103912, 31541
37300, 14139, 14140, 14151, 14150, 100578, 100582, 100626, 100622, 14647, 14669, 14670, 14667, 103768, 103914, 103915, 
103901, 103753, 103766, 103913, 103900
37301, 100578, 100582, 100626, 100622, 100579, 100583, 100627, 100623, 103768, 103914, 103915, 103901, 103771, 103917, 103918, 
103904, 103756, 103769, 103916, 103903
37302, 100579, 100583, 100627, 100623, 100580, 100584, 100628, 100624, 103771, 103917, 103918, 103904, 103774, 103920, 103921, 
103907, 103759, 103772, 103919, 103906
37303, 100580, 100584, 100628, 100624, 100581, 100585, 100629, 100625, 103774, 103920, 103921, 103907, 103777, 103923, 103924, 
103910, 103762, 103775, 103922, 103909
37304, 100581, 100585, 100629, 100625, 32374, 32375, 32386, 32385, 103777, 103923, 103924, 103910, 32882, 32904, 32905, 
32902, 103765, 103778, 103925, 103912
37305, 14140, 14141, 14152, 14151, 100582, 100586, 100630, 100626, 14649, 14671, 14672, 14669, 103781, 103927, 103928, 
103914, 103766, 103779, 103926, 103913
37306, 100582, 100586, 100630, 100626, 100583, 100587, 100631, 100627, 103781, 103927, 103928, 103914, 103784, 103930, 103931, 
103917, 103769, 103782, 103929, 103916
37307, 100583, 100587, 100631, 100627, 100584, 100588, 100632, 100628, 103784, 103930, 103931, 103917, 103787, 103933, 103934, 
103920, 103772, 103785, 103932, 103919
37308, 100584, 100588, 100632, 100628, 100585, 100589, 100633, 100629, 103787, 103933, 103934, 103920, 103790, 103936, 103937, 
103923, 103775, 103788, 103935, 103922
37309, 100585, 100589, 100633, 100629, 32375, 32376, 32387, 32386, 103790, 103936, 103937, 103923, 32884, 32906, 32907, 
32904, 103778, 103791, 103938, 103925
37310, 14141, 14142, 14153, 14152, 100586, 100590, 100634, 100630, 14651, 14673, 14674, 14671, 103794, 103940, 103941, 
103927, 103779, 103792, 103939, 103926
37311, 100586, 100590, 100634, 100630, 100587, 100591, 100635, 100631, 103794, 103940, 103941, 103927, 103797, 103943, 103944, 
103930, 103782, 103795, 103942, 103929
37312, 100587, 100591, 100635, 100631, 100588, 100592, 100636, 100632, 103797, 103943, 103944, 103930, 103800, 103946, 103947, 
103933, 103785, 103798, 103945, 103932
37313, 100588, 100592, 100636, 100632, 100589, 100593, 100637, 100633, 103800, 103946, 103947, 103933, 103803, 103949, 103950, 
103936, 103788, 103801, 103948, 103935
37314, 100589, 100593, 100637, 100633, 32376, 32377, 32388, 32387, 103803, 103949, 103950, 103936, 32886, 32908, 32909, 
32906, 103791, 103804, 103951, 103938
37315, 14142, 14143, 14154, 14153, 100590, 100594, 100638, 100634, 14653, 14675, 14676, 14673, 103807, 103953, 103954, 
103940, 103792, 103805, 103952, 103939
37316, 100590, 100594, 100638, 100634, 100591, 100595, 100639, 100635, 103807, 103953, 103954, 103940, 103810, 103956, 103957, 
103943, 103795, 103808, 103955, 103942
37317, 100591, 100595, 100639, 100635, 100592, 100596, 100640, 100636, 103810, 103956, 103957, 103943, 103813, 103959, 103960, 
103946, 103798, 103811, 103958, 103945
37318, 100592, 100596, 100640, 100636, 100593, 100597, 100641, 100637, 103813, 103959, 103960, 103946, 103816, 103962, 103963, 
103949, 103801, 103814, 103961, 103948
37319, 100593, 100597, 100641, 100637, 32377, 32378, 32389, 32388, 103816, 103962, 103963, 103949, 32888, 32910, 32911, 
32908, 103804, 103817, 103964, 103951
37320, 14143, 14144, 14155, 14154, 100594, 100598, 100642, 100638, 14655, 14677, 14678, 14675, 103820, 103966, 103967, 
103953, 103805, 103818, 103965, 103952
37321, 100594, 100598, 100642, 100638, 100595, 100599, 100643, 100639, 103820, 103966, 103967, 103953, 103823, 103969, 103970, 
103956, 103808, 103821, 103968, 103955
37322, 100595, 100599, 100643, 100639, 100596, 100600, 100644, 100640, 103823, 103969, 103970, 103956, 103826, 103972, 103973, 
103959, 103811, 103824, 103971, 103958
37323, 100596, 100600, 100644, 100640, 100597, 100601, 100645, 100641, 103826, 103972, 103973, 103959, 103829, 103975, 103976, 
103962, 103814, 103827, 103974, 103961
37324, 100597, 100601, 100645, 100641, 32378, 32379, 32390, 32389, 103829, 103975, 103976, 103962, 32890, 32912, 32913, 
32910, 103817, 103830, 103977, 103964
37325, 14144, 14145, 14156, 14155, 100598, 100602, 100646, 100642, 14657, 14679, 14680, 14677, 103833, 103979, 103980, 
103966, 103818, 103831, 103978, 103965
37326, 100598, 100602, 100646, 100642, 100599, 100603, 100647, 100643, 103833, 103979, 103980, 103966, 103836, 103982, 103983, 
103969, 103821, 103834, 103981, 103968
37327, 100599, 100603, 100647, 100643, 100600, 100604, 100648, 100644, 103836, 103982, 103983, 103969, 103839, 103985, 103986, 
103972, 103824, 103837, 103984, 103971
37328, 100600, 100604, 100648, 100644, 100601, 100605, 100649, 100645, 103839, 103985, 103986, 103972, 103842, 103988, 103989, 
103975, 103827, 103840, 103987, 103974
37329, 100601, 100605, 100649, 100645, 32379, 32380, 32391, 32390, 103842, 103988, 103989, 103975, 32892, 32914, 32915, 
32912, 103830, 103843, 103990, 103977
37330, 14145, 14146, 14157, 14156, 100602, 100606, 100650, 100646, 14659, 14681, 14682, 14679, 103846, 103992, 103993, 
103979, 103831, 103844, 103991, 103978
37331, 100602, 100606, 100650, 100646, 100603, 100607, 100651, 100647, 103846, 103992, 103993, 103979, 103849, 103995, 103996, 
103982, 103834, 103847, 103994, 103981
37332, 100603, 100607, 100651, 100647, 100604, 100608, 100652, 100648, 103849, 103995, 103996, 103982, 103852, 103998, 103999, 
103985, 103837, 103850, 103997, 103984
37333, 100604, 100608, 100652, 100648, 100605, 100609, 100653, 100649, 103852, 103998, 103999, 103985, 103855, 104001, 104002, 
103988, 103840, 103853, 104000, 103987
37334, 100605, 100609, 100653, 100649, 32380, 32381, 32392, 32391, 103855, 104001, 104002, 103988, 32894, 32916, 32917, 
32914, 103843, 103856, 104003, 103990
37335, 14146, 14147, 14158, 14157, 100606, 100610, 100654, 100650, 14661, 14683, 14684, 14681, 103859, 104005, 104006, 
103992, 103844, 103857, 104004, 103991
37336, 100606, 100610, 100654, 100650, 100607, 100611, 100655, 100651, 103859, 104005, 104006, 103992, 103862, 104008, 104009, 
103995, 103847, 103860, 104007, 103994
37337, 100607, 100611, 100655, 100651, 100608, 100612, 100656, 100652, 103862, 104008, 104009, 103995, 103865, 104011, 104012, 
103998, 103850, 103863, 104010, 103997
37338, 100608, 100612, 100656, 100652, 100609, 100613, 100657, 100653, 103865, 104011, 104012, 103998, 103868, 104014, 104015, 
104001, 103853, 103866, 104013, 104000
37339, 100609, 100613, 100657, 100653, 32381, 32382, 32393, 32392, 103868, 104014, 104015, 104001, 32896, 32918, 32919, 
32916, 103856, 103869, 104016, 104003
37340, 14147, 14148, 14159, 14158, 100610, 100614, 100658, 100654, 14663, 14685, 14686, 14683, 103872, 104018, 104019, 
104005, 103857, 103870, 104017, 104004
37341, 100610, 100614, 100658, 100654, 100611, 100615, 100659, 100655, 103872, 104018, 104019, 104005, 103875, 104021, 104022, 
104008, 103860, 103873, 104020, 104007
37342, 100611, 100615, 100659, 100655, 100612, 100616, 100660, 100656, 103875, 104021, 104022, 104008, 103878, 104024, 104025, 
104011, 103863, 103876, 104023, 104010
37343, 100612, 100616, 100660, 100656, 100613, 100617, 100661, 100657, 103878, 104024, 104025, 104011, 103881, 104027, 104028, 
104014, 103866, 103879, 104026, 104013
37344, 100613, 100617, 100661, 100657, 32382, 32383, 32394, 32393, 103881, 104027, 104028, 104014, 32898, 32920, 32921, 
32918, 103869, 103882, 104029, 104016
37345, 14148, 14149, 14160, 14159, 100614, 100618, 100662, 100658, 14665, 14687, 14688, 14685, 103885, 104031, 104032, 
104018, 103870, 103883, 104030, 104017
37346, 100614, 100618, 100662, 100658, 100615, 100619, 100663, 100659, 103885, 104031, 104032, 104018, 103888, 104034, 104035, 
104021, 103873, 103886, 104033, 104020
37347, 100615, 100619, 100663, 100659, 100616, 100620, 100664, 100660, 103888, 104034, 104035, 104021, 103891, 104037, 104038, 
104024, 103876, 103889, 104036, 104023
37348, 100616, 100620, 100664, 100660, 100617, 100621, 100665, 100661, 103891, 104037, 104038, 104024, 103894, 104040, 104041, 
104027, 103879, 103892, 104039, 104026
37349, 100617, 100621, 100665, 100661, 32383, 32384, 32395, 32394, 103894, 104040, 104041, 104027, 32900, 32922, 32923, 
32920, 103882, 103895, 104042, 104029
37350, 14149, 1124, 1125, 14160, 100618, 31777, 31781, 100662, 14666, 1148, 14689, 14687, 103896, 31984, 104043, 
104031, 103883, 31974, 31983, 104030
37351, 100618, 31777, 31781, 100662, 100619, 31778, 31782, 100663, 103896, 31984, 104043, 104031, 103897, 31986, 104044, 
104034, 103886, 31976, 31985, 104033
37352, 100619, 31778, 31782, 100663, 100620, 31779, 31783, 100664, 103897, 31986, 104044, 104034, 103898, 31988, 104045, 
104037, 103889, 31978, 31987, 104036
37353, 100620, 31779, 31783, 100664, 100621, 31780, 31784, 100665, 103898, 31988, 104045, 104037, 103899, 31990, 104046, 
104040, 103892, 31980, 31989, 104039
37354, 100621, 31780, 31784, 100665, 32384, 3306, 3307, 32395, 103899, 31990, 104046, 104040, 32901, 3330, 32924, 
32922, 103895, 31982, 31991, 104042
37355, 1045, 14150, 1075, 21, 31331, 100622, 31546, 3179, 14668, 14690, 1086, 1069, 103902, 104047, 31590, 
31542, 31534, 103900, 31591, 3183
37356, 31331, 100622, 31546, 3179, 31332, 100623, 31547, 3180, 103902, 104047, 31590, 31542, 103905, 104048, 31592, 
31543, 31536, 103903, 31593, 3184
37357, 31332, 100623, 31547, 3180, 31333, 100624, 31548, 3181, 103905, 104048, 31592, 31543, 103908, 104049, 31594, 
31544, 31538, 103906, 31595, 3185
37358, 31333, 100624, 31548, 3181, 31334, 100625, 31549, 3182, 103908, 104049, 31594, 31544, 103911, 104050, 31596, 
31545, 31540, 103909, 31597, 3186
37359, 31334, 100625, 31549, 3182, 3219, 32385, 3253, 77, 103911, 104050, 31596, 31545, 32903, 32925, 3264, 
3243, 31541, 103912, 31598, 3187
37360, 14150, 14151, 1076, 1075, 100622, 100626, 31550, 31546, 14670, 14691, 1087, 14690, 103915, 104051, 31599, 
104047, 103900, 103913, 31600, 31591
37361, 100622, 100626, 31550, 31546, 100623, 100627, 31551, 31547, 103915, 104051, 31599, 104047, 103918, 104052, 31601, 
104048, 103903, 103916, 31602, 31593
37362, 100623, 100627, 31551, 31547, 100624, 100628, 31552, 31548, 103918, 104052, 31601, 104048, 103921, 104053, 31603, 
104049, 103906, 103919, 31604, 31595
37363, 100624, 100628, 31552, 31548, 100625, 100629, 31553, 31549, 103921, 104053, 31603, 104049, 103924, 104054, 31605, 
104050, 103909, 103922, 31606, 31597
37364, 100625, 100629, 31553, 31549, 32385, 32386, 3254, 3253, 103924, 104054, 31605, 104050, 32905, 32926, 3265, 
32925, 103912, 103925, 31607, 31598
37365, 14151, 14152, 1077, 1076, 100626, 100630, 31554, 31550, 14672, 14692, 1088, 14691, 103928, 104055, 31608, 
104051, 103913, 103926, 31609, 31600
37366, 100626, 100630, 31554, 31550, 100627, 100631, 31555, 31551, 103928, 104055, 31608, 104051, 103931, 104056, 31610, 
104052, 103916, 103929, 31611, 31602
37367, 100627, 100631, 31555, 31551, 100628, 100632, 31556, 31552, 103931, 104056, 31610, 104052, 103934, 104057, 31612, 
104053, 103919, 103932, 31613, 31604
37368, 100628, 100632, 31556, 31552, 100629, 100633, 31557, 31553, 103934, 104057, 31612, 104053, 103937, 104058, 31614, 
104054, 103922, 103935, 31615, 31606
37369, 100629, 100633, 31557, 31553, 32386, 32387, 3255, 3254, 103937, 104058, 31614, 104054, 32907, 32927, 3266, 
32926, 103925, 103938, 31616, 31607
37370, 14152, 14153, 1078, 1077, 100630, 100634, 31558, 31554, 14674, 14693, 1089, 14692, 103941, 104059, 31617, 
104055, 103926, 103939, 31618, 31609
37371, 100630, 100634, 31558, 31554, 100631, 100635, 31559, 31555, 103941, 104059, 31617, 104055, 103944, 104060, 31619, 
104056, 103929, 103942, 31620, 31611
37372, 100631, 100635, 31559, 31555, 100632, 100636, 31560, 31556, 103944, 104060, 31619, 104056, 103947, 104061, 31621, 
104057, 103932, 103945, 31622, 31613
37373, 100632, 100636, 31560, 31556, 100633, 100637, 31561, 31557, 103947, 104061, 31621, 104057, 103950, 104062, 31623, 
104058, 103935, 103948, 31624, 31615
37374, 100633, 100637, 31561, 31557, 32387, 32388, 3256, 3255, 103950, 104062, 31623, 104058, 32909, 32928, 3267, 
32927, 103938, 103951, 31625, 31616
37375, 14153, 14154, 1079, 1078, 100634, 100638, 31562, 31558, 14676, 14694, 1090, 14693, 103954, 104063, 31626, 
104059, 103939, 103952, 31627, 31618
37376, 100634, 100638, 31562, 31558, 100635, 100639, 31563, 31559, 103954, 104063, 31626, 104059, 103957, 104064, 31628, 
104060, 103942, 103955, 31629, 31620
37377, 100635, 100639, 31563, 31559, 100636, 100640, 31564, 31560, 103957, 104064, 31628, 104060, 103960, 104065, 31630, 
104061, 103945, 103958, 31631, 31622
37378, 100636, 100640, 31564, 31560, 100637, 100641, 31565, 31561, 103960, 104065, 31630, 104061, 103963, 104066, 31632, 
104062, 103948, 103961, 31633, 31624
37379, 100637, 100641, 31565, 31561, 32388, 32389, 3257, 3256, 103963, 104066, 31632, 104062, 32911, 32929, 3268, 
32928, 103951, 103964, 31634, 31625
37380, 14154, 14155, 1080, 1079, 100638, 100642, 31566, 31562, 14678, 14695, 1091, 14694, 103967, 104067, 31635, 
104063, 103952, 103965, 31636, 31627
37381, 100638, 100642, 31566, 31562, 100639, 100643, 31567, 31563, 103967, 104067, 31635, 104063, 103970, 104068, 31637, 
104064, 103955, 103968, 31638, 31629
37382, 100639, 100643, 31567, 31563, 100640, 100644, 31568, 31564, 103970, 104068, 31637, 104064, 103973, 104069, 31639, 
104065, 103958, 103971, 31640, 31631
37383, 100640, 100644, 31568, 31564, 100641, 100645, 31569, 31565, 103973, 104069, 31639, 104065, 103976, 104070, 31641, 
104066, 103961, 103974, 31642, 31633
37384, 100641, 100645, 31569, 31565, 32389, 32390, 3258, 3257, 103976, 104070, 31641, 104066, 32913, 32930, 3269, 
32929, 103964, 103977, 31643, 31634
37385, 14155, 14156, 1081, 1080, 100642, 100646, 31570, 31566, 14680, 14696, 1092, 14695, 103980, 104071, 31644, 
104067, 103965, 103978, 31645, 31636
37386, 100642, 100646, 31570, 31566, 100643, 100647, 31571, 31567, 103980, 104071, 31644, 104067, 103983, 104072, 31646, 
104068, 103968, 103981, 31647, 31638
37387, 100643, 100647, 31571, 31567, 100644, 100648, 31572, 31568, 103983, 104072, 31646, 104068, 103986, 104073, 31648, 
104069, 103971, 103984, 31649, 31640
37388, 100644, 100648, 31572, 31568, 100645, 100649, 31573, 31569, 103986, 104073, 31648, 104069, 103989, 104074, 31650, 
104070, 103974, 103987, 31651, 31642
37389, 100645, 100649, 31573, 31569, 32390, 32391, 3259, 3258, 103989, 104074, 31650, 104070, 32915, 32931, 3270, 
32930, 103977, 103990, 31652, 31643
37390, 14156, 14157, 1082, 1081, 100646, 100650, 31574, 31570, 14682, 14697, 1093, 14696, 103993, 104075, 31653, 
104071, 103978, 103991, 31654, 31645
37391, 100646, 100650, 31574, 31570, 100647, 100651, 31575, 31571, 103993, 104075, 31653, 104071, 103996, 104076, 31655, 
104072, 103981, 103994, 31656, 31647
37392, 100647, 100651, 31575, 31571, 100648, 100652, 31576, 31572, 103996, 104076, 31655, 104072, 103999, 104077, 31657, 
104073, 103984, 103997, 31658, 31649
37393, 100648, 100652, 31576, 31572, 100649, 100653, 31577, 31573, 103999, 104077, 31657, 104073, 104002, 104078, 31659, 
104074, 103987, 104000, 31660, 31651
37394, 100649, 100653, 31577, 31573, 32391, 32392, 3260, 3259, 104002, 104078, 31659, 104074, 32917, 32932, 3271, 
32931, 103990, 104003, 31661, 31652
37395, 14157, 14158, 1083, 1082, 100650, 100654, 31578, 31574, 14684, 14698, 1094, 14697, 104006, 104079, 31662, 
104075, 103991, 104004, 31663, 31654
37396, 100650, 100654, 31578, 31574, 100651, 100655, 31579, 31575, 104006, 104079, 31662, 104075, 104009, 104080, 31664, 
104076, 103994, 104007, 31665, 31656
37397, 100651, 100655, 31579, 31575, 100652, 100656, 31580, 31576, 104009, 104080, 31664, 104076, 104012, 104081, 31666, 
104077, 103997, 104010, 31667, 31658
37398, 100652, 100656, 31580, 31576, 100653, 100657, 31581, 31577, 104012, 104081, 31666, 104077, 104015, 104082, 31668, 
104078, 104000, 104013, 31669, 31660
37399, 100653, 100657, 31581, 31577, 32392, 32393, 3261, 3260, 104015, 104082, 31668, 104078, 32919, 32933, 3272, 
32932, 104003, 104016, 31670, 31661
37400, 14158, 14159, 1084, 1083, 100654, 100658, 31582, 31578, 14686, 14699, 1095, 14698, 104019, 104083, 31671, 
104079, 104004, 104017, 31672, 31663
37401, 100654, 100658, 31582, 31578, 100655, 100659, 31583, 31579, 104019, 104083, 31671, 104079, 104022, 104084, 31673, 
104080, 104007, 104020, 31674, 31665
37402, 100655, 100659, 31583, 31579, 100656, 100660, 31584, 31580, 104022, 104084, 31673, 104080, 104025, 104085, 31675, 
104081, 104010, 104023, 31676, 31667
37403, 100656, 100660, 31584, 31580, 100657, 100661, 31585, 31581, 104025, 104085, 31675, 104081, 104028, 104086, 31677, 
104082, 104013, 104026, 31678, 31669
37404, 100657, 100661, 31585, 31581, 32393, 32394, 3262, 3261, 104028, 104086, 31677, 104082, 32921, 32934, 3273, 
32933, 104016, 104029, 31679, 31670
37405, 14159, 14160, 1085, 1084, 100658, 100662, 31586, 31582, 14688, 14700, 1096, 14699, 104032, 104087, 31680, 
104083, 104017, 104030, 31681, 31672
37406, 100658, 100662, 31586, 31582, 100659, 100663, 31587, 31583, 104032, 104087, 31680, 104083, 104035, 104088, 31682, 
104084, 104020, 104033, 31683, 31674
37407, 100659, 100663, 31587, 31583, 100660, 100664, 31588, 31584, 104035, 104088, 31682, 104084, 104038, 104089, 31684, 
104085, 104023, 104036, 31685, 31676
37408, 100660, 100664, 31588, 31584, 100661, 100665, 31589, 31585, 104038, 104089, 31684, 104085, 104041, 104090, 31686, 
104086, 104026, 104039, 31687, 31678
37409, 100661, 100665, 31589, 31585, 32394, 32395, 3263, 3262, 104041, 104090, 31686, 104086, 32923, 32935, 3274, 
32934, 104029, 104042, 31688, 31679
37410, 14160, 1125, 23, 1085, 100662, 31781, 3244, 31586, 14689, 1149, 1097, 14700, 104043, 31992, 31689, 
104087, 104030, 31983, 3248, 31681
37411, 100662, 31781, 3244, 31586, 100663, 31782, 3245, 31587, 104043, 31992, 31689, 104087, 104044, 31993, 31690, 
104088, 104033, 31985, 3249, 31683
37412, 100663, 31782, 3245, 31587, 100664, 31783, 3246, 31588, 104044, 31993, 31690, 104088, 104045, 31994, 31691, 
104089, 104036, 31987, 3250, 31685
37413, 100664, 31783, 3246, 31588, 100665, 31784, 3247, 31589, 104045, 31994, 31691, 104089, 104046, 31995, 31692, 
104090, 104039, 31989, 3251, 31687
37414, 100665, 31784, 3247, 31589, 32395, 3307, 79, 3263, 104046, 31995, 31692, 104090, 32924, 3331, 3275, 
32935, 104042, 31991, 3252, 31688
*ELEMENT, type=C3D20, ELSET=Volume21
37415, 21, 1075, 14908, 1205, 3179, 31546, 104091, 32992, 1086, 14952, 14953, 1209, 31590, 104268, 104269, 
33008, 3183, 31591, 104267, 33009
37416, 3179, 31546, 104091, 32992, 3180, 31547, 104092, 32993, 31590, 104268, 104269, 33008, 31592, 104271, 104272, 
33010, 3184, 31593, 104270, 33011
37417, 3180, 31547, 104092, 32993, 3181, 31548, 104093, 32994, 31592, 104271, 104272, 33010, 31594, 104274, 104275, 
33012, 3185, 31595, 104273, 33013
37418, 3181, 31548, 104093, 32994, 3182, 31549, 104094, 32995, 31594, 104274, 104275, 33012, 31596, 104277, 104278, 
33014, 3186, 31597, 104276, 33015
37419, 3182, 31549, 104094, 32995, 77, 3253, 33195, 3382, 31596, 104277, 104278, 33014, 3264, 33239, 33240, 
3386, 3187, 31598, 104279, 33016
37420, 1205, 14908, 14909, 1206, 32992, 104091, 104095, 32996, 14953, 14954, 14955, 1210, 104269, 104281, 104282, 
33017, 33009, 104267, 104280, 33018
37421, 32992, 104091, 104095, 32996, 32993, 104092, 104096, 32997, 104269, 104281, 104282, 33017, 104272, 104284, 104285, 
33019, 33011, 104270, 104283, 33020
37422, 32993, 104092, 104096, 32997, 32994, 104093, 104097, 32998, 104272, 104284, 104285, 33019, 104275, 104287, 104288, 
33021, 33013, 104273, 104286, 33022
37423, 32994, 104093, 104097, 32998, 32995, 104094, 104098, 32999, 104275, 104287, 104288, 33021, 104278, 104290, 104291, 
33023, 33015, 104276, 104289, 33024
37424, 32995, 104094, 104098, 32999, 3382, 33195, 33196, 3383, 104278, 104290, 104291, 33023, 33240, 33241, 33242, 
3387, 33016, 104279, 104292, 33025
37425, 1206, 14909, 14910, 1207, 32996, 104095, 104099, 33000, 14955, 14956, 14957, 1211, 104282, 104294, 104295, 
33026, 33018, 104280, 104293, 33027
37426, 32996, 104095, 104099, 33000, 32997, 104096, 104100, 33001, 104282, 104294, 104295, 33026, 104285, 104297, 104298, 
33028, 33020, 104283, 104296, 33029
37427, 32997, 104096, 104100, 33001, 32998, 104097, 104101, 33002, 104285, 104297, 104298, 33028, 104288, 104300, 104301, 
33030, 33022, 104286, 104299, 33031
37428, 32998, 104097, 104101, 33002, 32999, 104098, 104102, 33003, 104288, 104300, 104301, 33030, 104291, 104303, 104304, 
33032, 33024, 104289, 104302, 33033
37429, 32999, 104098, 104102, 33003, 3383, 33196, 33197, 3384, 104291, 104303, 104304, 33032, 33242, 33243, 33244, 
3388, 33025, 104292, 104305, 33034
37430, 1207, 14910, 14911, 1208, 33000, 104099, 104103, 33004, 14957, 14958, 14959, 1212, 104295, 104307, 104308, 
33035, 33027, 104293, 104306, 33036
37431, 33000, 104099, 104103, 33004, 33001, 104100, 104104, 33005, 104295, 104307, 104308, 33035, 104298, 104310, 104311, 
33037, 33029, 104296, 104309, 33038
37432, 33001, 104100, 104104, 33005, 33002, 104101, 104105, 33006, 104298, 104310, 104311, 33037, 104301, 104313, 104314, 
33039, 33031, 104299, 104312, 33040
37433, 33002, 104101, 104105, 33006, 33003, 104102, 104106, 33007, 104301, 104313, 104314, 33039, 104304, 104316, 104317, 
33041, 33033, 104302, 104315, 33042
37434, 33003, 104102, 104106, 33007, 3384, 33197, 33198, 3385, 104304, 104316, 104317, 33041, 33244, 33245, 33246, 
3389, 33034, 104305, 104318, 33043
37435, 1208, 14911, 1242, 28, 33004, 104103, 33048, 3373, 14959, 14960, 1253, 1213, 104308, 104319, 33092, 
33044, 33036, 104306, 33093, 3377
37436, 33004, 104103, 33048, 3373, 33005, 104104, 33049, 3374, 104308, 104319, 33092, 33044, 104311, 104320, 33094, 
33045, 33038, 104309, 33095, 3378
37437, 33005, 104104, 33049, 3374, 33006, 104105, 33050, 3375, 104311, 104320, 33094, 33045, 104314, 104321, 33096, 
33046, 33040, 104312, 33097, 3379
37438, 33006, 104105, 33050, 3375, 33007, 104106, 33051, 3376, 104314, 104321, 33096, 33046, 104317, 104322, 33098, 
33047, 33042, 104315, 33099, 3380
37439, 33007, 104106, 33051, 3376, 3385, 33198, 3391, 82, 104317, 104322, 33098, 33047, 33246, 33247, 3402, 
3390, 33043, 104318, 33100, 3381
37440, 1075, 1076, 14912, 14908, 31546, 31550, 104107, 104091, 1087, 14961, 14962, 14952, 31599, 104324, 104325, 
104268, 31591, 31600, 104323, 104267
37441, 31546, 31550, 104107, 104091, 31547, 31551, 104108, 104092, 31599, 104324, 104325, 104268, 31601, 104327, 104328, 
104271, 31593, 31602, 104326, 104270
37442, 31547, 31551, 104108, 104092, 31548, 31552, 104109, 104093, 31601, 104327, 104328, 104271, 31603, 104330, 104331, 
104274, 31595, 31604, 104329, 104273
37443, 31548, 31552, 104109, 104093, 31549, 31553, 104110, 104094, 31603, 104330, 104331, 104274, 31605, 104333, 104334, 
104277, 31597, 31606, 104332, 104276
37444, 31549, 31553, 104110, 104094, 3253, 3254, 33199, 33195, 31605, 104333, 104334, 104277, 3265, 33248, 33249, 
33239, 31598, 31607, 104335, 104279
37445, 14908, 14912, 14913, 14909, 104091, 104107, 104111, 104095, 14962, 14963, 14964, 14954, 104325, 104337, 104338, 
104281, 104267, 104323, 104336, 104280
37446, 104091, 104107, 104111, 104095, 104092, 104108, 104112, 104096, 104325, 104337, 104338, 104281, 104328, 104340, 104341, 
104284, 104270, 104326, 104339, 104283
37447, 104092, 104108, 104112, 104096, 104093, 104109, 104113, 104097, 104328, 104340, 104341, 104284, 104331, 104343, 104344, 
104287, 104273, 104329, 104342, 104286
37448, 104093, 104109, 104113, 104097, 104094, 104110, 104114, 104098, 104331, 104343, 104344, 104287, 104334, 104346, 104347, 
104290, 104276, 104332, 104345, 104289
37449, 104094, 104110, 104114, 104098, 33195, 33199, 33200, 33196, 104334, 104346, 104347, 104290, 33249, 33250, 33251, 
33241, 104279, 104335, 104348, 104292
37450, 14909, 14913, 14914, 14910, 104095, 104111, 104115, 104099, 14964, 14965, 14966, 14956, 104338, 104350, 104351, 
104294, 104280, 104336, 104349, 104293
37451, 104095, 104111, 104115, 104099, 104096, 104112, 104116, 104100, 104338, 104350, 104351, 104294, 104341, 104353, 104354, 
104297, 104283, 104339, 104352, 104296
37452, 104096, 104112, 104116, 104100, 104097, 104113, 104117, 104101, 104341, 104353, 104354, 104297, 104344, 104356, 104357, 
104300, 104286, 104342, 104355, 104299
37453, 104097, 104113, 104117, 104101, 104098, 104114, 104118, 104102, 104344, 104356, 104357, 104300, 104347, 104359, 104360, 
104303, 104289, 104345, 104358, 104302
37454, 104098, 104114, 104118, 104102, 33196, 33200, 33201, 33197, 104347, 104359, 104360, 104303, 33251, 33252, 33253, 
33243, 104292, 104348, 104361, 104305
37455, 14910, 14914, 14915, 14911, 104099, 104115, 104119, 104103, 14966, 14967, 14968, 14958, 104351, 104363, 104364, 
104307, 104293, 104349, 104362, 104306
37456, 104099, 104115, 104119, 104103, 104100, 104116, 104120, 104104, 104351, 104363, 104364, 104307, 104354, 104366, 104367, 
104310, 104296, 104352, 104365, 104309
37457, 104100, 104116, 104120, 104104, 104101, 104117, 104121, 104105, 104354, 104366, 104367, 104310, 104357, 104369, 104370, 
104313, 104299, 104355, 104368, 104312
37458, 104101, 104117, 104121, 104105, 104102, 104118, 104122, 104106, 104357, 104369, 104370, 104313, 104360, 104372, 104373, 
104316, 104302, 104358, 104371, 104315
37459, 104102, 104118, 104122, 104106, 33197, 33201, 33202, 33198, 104360, 104372, 104373, 104316, 33253, 33254, 33255, 
33245, 104305, 104361, 104374, 104318
37460, 14911, 14915, 1243, 1242, 104103, 104119, 33052, 33048, 14968, 14969, 1254, 14960, 104364, 104375, 33101, 
104319, 104306, 104362, 33102, 33093
37461, 104103, 104119, 33052, 33048, 104104, 104120, 33053, 33049, 104364, 104375, 33101, 104319, 104367, 104376, 33103, 
104320, 104309, 104365, 33104, 33095
37462, 104104, 104120, 33053, 33049, 104105, 104121, 33054, 33050, 104367, 104376, 33103, 104320, 104370, 104377, 33105, 
104321, 104312, 104368, 33106, 33097
37463, 104105, 104121, 33054, 33050, 104106, 104122, 33055, 33051, 104370, 104377, 33105, 104321, 104373, 104378, 33107, 
104322, 104315, 104371, 33108, 33099
37464, 104106, 104122, 33055, 33051, 33198, 33202, 3392, 3391, 104373, 104378, 33107, 104322, 33255, 33256, 3403, 
33247, 104318, 104374, 33109, 33100
37465, 1076, 1077, 14916, 14912, 31550, 31554, 104123, 104107, 1088, 14970, 14971, 14961, 31608, 104380, 104381, 
104324, 31600, 31609, 104379, 104323
37466, 31550, 31554, 104123, 104107, 31551, 31555, 104124, 104108, 31608, 104380, 104381, 104324, 31610, 104383, 104384, 
104327, 31602, 31611, 104382, 104326
37467, 31551, 31555, 104124, 104108, 31552, 31556, 104125, 104109, 31610, 104383, 104384, 104327, 31612, 104386, 104387, 
104330, 31604, 31613, 104385, 104329
37468, 31552, 31556, 104125, 104109, 31553, 31557, 104126, 104110, 31612, 104386, 104387, 104330, 31614, 104389, 104390, 
104333, 31606, 31615, 104388, 104332
37469, 31553, 31557, 104126, 104110, 3254, 3255, 33203, 33199, 31614, 104389, 104390, 104333, 3266, 33257, 33258, 
33248, 31607, 31616, 104391, 104335
37470, 14912, 14916, 14917, 14913, 104107, 104123, 104127, 104111, 14971, 14972, 14973, 14963, 104381, 104393, 104394, 
104337, 104323, 104379, 104392, 104336
37471, 104107, 104123, 104127, 104111, 104108, 104124, 104128, 104112, 104381, 104393, 104394, 104337, 104384, 104396, 104397, 
104340, 104326, 104382, 104395, 104339
37472, 104108, 104124, 104128, 104112, 104109, 104125, 104129, 104113, 104384, 104396, 104397, 104340, 104387, 104399, 104400, 
104343, 104329, 104385, 104398, 104342
37473, 104109, 104125, 104129, 104113, 104110, 104126, 104130, 104114, 104387, 104399, 104400, 104343, 104390, 104402, 104403, 
104346, 104332, 104388, 104401, 104345
37474, 104110, 104126, 104130, 104114, 33199, 33203, 33204, 33200, 104390, 104402, 104403, 104346, 33258, 33259, 33260, 
33250, 104335, 104391, 104404, 104348
37475, 14913, 14917, 14918, 14914, 104111, 104127, 104131, 104115, 14973, 14974, 14975, 14965, 104394, 104406, 104407, 
104350, 104336, 104392, 104405, 104349
37476, 104111, 104127, 104131, 104115, 104112, 104128, 104132, 104116, 104394, 104406, 104407, 104350, 104397, 104409, 104410, 
104353, 104339, 104395, 104408, 104352
37477, 104112, 104128, 104132, 104116, 104113, 104129, 104133, 104117, 104397, 104409, 104410, 104353, 104400, 104412, 104413, 
104356, 104342, 104398, 104411, 104355
37478, 104113, 104129, 104133, 104117, 104114, 104130, 104134, 104118, 104400, 104412, 104413, 104356, 104403, 104415, 104416, 
104359, 104345, 104401, 104414, 104358
37479, 104114, 104130, 104134, 104118, 33200, 33204, 33205, 33201, 104403, 104415, 104416, 104359, 33260, 33261, 33262, 
33252, 104348, 104404, 104417, 104361
37480, 14914, 14918, 14919, 14915, 104115, 104131, 104135, 104119, 14975, 14976, 14977, 14967, 104407, 104419, 104420, 
104363, 104349, 104405, 104418, 104362
37481, 104115, 104131, 104135, 104119, 104116, 104132, 104136, 104120, 104407, 104419, 104420, 104363, 104410, 104422, 104423, 
104366, 104352, 104408, 104421, 104365
37482, 104116, 104132, 104136, 104120, 104117, 104133, 104137, 104121, 104410, 104422, 104423, 104366, 104413, 104425, 104426, 
104369, 104355, 104411, 104424, 104368
37483, 104117, 104133, 104137, 104121, 104118, 104134, 104138, 104122, 104413, 104425, 104426, 104369, 104416, 104428, 104429, 
104372, 104358, 104414, 104427, 104371
37484, 104118, 104134, 104138, 104122, 33201, 33205, 33206, 33202, 104416, 104428, 104429, 104372, 33262, 33263, 33264, 
33254, 104361, 104417, 104430, 104374
37485, 14915, 14919, 1244, 1243, 104119, 104135, 33056, 33052, 14977, 14978, 1255, 14969, 104420, 104431, 33110, 
104375, 104362, 104418, 33111, 33102
37486, 104119, 104135, 33056, 33052, 104120, 104136, 33057, 33053, 104420, 104431, 33110, 104375, 104423, 104432, 33112, 
104376, 104365, 104421, 33113, 33104
37487, 104120, 104136, 33057, 33053, 104121, 104137, 33058, 33054, 104423, 104432, 33112, 104376, 104426, 104433, 33114, 
104377, 104368, 104424, 33115, 33106
37488, 104121, 104137, 33058, 33054, 104122, 104138, 33059, 33055, 104426, 104433, 33114, 104377, 104429, 104434, 33116, 
104378, 104371, 104427, 33117, 33108
37489, 104122, 104138, 33059, 33055, 33202, 33206, 3393, 3392, 104429, 104434, 33116, 104378, 33264, 33265, 3404, 
33256, 104374, 104430, 33118, 33109
37490, 1077, 1078, 14920, 14916, 31554, 31558, 104139, 104123, 1089, 14979, 14980, 14970, 31617, 104436, 104437, 
104380, 31609, 31618, 104435, 104379
37491, 31554, 31558, 104139, 104123, 31555, 31559, 104140, 104124, 31617, 104436, 104437, 104380, 31619, 104439, 104440, 
104383, 31611, 31620, 104438, 104382
37492, 31555, 31559, 104140, 104124, 31556, 31560, 104141, 104125, 31619, 104439, 104440, 104383, 31621, 104442, 104443, 
104386, 31613, 31622, 104441, 104385
37493, 31556, 31560, 104141, 104125, 31557, 31561, 104142, 104126, 31621, 104442, 104443, 104386, 31623, 104445, 104446, 
104389, 31615, 31624, 104444, 104388
37494, 31557, 31561, 104142, 104126, 3255, 3256, 33207, 33203, 31623, 104445, 104446, 104389, 3267, 33266, 33267, 
33257, 31616, 31625, 104447, 104391
37495, 14916, 14920, 14921, 14917, 104123, 104139, 104143, 104127, 14980, 14981, 14982, 14972, 104437, 104449, 104450, 
104393, 104379, 104435, 104448, 104392
37496, 104123, 104139, 104143, 104127, 104124, 104140, 104144, 104128, 104437, 104449, 104450, 104393, 104440, 104452, 104453, 
104396, 104382, 104438, 104451, 104395
37497, 104124, 104140, 104144, 104128, 104125, 104141, 104145, 104129, 104440, 104452, 104453, 104396, 104443, 104455, 104456, 
104399, 104385, 104441, 104454, 104398
37498, 104125, 104141, 104145, 104129, 104126, 104142, 104146, 104130, 104443, 104455, 104456, 104399, 104446, 104458, 104459, 
104402, 104388, 104444, 104457, 104401
37499, 104126, 104142, 104146, 104130, 33203, 33207, 33208, 33204, 104446, 104458, 104459, 104402, 33267, 33268, 33269, 
33259, 104391, 104447, 104460, 104404
37500, 14917, 14921, 14922, 14918, 104127, 104143, 104147, 104131, 14982, 14983, 14984, 14974, 104450, 104462, 104463, 
104406, 104392, 104448, 104461, 104405
37501, 104127, 104143, 104147, 104131, 104128, 104144, 104148, 104132, 104450, 104462, 104463, 104406, 104453, 104465, 104466, 
104409, 104395, 104451, 104464, 104408
37502, 104128, 104144, 104148, 104132, 104129, 104145, 104149, 104133, 104453, 104465, 104466, 104409, 104456, 104468, 104469, 
104412, 104398, 104454, 104467, 104411
37503, 104129, 104145, 104149, 104133, 104130, 104146, 104150, 104134, 104456, 104468, 104469, 104412, 104459, 104471, 104472, 
104415, 104401, 104457, 104470, 104414
37504, 104130, 104146, 104150, 104134, 33204, 33208, 33209, 33205, 104459, 104471, 104472, 104415, 33269, 33270, 33271, 
33261, 104404, 104460, 104473, 104417
37505, 14918, 14922, 14923, 14919, 104131, 104147, 104151, 104135, 14984, 14985, 14986, 14976, 104463, 104475, 104476, 
104419, 104405, 104461, 104474, 104418
37506, 104131, 104147, 104151, 104135, 104132, 104148, 104152, 104136, 104463, 104475, 104476, 104419, 104466, 104478, 104479, 
104422, 104408, 104464, 104477, 104421
37507, 104132, 104148, 104152, 104136, 104133, 104149, 104153, 104137, 104466, 104478, 104479, 104422, 104469, 104481, 104482, 
104425, 104411, 104467, 104480, 104424
37508, 104133, 104149, 104153, 104137, 104134, 104150, 104154, 104138, 104469, 104481, 104482, 104425, 104472, 104484, 104485, 
104428, 104414, 104470, 104483, 104427
37509, 104134, 104150, 104154, 104138, 33205, 33209, 33210, 33206, 104472, 104484, 104485, 104428, 33271, 33272, 33273, 
33263, 104417, 104473, 104486, 104430
37510, 14919, 14923, 1245, 1244, 104135, 104151, 33060, 33056, 14986, 14987, 1256, 14978, 104476, 104487, 33119, 
104431, 104418, 104474, 33120, 33111
37511, 104135, 104151, 33060, 33056, 104136, 104152, 33061, 33057, 104476, 104487, 33119, 104431, 104479, 104488, 33121, 
104432, 104421, 104477, 33122, 33113
37512, 104136, 104152, 33061, 33057, 104137, 104153, 33062, 33058, 104479, 104488, 33121, 104432, 104482, 104489, 33123, 
104433, 104424, 104480, 33124, 33115
37513, 104137, 104153, 33062, 33058, 104138, 104154, 33063, 33059, 104482, 104489, 33123, 104433, 104485, 104490, 33125, 
104434, 104427, 104483, 33126, 33117
37514, 104138, 104154, 33063, 33059, 33206, 33210, 3394, 3393, 104485, 104490, 33125, 104434, 33273, 33274, 3405, 
33265, 104430, 104486, 33127, 33118
37515, 1078, 1079, 14924, 14920, 31558, 31562, 104155, 104139, 1090, 14988, 14989, 14979, 31626, 104492, 104493, 
104436, 31618, 31627, 104491, 104435
37516, 31558, 31562, 104155, 104139, 31559, 31563, 104156, 104140, 31626, 104492, 104493, 104436, 31628, 104495, 104496, 
104439, 31620, 31629, 104494, 104438
37517, 31559, 31563, 104156, 104140, 31560, 31564, 104157, 104141, 31628, 104495, 104496, 104439, 31630, 104498, 104499, 
104442, 31622, 31631, 104497, 104441
37518, 31560, 31564, 104157, 104141, 31561, 31565, 104158, 104142, 31630, 104498, 104499, 104442, 31632, 104501, 104502, 
104445, 31624, 31633, 104500, 104444
37519, 31561, 31565, 104158, 104142, 3256, 3257, 33211, 33207, 31632, 104501, 104502, 104445, 3268, 33275, 33276, 
33266, 31625, 31634, 104503, 104447
37520, 14920, 14924, 14925, 14921, 104139, 104155, 104159, 104143, 14989, 14990, 14991, 14981, 104493, 104505, 104506, 
104449, 104435, 104491, 104504, 104448
37521, 104139, 104155, 104159, 104143, 104140, 104156, 104160, 104144, 104493, 104505, 104506, 104449, 104496, 104508, 104509, 
104452, 104438, 104494, 104507, 104451
37522, 104140, 104156, 104160, 104144, 104141, 104157, 104161, 104145, 104496, 104508, 104509, 104452, 104499, 104511, 104512, 
104455, 104441, 104497, 104510, 104454
37523, 104141, 104157, 104161, 104145, 104142, 104158, 104162, 104146, 104499, 104511, 104512, 104455, 104502, 104514, 104515, 
104458, 104444, 104500, 104513, 104457
37524, 104142, 104158, 104162, 104146, 33207, 33211, 33212, 33208, 104502, 104514, 104515, 104458, 33276, 33277, 33278, 
33268, 104447, 104503, 104516, 104460
37525, 14921, 14925, 14926, 14922, 104143, 104159, 104163, 104147, 14991, 14992, 14993, 14983, 104506, 104518, 104519, 
104462, 104448, 104504, 104517, 104461
37526, 104143, 104159, 104163, 104147, 104144, 104160, 104164, 104148, 104506, 104518, 104519, 104462, 104509, 104521, 104522, 
104465, 104451, 104507, 104520, 104464
37527, 104144, 104160, 104164, 104148, 104145, 104161, 104165, 104149, 104509, 104521, 104522, 104465, 104512, 104524, 104525, 
104468, 104454, 104510, 104523, 104467
37528, 104145, 104161, 104165, 104149, 104146, 104162, 104166, 104150, 104512, 104524, 104525, 104468, 104515, 104527, 104528, 
104471, 104457, 104513, 104526, 104470
37529, 104146, 104162, 104166, 104150, 33208, 33212, 33213, 33209, 104515, 104527, 104528, 104471, 33278, 33279, 33280, 
33270, 104460, 104516, 104529, 104473
37530, 14922, 14926, 14927, 14923, 104147, 104163, 104167, 104151, 14993, 14994, 14995, 14985, 104519, 104531, 104532, 
104475, 104461, 104517, 104530, 104474
37531, 104147, 104163, 104167, 104151, 104148, 104164, 104168, 104152, 104519, 104531, 104532, 104475, 104522, 104534, 104535, 
104478, 104464, 104520, 104533, 104477
37532, 104148, 104164, 104168, 104152, 104149, 104165, 104169, 104153, 104522, 104534, 104535, 104478, 104525, 104537, 104538, 
104481, 104467, 104523, 104536, 104480
37533, 104149, 104165, 104169, 104153, 104150, 104166, 104170, 104154, 104525, 104537, 104538, 104481, 104528, 104540, 104541, 
104484, 104470, 104526, 104539, 104483
37534, 104150, 104166, 104170, 104154, 33209, 33213, 33214, 33210, 104528, 104540, 104541, 104484, 33280, 33281, 33282, 
33272, 104473, 104529, 104542, 104486
37535, 14923, 14927, 1246, 1245, 104151, 104167, 33064, 33060, 14995, 14996, 1257, 14987, 104532, 104543, 33128, 
104487, 104474, 104530, 33129, 33120
37536, 104151, 104167, 33064, 33060, 104152, 104168, 33065, 33061, 104532, 104543, 33128, 104487, 104535, 104544, 33130, 
104488, 104477, 104533, 33131, 33122
37537, 104152, 104168, 33065, 33061, 104153, 104169, 33066, 33062, 104535, 104544, 33130, 104488, 104538, 104545, 33132, 
104489, 104480, 104536, 33133, 33124
37538, 104153, 104169, 33066, 33062, 104154, 104170, 33067, 33063, 104538, 104545, 33132, 104489, 104541, 104546, 33134, 
104490, 104483, 104539, 33135, 33126
37539, 104154, 104170, 33067, 33063, 33210, 33214, 3395, 3394, 104541, 104546, 33134, 104490, 33282, 33283, 3406, 
33274, 104486, 104542, 33136, 33127
37540, 1079, 1080, 14928, 14924, 31562, 31566, 104171, 104155, 1091, 14997, 14998, 14988, 31635, 104548, 104549, 
104492, 31627, 31636, 104547, 104491
37541, 31562, 31566, 104171, 104155, 31563, 31567, 104172, 104156, 31635, 104548, 104549, 104492, 31637, 104551, 104552, 
104495, 31629, 31638, 104550, 104494
37542, 31563, 31567, 104172, 104156, 31564, 31568, 104173, 104157, 31637, 104551, 104552, 104495, 31639, 104554, 104555, 
104498, 31631, 31640, 104553, 104497
37543, 31564, 31568, 104173, 104157, 31565, 31569, 104174, 104158, 31639, 104554, 104555, 104498, 31641, 104557, 104558, 
104501, 31633, 31642, 104556, 104500
37544, 31565, 31569, 104174, 104158, 3257, 3258, 33215, 33211, 31641, 104557, 104558, 104501, 3269, 33284, 33285, 
33275, 31634, 31643, 104559, 104503
37545, 14924, 14928, 14929, 14925, 104155, 104171, 104175, 104159, 14998, 14999, 15000, 14990, 104549, 104561, 104562, 
104505, 104491, 104547, 104560, 104504
37546, 104155, 104171, 104175, 104159, 104156, 104172, 104176, 104160, 104549, 104561, 104562, 104505, 104552, 104564, 104565, 
104508, 104494, 104550, 104563, 104507
37547, 104156, 104172, 104176, 104160, 104157, 104173, 104177, 104161, 104552, 104564, 104565, 104508, 104555, 104567, 104568, 
104511, 104497, 104553, 104566, 104510
37548, 104157, 104173, 104177, 104161, 104158, 104174, 104178, 104162, 104555, 104567, 104568, 104511, 104558, 104570, 104571, 
104514, 104500, 104556, 104569, 104513
37549, 104158, 104174, 104178, 104162, 33211, 33215, 33216, 33212, 104558, 104570, 104571, 104514, 33285, 33286, 33287, 
33277, 104503, 104559, 104572, 104516
37550, 14925, 14929, 14930, 14926, 104159, 104175, 104179, 104163, 15000, 15001, 15002, 14992, 104562, 104574, 104575, 
104518, 104504, 104560, 104573, 104517
37551, 104159, 104175, 104179, 104163, 104160, 104176, 104180, 104164, 104562, 104574, 104575, 104518, 104565, 104577, 104578, 
104521, 104507, 104563, 104576, 104520
37552, 104160, 104176, 104180, 104164, 104161, 104177, 104181, 104165, 104565, 104577, 104578, 104521, 104568, 104580, 104581, 
104524, 104510, 104566, 104579, 104523
37553, 104161, 104177, 104181, 104165, 104162, 104178, 104182, 104166, 104568, 104580, 104581, 104524, 104571, 104583, 104584, 
104527, 104513, 104569, 104582, 104526
37554, 104162, 104178, 104182, 104166, 33212, 33216, 33217, 33213, 104571, 104583, 104584, 104527, 33287, 33288, 33289, 
33279, 104516, 104572, 104585, 104529
37555, 14926, 14930, 14931, 14927, 104163, 104179, 104183, 104167, 15002, 15003, 15004, 14994, 104575, 104587, 104588, 
104531, 104517, 104573, 104586, 104530
37556, 104163, 104179, 104183, 104167, 104164, 104180, 104184, 104168, 104575, 104587, 104588, 104531, 104578, 104590, 104591, 
104534, 104520, 104576, 104589, 104533
37557, 104164, 104180, 104184, 104168, 104165, 104181, 104185, 104169, 104578, 104590, 104591, 104534, 104581, 104593, 104594, 
104537, 104523, 104579, 104592, 104536
37558, 104165, 104181, 104185, 104169, 104166, 104182, 104186, 104170, 104581, 104593, 104594, 104537, 104584, 104596, 104597, 
104540, 104526, 104582, 104595, 104539
37559, 104166, 104182, 104186, 104170, 33213, 33217, 33218, 33214, 104584, 104596, 104597, 104540, 33289, 33290, 33291, 
33281, 104529, 104585, 104598, 104542
37560, 14927, 14931, 1247, 1246, 104167, 104183, 33068, 33064, 15004, 15005, 1258, 14996, 104588, 104599, 33137, 
104543, 104530, 104586, 33138, 33129
37561, 104167, 104183, 33068, 33064, 104168, 104184, 33069, 33065, 104588, 104599, 33137, 104543, 104591, 104600, 33139, 
104544, 104533, 104589, 33140, 33131
37562, 104168, 104184, 33069, 33065, 104169, 104185, 33070, 33066, 104591, 104600, 33139, 104544, 104594, 104601, 33141, 
104545, 104536, 104592, 33142, 33133
37563, 104169, 104185, 33070, 33066, 104170, 104186, 33071, 33067, 104594, 104601, 33141, 104545, 104597, 104602, 33143, 
104546, 104539, 104595, 33144, 33135
37564, 104170, 104186, 33071, 33067, 33214, 33218, 3396, 3395, 104597, 104602, 33143, 104546, 33291, 33292, 3407, 
33283, 104542, 104598, 33145, 33136
37565, 1080, 1081, 14932, 14928, 31566, 31570, 104187, 104171, 1092, 15006, 15007, 14997, 31644, 104604, 104605, 
104548, 31636, 31645, 104603, 104547
37566, 31566, 31570, 104187, 104171, 31567, 31571, 104188, 104172, 31644, 104604, 104605, 104548, 31646, 104607, 104608, 
104551, 31638, 31647, 104606, 104550
37567, 31567, 31571, 104188, 104172, 31568, 31572, 104189, 104173, 31646, 104607, 104608, 104551, 31648, 104610, 104611, 
104554, 31640, 31649, 104609, 104553
37568, 31568, 31572, 104189, 104173, 31569, 31573, 104190, 104174, 31648, 104610, 104611, 104554, 31650, 104613, 104614, 
104557, 31642, 31651, 104612, 104556
37569, 31569, 31573, 104190, 104174, 3258, 3259, 33219, 33215, 31650, 104613, 104614, 104557, 3270, 33293, 33294, 
33284, 31643, 31652, 104615, 104559
37570, 14928, 14932, 14933, 14929, 104171, 104187, 104191, 104175, 15007, 15008, 15009, 14999, 104605, 104617, 104618, 
104561, 104547, 104603, 104616, 104560
37571, 104171, 104187, 104191, 104175, 104172, 104188, 104192, 104176, 104605, 104617, 104618, 104561, 104608, 104620, 104621, 
104564, 104550, 104606, 104619, 104563
37572, 104172, 104188, 104192, 104176, 104173, 104189, 104193, 104177, 104608, 104620, 104621, 104564, 104611, 104623, 104624, 
104567, 104553, 104609, 104622, 104566
37573, 104173, 104189, 104193, 104177, 104174, 104190, 104194, 104178, 104611, 104623, 104624, 104567, 104614, 104626, 104627, 
104570, 104556, 104612, 104625, 104569
37574, 104174, 104190, 104194, 104178, 33215, 33219, 33220, 33216, 104614, 104626, 104627, 104570, 33294, 33295, 33296, 
33286, 104559, 104615, 104628, 104572
37575, 14929, 14933, 14934, 14930, 104175, 104191, 104195, 104179, 15009, 15010, 15011, 15001, 104618, 104630, 104631, 
104574, 104560, 104616, 104629, 104573
37576, 104175, 104191, 104195, 104179, 104176, 104192, 104196, 104180, 104618, 104630, 104631, 104574, 104621, 104633, 104634, 
104577, 104563, 104619, 104632, 104576
37577, 104176, 104192, 104196, 104180, 104177, 104193, 104197, 104181, 104621, 104633, 104634, 104577, 104624, 104636, 104637, 
104580, 104566, 104622, 104635, 104579
37578, 104177, 104193, 104197, 104181, 104178, 104194, 104198, 104182, 104624, 104636, 104637, 104580, 104627, 104639, 104640, 
104583, 104569, 104625, 104638, 104582
37579, 104178, 104194, 104198, 104182, 33216, 33220, 33221, 33217, 104627, 104639, 104640, 104583, 33296, 33297, 33298, 
33288, 104572, 104628, 104641, 104585
37580, 14930, 14934, 14935, 14931, 104179, 104195, 104199, 104183, 15011, 15012, 15013, 15003, 104631, 104643, 104644, 
104587, 104573, 104629, 104642, 104586
37581, 104179, 104195, 104199, 104183, 104180, 104196, 104200, 104184, 104631, 104643, 104644, 104587, 104634, 104646, 104647, 
104590, 104576, 104632, 104645, 104589
37582, 104180, 104196, 104200, 104184, 104181, 104197, 104201, 104185, 104634, 104646, 104647, 104590, 104637, 104649, 104650, 
104593, 104579, 104635, 104648, 104592
37583, 104181, 104197, 104201, 104185, 104182, 104198, 104202, 104186, 104637, 104649, 104650, 104593, 104640, 104652, 104653, 
104596, 104582, 104638, 104651, 104595
37584, 104182, 104198, 104202, 104186, 33217, 33221, 33222, 33218, 104640, 104652, 104653, 104596, 33298, 33299, 33300, 
33290, 104585, 104641, 104654, 104598
37585, 14931, 14935, 1248, 1247, 104183, 104199, 33072, 33068, 15013, 15014, 1259, 15005, 104644, 104655, 33146, 
104599, 104586, 104642, 33147, 33138
37586, 104183, 104199, 33072, 33068, 104184, 104200, 33073, 33069, 104644, 104655, 33146, 104599, 104647, 104656, 33148, 
104600, 104589, 104645, 33149, 33140
37587, 104184, 104200, 33073, 33069, 104185, 104201, 33074, 33070, 104647, 104656, 33148, 104600, 104650, 104657, 33150, 
104601, 104592, 104648, 33151, 33142
37588, 104185, 104201, 33074, 33070, 104186, 104202, 33075, 33071, 104650, 104657, 33150, 104601, 104653, 104658, 33152, 
104602, 104595, 104651, 33153, 33144
37589, 104186, 104202, 33075, 33071, 33218, 33222, 3397, 3396, 104653, 104658, 33152, 104602, 33300, 33301, 3408, 
33292, 104598, 104654, 33154, 33145
37590, 1081, 1082, 14936, 14932, 31570, 31574, 104203, 104187, 1093, 15015, 15016, 15006, 31653, 104660, 104661, 
104604, 31645, 31654, 104659, 104603
37591, 31570, 31574, 104203, 104187, 31571, 31575, 104204, 104188, 31653, 104660, 104661, 104604, 31655, 104663, 104664, 
104607, 31647, 31656, 104662, 104606
37592, 31571, 31575, 104204, 104188, 31572, 31576, 104205, 104189, 31655, 104663, 104664, 104607, 31657, 104666, 104667, 
104610, 31649, 31658, 104665, 104609
37593, 31572, 31576, 104205, 104189, 31573, 31577, 104206, 104190, 31657, 104666, 104667, 104610, 31659, 104669, 104670, 
104613, 31651, 31660, 104668, 104612
37594, 31573, 31577, 104206, 104190, 3259, 3260, 33223, 33219, 31659, 104669, 104670, 104613, 3271, 33302, 33303, 
33293, 31652, 31661, 104671, 104615
37595, 14932, 14936, 14937, 14933, 104187, 104203, 104207, 104191, 15016, 15017, 15018, 15008, 104661, 104673, 104674, 
104617, 104603, 104659, 104672, 104616
37596, 104187, 104203, 104207, 104191, 104188, 104204, 104208, 104192, 104661, 104673, 104674, 104617, 104664, 104676, 104677, 
104620, 104606, 104662, 104675, 104619
37597, 104188, 104204, 104208, 104192, 104189, 104205, 104209, 104193, 104664, 104676, 104677, 104620, 104667, 104679, 104680, 
104623, 104609, 104665, 104678, 104622
37598, 104189, 104205, 104209, 104193, 104190, 104206, 104210, 104194, 104667, 104679, 104680, 104623, 104670, 104682, 104683, 
104626, 104612, 104668, 104681, 104625
37599, 104190, 104206, 104210, 104194, 33219, 33223, 33224, 33220, 104670, 104682, 104683, 104626, 33303, 33304, 33305, 
33295, 104615, 104671, 104684, 104628
37600, 14933, 14937, 14938, 14934, 104191, 104207, 104211, 104195, 15018, 15019, 15020, 15010, 104674, 104686, 104687, 
104630, 104616, 104672, 104685, 104629
37601, 104191, 104207, 104211, 104195, 104192, 104208, 104212, 104196, 104674, 104686, 104687, 104630, 104677, 104689, 104690, 
104633, 104619, 104675, 104688, 104632
37602, 104192, 104208, 104212, 104196, 104193, 104209, 104213, 104197, 104677, 104689, 104690, 104633, 104680, 104692, 104693, 
104636, 104622, 104678, 104691, 104635
37603, 104193, 104209, 104213, 104197, 104194, 104210, 104214, 104198, 104680, 104692, 104693, 104636, 104683, 104695, 104696, 
104639, 104625, 104681, 104694, 104638
37604, 104194, 104210, 104214, 104198, 33220, 33224, 33225, 33221, 104683, 104695, 104696, 104639, 33305, 33306, 33307, 
33297, 104628, 104684, 104697, 104641
37605, 14934, 14938, 14939, 14935, 104195, 104211, 104215, 104199, 15020, 15021, 15022, 15012, 104687, 104699, 104700, 
104643, 104629, 104685, 104698, 104642
37606, 104195, 104211, 104215, 104199, 104196, 104212, 104216, 104200, 104687, 104699, 104700, 104643, 104690, 104702, 104703, 
104646, 104632, 104688, 104701, 104645
37607, 104196, 104212, 104216, 104200, 104197, 104213, 104217, 104201, 104690, 104702, 104703, 104646, 104693, 104705, 104706, 
104649, 104635, 104691, 104704, 104648
37608, 104197, 104213, 104217, 104201, 104198, 104214, 104218, 104202, 104693, 104705, 104706, 104649, 104696, 104708, 104709, 
104652, 104638, 104694, 104707, 104651
37609, 104198, 104214, 104218, 104202, 33221, 33225, 33226, 33222, 104696, 104708, 104709, 104652, 33307, 33308, 33309, 
33299, 104641, 104697, 104710, 104654
37610, 14935, 14939, 1249, 1248, 104199, 104215, 33076, 33072, 15022, 15023, 1260, 15014, 104700, 104711, 33155, 
104655, 104642, 104698, 33156, 33147
37611, 104199, 104215, 33076, 33072, 104200, 104216, 33077, 33073, 104700, 104711, 33155, 104655, 104703, 104712, 33157, 
104656, 104645, 104701, 33158, 33149
37612, 104200, 104216, 33077, 33073, 104201, 104217, 33078, 33074, 104703, 104712, 33157, 104656, 104706, 104713, 33159, 
104657, 104648, 104704, 33160, 33151
37613, 104201, 104217, 33078, 33074, 104202, 104218, 33079, 33075, 104706, 104713, 33159, 104657, 104709, 104714, 33161, 
104658, 104651, 104707, 33162, 33153
37614, 104202, 104218, 33079, 33075, 33222, 33226, 3398, 3397, 104709, 104714, 33161, 104658, 33309, 33310, 3409, 
33301, 104654, 104710, 33163, 33154
37615, 1082, 1083, 14940, 14936, 31574, 31578, 104219, 104203, 1094, 15024, 15025, 15015, 31662, 104716, 104717, 
104660, 31654, 31663, 104715, 104659
37616, 31574, 31578, 104219, 104203, 31575, 31579, 104220, 104204, 31662, 104716, 104717, 104660, 31664, 104719, 104720, 
104663, 31656, 31665, 104718, 104662
37617, 31575, 31579, 104220, 104204, 31576, 31580, 104221, 104205, 31664, 104719, 104720, 104663, 31666, 104722, 104723, 
104666, 31658, 31667, 104721, 104665
37618, 31576, 31580, 104221, 104205, 31577, 31581, 104222, 104206, 31666, 104722, 104723, 104666, 31668, 104725, 104726, 
104669, 31660, 31669, 104724, 104668
37619, 31577, 31581, 104222, 104206, 3260, 3261, 33227, 33223, 31668, 104725, 104726, 104669, 3272, 33311, 33312, 
33302, 31661, 31670, 104727, 104671
37620, 14936, 14940, 14941, 14937, 104203, 104219, 104223, 104207, 15025, 15026, 15027, 15017, 104717, 104729, 104730, 
104673, 104659, 104715, 104728, 104672
37621, 104203, 104219, 104223, 104207, 104204, 104220, 104224, 104208, 104717, 104729, 104730, 104673, 104720, 104732, 104733, 
104676, 104662, 104718, 104731, 104675
37622, 104204, 104220, 104224, 104208, 104205, 104221, 104225, 104209, 104720, 104732, 104733, 104676, 104723, 104735, 104736, 
104679, 104665, 104721, 104734, 104678
37623, 104205, 104221, 104225, 104209, 104206, 104222, 104226, 104210, 104723, 104735, 104736, 104679, 104726, 104738, 104739, 
104682, 104668, 104724, 104737, 104681
37624, 104206, 104222, 104226, 104210, 33223, 33227, 33228, 33224, 104726, 104738, 104739, 104682, 33312, 33313, 33314, 
33304, 104671, 104727, 104740, 104684
37625, 14937, 14941, 14942, 14938, 104207, 104223, 104227, 104211, 15027, 15028, 15029, 15019, 104730, 104742, 104743, 
104686, 104672, 104728, 104741, 104685
37626, 104207, 104223, 104227, 104211, 104208, 104224, 104228, 104212, 104730, 104742, 104743, 104686, 104733, 104745, 104746, 
104689, 104675, 104731, 104744, 104688
37627, 104208, 104224, 104228, 104212, 104209, 104225, 104229, 104213, 104733, 104745, 104746, 104689, 104736, 104748, 104749, 
104692, 104678, 104734, 104747, 104691
37628, 104209, 104225, 104229, 104213, 104210, 104226, 104230, 104214, 104736, 104748, 104749, 104692, 104739, 104751, 104752, 
104695, 104681, 104737, 104750, 104694
37629, 104210, 104226, 104230, 104214, 33224, 33228, 33229, 33225, 104739, 104751, 104752, 104695, 33314, 33315, 33316, 
33306, 104684, 104740, 104753, 104697
37630, 14938, 14942, 14943, 14939, 104211, 104227, 104231, 104215, 15029, 15030, 15031, 15021, 104743, 104755, 104756, 
104699, 104685, 104741, 104754, 104698
37631, 104211, 104227, 104231, 104215, 104212, 104228, 104232, 104216, 104743, 104755, 104756, 104699, 104746, 104758, 104759, 
104702, 104688, 104744, 104757, 104701
37632, 104212, 104228, 104232, 104216, 104213, 104229, 104233, 104217, 104746, 104758, 104759, 104702, 104749, 104761, 104762, 
104705, 104691, 104747, 104760, 104704
37633, 104213, 104229, 104233, 104217, 104214, 104230, 104234, 104218, 104749, 104761, 104762, 104705, 104752, 104764, 104765, 
104708, 104694, 104750, 104763, 104707
37634, 104214, 104230, 104234, 104218, 33225, 33229, 33230, 33226, 104752, 104764, 104765, 104708, 33316, 33317, 33318, 
33308, 104697, 104753, 104766, 104710
37635, 14939, 14943, 1250, 1249, 104215, 104231, 33080, 33076, 15031, 15032, 1261, 15023, 104756, 104767, 33164, 
104711, 104698, 104754, 33165, 33156
37636, 104215, 104231, 33080, 33076, 104216, 104232, 33081, 33077, 104756, 104767, 33164, 104711, 104759, 104768, 33166, 
104712, 104701, 104757, 33167, 33158
37637, 104216, 104232, 33081, 33077, 104217, 104233, 33082, 33078, 104759, 104768, 33166, 104712, 104762, 104769, 33168, 
104713, 104704, 104760, 33169, 33160
37638, 104217, 104233, 33082, 33078, 104218, 104234, 33083, 33079, 104762, 104769, 33168, 104713, 104765, 104770, 33170, 
104714, 104707, 104763, 33171, 33162
37639, 104218, 104234, 33083, 33079, 33226, 33230, 3399, 3398, 104765, 104770, 33170, 104714, 33318, 33319, 3410, 
33310, 104710, 104766, 33172, 33163
37640, 1083, 1084, 14944, 14940, 31578, 31582, 104235, 104219, 1095, 15033, 15034, 15024, 31671, 104772, 104773, 
104716, 31663, 31672, 104771, 104715
37641, 31578, 31582, 104235, 104219, 31579, 31583, 104236, 104220, 31671, 104772, 104773, 104716, 31673, 104775, 104776, 
104719, 31665, 31674, 104774, 104718
37642, 31579, 31583, 104236, 104220, 31580, 31584, 104237, 104221, 31673, 104775, 104776, 104719, 31675, 104778, 104779, 
104722, 31667, 31676, 104777, 104721
37643, 31580, 31584, 104237, 104221, 31581, 31585, 104238, 104222, 31675, 104778, 104779, 104722, 31677, 104781, 104782, 
104725, 31669, 31678, 104780, 104724
37644, 31581, 31585, 104238, 104222, 3261, 3262, 33231, 33227, 31677, 104781, 104782, 104725, 3273, 33320, 33321, 
33311, 31670, 31679, 104783, 104727
37645, 14940, 14944, 14945, 14941, 104219, 104235, 104239, 104223, 15034, 15035, 15036, 15026, 104773, 104785, 104786, 
104729, 104715, 104771, 104784, 104728
37646, 104219, 104235, 104239, 104223, 104220, 104236, 104240, 104224, 104773, 104785, 104786, 104729, 104776, 104788, 104789, 
104732, 104718, 104774, 104787, 104731
37647, 104220, 104236, 104240, 104224, 104221, 104237, 104241, 104225, 104776, 104788, 104789, 104732, 104779, 104791, 104792, 
104735, 104721, 104777, 104790, 104734
37648, 104221, 104237, 104241, 104225, 104222, 104238, 104242, 104226, 104779, 104791, 104792, 104735, 104782, 104794, 104795, 
104738, 104724, 104780, 104793, 104737
37649, 104222, 104238, 104242, 104226, 33227, 33231, 33232, 33228, 104782, 104794, 104795, 104738, 33321, 33322, 33323, 
33313, 104727, 104783, 104796, 104740
37650, 14941, 14945, 14946, 14942, 104223, 104239, 104243, 104227, 15036, 15037, 15038, 15028, 104786, 104798, 104799, 
104742, 104728, 104784, 104797, 104741
37651, 104223, 104239, 104243, 104227, 104224, 104240, 104244, 104228, 104786, 104798, 104799, 104742, 104789, 104801, 104802, 
104745, 104731, 104787, 104800, 104744
37652, 104224, 104240, 104244, 104228, 104225, 104241, 104245, 104229, 104789, 104801, 104802, 104745, 104792, 104804, 104805, 
104748, 104734, 104790, 104803, 104747
37653, 104225, 104241, 104245, 104229, 104226, 104242, 104246, 104230, 104792, 104804, 104805, 104748, 104795, 104807, 104808, 
104751, 104737, 104793, 104806, 104750
37654, 104226, 104242, 104246, 104230, 33228, 33232, 33233, 33229, 104795, 104807, 104808, 104751, 33323, 33324, 33325, 
33315, 104740, 104796, 104809, 104753
37655, 14942, 14946, 14947, 14943, 104227, 104243, 104247, 104231, 15038, 15039, 15040, 15030, 104799, 104811, 104812, 
104755, 104741, 104797, 104810, 104754
37656, 104227, 104243, 104247, 104231, 104228, 104244, 104248, 104232, 104799, 104811, 104812, 104755, 104802, 104814, 104815, 
104758, 104744, 104800, 104813, 104757
37657, 104228, 104244, 104248, 104232, 104229, 104245, 104249, 104233, 104802, 104814, 104815, 104758, 104805, 104817, 104818, 
104761, 104747, 104803, 104816, 104760
37658, 104229, 104245, 104249, 104233, 104230, 104246, 104250, 104234, 104805, 104817, 104818, 104761, 104808, 104820, 104821, 
104764, 104750, 104806, 104819, 104763
37659, 104230, 104246, 104250, 104234, 33229, 33233, 33234, 33230, 104808, 104820, 104821, 104764, 33325, 33326, 33327, 
33317, 104753, 104809, 104822, 104766
37660, 14943, 14947, 1251, 1250, 104231, 104247, 33084, 33080, 15040, 15041, 1262, 15032, 104812, 104823, 33173, 
104767, 104754, 104810, 33174, 33165
37661, 104231, 104247, 33084, 33080, 104232, 104248, 33085, 33081, 104812, 104823, 33173, 104767, 104815, 104824, 33175, 
104768, 104757, 104813, 33176, 33167
37662, 104232, 104248, 33085, 33081, 104233, 104249, 33086, 33082, 104815, 104824, 33175, 104768, 104818, 104825, 33177, 
104769, 104760, 104816, 33178, 33169
37663, 104233, 104249, 33086, 33082, 104234, 104250, 33087, 33083, 104818, 104825, 33177, 104769, 104821, 104826, 33179, 
104770, 104763, 104819, 33180, 33171
37664, 104234, 104250, 33087, 33083, 33230, 33234, 3400, 3399, 104821, 104826, 33179, 104770, 33327, 33328, 3411, 
33319, 104766, 104822, 33181, 33172
37665, 1084, 1085, 14948, 14944, 31582, 31586, 104251, 104235, 1096, 15042, 15043, 15033, 31680, 104828, 104829, 
104772, 31672, 31681, 104827, 104771
37666, 31582, 31586, 104251, 104235, 31583, 31587, 104252, 104236, 31680, 104828, 104829, 104772, 31682, 104831, 104832, 
104775, 31674, 31683, 104830, 104774
37667, 31583, 31587, 104252, 104236, 31584, 31588, 104253, 104237, 31682, 104831, 104832, 104775, 31684, 104834, 104835, 
104778, 31676, 31685, 104833, 104777
37668, 31584, 31588, 104253, 104237, 31585, 31589, 104254, 104238, 31684, 104834, 104835, 104778, 31686, 104837, 104838, 
104781, 31678, 31687, 104836, 104780
37669, 31585, 31589, 104254, 104238, 3262, 3263, 33235, 33231, 31686, 104837, 104838, 104781, 3274, 33329, 33330, 
33320, 31679, 31688, 104839, 104783
37670, 14944, 14948, 14949, 14945, 104235, 104251, 104255, 104239, 15043, 15044, 15045, 15035, 104829, 104841, 104842, 
104785, 104771, 104827, 104840, 104784
37671, 104235, 104251, 104255, 104239, 104236, 104252, 104256, 104240, 104829, 104841, 104842, 104785, 104832, 104844, 104845, 
104788, 104774, 104830, 104843, 104787
37672, 104236, 104252, 104256, 104240, 104237, 104253, 104257, 104241, 104832, 104844, 104845, 104788, 104835, 104847, 104848, 
104791, 104777, 104833, 104846, 104790
37673, 104237, 104253, 104257, 104241, 104238, 104254, 104258, 104242, 104835, 104847, 104848, 104791, 104838, 104850, 104851, 
104794, 104780, 104836, 104849, 104793
37674, 104238, 104254, 104258, 104242, 33231, 33235, 33236, 33232, 104838, 104850, 104851, 104794, 33330, 33331, 33332, 
33322, 104783, 104839, 104852, 104796
37675, 14945, 14949, 14950, 14946, 104239, 104255, 104259, 104243, 15045, 15046, 15047, 15037, 104842, 104854, 104855, 
104798, 104784, 104840, 104853, 104797
37676, 104239, 104255, 104259, 104243, 104240, 104256, 104260, 104244, 104842, 104854, 104855, 104798, 104845, 104857, 104858, 
104801, 104787, 104843, 104856, 104800
37677, 104240, 104256, 104260, 104244, 104241, 104257, 104261, 104245, 104845, 104857, 104858, 104801, 104848, 104860, 104861, 
104804, 104790, 104846, 104859, 104803
37678, 104241, 104257, 104261, 104245, 104242, 104258, 104262, 104246, 104848, 104860, 104861, 104804, 104851, 104863, 104864, 
104807, 104793, 104849, 104862, 104806
37679, 104242, 104258, 104262, 104246, 33232, 33236, 33237, 33233, 104851, 104863, 104864, 104807, 33332, 33333, 33334, 
33324, 104796, 104852, 104865, 104809
37680, 14946, 14950, 14951, 14947, 104243, 104259, 104263, 104247, 15047, 15048, 15049, 15039, 104855, 104867, 104868, 
104811, 104797, 104853, 104866, 104810
37681, 104243, 104259, 104263, 104247, 104244, 104260, 104264, 104248, 104855, 104867, 104868, 104811, 104858, 104870, 104871, 
104814, 104800, 104856, 104869, 104813
37682, 104244, 104260, 104264, 104248, 104245, 104261, 104265, 104249, 104858, 104870, 104871, 104814, 104861, 104873, 104874, 
104817, 104803, 104859, 104872, 104816
37683, 104245, 104261, 104265, 104249, 104246, 104262, 104266, 104250, 104861, 104873, 104874, 104817, 104864, 104876, 104877, 
104820, 104806, 104862, 104875, 104819
37684, 104246, 104262, 104266, 104250, 33233, 33237, 33238, 33234, 104864, 104876, 104877, 104820, 33334, 33335, 33336, 
33326, 104809, 104865, 104878, 104822
37685, 14947, 14951, 1252, 1251, 104247, 104263, 33088, 33084, 15049, 15050, 1263, 15041, 104868, 104879, 33182, 
104823, 104810, 104866, 33183, 33174
37686, 104247, 104263, 33088, 33084, 104248, 104264, 33089, 33085, 104868, 104879, 33182, 104823, 104871, 104880, 33184, 
104824, 104813, 104869, 33185, 33176
37687, 104248, 104264, 33089, 33085, 104249, 104265, 33090, 33086, 104871, 104880, 33184, 104824, 104874, 104881, 33186, 
104825, 104816, 104872, 33187, 33178
37688, 104249, 104265, 33090, 33086, 104250, 104266, 33091, 33087, 104874, 104881, 33186, 104825, 104877, 104882, 33188, 
104826, 104819, 104875, 33189, 33180
37689, 104250, 104266, 33091, 33087, 33234, 33238, 3401, 3400, 104877, 104882, 33188, 104826, 33336, 33337, 3412, 
33328, 104822, 104878, 33190, 33181
37690, 1085, 23, 1182, 14948, 31586, 3244, 32936, 104251, 1097, 1186, 15051, 15042, 31689, 32953, 104883, 
104828, 31681, 3248, 32952, 104827
37691, 31586, 3244, 32936, 104251, 31587, 3245, 32937, 104252, 31689, 32953, 104883, 104828, 31690, 32955, 104884, 
104831, 31683, 3249, 32954, 104830
37692, 31587, 3245, 32937, 104252, 31588, 3246, 32938, 104253, 31690, 32955, 104884, 104831, 31691, 32957, 104885, 
104834, 31685, 3250, 32956, 104833
37693, 31588, 3246, 32938, 104253, 31589, 3247, 32939, 104254, 31691, 32957, 104885, 104834, 31692, 32959, 104886, 
104837, 31687, 3251, 32958, 104836
37694, 31589, 3247, 32939, 104254, 3263, 79, 3364, 33235, 31692, 32959, 104886, 104837, 3275, 3368, 33338, 
33329, 31688, 3252, 32960, 104839
37695, 14948, 1182, 1183, 14949, 104251, 32936, 32940, 104255, 15051, 1187, 15052, 15044, 104883, 32962, 104887, 
104841, 104827, 32952, 32961, 104840
37696, 104251, 32936, 32940, 104255, 104252, 32937, 32941, 104256, 104883, 32962, 104887, 104841, 104884, 32964, 104888, 
104844, 104830, 32954, 32963, 104843
37697, 104252, 32937, 32941, 104256, 104253, 32938, 32942, 104257, 104884, 32964, 104888, 104844, 104885, 32966, 104889, 
104847, 104833, 32956, 32965, 104846
37698, 104253, 32938, 32942, 104257, 104254, 32939, 32943, 104258, 104885, 32966, 104889, 104847, 104886, 32968, 104890, 
104850, 104836, 32958, 32967, 104849
37699, 104254, 32939, 32943, 104258, 33235, 3364, 3365, 33236, 104886, 32968, 104890, 104850, 33338, 3369, 33339, 
33331, 104839, 32960, 32969, 104852
37700, 14949, 1183, 1184, 14950, 104255, 32940, 32944, 104259, 15052, 1188, 15053, 15046, 104887, 32971, 104891, 
104854, 104840, 32961, 32970, 104853
37701, 104255, 32940, 32944, 104259, 104256, 32941, 32945, 104260, 104887, 32971, 104891, 104854, 104888, 32973, 104892, 
104857, 104843, 32963, 32972, 104856
37702, 104256, 32941, 32945, 104260, 104257, 32942, 32946, 104261, 104888, 32973, 104892, 104857, 104889, 32975, 104893, 
104860, 104846, 32965, 32974, 104859
37703, 104257, 32942, 32946, 104261, 104258, 32943, 32947, 104262, 104889, 32975, 104893, 104860, 104890, 32977, 104894, 
104863, 104849, 32967, 32976, 104862
37704, 104258, 32943, 32947, 104262, 33236, 3365, 3366, 33237, 104890, 32977, 104894, 104863, 33339, 3370, 33340, 
33333, 104852, 32969, 32978, 104865
37705, 14950, 1184, 1185, 14951, 104259, 32944, 32948, 104263, 15053, 1189, 15054, 15048, 104891, 32980, 104895, 
104867, 104853, 32970, 32979, 104866
37706, 104259, 32944, 32948, 104263, 104260, 32945, 32949, 104264, 104891, 32980, 104895, 104867, 104892, 32982, 104896, 
104870, 104856, 32972, 32981, 104869
37707, 104260, 32945, 32949, 104264, 104261, 32946, 32950, 104265, 104892, 32982, 104896, 104870, 104893, 32984, 104897, 
104873, 104859, 32974, 32983, 104872
37708, 104261, 32946, 32950, 104265, 104262, 32947, 32951, 104266, 104893, 32984, 104897, 104873, 104894, 32986, 104898, 
104876, 104862, 32976, 32985, 104875
37709, 104262, 32947, 32951, 104266, 33237, 3366, 3367, 33238, 104894, 32986, 104898, 104876, 33340, 3371, 33341, 
33335, 104865, 32978, 32987, 104878
37710, 14951, 1185, 26, 1252, 104263, 32948, 3355, 33088, 15054, 1190, 1264, 15050, 104895, 32988, 33191, 
104879, 104866, 32979, 3359, 33183
37711, 104263, 32948, 3355, 33088, 104264, 32949, 3356, 33089, 104895, 32988, 33191, 104879, 104896, 32989, 33192, 
104880, 104869, 32981, 3360, 33185
37712, 104264, 32949, 3356, 33089, 104265, 32950, 3357, 33090, 104896, 32989, 33192, 104880, 104897, 32990, 33193, 
104881, 104872, 32983, 3361, 33187
37713, 104265, 32950, 3357, 33090, 104266, 32951, 3358, 33091, 104897, 32990, 33193, 104881, 104898, 32991, 33194, 
104882, 104875, 32985, 3362, 33189
37714, 104266, 32951, 3358, 33091, 33238, 3367, 81, 3401, 104898, 32991, 33194, 104882, 33341, 3372, 3413, 
33337, 104878, 32987, 3363, 33190
*ELEMENT, type=C3D20, ELSET=Volume22
37715, 28, 1242, 16253, 1411, 3373, 33048, 104899, 33645, 1253, 16506, 16507, 1434, 33092, 105912, 105913, 
33737, 3377, 33093, 105911, 33738
37716, 3373, 33048, 104899, 33645, 3374, 33049, 104900, 33646, 33092, 105912, 105913, 33737, 33094, 105915, 105916, 
33739, 3378, 33095, 105914, 33740
37717, 3374, 33049, 104900, 33646, 3375, 33050, 104901, 33647, 33094, 105915, 105916, 33739, 33096, 105918, 105919, 
33741, 3379, 33097, 105917, 33742
37718, 3375, 33050, 104901, 33647, 3376, 33051, 104902, 33648, 33096, 105918, 105919, 33741, 33098, 105921, 105922, 
33743, 3380, 33099, 105920, 33744
37719, 3376, 33051, 104902, 33648, 82, 3391, 34095, 3479, 33098, 105921, 105922, 33743, 3402, 34348, 34349, 
3502, 3381, 33100, 105923, 33745
37720, 1411, 16253, 16254, 1412, 33645, 104899, 104903, 33649, 16507, 16508, 16509, 1435, 105913, 105925, 105926, 
33746, 33738, 105911, 105924, 33747
37721, 33645, 104899, 104903, 33649, 33646, 104900, 104904, 33650, 105913, 105925, 105926, 33746, 105916, 105928, 105929, 
33748, 33740, 105914, 105927, 33749
37722, 33646, 104900, 104904, 33650, 33647, 104901, 104905, 33651, 105916, 105928, 105929, 33748, 105919, 105931, 105932, 
33750, 33742, 105917, 105930, 33751
37723, 33647, 104901, 104905, 33651, 33648, 104902, 104906, 33652, 105919, 105931, 105932, 33750, 105922, 105934, 105935, 
33752, 33744, 105920, 105933, 33753
37724, 33648, 104902, 104906, 33652, 3479, 34095, 34096, 3480, 105922, 105934, 105935, 33752, 34349, 34350, 34351, 
3503, 33745, 105923, 105936, 33754
37725, 1412, 16254, 16255, 1413, 33649, 104903, 104907, 33653, 16509, 16510, 16511, 1436, 105926, 105938, 105939, 
33755, 33747, 105924, 105937, 33756
37726, 33649, 104903, 104907, 33653, 33650, 104904, 104908, 33654, 105926, 105938, 105939, 33755, 105929, 105941, 105942, 
33757, 33749, 105927, 105940, 33758
37727, 33650, 104904, 104908, 33654, 33651, 104905, 104909, 33655, 105929, 105941, 105942, 33757, 105932, 105944, 105945, 
33759, 33751, 105930, 105943, 33760
37728, 33651, 104905, 104909, 33655, 33652, 104906, 104910, 33656, 105932, 105944, 105945, 33759, 105935, 105947, 105948, 
33761, 33753, 105933, 105946, 33762
37729, 33652, 104906, 104910, 33656, 3480, 34096, 34097, 3481, 105935, 105947, 105948, 33761, 34351, 34352, 34353, 
3504, 33754, 105936, 105949, 33763
37730, 1413, 16255, 16256, 1414, 33653, 104907, 104911, 33657, 16511, 16512, 16513, 1437, 105939, 105951, 105952, 
33764, 33756, 105937, 105950, 33765
37731, 33653, 104907, 104911, 33657, 33654, 104908, 104912, 33658, 105939, 105951, 105952, 33764, 105942, 105954, 105955, 
33766, 33758, 105940, 105953, 33767
37732, 33654, 104908, 104912, 33658, 33655, 104909, 104913, 33659, 105942, 105954, 105955, 33766, 105945, 105957, 105958, 
33768, 33760, 105943, 105956, 33769
37733, 33655, 104909, 104913, 33659, 33656, 104910, 104914, 33660, 105945, 105957, 105958, 33768, 105948, 105960, 105961, 
33770, 33762, 105946, 105959, 33771
37734, 33656, 104910, 104914, 33660, 3481, 34097, 34098, 3482, 105948, 105960, 105961, 33770, 34353, 34354, 34355, 
3505, 33763, 105949, 105962, 33772
37735, 1414, 16256, 16257, 1415, 33657, 104911, 104915, 33661, 16513, 16514, 16515, 1438, 105952, 105964, 105965, 
33773, 33765, 105950, 105963, 33774
37736, 33657, 104911, 104915, 33661, 33658, 104912, 104916, 33662, 105952, 105964, 105965, 33773, 105955, 105967, 105968, 
33775, 33767, 105953, 105966, 33776
37737, 33658, 104912, 104916, 33662, 33659, 104913, 104917, 33663, 105955, 105967, 105968, 33775, 105958, 105970, 105971, 
33777, 33769, 105956, 105969, 33778
37738, 33659, 104913, 104917, 33663, 33660, 104914, 104918, 33664, 105958, 105970, 105971, 33777, 105961, 105973, 105974, 
33779, 33771, 105959, 105972, 33780
37739, 33660, 104914, 104918, 33664, 3482, 34098, 34099, 3483, 105961, 105973, 105974, 33779, 34355, 34356, 34357, 
3506, 33772, 105962, 105975, 33781
37740, 1415, 16257, 16258, 1416, 33661, 104915, 104919, 33665, 16515, 16516, 16517, 1439, 105965, 105977, 105978, 
33782, 33774, 105963, 105976, 33783
37741, 33661, 104915, 104919, 33665, 33662, 104916, 104920, 33666, 105965, 105977, 105978, 33782, 105968, 105980, 105981, 
33784, 33776, 105966, 105979, 33785
37742, 33662, 104916, 104920, 33666, 33663, 104917, 104921, 33667, 105968, 105980, 105981, 33784, 105971, 105983, 105984, 
33786, 33778, 105969, 105982, 33787
37743, 33663, 104917, 104921, 33667, 33664, 104918, 104922, 33668, 105971, 105983, 105984, 33786, 105974, 105986, 105987, 
33788, 33780, 105972, 105985, 33789
37744, 33664, 104918, 104922, 33668, 3483, 34099, 34100, 3484, 105974, 105986, 105987, 33788, 34357, 34358, 34359, 
3507, 33781, 105975, 105988, 33790
37745, 1416, 16258, 16259, 1417, 33665, 104919, 104923, 33669, 16517, 16518, 16519, 1440, 105978, 105990, 105991, 
33791, 33783, 105976, 105989, 33792
37746, 33665, 104919, 104923, 33669, 33666, 104920, 104924, 33670, 105978, 105990, 105991, 33791, 105981, 105993, 105994, 
33793, 33785, 105979, 105992, 33794
37747, 33666, 104920, 104924, 33670, 33667, 104921, 104925, 33671, 105981, 105993, 105994, 33793, 105984, 105996, 105997, 
33795, 33787, 105982, 105995, 33796
37748, 33667, 104921, 104925, 33671, 33668, 104922, 104926, 33672, 105984, 105996, 105997, 33795, 105987, 105999, 106000, 
33797, 33789, 105985, 105998, 33798
37749, 33668, 104922, 104926, 33672, 3484, 34100, 34101, 3485, 105987, 105999, 106000, 33797, 34359, 34360, 34361, 
3508, 33790, 105988, 106001, 33799
37750, 1417, 16259, 16260, 1418, 33669, 104923, 104927, 33673, 16519, 16520, 16521, 1441, 105991, 106003, 106004, 
33800, 33792, 105989, 106002, 33801
37751, 33669, 104923, 104927, 33673, 33670, 104924, 104928, 33674, 105991, 106003, 106004, 33800, 105994, 106006, 106007, 
33802, 33794, 105992, 106005, 33803
37752, 33670, 104924, 104928, 33674, 33671, 104925, 104929, 33675, 105994, 106006, 106007, 33802, 105997, 106009, 106010, 
33804, 33796, 105995, 106008, 33805
37753, 33671, 104925, 104929, 33675, 33672, 104926, 104930, 33676, 105997, 106009, 106010, 33804, 106000, 106012, 106013, 
33806, 33798, 105998, 106011, 33807
37754, 33672, 104926, 104930, 33676, 3485, 34101, 34102, 3486, 106000, 106012, 106013, 33806, 34361, 34362, 34363, 
3509, 33799, 106001, 106014, 33808
37755, 1418, 16260, 16261, 1419, 33673, 104927, 104931, 33677, 16521, 16522, 16523, 1442, 106004, 106016, 106017, 
33809, 33801, 106002, 106015, 33810
37756, 33673, 104927, 104931, 33677, 33674, 104928, 104932, 33678, 106004, 106016, 106017, 33809, 106007, 106019, 106020, 
33811, 33803, 106005, 106018, 33812
37757, 33674, 104928, 104932, 33678, 33675, 104929, 104933, 33679, 106007, 106019, 106020, 33811, 106010, 106022, 106023, 
33813, 33805, 106008, 106021, 33814
37758, 33675, 104929, 104933, 33679, 33676, 104930, 104934, 33680, 106010, 106022, 106023, 33813, 106013, 106025, 106026, 
33815, 33807, 106011, 106024, 33816
37759, 33676, 104930, 104934, 33680, 3486, 34102, 34103, 3487, 106013, 106025, 106026, 33815, 34363, 34364, 34365, 
3510, 33808, 106014, 106027, 33817
37760, 1419, 16261, 16262, 1420, 33677, 104931, 104935, 33681, 16523, 16524, 16525, 1443, 106017, 106029, 106030, 
33818, 33810, 106015, 106028, 33819
37761, 33677, 104931, 104935, 33681, 33678, 104932, 104936, 33682, 106017, 106029, 106030, 33818, 106020, 106032, 106033, 
33820, 33812, 106018, 106031, 33821
37762, 33678, 104932, 104936, 33682, 33679, 104933, 104937, 33683, 106020, 106032, 106033, 33820, 106023, 106035, 106036, 
33822, 33814, 106021, 106034, 33823
37763, 33679, 104933, 104937, 33683, 33680, 104934, 104938, 33684, 106023, 106035, 106036, 33822, 106026, 106038, 106039, 
33824, 33816, 106024, 106037, 33825
37764, 33680, 104934, 104938, 33684, 3487, 34103, 34104, 3488, 106026, 106038, 106039, 33824, 34365, 34366, 34367, 
3511, 33817, 106027, 106040, 33826
37765, 1420, 16262, 16263, 1421, 33681, 104935, 104939, 33685, 16525, 16526, 16527, 1444, 106030, 106042, 106043, 
33827, 33819, 106028, 106041, 33828
37766, 33681, 104935, 104939, 33685, 33682, 104936, 104940, 33686, 106030, 106042, 106043, 33827, 106033, 106045, 106046, 
33829, 33821, 106031, 106044, 33830
37767, 33682, 104936, 104940, 33686, 33683, 104937, 104941, 33687, 106033, 106045, 106046, 33829, 106036, 106048, 106049, 
33831, 33823, 106034, 106047, 33832
37768, 33683, 104937, 104941, 33687, 33684, 104938, 104942, 33688, 106036, 106048, 106049, 33831, 106039, 106051, 106052, 
33833, 33825, 106037, 106050, 33834
37769, 33684, 104938, 104942, 33688, 3488, 34104, 34105, 3489, 106039, 106051, 106052, 33833, 34367, 34368, 34369, 
3512, 33826, 106040, 106053, 33835
37770, 1421, 16263, 16264, 1422, 33685, 104939, 104943, 33689, 16527, 16528, 16529, 1445, 106043, 106055, 106056, 
33836, 33828, 106041, 106054, 33837
37771, 33685, 104939, 104943, 33689, 33686, 104940, 104944, 33690, 106043, 106055, 106056, 33836, 106046, 106058, 106059, 
33838, 33830, 106044, 106057, 33839
37772, 33686, 104940, 104944, 33690, 33687, 104941, 104945, 33691, 106046, 106058, 106059, 33838, 106049, 106061, 106062, 
33840, 33832, 106047, 106060, 33841
37773, 33687, 104941, 104945, 33691, 33688, 104942, 104946, 33692, 106049, 106061, 106062, 33840, 106052, 106064, 106065, 
33842, 33834, 106050, 106063, 33843
37774, 33688, 104942, 104946, 33692, 3489, 34105, 34106, 3490, 106052, 106064, 106065, 33842, 34369, 34370, 34371, 
3513, 33835, 106053, 106066, 33844
37775, 1422, 16264, 16265, 1423, 33689, 104943, 104947, 33693, 16529, 16530, 16531, 1446, 106056, 106068, 106069, 
33845, 33837, 106054, 106067, 33846
37776, 33689, 104943, 104947, 33693, 33690, 104944, 104948, 33694, 106056, 106068, 106069, 33845, 106059, 106071, 106072, 
33847, 33839, 106057, 106070, 33848
37777, 33690, 104944, 104948, 33694, 33691, 104945, 104949, 33695, 106059, 106071, 106072, 33847, 106062, 106074, 106075, 
33849, 33841, 106060, 106073, 33850
37778, 33691, 104945, 104949, 33695, 33692, 104946, 104950, 33696, 106062, 106074, 106075, 33849, 106065, 106077, 106078, 
33851, 33843, 106063, 106076, 33852
37779, 33692, 104946, 104950, 33696, 3490, 34106, 34107, 3491, 106065, 106077, 106078, 33851, 34371, 34372, 34373, 
3514, 33844, 106066, 106079, 33853
37780, 1423, 16265, 16266, 1424, 33693, 104947, 104951, 33697, 16531, 16532, 16533, 1447, 106069, 106081, 106082, 
33854, 33846, 106067, 106080, 33855
37781, 33693, 104947, 104951, 33697, 33694, 104948, 104952, 33698, 106069, 106081, 106082, 33854, 106072, 106084, 106085, 
33856, 33848, 106070, 106083, 33857
37782, 33694, 104948, 104952, 33698, 33695, 104949, 104953, 33699, 106072, 106084, 106085, 33856, 106075, 106087, 106088, 
33858, 33850, 106073, 106086, 33859
37783, 33695, 104949, 104953, 33699, 33696, 104950, 104954, 33700, 106075, 106087, 106088, 33858, 106078, 106090, 106091, 
33860, 33852, 106076, 106089, 33861
37784, 33696, 104950, 104954, 33700, 3491, 34107, 34108, 3492, 106078, 106090, 106091, 33860, 34373, 34374, 34375, 
3515, 33853, 106079, 106092, 33862
37785, 1424, 16266, 16267, 1425, 33697, 104951, 104955, 33701, 16533, 16534, 16535, 1448, 106082, 106094, 106095, 
33863, 33855, 106080, 106093, 33864
