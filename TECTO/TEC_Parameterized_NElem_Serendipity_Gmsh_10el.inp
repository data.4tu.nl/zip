108997, 1.3875, 1.58, 0.45833333333333
108998, 1.4083333333333, 1.58, 0.4375
108999, 1.4083333333333, 1.6, 0.45833333333333
109000, 1.3875, 1.62, 0.45833333333333
109001, 1.4083333333333, 1.62, 0.4375
109002, 1.4083333333333, 1.64, 0.45833333333333
109003, 1.3875, 1.66, 0.45833333333333
109004, 1.4083333333333, 1.66, 0.4375
109005, 1.4083333333333, 1.68, 0.45833333333333
109006, 1.45, 1.52, 0.45833333333333
109007, 1.4291666666667, 1.54, 0.45833333333333
109008, 1.45, 1.54, 0.4375
109009, 1.45, 1.56, 0.45833333333333
109010, 1.4291666666667, 1.58, 0.45833333333333
109011, 1.45, 1.58, 0.4375
109012, 1.45, 1.6, 0.45833333333333
109013, 1.4291666666667, 1.62, 0.45833333333333
109014, 1.45, 1.62, 0.4375
109015, 1.45, 1.64, 0.45833333333333
109016, 1.4291666666667, 1.66, 0.45833333333333
109017, 1.45, 1.66, 0.4375
109018, 1.45, 1.68, 0.45833333333333
109019, 1.4916666666667, 1.52, 0.45833333333333
109020, 1.4708333333333, 1.54, 0.45833333333333
109021, 1.4916666666667, 1.54, 0.4375
109022, 1.4916666666667, 1.56, 0.45833333333333
109023, 1.4708333333333, 1.58, 0.45833333333333
109024, 1.4916666666667, 1.58, 0.4375
109025, 1.4916666666667, 1.6, 0.45833333333333
109026, 1.4708333333333, 1.62, 0.45833333333333
109027, 1.4916666666667, 1.62, 0.4375
109028, 1.4916666666667, 1.64, 0.45833333333333
109029, 1.4708333333333, 1.66, 0.45833333333333
109030, 1.4916666666667, 1.66, 0.4375
109031, 1.4916666666667, 1.68, 0.45833333333333
109032, 1.5333333333333, 1.52, 0.45833333333333
109033, 1.5125, 1.54, 0.45833333333333
109034, 1.5333333333333, 1.54, 0.4375
109035, 1.5333333333333, 1.56, 0.45833333333333
109036, 1.5125, 1.58, 0.45833333333333
109037, 1.5333333333333, 1.58, 0.4375
109038, 1.5333333333333, 1.6, 0.45833333333333
109039, 1.5125, 1.62, 0.45833333333333
109040, 1.5333333333333, 1.62, 0.4375
109041, 1.5333333333333, 1.64, 0.45833333333333
109042, 1.5125, 1.66, 0.45833333333333
109043, 1.5333333333333, 1.66, 0.4375
109044, 1.5333333333333, 1.68, 0.45833333333333
109045, 1.575, 1.52, 0.45833333333333
109046, 1.5541666666667, 1.54, 0.45833333333333
109047, 1.575, 1.54, 0.4375
109048, 1.575, 1.56, 0.45833333333333
109049, 1.5541666666667, 1.58, 0.45833333333333
109050, 1.575, 1.58, 0.4375
109051, 1.575, 1.6, 0.45833333333333
109052, 1.5541666666667, 1.62, 0.45833333333333
109053, 1.575, 1.62, 0.4375
109054, 1.575, 1.64, 0.45833333333333
109055, 1.5541666666667, 1.66, 0.45833333333333
109056, 1.575, 1.66, 0.4375
109057, 1.575, 1.68, 0.45833333333333
109058, 1.6166666666667, 1.52, 0.45833333333333
109059, 1.5958333333333, 1.54, 0.45833333333333
109060, 1.6166666666667, 1.54, 0.4375
109061, 1.6166666666667, 1.56, 0.45833333333333
109062, 1.5958333333333, 1.58, 0.45833333333333
109063, 1.6166666666667, 1.58, 0.4375
109064, 1.6166666666667, 1.6, 0.45833333333333
109065, 1.5958333333333, 1.62, 0.45833333333333
109066, 1.6166666666667, 1.62, 0.4375
109067, 1.6166666666667, 1.64, 0.45833333333333
109068, 1.5958333333333, 1.66, 0.45833333333333
109069, 1.6166666666667, 1.66, 0.4375
109070, 1.6166666666667, 1.68, 0.45833333333333
109071, 1.6583333333333, 1.52, 0.45833333333333
109072, 1.6375, 1.54, 0.45833333333333
109073, 1.6583333333333, 1.54, 0.4375
109074, 1.6583333333333, 1.56, 0.45833333333333
109075, 1.6375, 1.58, 0.45833333333333
109076, 1.6583333333333, 1.58, 0.4375
109077, 1.6583333333333, 1.6, 0.45833333333333
109078, 1.6375, 1.62, 0.45833333333333
109079, 1.6583333333333, 1.62, 0.4375
109080, 1.6583333333333, 1.64, 0.45833333333333
109081, 1.6375, 1.66, 0.45833333333333
109082, 1.6583333333333, 1.66, 0.4375
109083, 1.6583333333333, 1.68, 0.45833333333333
109084, 1.7, 1.52, 0.45833333333333
109085, 1.6791666666667, 1.54, 0.45833333333333
109086, 1.7, 1.54, 0.4375
109087, 1.7, 1.56, 0.45833333333333
109088, 1.6791666666667, 1.58, 0.45833333333333
109089, 1.7, 1.58, 0.4375
109090, 1.7, 1.6, 0.45833333333333
109091, 1.6791666666667, 1.62, 0.45833333333333
109092, 1.7, 1.62, 0.4375
109093, 1.7, 1.64, 0.45833333333333
109094, 1.6791666666667, 1.66, 0.45833333333333
109095, 1.7, 1.66, 0.4375
109096, 1.7, 1.68, 0.45833333333333
109097, 1.7416666666667, 1.52, 0.45833333333333
109098, 1.7208333333333, 1.54, 0.45833333333333
109099, 1.7416666666667, 1.54, 0.4375
109100, 1.7416666666667, 1.56, 0.45833333333333
109101, 1.7208333333333, 1.58, 0.45833333333333
109102, 1.7416666666667, 1.58, 0.4375
109103, 1.7416666666667, 1.6, 0.45833333333333
109104, 1.7208333333333, 1.62, 0.45833333333333
109105, 1.7416666666667, 1.62, 0.4375
109106, 1.7416666666667, 1.64, 0.45833333333333
109107, 1.7208333333333, 1.66, 0.45833333333333
109108, 1.7416666666667, 1.66, 0.4375
109109, 1.7416666666667, 1.68, 0.45833333333333
109110, 1.7833333333333, 1.52, 0.45833333333333
109111, 1.7625, 1.54, 0.45833333333333
109112, 1.7833333333333, 1.54, 0.4375
109113, 1.7833333333333, 1.56, 0.45833333333333
109114, 1.7625, 1.58, 0.45833333333333
109115, 1.7833333333333, 1.58, 0.4375
109116, 1.7833333333333, 1.6, 0.45833333333333
109117, 1.7625, 1.62, 0.45833333333333
109118, 1.7833333333333, 1.62, 0.4375
109119, 1.7833333333333, 1.64, 0.45833333333333
109120, 1.7625, 1.66, 0.45833333333333
109121, 1.7833333333333, 1.66, 0.4375
109122, 1.7833333333333, 1.68, 0.45833333333333
109123, 1.825, 1.52, 0.45833333333333
109124, 1.8041666666667, 1.54, 0.45833333333333
109125, 1.825, 1.54, 0.4375
109126, 1.825, 1.56, 0.45833333333333
109127, 1.8041666666667, 1.58, 0.45833333333333
109128, 1.825, 1.58, 0.4375
109129, 1.825, 1.6, 0.45833333333333
109130, 1.8041666666667, 1.62, 0.45833333333333
109131, 1.825, 1.62, 0.4375
109132, 1.825, 1.64, 0.45833333333333
109133, 1.8041666666667, 1.66, 0.45833333333333
109134, 1.825, 1.66, 0.4375
109135, 1.825, 1.68, 0.45833333333333
109136, 1.8666666666667, 1.52, 0.45833333333333
109137, 1.8458333333333, 1.54, 0.45833333333333
109138, 1.8666666666667, 1.54, 0.4375
109139, 1.8666666666667, 1.56, 0.45833333333333
109140, 1.8458333333333, 1.58, 0.45833333333333
109141, 1.8666666666667, 1.58, 0.4375
109142, 1.8666666666667, 1.6, 0.45833333333333
109143, 1.8458333333333, 1.62, 0.45833333333333
109144, 1.8666666666667, 1.62, 0.4375
109145, 1.8666666666667, 1.64, 0.45833333333333
109146, 1.8458333333333, 1.66, 0.45833333333333
109147, 1.8666666666667, 1.66, 0.4375
109148, 1.8666666666667, 1.68, 0.45833333333333
109149, 1.9083333333333, 1.52, 0.45833333333333
109150, 1.8875, 1.54, 0.45833333333333
109151, 1.9083333333333, 1.54, 0.4375
109152, 1.9083333333333, 1.56, 0.45833333333333
109153, 1.8875, 1.58, 0.45833333333333
109154, 1.9083333333333, 1.58, 0.4375
109155, 1.9083333333333, 1.6, 0.45833333333333
109156, 1.8875, 1.62, 0.45833333333333
109157, 1.9083333333333, 1.62, 0.4375
109158, 1.9083333333333, 1.64, 0.45833333333333
109159, 1.8875, 1.66, 0.45833333333333
109160, 1.9083333333333, 1.66, 0.4375
109161, 1.9083333333333, 1.68, 0.45833333333333
109162, 1.95, 1.52, 0.45833333333333
109163, 1.9291666666667, 1.54, 0.45833333333333
109164, 1.95, 1.54, 0.4375
109165, 1.95, 1.56, 0.45833333333333
109166, 1.9291666666667, 1.58, 0.45833333333333
109167, 1.95, 1.58, 0.4375
109168, 1.95, 1.6, 0.45833333333333
109169, 1.9291666666667, 1.62, 0.45833333333333
109170, 1.95, 1.62, 0.4375
109171, 1.95, 1.64, 0.45833333333333
109172, 1.9291666666667, 1.66, 0.45833333333333
109173, 1.95, 1.66, 0.4375
109174, 1.95, 1.68, 0.45833333333333
109175, 1.9916666666667, 1.52, 0.45833333333333
109176, 1.9708333333333, 1.54, 0.45833333333333
109177, 1.9916666666667, 1.54, 0.4375
109178, 1.9916666666667, 1.56, 0.45833333333333
109179, 1.9708333333333, 1.58, 0.45833333333333
109180, 1.9916666666667, 1.58, 0.4375
109181, 1.9916666666667, 1.6, 0.45833333333333
109182, 1.9708333333333, 1.62, 0.45833333333333
109183, 1.9916666666667, 1.62, 0.4375
109184, 1.9916666666667, 1.64, 0.45833333333333
109185, 1.9708333333333, 1.66, 0.45833333333333
109186, 1.9916666666667, 1.66, 0.4375
109187, 1.9916666666667, 1.68, 0.45833333333333
109188, 2.0333333333333, 1.52, 0.45833333333333
109189, 2.0125, 1.54, 0.45833333333333
109190, 2.0333333333333, 1.54, 0.4375
109191, 2.0333333333333, 1.56, 0.45833333333333
109192, 2.0125, 1.58, 0.45833333333333
109193, 2.0333333333333, 1.58, 0.4375
109194, 2.0333333333333, 1.6, 0.45833333333333
109195, 2.0125, 1.62, 0.45833333333333
109196, 2.0333333333333, 1.62, 0.4375
109197, 2.0333333333333, 1.64, 0.45833333333333
109198, 2.0125, 1.66, 0.45833333333333
109199, 2.0333333333333, 1.66, 0.4375
109200, 2.0333333333333, 1.68, 0.45833333333333
109201, 2.075, 1.52, 0.45833333333333
109202, 2.0541666666667, 1.54, 0.45833333333333
109203, 2.075, 1.54, 0.4375
109204, 2.075, 1.56, 0.45833333333333
109205, 2.0541666666667, 1.58, 0.45833333333333
109206, 2.075, 1.58, 0.4375
109207, 2.075, 1.6, 0.45833333333333
109208, 2.0541666666667, 1.62, 0.45833333333333
109209, 2.075, 1.62, 0.4375
109210, 2.075, 1.64, 0.45833333333333
109211, 2.0541666666667, 1.66, 0.45833333333333
109212, 2.075, 1.66, 0.4375
109213, 2.075, 1.68, 0.45833333333333
109214, 2.1166666666667, 1.52, 0.45833333333333
109215, 2.0958333333333, 1.54, 0.45833333333333
109216, 2.1166666666667, 1.54, 0.4375
109217, 2.1166666666667, 1.56, 0.45833333333333
109218, 2.0958333333333, 1.58, 0.45833333333333
109219, 2.1166666666667, 1.58, 0.4375
109220, 2.1166666666667, 1.6, 0.45833333333333
109221, 2.0958333333333, 1.62, 0.45833333333333
109222, 2.1166666666667, 1.62, 0.4375
109223, 2.1166666666667, 1.64, 0.45833333333333
109224, 2.0958333333333, 1.66, 0.45833333333333
109225, 2.1166666666667, 1.66, 0.4375
109226, 2.1166666666667, 1.68, 0.45833333333333
109227, 2.1583333333333, 1.52, 0.45833333333333
109228, 2.1375, 1.54, 0.45833333333333
109229, 2.1583333333333, 1.54, 0.4375
109230, 2.1583333333333, 1.56, 0.45833333333333
109231, 2.1375, 1.58, 0.45833333333333
109232, 2.1583333333333, 1.58, 0.4375
109233, 2.1583333333333, 1.6, 0.45833333333333
109234, 2.1375, 1.62, 0.45833333333333
109235, 2.1583333333333, 1.62, 0.4375
109236, 2.1583333333333, 1.64, 0.45833333333333
109237, 2.1375, 1.66, 0.45833333333333
109238, 2.1583333333333, 1.66, 0.4375
109239, 2.1583333333333, 1.68, 0.45833333333333
109240, 2.1791666666667, 1.54, 0.45833333333333
109241, 2.1791666666667, 1.58, 0.45833333333333
109242, 2.1791666666667, 1.62, 0.45833333333333
109243, 2.1791666666667, 1.66, 0.45833333333333
109244, 1.2416666666667, 1.54, 0.47916666666667
109245, 1.2416666666667, 1.58, 0.47916666666667
109246, 1.2416666666667, 1.62, 0.47916666666667
109247, 1.2416666666667, 1.66, 0.47916666666667
109248, 1.2833333333333, 1.54, 0.47916666666667
109249, 1.2833333333333, 1.58, 0.47916666666667
109250, 1.2833333333333, 1.62, 0.47916666666667
109251, 1.2833333333333, 1.66, 0.47916666666667
109252, 1.325, 1.54, 0.47916666666667
109253, 1.325, 1.58, 0.47916666666667
109254, 1.325, 1.62, 0.47916666666667
109255, 1.325, 1.66, 0.47916666666667
109256, 1.3666666666667, 1.54, 0.47916666666667
109257, 1.3666666666667, 1.58, 0.47916666666667
109258, 1.3666666666667, 1.62, 0.47916666666667
109259, 1.3666666666667, 1.66, 0.47916666666667
109260, 1.4083333333333, 1.54, 0.47916666666667
109261, 1.4083333333333, 1.58, 0.47916666666667
109262, 1.4083333333333, 1.62, 0.47916666666667
109263, 1.4083333333333, 1.66, 0.47916666666667
109264, 1.45, 1.54, 0.47916666666667
109265, 1.45, 1.58, 0.47916666666667
109266, 1.45, 1.62, 0.47916666666667
109267, 1.45, 1.66, 0.47916666666667
109268, 1.4916666666667, 1.54, 0.47916666666667
109269, 1.4916666666667, 1.58, 0.47916666666667
109270, 1.4916666666667, 1.62, 0.47916666666667
109271, 1.4916666666667, 1.66, 0.47916666666667
109272, 1.5333333333333, 1.54, 0.47916666666667
109273, 1.5333333333333, 1.58, 0.47916666666667
109274, 1.5333333333333, 1.62, 0.47916666666667
109275, 1.5333333333333, 1.66, 0.47916666666667
109276, 1.575, 1.54, 0.47916666666667
109277, 1.575, 1.58, 0.47916666666667
109278, 1.575, 1.62, 0.47916666666667
109279, 1.575, 1.66, 0.47916666666667
109280, 1.6166666666667, 1.54, 0.47916666666667
109281, 1.6166666666667, 1.58, 0.47916666666667
109282, 1.6166666666667, 1.62, 0.47916666666667
109283, 1.6166666666667, 1.66, 0.47916666666667
109284, 1.6583333333333, 1.54, 0.47916666666667
109285, 1.6583333333333, 1.58, 0.47916666666667
109286, 1.6583333333333, 1.62, 0.47916666666667
109287, 1.6583333333333, 1.66, 0.47916666666667
109288, 1.7, 1.54, 0.47916666666667
109289, 1.7, 1.58, 0.47916666666667
109290, 1.7, 1.62, 0.47916666666667
109291, 1.7, 1.66, 0.47916666666667
109292, 1.7416666666667, 1.54, 0.47916666666667
109293, 1.7416666666667, 1.58, 0.47916666666667
109294, 1.7416666666667, 1.62, 0.47916666666667
109295, 1.7416666666667, 1.66, 0.47916666666667
109296, 1.7833333333333, 1.54, 0.47916666666667
109297, 1.7833333333333, 1.58, 0.47916666666667
109298, 1.7833333333333, 1.62, 0.47916666666667
109299, 1.7833333333333, 1.66, 0.47916666666667
109300, 1.825, 1.54, 0.47916666666667
109301, 1.825, 1.58, 0.47916666666667
109302, 1.825, 1.62, 0.47916666666667
109303, 1.825, 1.66, 0.47916666666667
109304, 1.8666666666667, 1.54, 0.47916666666667
109305, 1.8666666666667, 1.58, 0.47916666666667
109306, 1.8666666666667, 1.62, 0.47916666666667
109307, 1.8666666666667, 1.66, 0.47916666666667
109308, 1.9083333333333, 1.54, 0.47916666666667
109309, 1.9083333333333, 1.58, 0.47916666666667
109310, 1.9083333333333, 1.62, 0.47916666666667
109311, 1.9083333333333, 1.66, 0.47916666666667
109312, 1.95, 1.54, 0.47916666666667
109313, 1.95, 1.58, 0.47916666666667
109314, 1.95, 1.62, 0.47916666666667
109315, 1.95, 1.66, 0.47916666666667
109316, 1.9916666666667, 1.54, 0.47916666666667
109317, 1.9916666666667, 1.58, 0.47916666666667
109318, 1.9916666666667, 1.62, 0.47916666666667
109319, 1.9916666666667, 1.66, 0.47916666666667
109320, 2.0333333333333, 1.54, 0.47916666666667
109321, 2.0333333333333, 1.58, 0.47916666666667
109322, 2.0333333333333, 1.62, 0.47916666666667
109323, 2.0333333333333, 1.66, 0.47916666666667
109324, 2.075, 1.54, 0.47916666666667
109325, 2.075, 1.58, 0.47916666666667
109326, 2.075, 1.62, 0.47916666666667
109327, 2.075, 1.66, 0.47916666666667
109328, 2.1166666666667, 1.54, 0.47916666666667
109329, 2.1166666666667, 1.58, 0.47916666666667
109330, 2.1166666666667, 1.62, 0.47916666666667
109331, 2.1166666666667, 1.66, 0.47916666666667
109332, 2.1583333333333, 1.54, 0.47916666666667
109333, 2.1583333333333, 1.58, 0.47916666666667
109334, 2.1583333333333, 1.62, 0.47916666666667
109335, 2.1583333333333, 1.66, 0.47916666666667
109336, 0.041666666666667, -0.04, 0.041666666666667
109337, 0.041666666666667, -0.08, 0.041666666666667
109338, 0.041666666666667, -0.12, 0.041666666666667
109339, 0.041666666666667, -0.16, 0.041666666666667
109340, 0.041666666666667, -0.04, 0.083333333333333
109341, 0.041666666666667, -0.08, 0.083333333333333
109342, 0.041666666666667, -0.12, 0.083333333333333
109343, 0.041666666666667, -0.16, 0.083333333333333
109344, 0.041666666666667, -0.04, 0.125
109345, 0.041666666666667, -0.08, 0.125
109346, 0.041666666666667, -0.12, 0.125
109347, 0.041666666666667, -0.16, 0.125
109348, 0.041666666666667, -0.04, 0.16666666666667
109349, 0.041666666666667, -0.08, 0.16666666666667
109350, 0.041666666666667, -0.12, 0.16666666666667
109351, 0.041666666666667, -0.16, 0.16666666666667
109352, 0.041666666666667, -0.04, 0.20833333333333
109353, 0.041666666666667, -0.08, 0.20833333333333
109354, 0.041666666666667, -0.12, 0.20833333333333
109355, 0.041666666666667, -0.16, 0.20833333333333
109356, 0.041666666666667, -0.04, 0.25
109357, 0.041666666666667, -0.08, 0.25
109358, 0.041666666666667, -0.12, 0.25
109359, 0.041666666666667, -0.16, 0.25
109360, 0.041666666666667, -0.04, 0.29166666666667
109361, 0.041666666666667, -0.08, 0.29166666666667
109362, 0.041666666666667, -0.12, 0.29166666666667
109363, 0.041666666666667, -0.16, 0.29166666666667
109364, 0.041666666666667, -0.04, 0.33333333333333
109365, 0.041666666666667, -0.08, 0.33333333333333
109366, 0.041666666666667, -0.12, 0.33333333333333
109367, 0.041666666666667, -0.16, 0.33333333333333
109368, 0.041666666666667, -0.04, 0.375
109369, 0.041666666666667, -0.08, 0.375
109370, 0.041666666666667, -0.12, 0.375
109371, 0.041666666666667, -0.16, 0.375
109372, 0.041666666666667, -0.04, 0.41666666666667
109373, 0.041666666666667, -0.08, 0.41666666666667
109374, 0.041666666666667, -0.12, 0.41666666666667
109375, 0.041666666666667, -0.16, 0.41666666666667
109376, 0.041666666666667, -0.04, 0.45833333333333
109377, 0.041666666666667, -0.08, 0.45833333333333
109378, 0.041666666666667, -0.12, 0.45833333333333
109379, 0.041666666666667, -0.16, 0.45833333333333
109380, 0.083333333333333, -0.04, 0.041666666666667
109381, 0.083333333333333, -0.08, 0.041666666666667
109382, 0.083333333333333, -0.12, 0.041666666666667
109383, 0.083333333333333, -0.16, 0.041666666666667
109384, 0.083333333333333, -0.04, 0.083333333333333
109385, 0.083333333333333, -0.08, 0.083333333333333
109386, 0.083333333333333, -0.12, 0.083333333333333
109387, 0.083333333333333, -0.16, 0.083333333333333
109388, 0.083333333333333, -0.04, 0.125
109389, 0.083333333333333, -0.08, 0.125
109390, 0.083333333333333, -0.12, 0.125
109391, 0.083333333333333, -0.16, 0.125
109392, 0.083333333333333, -0.04, 0.16666666666667
109393, 0.083333333333333, -0.08, 0.16666666666667
109394, 0.083333333333333, -0.12, 0.16666666666667
109395, 0.083333333333333, -0.16, 0.16666666666667
109396, 0.083333333333333, -0.04, 0.20833333333333
109397, 0.083333333333333, -0.08, 0.20833333333333
109398, 0.083333333333333, -0.12, 0.20833333333333
109399, 0.083333333333333, -0.16, 0.20833333333333
109400, 0.083333333333333, -0.04, 0.25
109401, 0.083333333333333, -0.08, 0.25
109402, 0.083333333333333, -0.12, 0.25
109403, 0.083333333333333, -0.16, 0.25
109404, 0.083333333333333, -0.04, 0.29166666666667
109405, 0.083333333333333, -0.08, 0.29166666666667
109406, 0.083333333333333, -0.12, 0.29166666666667
109407, 0.083333333333333, -0.16, 0.29166666666667
109408, 0.083333333333333, -0.04, 0.33333333333333
109409, 0.083333333333333, -0.08, 0.33333333333333
109410, 0.083333333333333, -0.12, 0.33333333333333
109411, 0.083333333333333, -0.16, 0.33333333333333
109412, 0.083333333333333, -0.04, 0.375
109413, 0.083333333333333, -0.08, 0.375
109414, 0.083333333333333, -0.12, 0.375
109415, 0.083333333333333, -0.16, 0.375
109416, 0.083333333333333, -0.04, 0.41666666666667
109417, 0.083333333333333, -0.08, 0.41666666666667
109418, 0.083333333333333, -0.12, 0.41666666666667
109419, 0.083333333333333, -0.16, 0.41666666666667
109420, 0.083333333333333, -0.04, 0.45833333333333
109421, 0.083333333333333, -0.08, 0.45833333333333
109422, 0.083333333333333, -0.12, 0.45833333333333
109423, 0.083333333333333, -0.16, 0.45833333333333
109424, 0.125, -0.04, 0.041666666666667
109425, 0.125, -0.08, 0.041666666666667
109426, 0.125, -0.12, 0.041666666666667
109427, 0.125, -0.16, 0.041666666666667
109428, 0.125, -0.04, 0.083333333333333
109429, 0.125, -0.08, 0.083333333333333
109430, 0.125, -0.12, 0.083333333333333
109431, 0.125, -0.16, 0.083333333333333
109432, 0.125, -0.04, 0.125
109433, 0.125, -0.08, 0.125
109434, 0.125, -0.12, 0.125
109435, 0.125, -0.16, 0.125
109436, 0.125, -0.04, 0.16666666666667
109437, 0.125, -0.08, 0.16666666666667
109438, 0.125, -0.12, 0.16666666666667
109439, 0.125, -0.16, 0.16666666666667
109440, 0.125, -0.04, 0.20833333333333
109441, 0.125, -0.08, 0.20833333333333
109442, 0.125, -0.12, 0.20833333333333
109443, 0.125, -0.16, 0.20833333333333
109444, 0.125, -0.04, 0.25
109445, 0.125, -0.08, 0.25
109446, 0.125, -0.12, 0.25
109447, 0.125, -0.16, 0.25
109448, 0.125, -0.04, 0.29166666666667
109449, 0.125, -0.08, 0.29166666666667
109450, 0.125, -0.12, 0.29166666666667
109451, 0.125, -0.16, 0.29166666666667
109452, 0.125, -0.04, 0.33333333333333
109453, 0.125, -0.08, 0.33333333333333
109454, 0.125, -0.12, 0.33333333333333
109455, 0.125, -0.16, 0.33333333333333
109456, 0.125, -0.04, 0.375
109457, 0.125, -0.08, 0.375
109458, 0.125, -0.12, 0.375
109459, 0.125, -0.16, 0.375
109460, 0.125, -0.04, 0.41666666666667
109461, 0.125, -0.08, 0.41666666666667
109462, 0.125, -0.12, 0.41666666666667
109463, 0.125, -0.16, 0.41666666666667
109464, 0.125, -0.04, 0.45833333333333
109465, 0.125, -0.08, 0.45833333333333
109466, 0.125, -0.12, 0.45833333333333
109467, 0.125, -0.16, 0.45833333333333
109468, 0.16666666666667, -0.04, 0.041666666666667
109469, 0.16666666666667, -0.08, 0.041666666666667
109470, 0.16666666666667, -0.12, 0.041666666666667
109471, 0.16666666666667, -0.16, 0.041666666666667
109472, 0.16666666666667, -0.04, 0.083333333333333
109473, 0.16666666666667, -0.08, 0.083333333333333
109474, 0.16666666666667, -0.12, 0.083333333333333
109475, 0.16666666666667, -0.16, 0.083333333333333
109476, 0.16666666666667, -0.04, 0.125
109477, 0.16666666666667, -0.08, 0.125
109478, 0.16666666666667, -0.12, 0.125
109479, 0.16666666666667, -0.16, 0.125
109480, 0.16666666666667, -0.04, 0.16666666666667
109481, 0.16666666666667, -0.08, 0.16666666666667
109482, 0.16666666666667, -0.12, 0.16666666666667
109483, 0.16666666666667, -0.16, 0.16666666666667
109484, 0.16666666666667, -0.04, 0.20833333333333
109485, 0.16666666666667, -0.08, 0.20833333333333
109486, 0.16666666666667, -0.12, 0.20833333333333
109487, 0.16666666666667, -0.16, 0.20833333333333
109488, 0.16666666666667, -0.04, 0.25
109489, 0.16666666666667, -0.08, 0.25
109490, 0.16666666666667, -0.12, 0.25
109491, 0.16666666666667, -0.16, 0.25
109492, 0.16666666666667, -0.04, 0.29166666666667
109493, 0.16666666666667, -0.08, 0.29166666666667
109494, 0.16666666666667, -0.12, 0.29166666666667
109495, 0.16666666666667, -0.16, 0.29166666666667
109496, 0.16666666666667, -0.04, 0.33333333333333
109497, 0.16666666666667, -0.08, 0.33333333333333
109498, 0.16666666666667, -0.12, 0.33333333333333
109499, 0.16666666666667, -0.16, 0.33333333333333
109500, 0.16666666666667, -0.04, 0.375
109501, 0.16666666666667, -0.08, 0.375
109502, 0.16666666666667, -0.12, 0.375
109503, 0.16666666666667, -0.16, 0.375
109504, 0.16666666666667, -0.04, 0.41666666666667
109505, 0.16666666666667, -0.08, 0.41666666666667
109506, 0.16666666666667, -0.12, 0.41666666666667
109507, 0.16666666666667, -0.16, 0.41666666666667
109508, 0.16666666666667, -0.04, 0.45833333333333
109509, 0.16666666666667, -0.08, 0.45833333333333
109510, 0.16666666666667, -0.12, 0.45833333333333
109511, 0.16666666666667, -0.16, 0.45833333333333
109512, 0.20833333333333, -0.04, 0.041666666666667
109513, 0.20833333333333, -0.08, 0.041666666666667
109514, 0.20833333333333, -0.12, 0.041666666666667
109515, 0.20833333333333, -0.16, 0.041666666666667
109516, 0.20833333333333, -0.04, 0.083333333333333
109517, 0.20833333333333, -0.08, 0.083333333333333
109518, 0.20833333333333, -0.12, 0.083333333333333
109519, 0.20833333333333, -0.16, 0.083333333333333
109520, 0.20833333333333, -0.04, 0.125
109521, 0.20833333333333, -0.08, 0.125
109522, 0.20833333333333, -0.12, 0.125
109523, 0.20833333333333, -0.16, 0.125
109524, 0.20833333333333, -0.04, 0.16666666666667
109525, 0.20833333333333, -0.08, 0.16666666666667
109526, 0.20833333333333, -0.12, 0.16666666666667
109527, 0.20833333333333, -0.16, 0.16666666666667
109528, 0.20833333333333, -0.04, 0.20833333333333
109529, 0.20833333333333, -0.08, 0.20833333333333
109530, 0.20833333333333, -0.12, 0.20833333333333
109531, 0.20833333333333, -0.16, 0.20833333333333
109532, 0.20833333333333, -0.04, 0.25
109533, 0.20833333333333, -0.08, 0.25
109534, 0.20833333333333, -0.12, 0.25
109535, 0.20833333333333, -0.16, 0.25
109536, 0.20833333333333, -0.04, 0.29166666666667
109537, 0.20833333333333, -0.08, 0.29166666666667
109538, 0.20833333333333, -0.12, 0.29166666666667
109539, 0.20833333333333, -0.16, 0.29166666666667
109540, 0.20833333333333, -0.04, 0.33333333333333
109541, 0.20833333333333, -0.08, 0.33333333333333
109542, 0.20833333333333, -0.12, 0.33333333333333
109543, 0.20833333333333, -0.16, 0.33333333333333
109544, 0.20833333333333, -0.04, 0.375
109545, 0.20833333333333, -0.08, 0.375
109546, 0.20833333333333, -0.12, 0.375
109547, 0.20833333333333, -0.16, 0.375
109548, 0.20833333333333, -0.04, 0.41666666666667
109549, 0.20833333333333, -0.08, 0.41666666666667
109550, 0.20833333333333, -0.12, 0.41666666666667
109551, 0.20833333333333, -0.16, 0.41666666666667
109552, 0.20833333333333, -0.04, 0.45833333333333
109553, 0.20833333333333, -0.08, 0.45833333333333
109554, 0.20833333333333, -0.12, 0.45833333333333
109555, 0.20833333333333, -0.16, 0.45833333333333
109556, 0.25, -0.04, 0.041666666666667
109557, 0.25, -0.08, 0.041666666666667
109558, 0.25, -0.12, 0.041666666666667
109559, 0.25, -0.16, 0.041666666666667
109560, 0.25, -0.04, 0.083333333333333
109561, 0.25, -0.08, 0.083333333333333
109562, 0.25, -0.12, 0.083333333333333
109563, 0.25, -0.16, 0.083333333333333
109564, 0.25, -0.04, 0.125
109565, 0.25, -0.08, 0.125
109566, 0.25, -0.12, 0.125
109567, 0.25, -0.16, 0.125
109568, 0.25, -0.04, 0.16666666666667
109569, 0.25, -0.08, 0.16666666666667
109570, 0.25, -0.12, 0.16666666666667
109571, 0.25, -0.16, 0.16666666666667
109572, 0.25, -0.04, 0.20833333333333
109573, 0.25, -0.08, 0.20833333333333
109574, 0.25, -0.12, 0.20833333333333
109575, 0.25, -0.16, 0.20833333333333
109576, 0.25, -0.04, 0.25
109577, 0.25, -0.08, 0.25
109578, 0.25, -0.12, 0.25
109579, 0.25, -0.16, 0.25
109580, 0.25, -0.04, 0.29166666666667
109581, 0.25, -0.08, 0.29166666666667
109582, 0.25, -0.12, 0.29166666666667
109583, 0.25, -0.16, 0.29166666666667
109584, 0.25, -0.04, 0.33333333333333
109585, 0.25, -0.08, 0.33333333333333
109586, 0.25, -0.12, 0.33333333333333
109587, 0.25, -0.16, 0.33333333333333
109588, 0.25, -0.04, 0.375
109589, 0.25, -0.08, 0.375
109590, 0.25, -0.12, 0.375
109591, 0.25, -0.16, 0.375
109592, 0.25, -0.04, 0.41666666666667
109593, 0.25, -0.08, 0.41666666666667
109594, 0.25, -0.12, 0.41666666666667
109595, 0.25, -0.16, 0.41666666666667
109596, 0.25, -0.04, 0.45833333333333
109597, 0.25, -0.08, 0.45833333333333
109598, 0.25, -0.12, 0.45833333333333
109599, 0.25, -0.16, 0.45833333333333
109600, 0.29166666666667, -0.04, 0.041666666666667
109601, 0.29166666666667, -0.08, 0.041666666666667
109602, 0.29166666666667, -0.12, 0.041666666666667
109603, 0.29166666666667, -0.16, 0.041666666666667
109604, 0.29166666666667, -0.04, 0.083333333333333
109605, 0.29166666666667, -0.08, 0.083333333333333
109606, 0.29166666666667, -0.12, 0.083333333333333
109607, 0.29166666666667, -0.16, 0.083333333333333
109608, 0.29166666666667, -0.04, 0.125
109609, 0.29166666666667, -0.08, 0.125
109610, 0.29166666666667, -0.12, 0.125
109611, 0.29166666666667, -0.16, 0.125
109612, 0.29166666666667, -0.04, 0.16666666666667
109613, 0.29166666666667, -0.08, 0.16666666666667
109614, 0.29166666666667, -0.12, 0.16666666666667
109615, 0.29166666666667, -0.16, 0.16666666666667
109616, 0.29166666666667, -0.04, 0.20833333333333
109617, 0.29166666666667, -0.08, 0.20833333333333
109618, 0.29166666666667, -0.12, 0.20833333333333
109619, 0.29166666666667, -0.16, 0.20833333333333
109620, 0.29166666666667, -0.04, 0.25
109621, 0.29166666666667, -0.08, 0.25
109622, 0.29166666666667, -0.12, 0.25
109623, 0.29166666666667, -0.16, 0.25
109624, 0.29166666666667, -0.04, 0.29166666666667
109625, 0.29166666666667, -0.08, 0.29166666666667
109626, 0.29166666666667, -0.12, 0.29166666666667
109627, 0.29166666666667, -0.16, 0.29166666666667
109628, 0.29166666666667, -0.04, 0.33333333333333
109629, 0.29166666666667, -0.08, 0.33333333333333
109630, 0.29166666666667, -0.12, 0.33333333333333
109631, 0.29166666666667, -0.16, 0.33333333333333
109632, 0.29166666666667, -0.04, 0.375
109633, 0.29166666666667, -0.08, 0.375
109634, 0.29166666666667, -0.12, 0.375
109635, 0.29166666666667, -0.16, 0.375
109636, 0.29166666666667, -0.04, 0.41666666666667
109637, 0.29166666666667, -0.08, 0.41666666666667
109638, 0.29166666666667, -0.12, 0.41666666666667
109639, 0.29166666666667, -0.16, 0.41666666666667
109640, 0.29166666666667, -0.04, 0.45833333333333
109641, 0.29166666666667, -0.08, 0.45833333333333
109642, 0.29166666666667, -0.12, 0.45833333333333
109643, 0.29166666666667, -0.16, 0.45833333333333
109644, 0.33333333333333, -0.04, 0.041666666666667
109645, 0.33333333333333, -0.08, 0.041666666666667
109646, 0.33333333333333, -0.12, 0.041666666666667
109647, 0.33333333333333, -0.16, 0.041666666666667
109648, 0.33333333333333, -0.04, 0.083333333333333
109649, 0.33333333333333, -0.08, 0.083333333333333
109650, 0.33333333333333, -0.12, 0.083333333333333
109651, 0.33333333333333, -0.16, 0.083333333333333
109652, 0.33333333333333, -0.04, 0.125
109653, 0.33333333333333, -0.08, 0.125
109654, 0.33333333333333, -0.12, 0.125
109655, 0.33333333333333, -0.16, 0.125
109656, 0.33333333333333, -0.04, 0.16666666666667
109657, 0.33333333333333, -0.08, 0.16666666666667
109658, 0.33333333333333, -0.12, 0.16666666666667
109659, 0.33333333333333, -0.16, 0.16666666666667
109660, 0.33333333333333, -0.04, 0.20833333333333
109661, 0.33333333333333, -0.08, 0.20833333333333
109662, 0.33333333333333, -0.12, 0.20833333333333
109663, 0.33333333333333, -0.16, 0.20833333333333
109664, 0.33333333333333, -0.04, 0.25
109665, 0.33333333333333, -0.08, 0.25
109666, 0.33333333333333, -0.12, 0.25
109667, 0.33333333333333, -0.16, 0.25
109668, 0.33333333333333, -0.04, 0.29166666666667
109669, 0.33333333333333, -0.08, 0.29166666666667
109670, 0.33333333333333, -0.12, 0.29166666666667
109671, 0.33333333333333, -0.16, 0.29166666666667
109672, 0.33333333333333, -0.04, 0.33333333333333
109673, 0.33333333333333, -0.08, 0.33333333333333
109674, 0.33333333333333, -0.12, 0.33333333333333
109675, 0.33333333333333, -0.16, 0.33333333333333
109676, 0.33333333333333, -0.04, 0.375
109677, 0.33333333333333, -0.08, 0.375
109678, 0.33333333333333, -0.12, 0.375
109679, 0.33333333333333, -0.16, 0.375
109680, 0.33333333333333, -0.04, 0.41666666666667
109681, 0.33333333333333, -0.08, 0.41666666666667
109682, 0.33333333333333, -0.12, 0.41666666666667
109683, 0.33333333333333, -0.16, 0.41666666666667
109684, 0.33333333333333, -0.04, 0.45833333333333
109685, 0.33333333333333, -0.08, 0.45833333333333
109686, 0.33333333333333, -0.12, 0.45833333333333
109687, 0.33333333333333, -0.16, 0.45833333333333
109688, 0.375, -0.04, 0.041666666666667
109689, 0.375, -0.08, 0.041666666666667
109690, 0.375, -0.12, 0.041666666666667
109691, 0.375, -0.16, 0.041666666666667
109692, 0.375, -0.04, 0.083333333333333
109693, 0.375, -0.08, 0.083333333333333
109694, 0.375, -0.12, 0.083333333333333
109695, 0.375, -0.16, 0.083333333333333
109696, 0.375, -0.04, 0.125
109697, 0.375, -0.08, 0.125
109698, 0.375, -0.12, 0.125
109699, 0.375, -0.16, 0.125
109700, 0.375, -0.04, 0.16666666666667
109701, 0.375, -0.08, 0.16666666666667
109702, 0.375, -0.12, 0.16666666666667
109703, 0.375, -0.16, 0.16666666666667
109704, 0.375, -0.04, 0.20833333333333
109705, 0.375, -0.08, 0.20833333333333
109706, 0.375, -0.12, 0.20833333333333
109707, 0.375, -0.16, 0.20833333333333
109708, 0.375, -0.04, 0.25
109709, 0.375, -0.08, 0.25
109710, 0.375, -0.12, 0.25
109711, 0.375, -0.16, 0.25
109712, 0.375, -0.04, 0.29166666666667
109713, 0.375, -0.08, 0.29166666666667
109714, 0.375, -0.12, 0.29166666666667
109715, 0.375, -0.16, 0.29166666666667
109716, 0.375, -0.04, 0.33333333333333
109717, 0.375, -0.08, 0.33333333333333
109718, 0.375, -0.12, 0.33333333333333
109719, 0.375, -0.16, 0.33333333333333
109720, 0.375, -0.04, 0.375
109721, 0.375, -0.08, 0.375
109722, 0.375, -0.12, 0.375
109723, 0.375, -0.16, 0.375
109724, 0.375, -0.04, 0.41666666666667
109725, 0.375, -0.08, 0.41666666666667
109726, 0.375, -0.12, 0.41666666666667
109727, 0.375, -0.16, 0.41666666666667
109728, 0.375, -0.04, 0.45833333333333
109729, 0.375, -0.08, 0.45833333333333
109730, 0.375, -0.12, 0.45833333333333
109731, 0.375, -0.16, 0.45833333333333
109732, 0.41666666666667, -0.04, 0.041666666666667
109733, 0.41666666666667, -0.08, 0.041666666666667
109734, 0.41666666666667, -0.12, 0.041666666666667
109735, 0.41666666666667, -0.16, 0.041666666666667
109736, 0.41666666666667, -0.04, 0.083333333333333
109737, 0.41666666666667, -0.08, 0.083333333333333
109738, 0.41666666666667, -0.12, 0.083333333333333
109739, 0.41666666666667, -0.16, 0.083333333333333
109740, 0.41666666666667, -0.04, 0.125
109741, 0.41666666666667, -0.08, 0.125
109742, 0.41666666666667, -0.12, 0.125
109743, 0.41666666666667, -0.16, 0.125
109744, 0.41666666666667, -0.04, 0.16666666666667
109745, 0.41666666666667, -0.08, 0.16666666666667
109746, 0.41666666666667, -0.12, 0.16666666666667
109747, 0.41666666666667, -0.16, 0.16666666666667
109748, 0.41666666666667, -0.04, 0.20833333333333
109749, 0.41666666666667, -0.08, 0.20833333333333
109750, 0.41666666666667, -0.12, 0.20833333333333
109751, 0.41666666666667, -0.16, 0.20833333333333
109752, 0.41666666666667, -0.04, 0.25
109753, 0.41666666666667, -0.08, 0.25
109754, 0.41666666666667, -0.12, 0.25
109755, 0.41666666666667, -0.16, 0.25
109756, 0.41666666666667, -0.04, 0.29166666666667
109757, 0.41666666666667, -0.08, 0.29166666666667
109758, 0.41666666666667, -0.12, 0.29166666666667
109759, 0.41666666666667, -0.16, 0.29166666666667
109760, 0.41666666666667, -0.04, 0.33333333333333
109761, 0.41666666666667, -0.08, 0.33333333333333
109762, 0.41666666666667, -0.12, 0.33333333333333
109763, 0.41666666666667, -0.16, 0.33333333333333
109764, 0.41666666666667, -0.04, 0.375
109765, 0.41666666666667, -0.08, 0.375
109766, 0.41666666666667, -0.12, 0.375
109767, 0.41666666666667, -0.16, 0.375
109768, 0.41666666666667, -0.04, 0.41666666666667
109769, 0.41666666666667, -0.08, 0.41666666666667
109770, 0.41666666666667, -0.12, 0.41666666666667
109771, 0.41666666666667, -0.16, 0.41666666666667
109772, 0.41666666666667, -0.04, 0.45833333333333
109773, 0.41666666666667, -0.08, 0.45833333333333
109774, 0.41666666666667, -0.12, 0.45833333333333
109775, 0.41666666666667, -0.16, 0.45833333333333
109776, 0.45833333333333, -0.04, 0.041666666666667
109777, 0.45833333333333, -0.08, 0.041666666666667
109778, 0.45833333333333, -0.12, 0.041666666666667
109779, 0.45833333333333, -0.16, 0.041666666666667
109780, 0.45833333333333, -0.04, 0.083333333333333
109781, 0.45833333333333, -0.08, 0.083333333333333
109782, 0.45833333333333, -0.12, 0.083333333333333
109783, 0.45833333333333, -0.16, 0.083333333333333
109784, 0.45833333333333, -0.04, 0.125
109785, 0.45833333333333, -0.08, 0.125
109786, 0.45833333333333, -0.12, 0.125
109787, 0.45833333333333, -0.16, 0.125
109788, 0.45833333333333, -0.04, 0.16666666666667
109789, 0.45833333333333, -0.08, 0.16666666666667
109790, 0.45833333333333, -0.12, 0.16666666666667
109791, 0.45833333333333, -0.16, 0.16666666666667
109792, 0.45833333333333, -0.04, 0.20833333333333
109793, 0.45833333333333, -0.08, 0.20833333333333
109794, 0.45833333333333, -0.12, 0.20833333333333
109795, 0.45833333333333, -0.16, 0.20833333333333
109796, 0.45833333333333, -0.04, 0.25
109797, 0.45833333333333, -0.08, 0.25
109798, 0.45833333333333, -0.12, 0.25
109799, 0.45833333333333, -0.16, 0.25
109800, 0.45833333333333, -0.04, 0.29166666666667
109801, 0.45833333333333, -0.08, 0.29166666666667
109802, 0.45833333333333, -0.12, 0.29166666666667
109803, 0.45833333333333, -0.16, 0.29166666666667
109804, 0.45833333333333, -0.04, 0.33333333333333
109805, 0.45833333333333, -0.08, 0.33333333333333
109806, 0.45833333333333, -0.12, 0.33333333333333
109807, 0.45833333333333, -0.16, 0.33333333333333
109808, 0.45833333333333, -0.04, 0.375
109809, 0.45833333333333, -0.08, 0.375
109810, 0.45833333333333, -0.12, 0.375
109811, 0.45833333333333, -0.16, 0.375
109812, 0.45833333333333, -0.04, 0.41666666666667
109813, 0.45833333333333, -0.08, 0.41666666666667
109814, 0.45833333333333, -0.12, 0.41666666666667
109815, 0.45833333333333, -0.16, 0.41666666666667
109816, 0.45833333333333, -0.04, 0.45833333333333
109817, 0.45833333333333, -0.08, 0.45833333333333
109818, 0.45833333333333, -0.12, 0.45833333333333
109819, 0.45833333333333, -0.16, 0.45833333333333
109820, 0.5, -0.04, 0.041666666666667
109821, 0.5, -0.08, 0.041666666666667
109822, 0.5, -0.12, 0.041666666666667
109823, 0.5, -0.16, 0.041666666666667
109824, 0.5, -0.04, 0.083333333333333
109825, 0.5, -0.08, 0.083333333333333
109826, 0.5, -0.12, 0.083333333333333
109827, 0.5, -0.16, 0.083333333333333
109828, 0.5, -0.04, 0.125
109829, 0.5, -0.08, 0.125
109830, 0.5, -0.12, 0.125
109831, 0.5, -0.16, 0.125
109832, 0.5, -0.04, 0.16666666666667
109833, 0.5, -0.08, 0.16666666666667
109834, 0.5, -0.12, 0.16666666666667
109835, 0.5, -0.16, 0.16666666666667
109836, 0.5, -0.04, 0.20833333333333
109837, 0.5, -0.08, 0.20833333333333
109838, 0.5, -0.12, 0.20833333333333
109839, 0.5, -0.16, 0.20833333333333
109840, 0.5, -0.04, 0.25
109841, 0.5, -0.08, 0.25
109842, 0.5, -0.12, 0.25
109843, 0.5, -0.16, 0.25
109844, 0.5, -0.04, 0.29166666666667
109845, 0.5, -0.08, 0.29166666666667
109846, 0.5, -0.12, 0.29166666666667
109847, 0.5, -0.16, 0.29166666666667
109848, 0.5, -0.04, 0.33333333333333
109849, 0.5, -0.08, 0.33333333333333
109850, 0.5, -0.12, 0.33333333333333
109851, 0.5, -0.16, 0.33333333333333
109852, 0.5, -0.04, 0.375
109853, 0.5, -0.08, 0.375
109854, 0.5, -0.12, 0.375
109855, 0.5, -0.16, 0.375
109856, 0.5, -0.04, 0.41666666666667
109857, 0.5, -0.08, 0.41666666666667
109858, 0.5, -0.12, 0.41666666666667
109859, 0.5, -0.16, 0.41666666666667
109860, 0.5, -0.04, 0.45833333333333
109861, 0.5, -0.08, 0.45833333333333
109862, 0.5, -0.12, 0.45833333333333
109863, 0.5, -0.16, 0.45833333333333
109864, 0.54166666666667, -0.04, 0.041666666666667
109865, 0.54166666666667, -0.08, 0.041666666666667
109866, 0.54166666666667, -0.12, 0.041666666666667
109867, 0.54166666666667, -0.16, 0.041666666666667
109868, 0.54166666666667, -0.04, 0.083333333333333
109869, 0.54166666666667, -0.08, 0.083333333333333
109870, 0.54166666666667, -0.12, 0.083333333333333
109871, 0.54166666666667, -0.16, 0.083333333333333
109872, 0.54166666666667, -0.04, 0.125
109873, 0.54166666666667, -0.08, 0.125
109874, 0.54166666666667, -0.12, 0.125
109875, 0.54166666666667, -0.16, 0.125
109876, 0.54166666666667, -0.04, 0.16666666666667
109877, 0.54166666666667, -0.08, 0.16666666666667
109878, 0.54166666666667, -0.12, 0.16666666666667
109879, 0.54166666666667, -0.16, 0.16666666666667
109880, 0.54166666666667, -0.04, 0.20833333333333
109881, 0.54166666666667, -0.08, 0.20833333333333
109882, 0.54166666666667, -0.12, 0.20833333333333
109883, 0.54166666666667, -0.16, 0.20833333333333
109884, 0.54166666666667, -0.04, 0.25
109885, 0.54166666666667, -0.08, 0.25
109886, 0.54166666666667, -0.12, 0.25
109887, 0.54166666666667, -0.16, 0.25
109888, 0.54166666666667, -0.04, 0.29166666666667
109889, 0.54166666666667, -0.08, 0.29166666666667
109890, 0.54166666666667, -0.12, 0.29166666666667
109891, 0.54166666666667, -0.16, 0.29166666666667
109892, 0.54166666666667, -0.04, 0.33333333333333
109893, 0.54166666666667, -0.08, 0.33333333333333
109894, 0.54166666666667, -0.12, 0.33333333333333
109895, 0.54166666666667, -0.16, 0.33333333333333
109896, 0.54166666666667, -0.04, 0.375
109897, 0.54166666666667, -0.08, 0.375
109898, 0.54166666666667, -0.12, 0.375
109899, 0.54166666666667, -0.16, 0.375
109900, 0.54166666666667, -0.04, 0.41666666666667
109901, 0.54166666666667, -0.08, 0.41666666666667
109902, 0.54166666666667, -0.12, 0.41666666666667
109903, 0.54166666666667, -0.16, 0.41666666666667
109904, 0.54166666666667, -0.04, 0.45833333333333
109905, 0.54166666666667, -0.08, 0.45833333333333
109906, 0.54166666666667, -0.12, 0.45833333333333
109907, 0.54166666666667, -0.16, 0.45833333333333
109908, 0.58333333333333, -0.04, 0.041666666666667
109909, 0.58333333333333, -0.08, 0.041666666666667
109910, 0.58333333333333, -0.12, 0.041666666666667
109911, 0.58333333333333, -0.16, 0.041666666666667
109912, 0.58333333333333, -0.04, 0.083333333333333
109913, 0.58333333333333, -0.08, 0.083333333333333
109914, 0.58333333333333, -0.12, 0.083333333333333
109915, 0.58333333333333, -0.16, 0.083333333333333
109916, 0.58333333333333, -0.04, 0.125
109917, 0.58333333333333, -0.08, 0.125
109918, 0.58333333333333, -0.12, 0.125
109919, 0.58333333333333, -0.16, 0.125
109920, 0.58333333333333, -0.04, 0.16666666666667
109921, 0.58333333333333, -0.08, 0.16666666666667
109922, 0.58333333333333, -0.12, 0.16666666666667
109923, 0.58333333333333, -0.16, 0.16666666666667
109924, 0.58333333333333, -0.04, 0.20833333333333
109925, 0.58333333333333, -0.08, 0.20833333333333
109926, 0.58333333333333, -0.12, 0.20833333333333
109927, 0.58333333333333, -0.16, 0.20833333333333
109928, 0.58333333333333, -0.04, 0.25
109929, 0.58333333333333, -0.08, 0.25
109930, 0.58333333333333, -0.12, 0.25
109931, 0.58333333333333, -0.16, 0.25
109932, 0.58333333333333, -0.04, 0.29166666666667
109933, 0.58333333333333, -0.08, 0.29166666666667
109934, 0.58333333333333, -0.12, 0.29166666666667
109935, 0.58333333333333, -0.16, 0.29166666666667
109936, 0.58333333333333, -0.04, 0.33333333333333
109937, 0.58333333333333, -0.08, 0.33333333333333
109938, 0.58333333333333, -0.12, 0.33333333333333
109939, 0.58333333333333, -0.16, 0.33333333333333
109940, 0.58333333333333, -0.04, 0.375
109941, 0.58333333333333, -0.08, 0.375
109942, 0.58333333333333, -0.12, 0.375
109943, 0.58333333333333, -0.16, 0.375
109944, 0.58333333333333, -0.04, 0.41666666666667
109945, 0.58333333333333, -0.08, 0.41666666666667
109946, 0.58333333333333, -0.12, 0.41666666666667
109947, 0.58333333333333, -0.16, 0.41666666666667
109948, 0.58333333333333, -0.04, 0.45833333333333
109949, 0.58333333333333, -0.08, 0.45833333333333
109950, 0.58333333333333, -0.12, 0.45833333333333
109951, 0.58333333333333, -0.16, 0.45833333333333
109952, 0.625, -0.04, 0.041666666666667
109953, 0.625, -0.08, 0.041666666666667
109954, 0.625, -0.12, 0.041666666666667
109955, 0.625, -0.16, 0.041666666666667
109956, 0.625, -0.04, 0.083333333333333
109957, 0.625, -0.08, 0.083333333333333
109958, 0.625, -0.12, 0.083333333333333
109959, 0.625, -0.16, 0.083333333333333
109960, 0.625, -0.04, 0.125
109961, 0.625, -0.08, 0.125
109962, 0.625, -0.12, 0.125
109963, 0.625, -0.16, 0.125
109964, 0.625, -0.04, 0.16666666666667
109965, 0.625, -0.08, 0.16666666666667
109966, 0.625, -0.12, 0.16666666666667
109967, 0.625, -0.16, 0.16666666666667
109968, 0.625, -0.04, 0.20833333333333
109969, 0.625, -0.08, 0.20833333333333
109970, 0.625, -0.12, 0.20833333333333
109971, 0.625, -0.16, 0.20833333333333
109972, 0.625, -0.04, 0.25
109973, 0.625, -0.08, 0.25
109974, 0.625, -0.12, 0.25
109975, 0.625, -0.16, 0.25
109976, 0.625, -0.04, 0.29166666666667
109977, 0.625, -0.08, 0.29166666666667
109978, 0.625, -0.12, 0.29166666666667
109979, 0.625, -0.16, 0.29166666666667
109980, 0.625, -0.04, 0.33333333333333
109981, 0.625, -0.08, 0.33333333333333
109982, 0.625, -0.12, 0.33333333333333
109983, 0.625, -0.16, 0.33333333333333
109984, 0.625, -0.04, 0.375
109985, 0.625, -0.08, 0.375
109986, 0.625, -0.12, 0.375
109987, 0.625, -0.16, 0.375
109988, 0.625, -0.04, 0.41666666666667
109989, 0.625, -0.08, 0.41666666666667
109990, 0.625, -0.12, 0.41666666666667
109991, 0.625, -0.16, 0.41666666666667
109992, 0.625, -0.04, 0.45833333333333
109993, 0.625, -0.08, 0.45833333333333
109994, 0.625, -0.12, 0.45833333333333
109995, 0.625, -0.16, 0.45833333333333
109996, 0.66666666666667, -0.04, 0.041666666666667
109997, 0.66666666666667, -0.08, 0.041666666666667
109998, 0.66666666666667, -0.12, 0.041666666666667
109999, 0.66666666666667, -0.16, 0.041666666666667
110000, 0.66666666666667, -0.04, 0.083333333333333
110001, 0.66666666666667, -0.08, 0.083333333333333
110002, 0.66666666666667, -0.12, 0.083333333333333
110003, 0.66666666666667, -0.16, 0.083333333333333
110004, 0.66666666666667, -0.04, 0.125
110005, 0.66666666666667, -0.08, 0.125
110006, 0.66666666666667, -0.12, 0.125
110007, 0.66666666666667, -0.16, 0.125
110008, 0.66666666666667, -0.04, 0.16666666666667
110009, 0.66666666666667, -0.08, 0.16666666666667
110010, 0.66666666666667, -0.12, 0.16666666666667
110011, 0.66666666666667, -0.16, 0.16666666666667
110012, 0.66666666666667, -0.04, 0.20833333333333
110013, 0.66666666666667, -0.08, 0.20833333333333
110014, 0.66666666666667, -0.12, 0.20833333333333
110015, 0.66666666666667, -0.16, 0.20833333333333
110016, 0.66666666666667, -0.04, 0.25
110017, 0.66666666666667, -0.08, 0.25
110018, 0.66666666666667, -0.12, 0.25
110019, 0.66666666666667, -0.16, 0.25
110020, 0.66666666666667, -0.04, 0.29166666666667
110021, 0.66666666666667, -0.08, 0.29166666666667
110022, 0.66666666666667, -0.12, 0.29166666666667
110023, 0.66666666666667, -0.16, 0.29166666666667
110024, 0.66666666666667, -0.04, 0.33333333333333
110025, 0.66666666666667, -0.08, 0.33333333333333
110026, 0.66666666666667, -0.12, 0.33333333333333
110027, 0.66666666666667, -0.16, 0.33333333333333
110028, 0.66666666666667, -0.04, 0.375
110029, 0.66666666666667, -0.08, 0.375
110030, 0.66666666666667, -0.12, 0.375
110031, 0.66666666666667, -0.16, 0.375
110032, 0.66666666666667, -0.04, 0.41666666666667
110033, 0.66666666666667, -0.08, 0.41666666666667
110034, 0.66666666666667, -0.12, 0.41666666666667
110035, 0.66666666666667, -0.16, 0.41666666666667
110036, 0.66666666666667, -0.04, 0.45833333333333
110037, 0.66666666666667, -0.08, 0.45833333333333
110038, 0.66666666666667, -0.12, 0.45833333333333
110039, 0.66666666666667, -0.16, 0.45833333333333
110040, 0.70833333333333, -0.04, 0.041666666666667
110041, 0.70833333333333, -0.08, 0.041666666666667
110042, 0.70833333333333, -0.12, 0.041666666666667
110043, 0.70833333333333, -0.16, 0.041666666666667
110044, 0.70833333333333, -0.04, 0.083333333333333
110045, 0.70833333333333, -0.08, 0.083333333333333
110046, 0.70833333333333, -0.12, 0.083333333333333
110047, 0.70833333333333, -0.16, 0.083333333333333
110048, 0.70833333333333, -0.04, 0.125
110049, 0.70833333333333, -0.08, 0.125
110050, 0.70833333333333, -0.12, 0.125
110051, 0.70833333333333, -0.16, 0.125
110052, 0.70833333333333, -0.04, 0.16666666666667
110053, 0.70833333333333, -0.08, 0.16666666666667
110054, 0.70833333333333, -0.12, 0.16666666666667
110055, 0.70833333333333, -0.16, 0.16666666666667
110056, 0.70833333333333, -0.04, 0.20833333333333
110057, 0.70833333333333, -0.08, 0.20833333333333
110058, 0.70833333333333, -0.12, 0.20833333333333
110059, 0.70833333333333, -0.16, 0.20833333333333
110060, 0.70833333333333, -0.04, 0.25
110061, 0.70833333333333, -0.08, 0.25
110062, 0.70833333333333, -0.12, 0.25
110063, 0.70833333333333, -0.16, 0.25
110064, 0.70833333333333, -0.04, 0.29166666666667
110065, 0.70833333333333, -0.08, 0.29166666666667
110066, 0.70833333333333, -0.12, 0.29166666666667
110067, 0.70833333333333, -0.16, 0.29166666666667
110068, 0.70833333333333, -0.04, 0.33333333333333
110069, 0.70833333333333, -0.08, 0.33333333333333
110070, 0.70833333333333, -0.12, 0.33333333333333
110071, 0.70833333333333, -0.16, 0.33333333333333
110072, 0.70833333333333, -0.04, 0.375
110073, 0.70833333333333, -0.08, 0.375
110074, 0.70833333333333, -0.12, 0.375
110075, 0.70833333333333, -0.16, 0.375
110076, 0.70833333333333, -0.04, 0.41666666666667
110077, 0.70833333333333, -0.08, 0.41666666666667
110078, 0.70833333333333, -0.12, 0.41666666666667
110079, 0.70833333333333, -0.16, 0.41666666666667
110080, 0.70833333333333, -0.04, 0.45833333333333
110081, 0.70833333333333, -0.08, 0.45833333333333
110082, 0.70833333333333, -0.12, 0.45833333333333
110083, 0.70833333333333, -0.16, 0.45833333333333
110084, 0.75, -0.04, 0.041666666666667
110085, 0.75, -0.08, 0.041666666666667
110086, 0.75, -0.12, 0.041666666666667
110087, 0.75, -0.16, 0.041666666666667
110088, 0.75, -0.04, 0.083333333333333
110089, 0.75, -0.08, 0.083333333333333
110090, 0.75, -0.12, 0.083333333333333
110091, 0.75, -0.16, 0.083333333333333
110092, 0.75, -0.04, 0.125
110093, 0.75, -0.08, 0.125
110094, 0.75, -0.12, 0.125
110095, 0.75, -0.16, 0.125
110096, 0.75, -0.04, 0.16666666666667
110097, 0.75, -0.08, 0.16666666666667
110098, 0.75, -0.12, 0.16666666666667
110099, 0.75, -0.16, 0.16666666666667
110100, 0.75, -0.04, 0.20833333333333
110101, 0.75, -0.08, 0.20833333333333
110102, 0.75, -0.12, 0.20833333333333
110103, 0.75, -0.16, 0.20833333333333
110104, 0.75, -0.04, 0.25
110105, 0.75, -0.08, 0.25
110106, 0.75, -0.12, 0.25
110107, 0.75, -0.16, 0.25
110108, 0.75, -0.04, 0.29166666666667
110109, 0.75, -0.08, 0.29166666666667
110110, 0.75, -0.12, 0.29166666666667
110111, 0.75, -0.16, 0.29166666666667
110112, 0.75, -0.04, 0.33333333333333
110113, 0.75, -0.08, 0.33333333333333
110114, 0.75, -0.12, 0.33333333333333
110115, 0.75, -0.16, 0.33333333333333
110116, 0.75, -0.04, 0.375
110117, 0.75, -0.08, 0.375
110118, 0.75, -0.12, 0.375
110119, 0.75, -0.16, 0.375
110120, 0.75, -0.04, 0.41666666666667
110121, 0.75, -0.08, 0.41666666666667
110122, 0.75, -0.12, 0.41666666666667
110123, 0.75, -0.16, 0.41666666666667
110124, 0.75, -0.04, 0.45833333333333
110125, 0.75, -0.08, 0.45833333333333
110126, 0.75, -0.12, 0.45833333333333
110127, 0.75, -0.16, 0.45833333333333
110128, 0.79166666666667, -0.04, 0.041666666666667
110129, 0.79166666666667, -0.08, 0.041666666666667
110130, 0.79166666666667, -0.12, 0.041666666666667
110131, 0.79166666666667, -0.16, 0.041666666666667
110132, 0.79166666666667, -0.04, 0.083333333333333
110133, 0.79166666666667, -0.08, 0.083333333333333
110134, 0.79166666666667, -0.12, 0.083333333333333
110135, 0.79166666666667, -0.16, 0.083333333333333
110136, 0.79166666666667, -0.04, 0.125
110137, 0.79166666666667, -0.08, 0.125
110138, 0.79166666666667, -0.12, 0.125
110139, 0.79166666666667, -0.16, 0.125
110140, 0.79166666666667, -0.04, 0.16666666666667
110141, 0.79166666666667, -0.08, 0.16666666666667
110142, 0.79166666666667, -0.12, 0.16666666666667
110143, 0.79166666666667, -0.16, 0.16666666666667
110144, 0.79166666666667, -0.04, 0.20833333333333
110145, 0.79166666666667, -0.08, 0.20833333333333
110146, 0.79166666666667, -0.12, 0.20833333333333
110147, 0.79166666666667, -0.16, 0.20833333333333
110148, 0.79166666666667, -0.04, 0.25
110149, 0.79166666666667, -0.08, 0.25
110150, 0.79166666666667, -0.12, 0.25
110151, 0.79166666666667, -0.16, 0.25
110152, 0.79166666666667, -0.04, 0.29166666666667
110153, 0.79166666666667, -0.08, 0.29166666666667
110154, 0.79166666666667, -0.12, 0.29166666666667
110155, 0.79166666666667, -0.16, 0.29166666666667
110156, 0.79166666666667, -0.04, 0.33333333333333
110157, 0.79166666666667, -0.08, 0.33333333333333
110158, 0.79166666666667, -0.12, 0.33333333333333
110159, 0.79166666666667, -0.16, 0.33333333333333
110160, 0.79166666666667, -0.04, 0.375
110161, 0.79166666666667, -0.08, 0.375
110162, 0.79166666666667, -0.12, 0.375
110163, 0.79166666666667, -0.16, 0.375
110164, 0.79166666666667, -0.04, 0.41666666666667
110165, 0.79166666666667, -0.08, 0.41666666666667
110166, 0.79166666666667, -0.12, 0.41666666666667
110167, 0.79166666666667, -0.16, 0.41666666666667
110168, 0.79166666666667, -0.04, 0.45833333333333
110169, 0.79166666666667, -0.08, 0.45833333333333
110170, 0.79166666666667, -0.12, 0.45833333333333
110171, 0.79166666666667, -0.16, 0.45833333333333
110172, 0.83333333333333, -0.04, 0.041666666666667
110173, 0.83333333333333, -0.08, 0.041666666666667
110174, 0.83333333333333, -0.12, 0.041666666666667
110175, 0.83333333333333, -0.16, 0.041666666666667
110176, 0.83333333333333, -0.04, 0.083333333333333
110177, 0.83333333333333, -0.08, 0.083333333333333
110178, 0.83333333333333, -0.12, 0.083333333333333
110179, 0.83333333333333, -0.16, 0.083333333333333
110180, 0.83333333333333, -0.04, 0.125
110181, 0.83333333333333, -0.08, 0.125
110182, 0.83333333333333, -0.12, 0.125
110183, 0.83333333333333, -0.16, 0.125
110184, 0.83333333333333, -0.04, 0.16666666666667
110185, 0.83333333333333, -0.08, 0.16666666666667
110186, 0.83333333333333, -0.12, 0.16666666666667
110187, 0.83333333333333, -0.16, 0.16666666666667
110188, 0.83333333333333, -0.04, 0.20833333333333
110189, 0.83333333333333, -0.08, 0.20833333333333
110190, 0.83333333333333, -0.12, 0.20833333333333
110191, 0.83333333333333, -0.16, 0.20833333333333
110192, 0.83333333333333, -0.04, 0.25
110193, 0.83333333333333, -0.08, 0.25
110194, 0.83333333333333, -0.12, 0.25
110195, 0.83333333333333, -0.16, 0.25
110196, 0.83333333333333, -0.04, 0.29166666666667
110197, 0.83333333333333, -0.08, 0.29166666666667
110198, 0.83333333333333, -0.12, 0.29166666666667
110199, 0.83333333333333, -0.16, 0.29166666666667
110200, 0.83333333333333, -0.04, 0.33333333333333
110201, 0.83333333333333, -0.08, 0.33333333333333
110202, 0.83333333333333, -0.12, 0.33333333333333
110203, 0.83333333333333, -0.16, 0.33333333333333
110204, 0.83333333333333, -0.04, 0.375
110205, 0.83333333333333, -0.08, 0.375
110206, 0.83333333333333, -0.12, 0.375
110207, 0.83333333333333, -0.16, 0.375
110208, 0.83333333333333, -0.04, 0.41666666666667
110209, 0.83333333333333, -0.08, 0.41666666666667
110210, 0.83333333333333, -0.12, 0.41666666666667
110211, 0.83333333333333, -0.16, 0.41666666666667
110212, 0.83333333333333, -0.04, 0.45833333333333
110213, 0.83333333333333, -0.08, 0.45833333333333
110214, 0.83333333333333, -0.12, 0.45833333333333
110215, 0.83333333333333, -0.16, 0.45833333333333
110216, 0.875, -0.04, 0.041666666666667
110217, 0.875, -0.08, 0.041666666666667
110218, 0.875, -0.12, 0.041666666666667
110219, 0.875, -0.16, 0.041666666666667
110220, 0.875, -0.04, 0.083333333333333
110221, 0.875, -0.08, 0.083333333333333
110222, 0.875, -0.12, 0.083333333333333
110223, 0.875, -0.16, 0.083333333333333
110224, 0.875, -0.04, 0.125
110225, 0.875, -0.08, 0.125
110226, 0.875, -0.12, 0.125
110227, 0.875, -0.16, 0.125
110228, 0.875, -0.04, 0.16666666666667
110229, 0.875, -0.08, 0.16666666666667
110230, 0.875, -0.12, 0.16666666666667
110231, 0.875, -0.16, 0.16666666666667
110232, 0.875, -0.04, 0.20833333333333
110233, 0.875, -0.08, 0.20833333333333
110234, 0.875, -0.12, 0.20833333333333
110235, 0.875, -0.16, 0.20833333333333
110236, 0.875, -0.04, 0.25
110237, 0.875, -0.08, 0.25
110238, 0.875, -0.12, 0.25
110239, 0.875, -0.16, 0.25
110240, 0.875, -0.04, 0.29166666666667
110241, 0.875, -0.08, 0.29166666666667
110242, 0.875, -0.12, 0.29166666666667
110243, 0.875, -0.16, 0.29166666666667
110244, 0.875, -0.04, 0.33333333333333
110245, 0.875, -0.08, 0.33333333333333
110246, 0.875, -0.12, 0.33333333333333
110247, 0.875, -0.16, 0.33333333333333
110248, 0.875, -0.04, 0.375
110249, 0.875, -0.08, 0.375
110250, 0.875, -0.12, 0.375
110251, 0.875, -0.16, 0.375
110252, 0.875, -0.04, 0.41666666666667
110253, 0.875, -0.08, 0.41666666666667
110254, 0.875, -0.12, 0.41666666666667
110255, 0.875, -0.16, 0.41666666666667
110256, 0.875, -0.04, 0.45833333333333
110257, 0.875, -0.08, 0.45833333333333
110258, 0.875, -0.12, 0.45833333333333
110259, 0.875, -0.16, 0.45833333333333
110260, 0.91666666666667, -0.04, 0.041666666666667
110261, 0.91666666666667, -0.08, 0.041666666666667
110262, 0.91666666666667, -0.12, 0.041666666666667
110263, 0.91666666666667, -0.16, 0.041666666666667
110264, 0.91666666666667, -0.04, 0.083333333333333
110265, 0.91666666666667, -0.08, 0.083333333333333
110266, 0.91666666666667, -0.12, 0.083333333333333
110267, 0.91666666666667, -0.16, 0.083333333333333
110268, 0.91666666666667, -0.04, 0.125
110269, 0.91666666666667, -0.08, 0.125
110270, 0.91666666666667, -0.12, 0.125
110271, 0.91666666666667, -0.16, 0.125
110272, 0.91666666666667, -0.04, 0.16666666666667
110273, 0.91666666666667, -0.08, 0.16666666666667
110274, 0.91666666666667, -0.12, 0.16666666666667
110275, 0.91666666666667, -0.16, 0.16666666666667
110276, 0.91666666666667, -0.04, 0.20833333333333
110277, 0.91666666666667, -0.08, 0.20833333333333
110278, 0.91666666666667, -0.12, 0.20833333333333
110279, 0.91666666666667, -0.16, 0.20833333333333
110280, 0.91666666666667, -0.04, 0.25
110281, 0.91666666666667, -0.08, 0.25
110282, 0.91666666666667, -0.12, 0.25
110283, 0.91666666666667, -0.16, 0.25
110284, 0.91666666666667, -0.04, 0.29166666666667
110285, 0.91666666666667, -0.08, 0.29166666666667
110286, 0.91666666666667, -0.12, 0.29166666666667
110287, 0.91666666666667, -0.16, 0.29166666666667
110288, 0.91666666666667, -0.04, 0.33333333333333
110289, 0.91666666666667, -0.08, 0.33333333333333
110290, 0.91666666666667, -0.12, 0.33333333333333
110291, 0.91666666666667, -0.16, 0.33333333333333
110292, 0.91666666666667, -0.04, 0.375
110293, 0.91666666666667, -0.08, 0.375
110294, 0.91666666666667, -0.12, 0.375
110295, 0.91666666666667, -0.16, 0.375
110296, 0.91666666666667, -0.04, 0.41666666666667
110297, 0.91666666666667, -0.08, 0.41666666666667
110298, 0.91666666666667, -0.12, 0.41666666666667
110299, 0.91666666666667, -0.16, 0.41666666666667
110300, 0.91666666666667, -0.04, 0.45833333333333
110301, 0.91666666666667, -0.08, 0.45833333333333
110302, 0.91666666666667, -0.12, 0.45833333333333
110303, 0.91666666666667, -0.16, 0.45833333333333
110304, 0.95833333333333, -0.04, 0.041666666666667
110305, 0.95833333333333, -0.08, 0.041666666666667
110306, 0.95833333333333, -0.12, 0.041666666666667
110307, 0.95833333333333, -0.16, 0.041666666666667
110308, 0.95833333333333, -0.04, 0.083333333333333
110309, 0.95833333333333, -0.08, 0.083333333333333
110310, 0.95833333333333, -0.12, 0.083333333333333
110311, 0.95833333333333, -0.16, 0.083333333333333
110312, 0.95833333333333, -0.04, 0.125
110313, 0.95833333333333, -0.08, 0.125
110314, 0.95833333333333, -0.12, 0.125
110315, 0.95833333333333, -0.16, 0.125
110316, 0.95833333333333, -0.04, 0.16666666666667
110317, 0.95833333333333, -0.08, 0.16666666666667
110318, 0.95833333333333, -0.12, 0.16666666666667
110319, 0.95833333333333, -0.16, 0.16666666666667
110320, 0.95833333333333, -0.04, 0.20833333333333
110321, 0.95833333333333, -0.08, 0.20833333333333
110322, 0.95833333333333, -0.12, 0.20833333333333
110323, 0.95833333333333, -0.16, 0.20833333333333
110324, 0.95833333333333, -0.04, 0.25
110325, 0.95833333333333, -0.08, 0.25
110326, 0.95833333333333, -0.12, 0.25
110327, 0.95833333333333, -0.16, 0.25
110328, 0.95833333333333, -0.04, 0.29166666666667
110329, 0.95833333333333, -0.08, 0.29166666666667
110330, 0.95833333333333, -0.12, 0.29166666666667
110331, 0.95833333333333, -0.16, 0.29166666666667
110332, 0.95833333333333, -0.04, 0.33333333333333
110333, 0.95833333333333, -0.08, 0.33333333333333
110334, 0.95833333333333, -0.12, 0.33333333333333
110335, 0.95833333333333, -0.16, 0.33333333333333
110336, 0.95833333333333, -0.04, 0.375
110337, 0.95833333333333, -0.08, 0.375
110338, 0.95833333333333, -0.12, 0.375
110339, 0.95833333333333, -0.16, 0.375
110340, 0.95833333333333, -0.04, 0.41666666666667
110341, 0.95833333333333, -0.08, 0.41666666666667
110342, 0.95833333333333, -0.12, 0.41666666666667
110343, 0.95833333333333, -0.16, 0.41666666666667
110344, 0.95833333333333, -0.04, 0.45833333333333
110345, 0.95833333333333, -0.08, 0.45833333333333
110346, 0.95833333333333, -0.12, 0.45833333333333
110347, 0.95833333333333, -0.16, 0.45833333333333
110348, 0.041666666666667, -0.02, 0.041666666666667
110349, 0.041666666666667, -0.04, 0.020833333333333
110350, 0.020833333333333, -0.04, 0.041666666666667
110351, 0.041666666666667, -0.06, 0.041666666666667
110352, 0.041666666666667, -0.08, 0.020833333333333
110353, 0.020833333333333, -0.08, 0.041666666666667
110354, 0.041666666666667, -0.1, 0.041666666666667
110355, 0.041666666666667, -0.12, 0.020833333333333
110356, 0.020833333333333, -0.12, 0.041666666666667
110357, 0.041666666666667, -0.14, 0.041666666666667
110358, 0.041666666666667, -0.16, 0.020833333333333
110359, 0.020833333333333, -0.16, 0.041666666666667
110360, 0.041666666666667, -0.18, 0.041666666666667
110361, 0.041666666666667, -0.02, 0.083333333333333
110362, 0.041666666666667, -0.04, 0.0625
110363, 0.020833333333333, -0.04, 0.083333333333333
110364, 0.041666666666667, -0.06, 0.083333333333333
110365, 0.041666666666667, -0.08, 0.0625
110366, 0.020833333333333, -0.08, 0.083333333333333
110367, 0.041666666666667, -0.1, 0.083333333333333
110368, 0.041666666666667, -0.12, 0.0625
110369, 0.020833333333333, -0.12, 0.083333333333333
110370, 0.041666666666667, -0.14, 0.083333333333333
110371, 0.041666666666667, -0.16, 0.0625
110372, 0.020833333333333, -0.16, 0.083333333333333
110373, 0.041666666666667, -0.18, 0.083333333333333
110374, 0.041666666666667, -0.02, 0.125
110375, 0.041666666666667, -0.04, 0.10416666666667
110376, 0.020833333333333, -0.04, 0.125
110377, 0.041666666666667, -0.06, 0.125
110378, 0.041666666666667, -0.08, 0.10416666666667
110379, 0.020833333333333, -0.08, 0.125
110380, 0.041666666666667, -0.1, 0.125
110381, 0.041666666666667, -0.12, 0.10416666666667
110382, 0.020833333333333, -0.12, 0.125
110383, 0.041666666666667, -0.14, 0.125
110384, 0.041666666666667, -0.16, 0.10416666666667
110385, 0.020833333333333, -0.16, 0.125
110386, 0.041666666666667, -0.18, 0.125
110387, 0.041666666666667, -0.02, 0.16666666666667
110388, 0.041666666666667, -0.04, 0.14583333333333
110389, 0.020833333333333, -0.04, 0.16666666666667
110390, 0.041666666666667, -0.06, 0.16666666666667
110391, 0.041666666666667, -0.08, 0.14583333333333
110392, 0.020833333333333, -0.08, 0.16666666666667
110393, 0.041666666666667, -0.1, 0.16666666666667
110394, 0.041666666666667, -0.12, 0.14583333333333
110395, 0.020833333333333, -0.12, 0.16666666666667
110396, 0.041666666666667, -0.14, 0.16666666666667
110397, 0.041666666666667, -0.16, 0.14583333333333
110398, 0.020833333333333, -0.16, 0.16666666666667
110399, 0.041666666666667, -0.18, 0.16666666666667
110400, 0.041666666666667, -0.02, 0.20833333333333
110401, 0.041666666666667, -0.04, 0.1875
110402, 0.020833333333333, -0.04, 0.20833333333333
110403, 0.041666666666667, -0.06, 0.20833333333333
110404, 0.041666666666667, -0.08, 0.1875
110405, 0.020833333333333, -0.08, 0.20833333333333
110406, 0.041666666666667, -0.1, 0.20833333333333
110407, 0.041666666666667, -0.12, 0.1875
110408, 0.020833333333333, -0.12, 0.20833333333333
110409, 0.041666666666667, -0.14, 0.20833333333333
110410, 0.041666666666667, -0.16, 0.1875
110411, 0.020833333333333, -0.16, 0.20833333333333
110412, 0.041666666666667, -0.18, 0.20833333333333
110413, 0.041666666666667, -0.02, 0.25
110414, 0.041666666666667, -0.04, 0.22916666666667
110415, 0.020833333333333, -0.04, 0.25
110416, 0.041666666666667, -0.06, 0.25
110417, 0.041666666666667, -0.08, 0.22916666666667
110418, 0.020833333333333, -0.08, 0.25
110419, 0.041666666666667, -0.1, 0.25
110420, 0.041666666666667, -0.12, 0.22916666666667
110421, 0.020833333333333, -0.12, 0.25
110422, 0.041666666666667, -0.14, 0.25
110423, 0.041666666666667, -0.16, 0.22916666666667
110424, 0.020833333333333, -0.16, 0.25
110425, 0.041666666666667, -0.18, 0.25
110426, 0.041666666666667, -0.02, 0.29166666666667
110427, 0.041666666666667, -0.04, 0.27083333333333
110428, 0.020833333333333, -0.04, 0.29166666666667
110429, 0.041666666666667, -0.06, 0.29166666666667
110430, 0.041666666666667, -0.08, 0.27083333333333
110431, 0.020833333333333, -0.08, 0.29166666666667
110432, 0.041666666666667, -0.1, 0.29166666666667
110433, 0.041666666666667, -0.12, 0.27083333333333
110434, 0.020833333333333, -0.12, 0.29166666666667
110435, 0.041666666666667, -0.14, 0.29166666666667
110436, 0.041666666666667, -0.16, 0.27083333333333
110437, 0.020833333333333, -0.16, 0.29166666666667
110438, 0.041666666666667, -0.18, 0.29166666666667
110439, 0.041666666666667, -0.02, 0.33333333333333
110440, 0.041666666666667, -0.04, 0.3125
110441, 0.020833333333333, -0.04, 0.33333333333333
110442, 0.041666666666667, -0.06, 0.33333333333333
110443, 0.041666666666667, -0.08, 0.3125
110444, 0.020833333333333, -0.08, 0.33333333333333
110445, 0.041666666666667, -0.1, 0.33333333333333
110446, 0.041666666666667, -0.12, 0.3125
110447, 0.020833333333333, -0.12, 0.33333333333333
110448, 0.041666666666667, -0.14, 0.33333333333333
110449, 0.041666666666667, -0.16, 0.3125
110450, 0.020833333333333, -0.16, 0.33333333333333
110451, 0.041666666666667, -0.18, 0.33333333333333
110452, 0.041666666666667, -0.02, 0.375
110453, 0.041666666666667, -0.04, 0.35416666666667
110454, 0.020833333333333, -0.04, 0.375
110455, 0.041666666666667, -0.06, 0.375
110456, 0.041666666666667, -0.08, 0.35416666666667
110457, 0.020833333333333, -0.08, 0.375
110458, 0.041666666666667, -0.1, 0.375
110459, 0.041666666666667, -0.12, 0.35416666666667
110460, 0.020833333333333, -0.12, 0.375
110461, 0.041666666666667, -0.14, 0.375
110462, 0.041666666666667, -0.16, 0.35416666666667
110463, 0.020833333333333, -0.16, 0.375
110464, 0.041666666666667, -0.18, 0.375
110465, 0.041666666666667, -0.02, 0.41666666666667
110466, 0.041666666666667, -0.04, 0.39583333333333
110467, 0.020833333333333, -0.04, 0.41666666666667
110468, 0.041666666666667, -0.06, 0.41666666666667
110469, 0.041666666666667, -0.08, 0.39583333333333
110470, 0.020833333333333, -0.08, 0.41666666666667
110471, 0.041666666666667, -0.1, 0.41666666666667
110472, 0.041666666666667, -0.12, 0.39583333333333
110473, 0.020833333333333, -0.12, 0.41666666666667
110474, 0.041666666666667, -0.14, 0.41666666666667
110475, 0.041666666666667, -0.16, 0.39583333333333
110476, 0.020833333333333, -0.16, 0.41666666666667
110477, 0.041666666666667, -0.18, 0.41666666666667
110478, 0.041666666666667, -0.02, 0.45833333333333
110479, 0.041666666666667, -0.04, 0.4375
110480, 0.020833333333333, -0.04, 0.45833333333333
110481, 0.041666666666667, -0.06, 0.45833333333333
110482, 0.041666666666667, -0.08, 0.4375
110483, 0.020833333333333, -0.08, 0.45833333333333
110484, 0.041666666666667, -0.1, 0.45833333333333
110485, 0.041666666666667, -0.12, 0.4375
110486, 0.020833333333333, -0.12, 0.45833333333333
110487, 0.041666666666667, -0.14, 0.45833333333333
110488, 0.041666666666667, -0.16, 0.4375
110489, 0.020833333333333, -0.16, 0.45833333333333
110490, 0.041666666666667, -0.18, 0.45833333333333
110491, 0.041666666666667, -0.04, 0.47916666666667
110492, 0.041666666666667, -0.08, 0.47916666666667
110493, 0.041666666666667, -0.12, 0.47916666666667
110494, 0.041666666666667, -0.16, 0.47916666666667
110495, 0.083333333333333, -0.02, 0.041666666666667
110496, 0.083333333333333, -0.04, 0.020833333333333
110497, 0.0625, -0.04, 0.041666666666667
110498, 0.083333333333333, -0.06, 0.041666666666667
110499, 0.083333333333333, -0.08, 0.020833333333333
110500, 0.0625, -0.08, 0.041666666666667
110501, 0.083333333333333, -0.1, 0.041666666666667
110502, 0.083333333333333, -0.12, 0.020833333333333
110503, 0.0625, -0.12, 0.041666666666667
110504, 0.083333333333333, -0.14, 0.041666666666667
110505, 0.083333333333333, -0.16, 0.020833333333333
110506, 0.0625, -0.16, 0.041666666666667
110507, 0.083333333333333, -0.18, 0.041666666666667
110508, 0.083333333333333, -0.02, 0.083333333333333
110509, 0.083333333333333, -0.04, 0.0625
110510, 0.0625, -0.04, 0.083333333333333
110511, 0.083333333333333, -0.06, 0.083333333333333
110512, 0.083333333333333, -0.08, 0.0625
110513, 0.0625, -0.08, 0.083333333333333
110514, 0.083333333333333, -0.1, 0.083333333333333
110515, 0.083333333333333, -0.12, 0.0625
110516, 0.0625, -0.12, 0.083333333333333
110517, 0.083333333333333, -0.14, 0.083333333333333
110518, 0.083333333333333, -0.16, 0.0625
110519, 0.0625, -0.16, 0.083333333333333
110520, 0.083333333333333, -0.18, 0.083333333333333
110521, 0.083333333333333, -0.02, 0.125
110522, 0.083333333333333, -0.04, 0.10416666666667
110523, 0.0625, -0.04, 0.125
110524, 0.083333333333333, -0.06, 0.125
110525, 0.083333333333333, -0.08, 0.10416666666667
110526, 0.0625, -0.08, 0.125
110527, 0.083333333333333, -0.1, 0.125
110528, 0.083333333333333, -0.12, 0.10416666666667
110529, 0.0625, -0.12, 0.125
110530, 0.083333333333333, -0.14, 0.125
110531, 0.083333333333333, -0.16, 0.10416666666667
110532, 0.0625, -0.16, 0.125
110533, 0.083333333333333, -0.18, 0.125
110534, 0.083333333333333, -0.02, 0.16666666666667
110535, 0.083333333333333, -0.04, 0.14583333333333
110536, 0.0625, -0.04, 0.16666666666667
110537, 0.083333333333333, -0.06, 0.16666666666667
110538, 0.083333333333333, -0.08, 0.14583333333333
110539, 0.0625, -0.08, 0.16666666666667
110540, 0.083333333333333, -0.1, 0.16666666666667
110541, 0.083333333333333, -0.12, 0.14583333333333
110542, 0.0625, -0.12, 0.16666666666667
110543, 0.083333333333333, -0.14, 0.16666666666667
110544, 0.083333333333333, -0.16, 0.14583333333333
110545, 0.0625, -0.16, 0.16666666666667
110546, 0.083333333333333, -0.18, 0.16666666666667
110547, 0.083333333333333, -0.02, 0.20833333333333
110548, 0.083333333333333, -0.04, 0.1875
110549, 0.0625, -0.04, 0.20833333333333
110550, 0.083333333333333, -0.06, 0.20833333333333
110551, 0.083333333333333, -0.08, 0.1875
110552, 0.0625, -0.08, 0.20833333333333
110553, 0.083333333333333, -0.1, 0.20833333333333
110554, 0.083333333333333, -0.12, 0.1875
110555, 0.0625, -0.12, 0.20833333333333
110556, 0.083333333333333, -0.14, 0.20833333333333
110557, 0.083333333333333, -0.16, 0.1875
110558, 0.0625, -0.16, 0.20833333333333
110559, 0.083333333333333, -0.18, 0.20833333333333
110560, 0.083333333333333, -0.02, 0.25
110561, 0.083333333333333, -0.04, 0.22916666666667
110562, 0.0625, -0.04, 0.25
110563, 0.083333333333333, -0.06, 0.25
110564, 0.083333333333333, -0.08, 0.22916666666667
110565, 0.0625, -0.08, 0.25
110566, 0.083333333333333, -0.1, 0.25
110567, 0.083333333333333, -0.12, 0.22916666666667
110568, 0.0625, -0.12, 0.25
110569, 0.083333333333333, -0.14, 0.25
110570, 0.083333333333333, -0.16, 0.22916666666667
110571, 0.0625, -0.16, 0.25
110572, 0.083333333333333, -0.18, 0.25
110573, 0.083333333333333, -0.02, 0.29166666666667
110574, 0.083333333333333, -0.04, 0.27083333333333
110575, 0.0625, -0.04, 0.29166666666667
110576, 0.083333333333333, -0.06, 0.29166666666667
110577, 0.083333333333333, -0.08, 0.27083333333333
110578, 0.0625, -0.08, 0.29166666666667
110579, 0.083333333333333, -0.1, 0.29166666666667
110580, 0.083333333333333, -0.12, 0.27083333333333
110581, 0.0625, -0.12, 0.29166666666667
110582, 0.083333333333333, -0.14, 0.29166666666667
110583, 0.083333333333333, -0.16, 0.27083333333333
110584, 0.0625, -0.16, 0.29166666666667
110585, 0.083333333333333, -0.18, 0.29166666666667
110586, 0.083333333333333, -0.02, 0.33333333333333
110587, 0.083333333333333, -0.04, 0.3125
110588, 0.0625, -0.04, 0.33333333333333
110589, 0.083333333333333, -0.06, 0.33333333333333
110590, 0.083333333333333, -0.08, 0.3125
110591, 0.0625, -0.08, 0.33333333333333
110592, 0.083333333333333, -0.1, 0.33333333333333
110593, 0.083333333333333, -0.12, 0.3125
110594, 0.0625, -0.12, 0.33333333333333
110595, 0.083333333333333, -0.14, 0.33333333333333
110596, 0.083333333333333, -0.16, 0.3125
110597, 0.0625, -0.16, 0.33333333333333
110598, 0.083333333333333, -0.18, 0.33333333333333
110599, 0.083333333333333, -0.02, 0.375
110600, 0.083333333333333, -0.04, 0.35416666666667
110601, 0.0625, -0.04, 0.375
110602, 0.083333333333333, -0.06, 0.375
110603, 0.083333333333333, -0.08, 0.35416666666667
110604, 0.0625, -0.08, 0.375
110605, 0.083333333333333, -0.1, 0.375
110606, 0.083333333333333, -0.12, 0.35416666666667
110607, 0.0625, -0.12, 0.375
110608, 0.083333333333333, -0.14, 0.375
110609, 0.083333333333333, -0.16, 0.35416666666667
110610, 0.0625, -0.16, 0.375
110611, 0.083333333333333, -0.18, 0.375
110612, 0.083333333333333, -0.02, 0.41666666666667
110613, 0.083333333333333, -0.04, 0.39583333333333
110614, 0.0625, -0.04, 0.41666666666667
110615, 0.083333333333333, -0.06, 0.41666666666667
110616, 0.083333333333333, -0.08, 0.39583333333333
110617, 0.0625, -0.08, 0.41666666666667
110618, 0.083333333333333, -0.1, 0.41666666666667
110619, 0.083333333333333, -0.12, 0.39583333333333
110620, 0.0625, -0.12, 0.41666666666667
110621, 0.083333333333333, -0.14, 0.41666666666667
110622, 0.083333333333333, -0.16, 0.39583333333333
110623, 0.0625, -0.16, 0.41666666666667
110624, 0.083333333333333, -0.18, 0.41666666666667
110625, 0.083333333333333, -0.02, 0.45833333333333
110626, 0.083333333333333, -0.04, 0.4375
110627, 0.0625, -0.04, 0.45833333333333
110628, 0.083333333333333, -0.06, 0.45833333333333
110629, 0.083333333333333, -0.08, 0.4375
110630, 0.0625, -0.08, 0.45833333333333
110631, 0.083333333333333, -0.1, 0.45833333333333
110632, 0.083333333333333, -0.12, 0.4375
110633, 0.0625, -0.12, 0.45833333333333
110634, 0.083333333333333, -0.14, 0.45833333333333
110635, 0.083333333333333, -0.16, 0.4375
110636, 0.0625, -0.16, 0.45833333333333
110637, 0.083333333333333, -0.18, 0.45833333333333
110638, 0.083333333333333, -0.04, 0.47916666666667
110639, 0.083333333333333, -0.08, 0.47916666666667
110640, 0.083333333333333, -0.12, 0.47916666666667
110641, 0.083333333333333, -0.16, 0.47916666666667
110642, 0.125, -0.02, 0.041666666666667
110643, 0.125, -0.04, 0.020833333333333
110644, 0.10416666666667, -0.04, 0.041666666666667
110645, 0.125, -0.06, 0.041666666666667
110646, 0.125, -0.08, 0.020833333333333
110647, 0.10416666666667, -0.08, 0.041666666666667
110648, 0.125, -0.1, 0.041666666666667
110649, 0.125, -0.12, 0.020833333333333
110650, 0.10416666666667, -0.12, 0.041666666666667
110651, 0.125, -0.14, 0.041666666666667
110652, 0.125, -0.16, 0.020833333333333
110653, 0.10416666666667, -0.16, 0.041666666666667
110654, 0.125, -0.18, 0.041666666666667
110655, 0.125, -0.02, 0.083333333333333
110656, 0.125, -0.04, 0.0625
110657, 0.10416666666667, -0.04, 0.083333333333333
110658, 0.125, -0.06, 0.083333333333333
110659, 0.125, -0.08, 0.0625
110660, 0.10416666666667, -0.08, 0.083333333333333
110661, 0.125, -0.1, 0.083333333333333
110662, 0.125, -0.12, 0.0625
110663, 0.10416666666667, -0.12, 0.083333333333333
110664, 0.125, -0.14, 0.083333333333333
110665, 0.125, -0.16, 0.0625
110666, 0.10416666666667, -0.16, 0.083333333333333
110667, 0.125, -0.18, 0.083333333333333
110668, 0.125, -0.02, 0.125
110669, 0.125, -0.04, 0.10416666666667
110670, 0.10416666666667, -0.04, 0.125
110671, 0.125, -0.06, 0.125
110672, 0.125, -0.08, 0.10416666666667
110673, 0.10416666666667, -0.08, 0.125
110674, 0.125, -0.1, 0.125
110675, 0.125, -0.12, 0.10416666666667
110676, 0.10416666666667, -0.12, 0.125
110677, 0.125, -0.14, 0.125
110678, 0.125, -0.16, 0.10416666666667
110679, 0.10416666666667, -0.16, 0.125
110680, 0.125, -0.18, 0.125
110681, 0.125, -0.02, 0.16666666666667
110682, 0.125, -0.04, 0.14583333333333
110683, 0.10416666666667, -0.04, 0.16666666666667
110684, 0.125, -0.06, 0.16666666666667
110685, 0.125, -0.08, 0.14583333333333
110686, 0.10416666666667, -0.08, 0.16666666666667
110687, 0.125, -0.1, 0.16666666666667
110688, 0.125, -0.12, 0.14583333333333
110689, 0.10416666666667, -0.12, 0.16666666666667
110690, 0.125, -0.14, 0.16666666666667
110691, 0.125, -0.16, 0.14583333333333
110692, 0.10416666666667, -0.16, 0.16666666666667
110693, 0.125, -0.18, 0.16666666666667
110694, 0.125, -0.02, 0.20833333333333
110695, 0.125, -0.04, 0.1875
110696, 0.10416666666667, -0.04, 0.20833333333333
110697, 0.125, -0.06, 0.20833333333333
110698, 0.125, -0.08, 0.1875
110699, 0.10416666666667, -0.08, 0.20833333333333
110700, 0.125, -0.1, 0.20833333333333
110701, 0.125, -0.12, 0.1875
110702, 0.10416666666667, -0.12, 0.20833333333333
110703, 0.125, -0.14, 0.20833333333333
110704, 0.125, -0.16, 0.1875
110705, 0.10416666666667, -0.16, 0.20833333333333
110706, 0.125, -0.18, 0.20833333333333
110707, 0.125, -0.02, 0.25
110708, 0.125, -0.04, 0.22916666666667
110709, 0.10416666666667, -0.04, 0.25
110710, 0.125, -0.06, 0.25
110711, 0.125, -0.08, 0.22916666666667
110712, 0.10416666666667, -0.08, 0.25
110713, 0.125, -0.1, 0.25
110714, 0.125, -0.12, 0.22916666666667
110715, 0.10416666666667, -0.12, 0.25
110716, 0.125, -0.14, 0.25
110717, 0.125, -0.16, 0.22916666666667
110718, 0.10416666666667, -0.16, 0.25
110719, 0.125, -0.18, 0.25
110720, 0.125, -0.02, 0.29166666666667
110721, 0.125, -0.04, 0.27083333333333
110722, 0.10416666666667, -0.04, 0.29166666666667
110723, 0.125, -0.06, 0.29166666666667
110724, 0.125, -0.08, 0.27083333333333
110725, 0.10416666666667, -0.08, 0.29166666666667
110726, 0.125, -0.1, 0.29166666666667
110727, 0.125, -0.12, 0.27083333333333
110728, 0.10416666666667, -0.12, 0.29166666666667
110729, 0.125, -0.14, 0.29166666666667
110730, 0.125, -0.16, 0.27083333333333
110731, 0.10416666666667, -0.16, 0.29166666666667
110732, 0.125, -0.18, 0.29166666666667
110733, 0.125, -0.02, 0.33333333333333
110734, 0.125, -0.04, 0.3125
110735, 0.10416666666667, -0.04, 0.33333333333333
110736, 0.125, -0.06, 0.33333333333333
110737, 0.125, -0.08, 0.3125
110738, 0.10416666666667, -0.08, 0.33333333333333
110739, 0.125, -0.1, 0.33333333333333
110740, 0.125, -0.12, 0.3125
110741, 0.10416666666667, -0.12, 0.33333333333333
110742, 0.125, -0.14, 0.33333333333333
110743, 0.125, -0.16, 0.3125
110744, 0.10416666666667, -0.16, 0.33333333333333
110745, 0.125, -0.18, 0.33333333333333
110746, 0.125, -0.02, 0.375
110747, 0.125, -0.04, 0.35416666666667
110748, 0.10416666666667, -0.04, 0.375
110749, 0.125, -0.06, 0.375
110750, 0.125, -0.08, 0.35416666666667
110751, 0.10416666666667, -0.08, 0.375
110752, 0.125, -0.1, 0.375
110753, 0.125, -0.12, 0.35416666666667
110754, 0.10416666666667, -0.12, 0.375
110755, 0.125, -0.14, 0.375
110756, 0.125, -0.16, 0.35416666666667
110757, 0.10416666666667, -0.16, 0.375
110758, 0.125, -0.18, 0.375
110759, 0.125, -0.02, 0.41666666666667
110760, 0.125, -0.04, 0.39583333333333
110761, 0.10416666666667, -0.04, 0.41666666666667
110762, 0.125, -0.06, 0.41666666666667
110763, 0.125, -0.08, 0.39583333333333
110764, 0.10416666666667, -0.08, 0.41666666666667
110765, 0.125, -0.1, 0.41666666666667
110766, 0.125, -0.12, 0.39583333333333
110767, 0.10416666666667, -0.12, 0.41666666666667
110768, 0.125, -0.14, 0.41666666666667
110769, 0.125, -0.16, 0.39583333333333
110770, 0.10416666666667, -0.16, 0.41666666666667
110771, 0.125, -0.18, 0.41666666666667
110772, 0.125, -0.02, 0.45833333333333
110773, 0.125, -0.04, 0.4375
110774, 0.10416666666667, -0.04, 0.45833333333333
110775, 0.125, -0.06, 0.45833333333333
110776, 0.125, -0.08, 0.4375
110777, 0.10416666666667, -0.08, 0.45833333333333
110778, 0.125, -0.1, 0.45833333333333
110779, 0.125, -0.12, 0.4375
110780, 0.10416666666667, -0.12, 0.45833333333333
110781, 0.125, -0.14, 0.45833333333333
110782, 0.125, -0.16, 0.4375
110783, 0.10416666666667, -0.16, 0.45833333333333
110784, 0.125, -0.18, 0.45833333333333
110785, 0.125, -0.04, 0.47916666666667
110786, 0.125, -0.08, 0.47916666666667
110787, 0.125, -0.12, 0.47916666666667
110788, 0.125, -0.16, 0.47916666666667
110789, 0.16666666666667, -0.02, 0.041666666666667
110790, 0.16666666666667, -0.04, 0.020833333333333
110791, 0.14583333333333, -0.04, 0.041666666666667
110792, 0.16666666666667, -0.06, 0.041666666666667
110793, 0.16666666666667, -0.08, 0.020833333333333
110794, 0.14583333333333, -0.08, 0.041666666666667
110795, 0.16666666666667, -0.1, 0.041666666666667
110796, 0.16666666666667, -0.12, 0.020833333333333
110797, 0.14583333333333, -0.12, 0.041666666666667
110798, 0.16666666666667, -0.14, 0.041666666666667
110799, 0.16666666666667, -0.16, 0.020833333333333
110800, 0.14583333333333, -0.16, 0.041666666666667
110801, 0.16666666666667, -0.18, 0.041666666666667
110802, 0.16666666666667, -0.02, 0.083333333333333
110803, 0.16666666666667, -0.04, 0.0625
110804, 0.14583333333333, -0.04, 0.083333333333333
110805, 0.16666666666667, -0.06, 0.083333333333333
110806, 0.16666666666667, -0.08, 0.0625
110807, 0.14583333333333, -0.08, 0.083333333333333
110808, 0.16666666666667, -0.1, 0.083333333333333
110809, 0.16666666666667, -0.12, 0.0625
110810, 0.14583333333333, -0.12, 0.083333333333333
110811, 0.16666666666667, -0.14, 0.083333333333333
110812, 0.16666666666667, -0.16, 0.0625
110813, 0.14583333333333, -0.16, 0.083333333333333
110814, 0.16666666666667, -0.18, 0.083333333333333
110815, 0.16666666666667, -0.02, 0.125
110816, 0.16666666666667, -0.04, 0.10416666666667
110817, 0.14583333333333, -0.04, 0.125
110818, 0.16666666666667, -0.06, 0.125
110819, 0.16666666666667, -0.08, 0.10416666666667
110820, 0.14583333333333, -0.08, 0.125
110821, 0.16666666666667, -0.1, 0.125
110822, 0.16666666666667, -0.12, 0.10416666666667
110823, 0.14583333333333, -0.12, 0.125
110824, 0.16666666666667, -0.14, 0.125
110825, 0.16666666666667, -0.16, 0.10416666666667
110826, 0.14583333333333, -0.16, 0.125
110827, 0.16666666666667, -0.18, 0.125
110828, 0.16666666666667, -0.02, 0.16666666666667
110829, 0.16666666666667, -0.04, 0.14583333333333
110830, 0.14583333333333, -0.04, 0.16666666666667
110831, 0.16666666666667, -0.06, 0.16666666666667
110832, 0.16666666666667, -0.08, 0.14583333333333
110833, 0.14583333333333, -0.08, 0.16666666666667
110834, 0.16666666666667, -0.1, 0.16666666666667
110835, 0.16666666666667, -0.12, 0.14583333333333
110836, 0.14583333333333, -0.12, 0.16666666666667
110837, 0.16666666666667, -0.14, 0.16666666666667
110838, 0.16666666666667, -0.16, 0.14583333333333
110839, 0.14583333333333, -0.16, 0.16666666666667
110840, 0.16666666666667, -0.18, 0.16666666666667
110841, 0.16666666666667, -0.02, 0.20833333333333
110842, 0.16666666666667, -0.04, 0.1875
110843, 0.14583333333333, -0.04, 0.20833333333333
110844, 0.16666666666667, -0.06, 0.20833333333333
110845, 0.16666666666667, -0.08, 0.1875
110846, 0.14583333333333, -0.08, 0.20833333333333
110847, 0.16666666666667, -0.1, 0.20833333333333
110848, 0.16666666666667, -0.12, 0.1875
110849, 0.14583333333333, -0.12, 0.20833333333333
110850, 0.16666666666667, -0.14, 0.20833333333333
110851, 0.16666666666667, -0.16, 0.1875
110852, 0.14583333333333, -0.16, 0.20833333333333
110853, 0.16666666666667, -0.18, 0.20833333333333
110854, 0.16666666666667, -0.02, 0.25
110855, 0.16666666666667, -0.04, 0.22916666666667
110856, 0.14583333333333, -0.04, 0.25
110857, 0.16666666666667, -0.06, 0.25
110858, 0.16666666666667, -0.08, 0.22916666666667
110859, 0.14583333333333, -0.08, 0.25
110860, 0.16666666666667, -0.1, 0.25
110861, 0.16666666666667, -0.12, 0.22916666666667
110862, 0.14583333333333, -0.12, 0.25
110863, 0.16666666666667, -0.14, 0.25
110864, 0.16666666666667, -0.16, 0.22916666666667
110865, 0.14583333333333, -0.16, 0.25
110866, 0.16666666666667, -0.18, 0.25
110867, 0.16666666666667, -0.02, 0.29166666666667
110868, 0.16666666666667, -0.04, 0.27083333333333
110869, 0.14583333333333, -0.04, 0.29166666666667
110870, 0.16666666666667, -0.06, 0.29166666666667
110871, 0.16666666666667, -0.08, 0.27083333333333
110872, 0.14583333333333, -0.08, 0.29166666666667
110873, 0.16666666666667, -0.1, 0.29166666666667
110874, 0.16666666666667, -0.12, 0.27083333333333
110875, 0.14583333333333, -0.12, 0.29166666666667
110876, 0.16666666666667, -0.14, 0.29166666666667
110877, 0.16666666666667, -0.16, 0.27083333333333
110878, 0.14583333333333, -0.16, 0.29166666666667
110879, 0.16666666666667, -0.18, 0.29166666666667
110880, 0.16666666666667, -0.02, 0.33333333333333
110881, 0.16666666666667, -0.04, 0.3125
110882, 0.14583333333333, -0.04, 0.33333333333333
110883, 0.16666666666667, -0.06, 0.33333333333333
110884, 0.16666666666667, -0.08, 0.3125
110885, 0.14583333333333, -0.08, 0.33333333333333
110886, 0.16666666666667, -0.1, 0.33333333333333
110887, 0.16666666666667, -0.12, 0.3125
110888, 0.14583333333333, -0.12, 0.33333333333333
110889, 0.16666666666667, -0.14, 0.33333333333333
110890, 0.16666666666667, -0.16, 0.3125
110891, 0.14583333333333, -0.16, 0.33333333333333
110892, 0.16666666666667, -0.18, 0.33333333333333
110893, 0.16666666666667, -0.02, 0.375
110894, 0.16666666666667, -0.04, 0.35416666666667
110895, 0.14583333333333, -0.04, 0.375
110896, 0.16666666666667, -0.06, 0.375
110897, 0.16666666666667, -0.08, 0.35416666666667
110898, 0.14583333333333, -0.08, 0.375
110899, 0.16666666666667, -0.1, 0.375
110900, 0.16666666666667, -0.12, 0.35416666666667
110901, 0.14583333333333, -0.12, 0.375
110902, 0.16666666666667, -0.14, 0.375
110903, 0.16666666666667, -0.16, 0.35416666666667
110904, 0.14583333333333, -0.16, 0.375
110905, 0.16666666666667, -0.18, 0.375
110906, 0.16666666666667, -0.02, 0.41666666666667
110907, 0.16666666666667, -0.04, 0.39583333333333
110908, 0.14583333333333, -0.04, 0.41666666666667
110909, 0.16666666666667, -0.06, 0.41666666666667
110910, 0.16666666666667, -0.08, 0.39583333333333
110911, 0.14583333333333, -0.08, 0.41666666666667
110912, 0.16666666666667, -0.1, 0.41666666666667
110913, 0.16666666666667, -0.12, 0.39583333333333
110914, 0.14583333333333, -0.12, 0.41666666666667
110915, 0.16666666666667, -0.14, 0.41666666666667
110916, 0.16666666666667, -0.16, 0.39583333333333
110917, 0.14583333333333, -0.16, 0.41666666666667
110918, 0.16666666666667, -0.18, 0.41666666666667
110919, 0.16666666666667, -0.02, 0.45833333333333
110920, 0.16666666666667, -0.04, 0.4375
110921, 0.14583333333333, -0.04, 0.45833333333333
110922, 0.16666666666667, -0.06, 0.45833333333333
110923, 0.16666666666667, -0.08, 0.4375
110924, 0.14583333333333, -0.08, 0.45833333333333
110925, 0.16666666666667, -0.1, 0.45833333333333
110926, 0.16666666666667, -0.12, 0.4375
110927, 0.14583333333333, -0.12, 0.45833333333333
110928, 0.16666666666667, -0.14, 0.45833333333333
110929, 0.16666666666667, -0.16, 0.4375
110930, 0.14583333333333, -0.16, 0.45833333333333
110931, 0.16666666666667, -0.18, 0.45833333333333
110932, 0.16666666666667, -0.04, 0.47916666666667
110933, 0.16666666666667, -0.08, 0.47916666666667
110934, 0.16666666666667, -0.12, 0.47916666666667
110935, 0.16666666666667, -0.16, 0.47916666666667
110936, 0.20833333333333, -0.02, 0.041666666666667
110937, 0.20833333333333, -0.04, 0.020833333333333
110938, 0.1875, -0.04, 0.041666666666667
110939, 0.20833333333333, -0.06, 0.041666666666667
110940, 0.20833333333333, -0.08, 0.020833333333333
110941, 0.1875, -0.08, 0.041666666666667
110942, 0.20833333333333, -0.1, 0.041666666666667
110943, 0.20833333333333, -0.12, 0.020833333333333
110944, 0.1875, -0.12, 0.041666666666667
110945, 0.20833333333333, -0.14, 0.041666666666667
110946, 0.20833333333333, -0.16, 0.020833333333333
110947, 0.1875, -0.16, 0.041666666666667
110948, 0.20833333333333, -0.18, 0.041666666666667
110949, 0.20833333333333, -0.02, 0.083333333333333
110950, 0.20833333333333, -0.04, 0.0625
110951, 0.1875, -0.04, 0.083333333333333
110952, 0.20833333333333, -0.06, 0.083333333333333
110953, 0.20833333333333, -0.08, 0.0625
110954, 0.1875, -0.08, 0.083333333333333
110955, 0.20833333333333, -0.1, 0.083333333333333
110956, 0.20833333333333, -0.12, 0.0625
110957, 0.1875, -0.12, 0.083333333333333
110958, 0.20833333333333, -0.14, 0.083333333333333
110959, 0.20833333333333, -0.16, 0.0625
110960, 0.1875, -0.16, 0.083333333333333
110961, 0.20833333333333, -0.18, 0.083333333333333
110962, 0.20833333333333, -0.02, 0.125
110963, 0.20833333333333, -0.04, 0.10416666666667
110964, 0.1875, -0.04, 0.125
110965, 0.20833333333333, -0.06, 0.125
110966, 0.20833333333333, -0.08, 0.10416666666667
110967, 0.1875, -0.08, 0.125
110968, 0.20833333333333, -0.1, 0.125
110969, 0.20833333333333, -0.12, 0.10416666666667
110970, 0.1875, -0.12, 0.125
110971, 0.20833333333333, -0.14, 0.125
110972, 0.20833333333333, -0.16, 0.10416666666667
110973, 0.1875, -0.16, 0.125
110974, 0.20833333333333, -0.18, 0.125
110975, 0.20833333333333, -0.02, 0.16666666666667
110976, 0.20833333333333, -0.04, 0.14583333333333
110977, 0.1875, -0.04, 0.16666666666667
110978, 0.20833333333333, -0.06, 0.16666666666667
110979, 0.20833333333333, -0.08, 0.14583333333333
110980, 0.1875, -0.08, 0.16666666666667
110981, 0.20833333333333, -0.1, 0.16666666666667
110982, 0.20833333333333, -0.12, 0.14583333333333
110983, 0.1875, -0.12, 0.16666666666667
110984, 0.20833333333333, -0.14, 0.16666666666667
110985, 0.20833333333333, -0.16, 0.14583333333333
110986, 0.1875, -0.16, 0.16666666666667
110987, 0.20833333333333, -0.18, 0.16666666666667
110988, 0.20833333333333, -0.02, 0.20833333333333
110989, 0.20833333333333, -0.04, 0.1875
110990, 0.1875, -0.04, 0.20833333333333
110991, 0.20833333333333, -0.06, 0.20833333333333
110992, 0.20833333333333, -0.08, 0.1875
110993, 0.1875, -0.08, 0.20833333333333
110994, 0.20833333333333, -0.1, 0.20833333333333
110995, 0.20833333333333, -0.12, 0.1875
110996, 0.1875, -0.12, 0.20833333333333
110997, 0.20833333333333, -0.14, 0.20833333333333
110998, 0.20833333333333, -0.16, 0.1875
110999, 0.1875, -0.16, 0.20833333333333
111000, 0.20833333333333, -0.18, 0.20833333333333
111001, 0.20833333333333, -0.02, 0.25
111002, 0.20833333333333, -0.04, 0.22916666666667
111003, 0.1875, -0.04, 0.25
111004, 0.20833333333333, -0.06, 0.25
111005, 0.20833333333333, -0.08, 0.22916666666667
111006, 0.1875, -0.08, 0.25
111007, 0.20833333333333, -0.1, 0.25
111008, 0.20833333333333, -0.12, 0.22916666666667
111009, 0.1875, -0.12, 0.25
111010, 0.20833333333333, -0.14, 0.25
111011, 0.20833333333333, -0.16, 0.22916666666667
111012, 0.1875, -0.16, 0.25
111013, 0.20833333333333, -0.18, 0.25
111014, 0.20833333333333, -0.02, 0.29166666666667
111015, 0.20833333333333, -0.04, 0.27083333333333
111016, 0.1875, -0.04, 0.29166666666667
111017, 0.20833333333333, -0.06, 0.29166666666667
111018, 0.20833333333333, -0.08, 0.27083333333333
111019, 0.1875, -0.08, 0.29166666666667
111020, 0.20833333333333, -0.1, 0.29166666666667
111021, 0.20833333333333, -0.12, 0.27083333333333
111022, 0.1875, -0.12, 0.29166666666667
111023, 0.20833333333333, -0.14, 0.29166666666667
111024, 0.20833333333333, -0.16, 0.27083333333333
111025, 0.1875, -0.16, 0.29166666666667
111026, 0.20833333333333, -0.18, 0.29166666666667
111027, 0.20833333333333, -0.02, 0.33333333333333
111028, 0.20833333333333, -0.04, 0.3125
111029, 0.1875, -0.04, 0.33333333333333
111030, 0.20833333333333, -0.06, 0.33333333333333
111031, 0.20833333333333, -0.08, 0.3125
111032, 0.1875, -0.08, 0.33333333333333
111033, 0.20833333333333, -0.1, 0.33333333333333
111034, 0.20833333333333, -0.12, 0.3125
111035, 0.1875, -0.12, 0.33333333333333
111036, 0.20833333333333, -0.14, 0.33333333333333
111037, 0.20833333333333, -0.16, 0.3125
111038, 0.1875, -0.16, 0.33333333333333
111039, 0.20833333333333, -0.18, 0.33333333333333
111040, 0.20833333333333, -0.02, 0.375
111041, 0.20833333333333, -0.04, 0.35416666666667
111042, 0.1875, -0.04, 0.375
111043, 0.20833333333333, -0.06, 0.375
111044, 0.20833333333333, -0.08, 0.35416666666667
111045, 0.1875, -0.08, 0.375
111046, 0.20833333333333, -0.1, 0.375
111047, 0.20833333333333, -0.12, 0.35416666666667
111048, 0.1875, -0.12, 0.375
111049, 0.20833333333333, -0.14, 0.375
111050, 0.20833333333333, -0.16, 0.35416666666667
111051, 0.1875, -0.16, 0.375
111052, 0.20833333333333, -0.18, 0.375
111053, 0.20833333333333, -0.02, 0.41666666666667
111054, 0.20833333333333, -0.04, 0.39583333333333
111055, 0.1875, -0.04, 0.41666666666667
111056, 0.20833333333333, -0.06, 0.41666666666667
111057, 0.20833333333333, -0.08, 0.39583333333333
111058, 0.1875, -0.08, 0.41666666666667
111059, 0.20833333333333, -0.1, 0.41666666666667
111060, 0.20833333333333, -0.12, 0.39583333333333
111061, 0.1875, -0.12, 0.41666666666667
111062, 0.20833333333333, -0.14, 0.41666666666667
111063, 0.20833333333333, -0.16, 0.39583333333333
111064, 0.1875, -0.16, 0.41666666666667
111065, 0.20833333333333, -0.18, 0.41666666666667
111066, 0.20833333333333, -0.02, 0.45833333333333
111067, 0.20833333333333, -0.04, 0.4375
111068, 0.1875, -0.04, 0.45833333333333
111069, 0.20833333333333, -0.06, 0.45833333333333
111070, 0.20833333333333, -0.08, 0.4375
111071, 0.1875, -0.08, 0.45833333333333
111072, 0.20833333333333, -0.1, 0.45833333333333
111073, 0.20833333333333, -0.12, 0.4375
111074, 0.1875, -0.12, 0.45833333333333
111075, 0.20833333333333, -0.14, 0.45833333333333
111076, 0.20833333333333, -0.16, 0.4375
111077, 0.1875, -0.16, 0.45833333333333
111078, 0.20833333333333, -0.18, 0.45833333333333
111079, 0.20833333333333, -0.04, 0.47916666666667
111080, 0.20833333333333, -0.08, 0.47916666666667
111081, 0.20833333333333, -0.12, 0.47916666666667
111082, 0.20833333333333, -0.16, 0.47916666666667
111083, 0.25, -0.02, 0.041666666666667
111084, 0.25, -0.04, 0.020833333333333
111085, 0.22916666666667, -0.04, 0.041666666666667
111086, 0.25, -0.06, 0.041666666666667
111087, 0.25, -0.08, 0.020833333333333
111088, 0.22916666666667, -0.08, 0.041666666666667
111089, 0.25, -0.1, 0.041666666666667
111090, 0.25, -0.12, 0.020833333333333
111091, 0.22916666666667, -0.12, 0.041666666666667
111092, 0.25, -0.14, 0.041666666666667
111093, 0.25, -0.16, 0.020833333333333
111094, 0.22916666666667, -0.16, 0.041666666666667
111095, 0.25, -0.18, 0.041666666666667
111096, 0.25, -0.02, 0.083333333333333
111097, 0.25, -0.04, 0.0625
111098, 0.22916666666667, -0.04, 0.083333333333333
111099, 0.25, -0.06, 0.083333333333333
111100, 0.25, -0.08, 0.0625
111101, 0.22916666666667, -0.08, 0.083333333333333
111102, 0.25, -0.1, 0.083333333333333
111103, 0.25, -0.12, 0.0625
111104, 0.22916666666667, -0.12, 0.083333333333333
111105, 0.25, -0.14, 0.083333333333333
111106, 0.25, -0.16, 0.0625
111107, 0.22916666666667, -0.16, 0.083333333333333
111108, 0.25, -0.18, 0.083333333333333
111109, 0.25, -0.02, 0.125
111110, 0.25, -0.04, 0.10416666666667
111111, 0.22916666666667, -0.04, 0.125
111112, 0.25, -0.06, 0.125
111113, 0.25, -0.08, 0.10416666666667
111114, 0.22916666666667, -0.08, 0.125
111115, 0.25, -0.1, 0.125
111116, 0.25, -0.12, 0.10416666666667
111117, 0.22916666666667, -0.12, 0.125
111118, 0.25, -0.14, 0.125
111119, 0.25, -0.16, 0.10416666666667
111120, 0.22916666666667, -0.16, 0.125
111121, 0.25, -0.18, 0.125
111122, 0.25, -0.02, 0.16666666666667
111123, 0.25, -0.04, 0.14583333333333
111124, 0.22916666666667, -0.04, 0.16666666666667
111125, 0.25, -0.06, 0.16666666666667
111126, 0.25, -0.08, 0.14583333333333
111127, 0.22916666666667, -0.08, 0.16666666666667
111128, 0.25, -0.1, 0.16666666666667
111129, 0.25, -0.12, 0.14583333333333
111130, 0.22916666666667, -0.12, 0.16666666666667
111131, 0.25, -0.14, 0.16666666666667
111132, 0.25, -0.16, 0.14583333333333
111133, 0.22916666666667, -0.16, 0.16666666666667
111134, 0.25, -0.18, 0.16666666666667
111135, 0.25, -0.02, 0.20833333333333
111136, 0.25, -0.04, 0.1875
111137, 0.22916666666667, -0.04, 0.20833333333333
111138, 0.25, -0.06, 0.20833333333333
111139, 0.25, -0.08, 0.1875
111140, 0.22916666666667, -0.08, 0.20833333333333
111141, 0.25, -0.1, 0.20833333333333
111142, 0.25, -0.12, 0.1875
111143, 0.22916666666667, -0.12, 0.20833333333333
111144, 0.25, -0.14, 0.20833333333333
111145, 0.25, -0.16, 0.1875
111146, 0.22916666666667, -0.16, 0.20833333333333
111147, 0.25, -0.18, 0.20833333333333
111148, 0.25, -0.02, 0.25
111149, 0.25, -0.04, 0.22916666666667
111150, 0.22916666666667, -0.04, 0.25
111151, 0.25, -0.06, 0.25
111152, 0.25, -0.08, 0.22916666666667
111153, 0.22916666666667, -0.08, 0.25
111154, 0.25, -0.1, 0.25
111155, 0.25, -0.12, 0.22916666666667
111156, 0.22916666666667, -0.12, 0.25
111157, 0.25, -0.14, 0.25
111158, 0.25, -0.16, 0.22916666666667
111159, 0.22916666666667, -0.16, 0.25
111160, 0.25, -0.18, 0.25
111161, 0.25, -0.02, 0.29166666666667
111162, 0.25, -0.04, 0.27083333333333
111163, 0.22916666666667, -0.04, 0.29166666666667
111164, 0.25, -0.06, 0.29166666666667
111165, 0.25, -0.08, 0.27083333333333
111166, 0.22916666666667, -0.08, 0.29166666666667
111167, 0.25, -0.1, 0.29166666666667
111168, 0.25, -0.12, 0.27083333333333
111169, 0.22916666666667, -0.12, 0.29166666666667
111170, 0.25, -0.14, 0.29166666666667
111171, 0.25, -0.16, 0.27083333333333
111172, 0.22916666666667, -0.16, 0.29166666666667
111173, 0.25, -0.18, 0.29166666666667
111174, 0.25, -0.02, 0.33333333333333
111175, 0.25, -0.04, 0.3125
111176, 0.22916666666667, -0.04, 0.33333333333333
111177, 0.25, -0.06, 0.33333333333333
111178, 0.25, -0.08, 0.3125
111179, 0.22916666666667, -0.08, 0.33333333333333
111180, 0.25, -0.1, 0.33333333333333
111181, 0.25, -0.12, 0.3125
111182, 0.22916666666667, -0.12, 0.33333333333333
111183, 0.25, -0.14, 0.33333333333333
111184, 0.25, -0.16, 0.3125
111185, 0.22916666666667, -0.16, 0.33333333333333
111186, 0.25, -0.18, 0.33333333333333
111187, 0.25, -0.02, 0.375
111188, 0.25, -0.04, 0.35416666666667
111189, 0.22916666666667, -0.04, 0.375
111190, 0.25, -0.06, 0.375
111191, 0.25, -0.08, 0.35416666666667
111192, 0.22916666666667, -0.08, 0.375
111193, 0.25, -0.1, 0.375
111194, 0.25, -0.12, 0.35416666666667
111195, 0.22916666666667, -0.12, 0.375
111196, 0.25, -0.14, 0.375
111197, 0.25, -0.16, 0.35416666666667
111198, 0.22916666666667, -0.16, 0.375
111199, 0.25, -0.18, 0.375
111200, 0.25, -0.02, 0.41666666666667
111201, 0.25, -0.04, 0.39583333333333
111202, 0.22916666666667, -0.04, 0.41666666666667
111203, 0.25, -0.06, 0.41666666666667
111204, 0.25, -0.08, 0.39583333333333
111205, 0.22916666666667, -0.08, 0.41666666666667
111206, 0.25, -0.1, 0.41666666666667
111207, 0.25, -0.12, 0.39583333333333
111208, 0.22916666666667, -0.12, 0.41666666666667
111209, 0.25, -0.14, 0.41666666666667
111210, 0.25, -0.16, 0.39583333333333
111211, 0.22916666666667, -0.16, 0.41666666666667
111212, 0.25, -0.18, 0.41666666666667
111213, 0.25, -0.02, 0.45833333333333
111214, 0.25, -0.04, 0.4375
111215, 0.22916666666667, -0.04, 0.45833333333333
111216, 0.25, -0.06, 0.45833333333333
111217, 0.25, -0.08, 0.4375
111218, 0.22916666666667, -0.08, 0.45833333333333
111219, 0.25, -0.1, 0.45833333333333
111220, 0.25, -0.12, 0.4375
111221, 0.22916666666667, -0.12, 0.45833333333333
111222, 0.25, -0.14, 0.45833333333333
111223, 0.25, -0.16, 0.4375
111224, 0.22916666666667, -0.16, 0.45833333333333
111225, 0.25, -0.18, 0.45833333333333
111226, 0.25, -0.04, 0.47916666666667
111227, 0.25, -0.08, 0.47916666666667
111228, 0.25, -0.12, 0.47916666666667
111229, 0.25, -0.16, 0.47916666666667
111230, 0.29166666666667, -0.02, 0.041666666666667
111231, 0.29166666666667, -0.04, 0.020833333333333
111232, 0.27083333333333, -0.04, 0.041666666666667
111233, 0.29166666666667, -0.06, 0.041666666666667
111234, 0.29166666666667, -0.08, 0.020833333333333
111235, 0.27083333333333, -0.08, 0.041666666666667
111236, 0.29166666666667, -0.1, 0.041666666666667
111237, 0.29166666666667, -0.12, 0.020833333333333
111238, 0.27083333333333, -0.12, 0.041666666666667
111239, 0.29166666666667, -0.14, 0.041666666666667
111240, 0.29166666666667, -0.16, 0.020833333333333
111241, 0.27083333333333, -0.16, 0.041666666666667
111242, 0.29166666666667, -0.18, 0.041666666666667
111243, 0.29166666666667, -0.02, 0.083333333333333
111244, 0.29166666666667, -0.04, 0.0625
111245, 0.27083333333333, -0.04, 0.083333333333333
111246, 0.29166666666667, -0.06, 0.083333333333333
111247, 0.29166666666667, -0.08, 0.0625
111248, 0.27083333333333, -0.08, 0.083333333333333
111249, 0.29166666666667, -0.1, 0.083333333333333
111250, 0.29166666666667, -0.12, 0.0625
111251, 0.27083333333333, -0.12, 0.083333333333333
111252, 0.29166666666667, -0.14, 0.083333333333333
111253, 0.29166666666667, -0.16, 0.0625
111254, 0.27083333333333, -0.16, 0.083333333333333
111255, 0.29166666666667, -0.18, 0.083333333333333
111256, 0.29166666666667, -0.02, 0.125
111257, 0.29166666666667, -0.04, 0.10416666666667
111258, 0.27083333333333, -0.04, 0.125
111259, 0.29166666666667, -0.06, 0.125
111260, 0.29166666666667, -0.08, 0.10416666666667
111261, 0.27083333333333, -0.08, 0.125
111262, 0.29166666666667, -0.1, 0.125
111263, 0.29166666666667, -0.12, 0.10416666666667
111264, 0.27083333333333, -0.12, 0.125
111265, 0.29166666666667, -0.14, 0.125
111266, 0.29166666666667, -0.16, 0.10416666666667
111267, 0.27083333333333, -0.16, 0.125
111268, 0.29166666666667, -0.18, 0.125
111269, 0.29166666666667, -0.02, 0.16666666666667
111270, 0.29166666666667, -0.04, 0.14583333333333
111271, 0.27083333333333, -0.04, 0.16666666666667
111272, 0.29166666666667, -0.06, 0.16666666666667
111273, 0.29166666666667, -0.08, 0.14583333333333
111274, 0.27083333333333, -0.08, 0.16666666666667
111275, 0.29166666666667, -0.1, 0.16666666666667
111276, 0.29166666666667, -0.12, 0.14583333333333
111277, 0.27083333333333, -0.12, 0.16666666666667
111278, 0.29166666666667, -0.14, 0.16666666666667
111279, 0.29166666666667, -0.16, 0.14583333333333
111280, 0.27083333333333, -0.16, 0.16666666666667
111281, 0.29166666666667, -0.18, 0.16666666666667
111282, 0.29166666666667, -0.02, 0.20833333333333
111283, 0.29166666666667, -0.04, 0.1875
111284, 0.27083333333333, -0.04, 0.20833333333333
111285, 0.29166666666667, -0.06, 0.20833333333333
111286, 0.29166666666667, -0.08, 0.1875
111287, 0.27083333333333, -0.08, 0.20833333333333
111288, 0.29166666666667, -0.1, 0.20833333333333
111289, 0.29166666666667, -0.12, 0.1875
111290, 0.27083333333333, -0.12, 0.20833333333333
111291, 0.29166666666667, -0.14, 0.20833333333333
111292, 0.29166666666667, -0.16, 0.1875
111293, 0.27083333333333, -0.16, 0.20833333333333
