38401, 105331, 105423, 105427, 105335, 105332, 105424, 105428, 105336, 107636, 107648, 107649, 107345, 107639, 107651, 107652, 
107348, 107334, 107637, 107650, 107347
38402, 105332, 105424, 105428, 105336, 105333, 105425, 105429, 105337, 107639, 107651, 107652, 107348, 107642, 107654, 107655, 
107351, 107337, 107640, 107653, 107350
38403, 105333, 105425, 105429, 105337, 105334, 105426, 105430, 105338, 107642, 107654, 107655, 107351, 107645, 107657, 107658, 
107354, 107340, 107643, 107656, 107353
38404, 105334, 105426, 105430, 105338, 34203, 34226, 34227, 34204, 107645, 107657, 107658, 107354, 34616, 34617, 34618, 
34570, 107343, 107646, 107659, 107356
38405, 16362, 16385, 16386, 16363, 105335, 105427, 105431, 105339, 16776, 16777, 16778, 16730, 107649, 107661, 107662, 
107358, 107344, 107647, 107660, 107357
38406, 105335, 105427, 105431, 105339, 105336, 105428, 105432, 105340, 107649, 107661, 107662, 107358, 107652, 107664, 107665, 
107361, 107347, 107650, 107663, 107360
38407, 105336, 105428, 105432, 105340, 105337, 105429, 105433, 105341, 107652, 107664, 107665, 107361, 107655, 107667, 107668, 
107364, 107350, 107653, 107666, 107363
38408, 105337, 105429, 105433, 105341, 105338, 105430, 105434, 105342, 107655, 107667, 107668, 107364, 107658, 107670, 107671, 
107367, 107353, 107656, 107669, 107366
38409, 105338, 105430, 105434, 105342, 34204, 34227, 34228, 34205, 107658, 107670, 107671, 107367, 34618, 34619, 34620, 
34572, 107356, 107659, 107672, 107369
38410, 16363, 16386, 16387, 16364, 105339, 105431, 105435, 105343, 16778, 16779, 16780, 16732, 107662, 107674, 107675, 
107371, 107357, 107660, 107673, 107370
38411, 105339, 105431, 105435, 105343, 105340, 105432, 105436, 105344, 107662, 107674, 107675, 107371, 107665, 107677, 107678, 
107374, 107360, 107663, 107676, 107373
38412, 105340, 105432, 105436, 105344, 105341, 105433, 105437, 105345, 107665, 107677, 107678, 107374, 107668, 107680, 107681, 
107377, 107363, 107666, 107679, 107376
38413, 105341, 105433, 105437, 105345, 105342, 105434, 105438, 105346, 107668, 107680, 107681, 107377, 107671, 107683, 107684, 
107380, 107366, 107669, 107682, 107379
38414, 105342, 105434, 105438, 105346, 34205, 34228, 34229, 34206, 107671, 107683, 107684, 107380, 34620, 34621, 34622, 
34574, 107369, 107672, 107685, 107382
38415, 16364, 16387, 16388, 16365, 105343, 105435, 105439, 105347, 16780, 16781, 16782, 16734, 107675, 107687, 107688, 
107384, 107370, 107673, 107686, 107383
38416, 105343, 105435, 105439, 105347, 105344, 105436, 105440, 105348, 107675, 107687, 107688, 107384, 107678, 107690, 107691, 
107387, 107373, 107676, 107689, 107386
38417, 105344, 105436, 105440, 105348, 105345, 105437, 105441, 105349, 107678, 107690, 107691, 107387, 107681, 107693, 107694, 
107390, 107376, 107679, 107692, 107389
38418, 105345, 105437, 105441, 105349, 105346, 105438, 105442, 105350, 107681, 107693, 107694, 107390, 107684, 107696, 107697, 
107393, 107379, 107682, 107695, 107392
38419, 105346, 105438, 105442, 105350, 34206, 34229, 34230, 34207, 107684, 107696, 107697, 107393, 34622, 34623, 34624, 
34576, 107382, 107685, 107698, 107395
38420, 16365, 16388, 16389, 16366, 105347, 105439, 105443, 105351, 16782, 16783, 16784, 16736, 107688, 107700, 107701, 
107397, 107383, 107686, 107699, 107396
38421, 105347, 105439, 105443, 105351, 105348, 105440, 105444, 105352, 107688, 107700, 107701, 107397, 107691, 107703, 107704, 
107400, 107386, 107689, 107702, 107399
38422, 105348, 105440, 105444, 105352, 105349, 105441, 105445, 105353, 107691, 107703, 107704, 107400, 107694, 107706, 107707, 
107403, 107389, 107692, 107705, 107402
38423, 105349, 105441, 105445, 105353, 105350, 105442, 105446, 105354, 107694, 107706, 107707, 107403, 107697, 107709, 107710, 
107406, 107392, 107695, 107708, 107405
38424, 105350, 105442, 105446, 105354, 34207, 34230, 34231, 34208, 107697, 107709, 107710, 107406, 34624, 34625, 34626, 
34578, 107395, 107698, 107711, 107408
38425, 16366, 16389, 16390, 16367, 105351, 105443, 105447, 105355, 16784, 16785, 16786, 16738, 107701, 107713, 107714, 
107410, 107396, 107699, 107712, 107409
38426, 105351, 105443, 105447, 105355, 105352, 105444, 105448, 105356, 107701, 107713, 107714, 107410, 107704, 107716, 107717, 
107413, 107399, 107702, 107715, 107412
38427, 105352, 105444, 105448, 105356, 105353, 105445, 105449, 105357, 107704, 107716, 107717, 107413, 107707, 107719, 107720, 
107416, 107402, 107705, 107718, 107415
38428, 105353, 105445, 105449, 105357, 105354, 105446, 105450, 105358, 107707, 107719, 107720, 107416, 107710, 107722, 107723, 
107419, 107405, 107708, 107721, 107418
38429, 105354, 105446, 105450, 105358, 34208, 34231, 34232, 34209, 107710, 107722, 107723, 107419, 34626, 34627, 34628, 
34580, 107408, 107711, 107724, 107421
38430, 16367, 16390, 1491, 1490, 105355, 105447, 33968, 33964, 16786, 16787, 1502, 16740, 107714, 107725, 34037, 
107422, 107409, 107712, 34038, 34029
38431, 105355, 105447, 33968, 33964, 105356, 105448, 33969, 33965, 107714, 107725, 34037, 107422, 107717, 107726, 34039, 
107423, 107412, 107715, 34040, 34031
38432, 105356, 105448, 33969, 33965, 105357, 105449, 33970, 33966, 107717, 107726, 34039, 107423, 107720, 107727, 34041, 
107424, 107415, 107718, 34042, 34033
38433, 105357, 105449, 33970, 33966, 105358, 105450, 33971, 33967, 107720, 107727, 34041, 107424, 107723, 107728, 34043, 
107425, 107418, 107721, 34044, 34035
38434, 105358, 105450, 33971, 33967, 34209, 34232, 3531, 3530, 107723, 107728, 34043, 107425, 34628, 34629, 3542, 
34582, 107421, 107724, 34045, 34036
38435, 1247, 1248, 16391, 16368, 33068, 33072, 105451, 105359, 1259, 16788, 16789, 16741, 33146, 107730, 107731, 
107427, 33138, 33147, 107729, 107426
38436, 33068, 33072, 105451, 105359, 33069, 33073, 105452, 105360, 33146, 107730, 107731, 107427, 33148, 107733, 107734, 
107430, 33140, 33149, 107732, 107429
38437, 33069, 33073, 105452, 105360, 33070, 33074, 105453, 105361, 33148, 107733, 107734, 107430, 33150, 107736, 107737, 
107433, 33142, 33151, 107735, 107432
38438, 33070, 33074, 105453, 105361, 33071, 33075, 105454, 105362, 33150, 107736, 107737, 107433, 33152, 107739, 107740, 
107436, 33144, 33153, 107738, 107435
38439, 33071, 33075, 105454, 105362, 3396, 3397, 34233, 34210, 33152, 107739, 107740, 107436, 3408, 34630, 34631, 
34583, 33145, 33154, 107741, 107438
38440, 16368, 16391, 16392, 16369, 105359, 105451, 105455, 105363, 16789, 16790, 16791, 16743, 107731, 107743, 107744, 
107440, 107426, 107729, 107742, 107439
38441, 105359, 105451, 105455, 105363, 105360, 105452, 105456, 105364, 107731, 107743, 107744, 107440, 107734, 107746, 107747, 
107443, 107429, 107732, 107745, 107442
38442, 105360, 105452, 105456, 105364, 105361, 105453, 105457, 105365, 107734, 107746, 107747, 107443, 107737, 107749, 107750, 
107446, 107432, 107735, 107748, 107445
38443, 105361, 105453, 105457, 105365, 105362, 105454, 105458, 105366, 107737, 107749, 107750, 107446, 107740, 107752, 107753, 
107449, 107435, 107738, 107751, 107448
38444, 105362, 105454, 105458, 105366, 34210, 34233, 34234, 34211, 107740, 107752, 107753, 107449, 34631, 34632, 34633, 
34585, 107438, 107741, 107754, 107451
38445, 16369, 16392, 16393, 16370, 105363, 105455, 105459, 105367, 16791, 16792, 16793, 16745, 107744, 107756, 107757, 
107453, 107439, 107742, 107755, 107452
38446, 105363, 105455, 105459, 105367, 105364, 105456, 105460, 105368, 107744, 107756, 107757, 107453, 107747, 107759, 107760, 
107456, 107442, 107745, 107758, 107455
38447, 105364, 105456, 105460, 105368, 105365, 105457, 105461, 105369, 107747, 107759, 107760, 107456, 107750, 107762, 107763, 
107459, 107445, 107748, 107761, 107458
38448, 105365, 105457, 105461, 105369, 105366, 105458, 105462, 105370, 107750, 107762, 107763, 107459, 107753, 107765, 107766, 
107462, 107448, 107751, 107764, 107461
38449, 105366, 105458, 105462, 105370, 34211, 34234, 34235, 34212, 107753, 107765, 107766, 107462, 34633, 34634, 34635, 
34587, 107451, 107754, 107767, 107464
38450, 16370, 16393, 16394, 16371, 105367, 105459, 105463, 105371, 16793, 16794, 16795, 16747, 107757, 107769, 107770, 
107466, 107452, 107755, 107768, 107465
38451, 105367, 105459, 105463, 105371, 105368, 105460, 105464, 105372, 107757, 107769, 107770, 107466, 107760, 107772, 107773, 
107469, 107455, 107758, 107771, 107468
38452, 105368, 105460, 105464, 105372, 105369, 105461, 105465, 105373, 107760, 107772, 107773, 107469, 107763, 107775, 107776, 
107472, 107458, 107761, 107774, 107471
38453, 105369, 105461, 105465, 105373, 105370, 105462, 105466, 105374, 107763, 107775, 107776, 107472, 107766, 107778, 107779, 
107475, 107461, 107764, 107777, 107474
38454, 105370, 105462, 105466, 105374, 34212, 34235, 34236, 34213, 107766, 107778, 107779, 107475, 34635, 34636, 34637, 
34589, 107464, 107767, 107780, 107477
38455, 16371, 16394, 16395, 16372, 105371, 105463, 105467, 105375, 16795, 16796, 16797, 16749, 107770, 107782, 107783, 
107479, 107465, 107768, 107781, 107478
38456, 105371, 105463, 105467, 105375, 105372, 105464, 105468, 105376, 107770, 107782, 107783, 107479, 107773, 107785, 107786, 
107482, 107468, 107771, 107784, 107481
38457, 105372, 105464, 105468, 105376, 105373, 105465, 105469, 105377, 107773, 107785, 107786, 107482, 107776, 107788, 107789, 
107485, 107471, 107774, 107787, 107484
38458, 105373, 105465, 105469, 105377, 105374, 105466, 105470, 105378, 107776, 107788, 107789, 107485, 107779, 107791, 107792, 
107488, 107474, 107777, 107790, 107487
38459, 105374, 105466, 105470, 105378, 34213, 34236, 34237, 34214, 107779, 107791, 107792, 107488, 34637, 34638, 34639, 
34591, 107477, 107780, 107793, 107490
38460, 16372, 16395, 16396, 16373, 105375, 105467, 105471, 105379, 16797, 16798, 16799, 16751, 107783, 107795, 107796, 
107492, 107478, 107781, 107794, 107491
38461, 105375, 105467, 105471, 105379, 105376, 105468, 105472, 105380, 107783, 107795, 107796, 107492, 107786, 107798, 107799, 
107495, 107481, 107784, 107797, 107494
38462, 105376, 105468, 105472, 105380, 105377, 105469, 105473, 105381, 107786, 107798, 107799, 107495, 107789, 107801, 107802, 
107498, 107484, 107787, 107800, 107497
38463, 105377, 105469, 105473, 105381, 105378, 105470, 105474, 105382, 107789, 107801, 107802, 107498, 107792, 107804, 107805, 
107501, 107487, 107790, 107803, 107500
38464, 105378, 105470, 105474, 105382, 34214, 34237, 34238, 34215, 107792, 107804, 107805, 107501, 34639, 34640, 34641, 
34593, 107490, 107793, 107806, 107503
38465, 16373, 16396, 16397, 16374, 105379, 105471, 105475, 105383, 16799, 16800, 16801, 16753, 107796, 107808, 107809, 
107505, 107491, 107794, 107807, 107504
38466, 105379, 105471, 105475, 105383, 105380, 105472, 105476, 105384, 107796, 107808, 107809, 107505, 107799, 107811, 107812, 
107508, 107494, 107797, 107810, 107507
38467, 105380, 105472, 105476, 105384, 105381, 105473, 105477, 105385, 107799, 107811, 107812, 107508, 107802, 107814, 107815, 
107511, 107497, 107800, 107813, 107510
38468, 105381, 105473, 105477, 105385, 105382, 105474, 105478, 105386, 107802, 107814, 107815, 107511, 107805, 107817, 107818, 
107514, 107500, 107803, 107816, 107513
38469, 105382, 105474, 105478, 105386, 34215, 34238, 34239, 34216, 107805, 107817, 107818, 107514, 34641, 34642, 34643, 
34595, 107503, 107806, 107819, 107516
38470, 16374, 16397, 16398, 16375, 105383, 105475, 105479, 105387, 16801, 16802, 16803, 16755, 107809, 107821, 107822, 
107518, 107504, 107807, 107820, 107517
38471, 105383, 105475, 105479, 105387, 105384, 105476, 105480, 105388, 107809, 107821, 107822, 107518, 107812, 107824, 107825, 
107521, 107507, 107810, 107823, 107520
38472, 105384, 105476, 105480, 105388, 105385, 105477, 105481, 105389, 107812, 107824, 107825, 107521, 107815, 107827, 107828, 
107524, 107510, 107813, 107826, 107523
38473, 105385, 105477, 105481, 105389, 105386, 105478, 105482, 105390, 107815, 107827, 107828, 107524, 107818, 107830, 107831, 
107527, 107513, 107816, 107829, 107526
38474, 105386, 105478, 105482, 105390, 34216, 34239, 34240, 34217, 107818, 107830, 107831, 107527, 34643, 34644, 34645, 
34597, 107516, 107819, 107832, 107529
38475, 16375, 16398, 16399, 16376, 105387, 105479, 105483, 105391, 16803, 16804, 16805, 16757, 107822, 107834, 107835, 
107531, 107517, 107820, 107833, 107530
38476, 105387, 105479, 105483, 105391, 105388, 105480, 105484, 105392, 107822, 107834, 107835, 107531, 107825, 107837, 107838, 
107534, 107520, 107823, 107836, 107533
38477, 105388, 105480, 105484, 105392, 105389, 105481, 105485, 105393, 107825, 107837, 107838, 107534, 107828, 107840, 107841, 
107537, 107523, 107826, 107839, 107536
38478, 105389, 105481, 105485, 105393, 105390, 105482, 105486, 105394, 107828, 107840, 107841, 107537, 107831, 107843, 107844, 
107540, 107526, 107829, 107842, 107539
38479, 105390, 105482, 105486, 105394, 34217, 34240, 34241, 34218, 107831, 107843, 107844, 107540, 34645, 34646, 34647, 
34599, 107529, 107832, 107845, 107542
38480, 16376, 16399, 16400, 16377, 105391, 105483, 105487, 105395, 16805, 16806, 16807, 16759, 107835, 107847, 107848, 
107544, 107530, 107833, 107846, 107543
38481, 105391, 105483, 105487, 105395, 105392, 105484, 105488, 105396, 107835, 107847, 107848, 107544, 107838, 107850, 107851, 
107547, 107533, 107836, 107849, 107546
38482, 105392, 105484, 105488, 105396, 105393, 105485, 105489, 105397, 107838, 107850, 107851, 107547, 107841, 107853, 107854, 
107550, 107536, 107839, 107852, 107549
38483, 105393, 105485, 105489, 105397, 105394, 105486, 105490, 105398, 107841, 107853, 107854, 107550, 107844, 107856, 107857, 
107553, 107539, 107842, 107855, 107552
38484, 105394, 105486, 105490, 105398, 34218, 34241, 34242, 34219, 107844, 107856, 107857, 107553, 34647, 34648, 34649, 
34601, 107542, 107845, 107858, 107555
38485, 16377, 16400, 16401, 16378, 105395, 105487, 105491, 105399, 16807, 16808, 16809, 16761, 107848, 107860, 107861, 
107557, 107543, 107846, 107859, 107556
38486, 105395, 105487, 105491, 105399, 105396, 105488, 105492, 105400, 107848, 107860, 107861, 107557, 107851, 107863, 107864, 
107560, 107546, 107849, 107862, 107559
38487, 105396, 105488, 105492, 105400, 105397, 105489, 105493, 105401, 107851, 107863, 107864, 107560, 107854, 107866, 107867, 
107563, 107549, 107852, 107865, 107562
38488, 105397, 105489, 105493, 105401, 105398, 105490, 105494, 105402, 107854, 107866, 107867, 107563, 107857, 107869, 107870, 
107566, 107552, 107855, 107868, 107565
38489, 105398, 105490, 105494, 105402, 34219, 34242, 34243, 34220, 107857, 107869, 107870, 107566, 34649, 34650, 34651, 
34603, 107555, 107858, 107871, 107568
38490, 16378, 16401, 16402, 16379, 105399, 105491, 105495, 105403, 16809, 16810, 16811, 16763, 107861, 107873, 107874, 
107570, 107556, 107859, 107872, 107569
38491, 105399, 105491, 105495, 105403, 105400, 105492, 105496, 105404, 107861, 107873, 107874, 107570, 107864, 107876, 107877, 
107573, 107559, 107862, 107875, 107572
38492, 105400, 105492, 105496, 105404, 105401, 105493, 105497, 105405, 107864, 107876, 107877, 107573, 107867, 107879, 107880, 
107576, 107562, 107865, 107878, 107575
38493, 105401, 105493, 105497, 105405, 105402, 105494, 105498, 105406, 107867, 107879, 107880, 107576, 107870, 107882, 107883, 
107579, 107565, 107868, 107881, 107578
38494, 105402, 105494, 105498, 105406, 34220, 34243, 34244, 34221, 107870, 107882, 107883, 107579, 34651, 34652, 34653, 
34605, 107568, 107871, 107884, 107581
38495, 16379, 16402, 16403, 16380, 105403, 105495, 105499, 105407, 16811, 16812, 16813, 16765, 107874, 107886, 107887, 
107583, 107569, 107872, 107885, 107582
38496, 105403, 105495, 105499, 105407, 105404, 105496, 105500, 105408, 107874, 107886, 107887, 107583, 107877, 107889, 107890, 
107586, 107572, 107875, 107888, 107585
38497, 105404, 105496, 105500, 105408, 105405, 105497, 105501, 105409, 107877, 107889, 107890, 107586, 107880, 107892, 107893, 
107589, 107575, 107878, 107891, 107588
38498, 105405, 105497, 105501, 105409, 105406, 105498, 105502, 105410, 107880, 107892, 107893, 107589, 107883, 107895, 107896, 
107592, 107578, 107881, 107894, 107591
38499, 105406, 105498, 105502, 105410, 34221, 34244, 34245, 34222, 107883, 107895, 107896, 107592, 34653, 34654, 34655, 
34607, 107581, 107884, 107897, 107594
38500, 16380, 16403, 16404, 16381, 105407, 105499, 105503, 105411, 16813, 16814, 16815, 16767, 107887, 107899, 107900, 
107596, 107582, 107885, 107898, 107595
38501, 105407, 105499, 105503, 105411, 105408, 105500, 105504, 105412, 107887, 107899, 107900, 107596, 107890, 107902, 107903, 
107599, 107585, 107888, 107901, 107598
38502, 105408, 105500, 105504, 105412, 105409, 105501, 105505, 105413, 107890, 107902, 107903, 107599, 107893, 107905, 107906, 
107602, 107588, 107891, 107904, 107601
38503, 105409, 105501, 105505, 105413, 105410, 105502, 105506, 105414, 107893, 107905, 107906, 107602, 107896, 107908, 107909, 
107605, 107591, 107894, 107907, 107604
38504, 105410, 105502, 105506, 105414, 34222, 34245, 34246, 34223, 107896, 107908, 107909, 107605, 34655, 34656, 34657, 
34609, 107594, 107897, 107910, 107607
38505, 16381, 16404, 16405, 16382, 105411, 105503, 105507, 105415, 16815, 16816, 16817, 16769, 107900, 107912, 107913, 
107609, 107595, 107898, 107911, 107608
38506, 105411, 105503, 105507, 105415, 105412, 105504, 105508, 105416, 107900, 107912, 107913, 107609, 107903, 107915, 107916, 
107612, 107598, 107901, 107914, 107611
38507, 105412, 105504, 105508, 105416, 105413, 105505, 105509, 105417, 107903, 107915, 107916, 107612, 107906, 107918, 107919, 
107615, 107601, 107904, 107917, 107614
38508, 105413, 105505, 105509, 105417, 105414, 105506, 105510, 105418, 107906, 107918, 107919, 107615, 107909, 107921, 107922, 
107618, 107604, 107907, 107920, 107617
38509, 105414, 105506, 105510, 105418, 34223, 34246, 34247, 34224, 107909, 107921, 107922, 107618, 34657, 34658, 34659, 
34611, 107607, 107910, 107923, 107620
38510, 16382, 16405, 16406, 16383, 105415, 105507, 105511, 105419, 16817, 16818, 16819, 16771, 107913, 107925, 107926, 
107622, 107608, 107911, 107924, 107621
38511, 105415, 105507, 105511, 105419, 105416, 105508, 105512, 105420, 107913, 107925, 107926, 107622, 107916, 107928, 107929, 
107625, 107611, 107914, 107927, 107624
38512, 105416, 105508, 105512, 105420, 105417, 105509, 105513, 105421, 107916, 107928, 107929, 107625, 107919, 107931, 107932, 
107628, 107614, 107917, 107930, 107627
38513, 105417, 105509, 105513, 105421, 105418, 105510, 105514, 105422, 107919, 107931, 107932, 107628, 107922, 107934, 107935, 
107631, 107617, 107920, 107933, 107630
38514, 105418, 105510, 105514, 105422, 34224, 34247, 34248, 34225, 107922, 107934, 107935, 107631, 34659, 34660, 34661, 
34613, 107620, 107923, 107936, 107633
38515, 16383, 16406, 16407, 16384, 105419, 105511, 105515, 105423, 16819, 16820, 16821, 16773, 107926, 107938, 107939, 
107635, 107621, 107924, 107937, 107634
38516, 105419, 105511, 105515, 105423, 105420, 105512, 105516, 105424, 107926, 107938, 107939, 107635, 107929, 107941, 107942, 
107638, 107624, 107927, 107940, 107637
38517, 105420, 105512, 105516, 105424, 105421, 105513, 105517, 105425, 107929, 107941, 107942, 107638, 107932, 107944, 107945, 
107641, 107627, 107930, 107943, 107640
38518, 105421, 105513, 105517, 105425, 105422, 105514, 105518, 105426, 107932, 107944, 107945, 107641, 107935, 107947, 107948, 
107644, 107630, 107933, 107946, 107643
38519, 105422, 105514, 105518, 105426, 34225, 34248, 34249, 34226, 107935, 107947, 107948, 107644, 34661, 34662, 34663, 
34615, 107633, 107936, 107949, 107646
38520, 16384, 16407, 16408, 16385, 105423, 105515, 105519, 105427, 16821, 16822, 16823, 16775, 107939, 107951, 107952, 
107648, 107634, 107937, 107950, 107647
38521, 105423, 105515, 105519, 105427, 105424, 105516, 105520, 105428, 107939, 107951, 107952, 107648, 107942, 107954, 107955, 
107651, 107637, 107940, 107953, 107650
38522, 105424, 105516, 105520, 105428, 105425, 105517, 105521, 105429, 107942, 107954, 107955, 107651, 107945, 107957, 107958, 
107654, 107640, 107943, 107956, 107653
38523, 105425, 105517, 105521, 105429, 105426, 105518, 105522, 105430, 107945, 107957, 107958, 107654, 107948, 107960, 107961, 
107657, 107643, 107946, 107959, 107656
38524, 105426, 105518, 105522, 105430, 34226, 34249, 34250, 34227, 107948, 107960, 107961, 107657, 34663, 34664, 34665, 
34617, 107646, 107949, 107962, 107659
38525, 16385, 16408, 16409, 16386, 105427, 105519, 105523, 105431, 16823, 16824, 16825, 16777, 107952, 107964, 107965, 
107661, 107647, 107950, 107963, 107660
38526, 105427, 105519, 105523, 105431, 105428, 105520, 105524, 105432, 107952, 107964, 107965, 107661, 107955, 107967, 107968, 
107664, 107650, 107953, 107966, 107663
38527, 105428, 105520, 105524, 105432, 105429, 105521, 105525, 105433, 107955, 107967, 107968, 107664, 107958, 107970, 107971, 
107667, 107653, 107956, 107969, 107666
38528, 105429, 105521, 105525, 105433, 105430, 105522, 105526, 105434, 107958, 107970, 107971, 107667, 107961, 107973, 107974, 
107670, 107656, 107959, 107972, 107669
38529, 105430, 105522, 105526, 105434, 34227, 34250, 34251, 34228, 107961, 107973, 107974, 107670, 34665, 34666, 34667, 
34619, 107659, 107962, 107975, 107672
38530, 16386, 16409, 16410, 16387, 105431, 105523, 105527, 105435, 16825, 16826, 16827, 16779, 107965, 107977, 107978, 
107674, 107660, 107963, 107976, 107673
38531, 105431, 105523, 105527, 105435, 105432, 105524, 105528, 105436, 107965, 107977, 107978, 107674, 107968, 107980, 107981, 
107677, 107663, 107966, 107979, 107676
38532, 105432, 105524, 105528, 105436, 105433, 105525, 105529, 105437, 107968, 107980, 107981, 107677, 107971, 107983, 107984, 
107680, 107666, 107969, 107982, 107679
38533, 105433, 105525, 105529, 105437, 105434, 105526, 105530, 105438, 107971, 107983, 107984, 107680, 107974, 107986, 107987, 
107683, 107669, 107972, 107985, 107682
38534, 105434, 105526, 105530, 105438, 34228, 34251, 34252, 34229, 107974, 107986, 107987, 107683, 34667, 34668, 34669, 
34621, 107672, 107975, 107988, 107685
38535, 16387, 16410, 16411, 16388, 105435, 105527, 105531, 105439, 16827, 16828, 16829, 16781, 107978, 107990, 107991, 
107687, 107673, 107976, 107989, 107686
38536, 105435, 105527, 105531, 105439, 105436, 105528, 105532, 105440, 107978, 107990, 107991, 107687, 107981, 107993, 107994, 
107690, 107676, 107979, 107992, 107689
38537, 105436, 105528, 105532, 105440, 105437, 105529, 105533, 105441, 107981, 107993, 107994, 107690, 107984, 107996, 107997, 
107693, 107679, 107982, 107995, 107692
38538, 105437, 105529, 105533, 105441, 105438, 105530, 105534, 105442, 107984, 107996, 107997, 107693, 107987, 107999, 108000, 
107696, 107682, 107985, 107998, 107695
38539, 105438, 105530, 105534, 105442, 34229, 34252, 34253, 34230, 107987, 107999, 108000, 107696, 34669, 34670, 34671, 
34623, 107685, 107988, 108001, 107698
38540, 16388, 16411, 16412, 16389, 105439, 105531, 105535, 105443, 16829, 16830, 16831, 16783, 107991, 108003, 108004, 
107700, 107686, 107989, 108002, 107699
38541, 105439, 105531, 105535, 105443, 105440, 105532, 105536, 105444, 107991, 108003, 108004, 107700, 107994, 108006, 108007, 
107703, 107689, 107992, 108005, 107702
38542, 105440, 105532, 105536, 105444, 105441, 105533, 105537, 105445, 107994, 108006, 108007, 107703, 107997, 108009, 108010, 
107706, 107692, 107995, 108008, 107705
38543, 105441, 105533, 105537, 105445, 105442, 105534, 105538, 105446, 107997, 108009, 108010, 107706, 108000, 108012, 108013, 
107709, 107695, 107998, 108011, 107708
38544, 105442, 105534, 105538, 105446, 34230, 34253, 34254, 34231, 108000, 108012, 108013, 107709, 34671, 34672, 34673, 
34625, 107698, 108001, 108014, 107711
38545, 16389, 16412, 16413, 16390, 105443, 105535, 105539, 105447, 16831, 16832, 16833, 16785, 108004, 108016, 108017, 
107713, 107699, 108002, 108015, 107712
38546, 105443, 105535, 105539, 105447, 105444, 105536, 105540, 105448, 108004, 108016, 108017, 107713, 108007, 108019, 108020, 
107716, 107702, 108005, 108018, 107715
38547, 105444, 105536, 105540, 105448, 105445, 105537, 105541, 105449, 108007, 108019, 108020, 107716, 108010, 108022, 108023, 
107719, 107705, 108008, 108021, 107718
38548, 105445, 105537, 105541, 105449, 105446, 105538, 105542, 105450, 108010, 108022, 108023, 107719, 108013, 108025, 108026, 
107722, 107708, 108011, 108024, 107721
38549, 105446, 105538, 105542, 105450, 34231, 34254, 34255, 34232, 108013, 108025, 108026, 107722, 34673, 34674, 34675, 
34627, 107711, 108014, 108027, 107724
38550, 16390, 16413, 1492, 1491, 105447, 105539, 33972, 33968, 16833, 16834, 1503, 16787, 108017, 108028, 34046, 
107725, 107712, 108015, 34047, 34038
38551, 105447, 105539, 33972, 33968, 105448, 105540, 33973, 33969, 108017, 108028, 34046, 107725, 108020, 108029, 34048, 
107726, 107715, 108018, 34049, 34040
38552, 105448, 105540, 33973, 33969, 105449, 105541, 33974, 33970, 108020, 108029, 34048, 107726, 108023, 108030, 34050, 
107727, 107718, 108021, 34051, 34042
38553, 105449, 105541, 33974, 33970, 105450, 105542, 33975, 33971, 108023, 108030, 34050, 107727, 108026, 108031, 34052, 
107728, 107721, 108024, 34053, 34044
38554, 105450, 105542, 33975, 33971, 34232, 34255, 3532, 3531, 108026, 108031, 34052, 107728, 34675, 34676, 3543, 
34629, 107724, 108027, 34054, 34045
38555, 1248, 1249, 16414, 16391, 33072, 33076, 105543, 105451, 1260, 16835, 16836, 16788, 33155, 108033, 108034, 
107730, 33147, 33156, 108032, 107729
38556, 33072, 33076, 105543, 105451, 33073, 33077, 105544, 105452, 33155, 108033, 108034, 107730, 33157, 108036, 108037, 
107733, 33149, 33158, 108035, 107732
38557, 33073, 33077, 105544, 105452, 33074, 33078, 105545, 105453, 33157, 108036, 108037, 107733, 33159, 108039, 108040, 
107736, 33151, 33160, 108038, 107735
38558, 33074, 33078, 105545, 105453, 33075, 33079, 105546, 105454, 33159, 108039, 108040, 107736, 33161, 108042, 108043, 
107739, 33153, 33162, 108041, 107738
38559, 33075, 33079, 105546, 105454, 3397, 3398, 34256, 34233, 33161, 108042, 108043, 107739, 3409, 34677, 34678, 
34630, 33154, 33163, 108044, 107741
38560, 16391, 16414, 16415, 16392, 105451, 105543, 105547, 105455, 16836, 16837, 16838, 16790, 108034, 108046, 108047, 
107743, 107729, 108032, 108045, 107742
38561, 105451, 105543, 105547, 105455, 105452, 105544, 105548, 105456, 108034, 108046, 108047, 107743, 108037, 108049, 108050, 
107746, 107732, 108035, 108048, 107745
38562, 105452, 105544, 105548, 105456, 105453, 105545, 105549, 105457, 108037, 108049, 108050, 107746, 108040, 108052, 108053, 
107749, 107735, 108038, 108051, 107748
38563, 105453, 105545, 105549, 105457, 105454, 105546, 105550, 105458, 108040, 108052, 108053, 107749, 108043, 108055, 108056, 
107752, 107738, 108041, 108054, 107751
38564, 105454, 105546, 105550, 105458, 34233, 34256, 34257, 34234, 108043, 108055, 108056, 107752, 34678, 34679, 34680, 
34632, 107741, 108044, 108057, 107754
38565, 16392, 16415, 16416, 16393, 105455, 105547, 105551, 105459, 16838, 16839, 16840, 16792, 108047, 108059, 108060, 
107756, 107742, 108045, 108058, 107755
38566, 105455, 105547, 105551, 105459, 105456, 105548, 105552, 105460, 108047, 108059, 108060, 107756, 108050, 108062, 108063, 
107759, 107745, 108048, 108061, 107758
38567, 105456, 105548, 105552, 105460, 105457, 105549, 105553, 105461, 108050, 108062, 108063, 107759, 108053, 108065, 108066, 
107762, 107748, 108051, 108064, 107761
38568, 105457, 105549, 105553, 105461, 105458, 105550, 105554, 105462, 108053, 108065, 108066, 107762, 108056, 108068, 108069, 
107765, 107751, 108054, 108067, 107764
38569, 105458, 105550, 105554, 105462, 34234, 34257, 34258, 34235, 108056, 108068, 108069, 107765, 34680, 34681, 34682, 
34634, 107754, 108057, 108070, 107767
38570, 16393, 16416, 16417, 16394, 105459, 105551, 105555, 105463, 16840, 16841, 16842, 16794, 108060, 108072, 108073, 
107769, 107755, 108058, 108071, 107768
38571, 105459, 105551, 105555, 105463, 105460, 105552, 105556, 105464, 108060, 108072, 108073, 107769, 108063, 108075, 108076, 
107772, 107758, 108061, 108074, 107771
38572, 105460, 105552, 105556, 105464, 105461, 105553, 105557, 105465, 108063, 108075, 108076, 107772, 108066, 108078, 108079, 
107775, 107761, 108064, 108077, 107774
38573, 105461, 105553, 105557, 105465, 105462, 105554, 105558, 105466, 108066, 108078, 108079, 107775, 108069, 108081, 108082, 
107778, 107764, 108067, 108080, 107777
38574, 105462, 105554, 105558, 105466, 34235, 34258, 34259, 34236, 108069, 108081, 108082, 107778, 34682, 34683, 34684, 
34636, 107767, 108070, 108083, 107780
38575, 16394, 16417, 16418, 16395, 105463, 105555, 105559, 105467, 16842, 16843, 16844, 16796, 108073, 108085, 108086, 
107782, 107768, 108071, 108084, 107781
38576, 105463, 105555, 105559, 105467, 105464, 105556, 105560, 105468, 108073, 108085, 108086, 107782, 108076, 108088, 108089, 
107785, 107771, 108074, 108087, 107784
38577, 105464, 105556, 105560, 105468, 105465, 105557, 105561, 105469, 108076, 108088, 108089, 107785, 108079, 108091, 108092, 
107788, 107774, 108077, 108090, 107787
38578, 105465, 105557, 105561, 105469, 105466, 105558, 105562, 105470, 108079, 108091, 108092, 107788, 108082, 108094, 108095, 
107791, 107777, 108080, 108093, 107790
38579, 105466, 105558, 105562, 105470, 34236, 34259, 34260, 34237, 108082, 108094, 108095, 107791, 34684, 34685, 34686, 
34638, 107780, 108083, 108096, 107793
38580, 16395, 16418, 16419, 16396, 105467, 105559, 105563, 105471, 16844, 16845, 16846, 16798, 108086, 108098, 108099, 
107795, 107781, 108084, 108097, 107794
38581, 105467, 105559, 105563, 105471, 105468, 105560, 105564, 105472, 108086, 108098, 108099, 107795, 108089, 108101, 108102, 
107798, 107784, 108087, 108100, 107797
38582, 105468, 105560, 105564, 105472, 105469, 105561, 105565, 105473, 108089, 108101, 108102, 107798, 108092, 108104, 108105, 
107801, 107787, 108090, 108103, 107800
38583, 105469, 105561, 105565, 105473, 105470, 105562, 105566, 105474, 108092, 108104, 108105, 107801, 108095, 108107, 108108, 
107804, 107790, 108093, 108106, 107803
38584, 105470, 105562, 105566, 105474, 34237, 34260, 34261, 34238, 108095, 108107, 108108, 107804, 34686, 34687, 34688, 
34640, 107793, 108096, 108109, 107806
38585, 16396, 16419, 16420, 16397, 105471, 105563, 105567, 105475, 16846, 16847, 16848, 16800, 108099, 108111, 108112, 
107808, 107794, 108097, 108110, 107807
38586, 105471, 105563, 105567, 105475, 105472, 105564, 105568, 105476, 108099, 108111, 108112, 107808, 108102, 108114, 108115, 
107811, 107797, 108100, 108113, 107810
38587, 105472, 105564, 105568, 105476, 105473, 105565, 105569, 105477, 108102, 108114, 108115, 107811, 108105, 108117, 108118, 
107814, 107800, 108103, 108116, 107813
38588, 105473, 105565, 105569, 105477, 105474, 105566, 105570, 105478, 108105, 108117, 108118, 107814, 108108, 108120, 108121, 
107817, 107803, 108106, 108119, 107816
38589, 105474, 105566, 105570, 105478, 34238, 34261, 34262, 34239, 108108, 108120, 108121, 107817, 34688, 34689, 34690, 
34642, 107806, 108109, 108122, 107819
38590, 16397, 16420, 16421, 16398, 105475, 105567, 105571, 105479, 16848, 16849, 16850, 16802, 108112, 108124, 108125, 
107821, 107807, 108110, 108123, 107820
38591, 105475, 105567, 105571, 105479, 105476, 105568, 105572, 105480, 108112, 108124, 108125, 107821, 108115, 108127, 108128, 
107824, 107810, 108113, 108126, 107823
38592, 105476, 105568, 105572, 105480, 105477, 105569, 105573, 105481, 108115, 108127, 108128, 107824, 108118, 108130, 108131, 
107827, 107813, 108116, 108129, 107826
38593, 105477, 105569, 105573, 105481, 105478, 105570, 105574, 105482, 108118, 108130, 108131, 107827, 108121, 108133, 108134, 
107830, 107816, 108119, 108132, 107829
38594, 105478, 105570, 105574, 105482, 34239, 34262, 34263, 34240, 108121, 108133, 108134, 107830, 34690, 34691, 34692, 
34644, 107819, 108122, 108135, 107832
38595, 16398, 16421, 16422, 16399, 105479, 105571, 105575, 105483, 16850, 16851, 16852, 16804, 108125, 108137, 108138, 
107834, 107820, 108123, 108136, 107833
38596, 105479, 105571, 105575, 105483, 105480, 105572, 105576, 105484, 108125, 108137, 108138, 107834, 108128, 108140, 108141, 
107837, 107823, 108126, 108139, 107836
38597, 105480, 105572, 105576, 105484, 105481, 105573, 105577, 105485, 108128, 108140, 108141, 107837, 108131, 108143, 108144, 
107840, 107826, 108129, 108142, 107839
38598, 105481, 105573, 105577, 105485, 105482, 105574, 105578, 105486, 108131, 108143, 108144, 107840, 108134, 108146, 108147, 
107843, 107829, 108132, 108145, 107842
38599, 105482, 105574, 105578, 105486, 34240, 34263, 34264, 34241, 108134, 108146, 108147, 107843, 34692, 34693, 34694, 
34646, 107832, 108135, 108148, 107845
38600, 16399, 16422, 16423, 16400, 105483, 105575, 105579, 105487, 16852, 16853, 16854, 16806, 108138, 108150, 108151, 
107847, 107833, 108136, 108149, 107846
38601, 105483, 105575, 105579, 105487, 105484, 105576, 105580, 105488, 108138, 108150, 108151, 107847, 108141, 108153, 108154, 
107850, 107836, 108139, 108152, 107849
38602, 105484, 105576, 105580, 105488, 105485, 105577, 105581, 105489, 108141, 108153, 108154, 107850, 108144, 108156, 108157, 
107853, 107839, 108142, 108155, 107852
38603, 105485, 105577, 105581, 105489, 105486, 105578, 105582, 105490, 108144, 108156, 108157, 107853, 108147, 108159, 108160, 
107856, 107842, 108145, 108158, 107855
38604, 105486, 105578, 105582, 105490, 34241, 34264, 34265, 34242, 108147, 108159, 108160, 107856, 34694, 34695, 34696, 
34648, 107845, 108148, 108161, 107858
38605, 16400, 16423, 16424, 16401, 105487, 105579, 105583, 105491, 16854, 16855, 16856, 16808, 108151, 108163, 108164, 
107860, 107846, 108149, 108162, 107859
38606, 105487, 105579, 105583, 105491, 105488, 105580, 105584, 105492, 108151, 108163, 108164, 107860, 108154, 108166, 108167, 
107863, 107849, 108152, 108165, 107862
38607, 105488, 105580, 105584, 105492, 105489, 105581, 105585, 105493, 108154, 108166, 108167, 107863, 108157, 108169, 108170, 
107866, 107852, 108155, 108168, 107865
38608, 105489, 105581, 105585, 105493, 105490, 105582, 105586, 105494, 108157, 108169, 108170, 107866, 108160, 108172, 108173, 
107869, 107855, 108158, 108171, 107868
38609, 105490, 105582, 105586, 105494, 34242, 34265, 34266, 34243, 108160, 108172, 108173, 107869, 34696, 34697, 34698, 
34650, 107858, 108161, 108174, 107871
38610, 16401, 16424, 16425, 16402, 105491, 105583, 105587, 105495, 16856, 16857, 16858, 16810, 108164, 108176, 108177, 
107873, 107859, 108162, 108175, 107872
38611, 105491, 105583, 105587, 105495, 105492, 105584, 105588, 105496, 108164, 108176, 108177, 107873, 108167, 108179, 108180, 
107876, 107862, 108165, 108178, 107875
38612, 105492, 105584, 105588, 105496, 105493, 105585, 105589, 105497, 108167, 108179, 108180, 107876, 108170, 108182, 108183, 
107879, 107865, 108168, 108181, 107878
38613, 105493, 105585, 105589, 105497, 105494, 105586, 105590, 105498, 108170, 108182, 108183, 107879, 108173, 108185, 108186, 
107882, 107868, 108171, 108184, 107881
38614, 105494, 105586, 105590, 105498, 34243, 34266, 34267, 34244, 108173, 108185, 108186, 107882, 34698, 34699, 34700, 
34652, 107871, 108174, 108187, 107884
38615, 16402, 16425, 16426, 16403, 105495, 105587, 105591, 105499, 16858, 16859, 16860, 16812, 108177, 108189, 108190, 
107886, 107872, 108175, 108188, 107885
38616, 105495, 105587, 105591, 105499, 105496, 105588, 105592, 105500, 108177, 108189, 108190, 107886, 108180, 108192, 108193, 
107889, 107875, 108178, 108191, 107888
38617, 105496, 105588, 105592, 105500, 105497, 105589, 105593, 105501, 108180, 108192, 108193, 107889, 108183, 108195, 108196, 
107892, 107878, 108181, 108194, 107891
38618, 105497, 105589, 105593, 105501, 105498, 105590, 105594, 105502, 108183, 108195, 108196, 107892, 108186, 108198, 108199, 
107895, 107881, 108184, 108197, 107894
38619, 105498, 105590, 105594, 105502, 34244, 34267, 34268, 34245, 108186, 108198, 108199, 107895, 34700, 34701, 34702, 
34654, 107884, 108187, 108200, 107897
38620, 16403, 16426, 16427, 16404, 105499, 105591, 105595, 105503, 16860, 16861, 16862, 16814, 108190, 108202, 108203, 
107899, 107885, 108188, 108201, 107898
38621, 105499, 105591, 105595, 105503, 105500, 105592, 105596, 105504, 108190, 108202, 108203, 107899, 108193, 108205, 108206, 
107902, 107888, 108191, 108204, 107901
38622, 105500, 105592, 105596, 105504, 105501, 105593, 105597, 105505, 108193, 108205, 108206, 107902, 108196, 108208, 108209, 
107905, 107891, 108194, 108207, 107904
38623, 105501, 105593, 105597, 105505, 105502, 105594, 105598, 105506, 108196, 108208, 108209, 107905, 108199, 108211, 108212, 
107908, 107894, 108197, 108210, 107907
38624, 105502, 105594, 105598, 105506, 34245, 34268, 34269, 34246, 108199, 108211, 108212, 107908, 34702, 34703, 34704, 
34656, 107897, 108200, 108213, 107910
38625, 16404, 16427, 16428, 16405, 105503, 105595, 105599, 105507, 16862, 16863, 16864, 16816, 108203, 108215, 108216, 
107912, 107898, 108201, 108214, 107911
38626, 105503, 105595, 105599, 105507, 105504, 105596, 105600, 105508, 108203, 108215, 108216, 107912, 108206, 108218, 108219, 
107915, 107901, 108204, 108217, 107914
38627, 105504, 105596, 105600, 105508, 105505, 105597, 105601, 105509, 108206, 108218, 108219, 107915, 108209, 108221, 108222, 
107918, 107904, 108207, 108220, 107917
38628, 105505, 105597, 105601, 105509, 105506, 105598, 105602, 105510, 108209, 108221, 108222, 107918, 108212, 108224, 108225, 
107921, 107907, 108210, 108223, 107920
38629, 105506, 105598, 105602, 105510, 34246, 34269, 34270, 34247, 108212, 108224, 108225, 107921, 34704, 34705, 34706, 
34658, 107910, 108213, 108226, 107923
38630, 16405, 16428, 16429, 16406, 105507, 105599, 105603, 105511, 16864, 16865, 16866, 16818, 108216, 108228, 108229, 
107925, 107911, 108214, 108227, 107924
38631, 105507, 105599, 105603, 105511, 105508, 105600, 105604, 105512, 108216, 108228, 108229, 107925, 108219, 108231, 108232, 
107928, 107914, 108217, 108230, 107927
38632, 105508, 105600, 105604, 105512, 105509, 105601, 105605, 105513, 108219, 108231, 108232, 107928, 108222, 108234, 108235, 
107931, 107917, 108220, 108233, 107930
38633, 105509, 105601, 105605, 105513, 105510, 105602, 105606, 105514, 108222, 108234, 108235, 107931, 108225, 108237, 108238, 
107934, 107920, 108223, 108236, 107933
38634, 105510, 105602, 105606, 105514, 34247, 34270, 34271, 34248, 108225, 108237, 108238, 107934, 34706, 34707, 34708, 
34660, 107923, 108226, 108239, 107936
38635, 16406, 16429, 16430, 16407, 105511, 105603, 105607, 105515, 16866, 16867, 16868, 16820, 108229, 108241, 108242, 
107938, 107924, 108227, 108240, 107937
38636, 105511, 105603, 105607, 105515, 105512, 105604, 105608, 105516, 108229, 108241, 108242, 107938, 108232, 108244, 108245, 
107941, 107927, 108230, 108243, 107940
38637, 105512, 105604, 105608, 105516, 105513, 105605, 105609, 105517, 108232, 108244, 108245, 107941, 108235, 108247, 108248, 
107944, 107930, 108233, 108246, 107943
38638, 105513, 105605, 105609, 105517, 105514, 105606, 105610, 105518, 108235, 108247, 108248, 107944, 108238, 108250, 108251, 
107947, 107933, 108236, 108249, 107946
38639, 105514, 105606, 105610, 105518, 34248, 34271, 34272, 34249, 108238, 108250, 108251, 107947, 34708, 34709, 34710, 
34662, 107936, 108239, 108252, 107949
38640, 16407, 16430, 16431, 16408, 105515, 105607, 105611, 105519, 16868, 16869, 16870, 16822, 108242, 108254, 108255, 
107951, 107937, 108240, 108253, 107950
38641, 105515, 105607, 105611, 105519, 105516, 105608, 105612, 105520, 108242, 108254, 108255, 107951, 108245, 108257, 108258, 
107954, 107940, 108243, 108256, 107953
38642, 105516, 105608, 105612, 105520, 105517, 105609, 105613, 105521, 108245, 108257, 108258, 107954, 108248, 108260, 108261, 
107957, 107943, 108246, 108259, 107956
38643, 105517, 105609, 105613, 105521, 105518, 105610, 105614, 105522, 108248, 108260, 108261, 107957, 108251, 108263, 108264, 
107960, 107946, 108249, 108262, 107959
38644, 105518, 105610, 105614, 105522, 34249, 34272, 34273, 34250, 108251, 108263, 108264, 107960, 34710, 34711, 34712, 
34664, 107949, 108252, 108265, 107962
38645, 16408, 16431, 16432, 16409, 105519, 105611, 105615, 105523, 16870, 16871, 16872, 16824, 108255, 108267, 108268, 
107964, 107950, 108253, 108266, 107963
38646, 105519, 105611, 105615, 105523, 105520, 105612, 105616, 105524, 108255, 108267, 108268, 107964, 108258, 108270, 108271, 
107967, 107953, 108256, 108269, 107966
38647, 105520, 105612, 105616, 105524, 105521, 105613, 105617, 105525, 108258, 108270, 108271, 107967, 108261, 108273, 108274, 
107970, 107956, 108259, 108272, 107969
38648, 105521, 105613, 105617, 105525, 105522, 105614, 105618, 105526, 108261, 108273, 108274, 107970, 108264, 108276, 108277, 
107973, 107959, 108262, 108275, 107972
38649, 105522, 105614, 105618, 105526, 34250, 34273, 34274, 34251, 108264, 108276, 108277, 107973, 34712, 34713, 34714, 
34666, 107962, 108265, 108278, 107975
38650, 16409, 16432, 16433, 16410, 105523, 105615, 105619, 105527, 16872, 16873, 16874, 16826, 108268, 108280, 108281, 
107977, 107963, 108266, 108279, 107976
38651, 105523, 105615, 105619, 105527, 105524, 105616, 105620, 105528, 108268, 108280, 108281, 107977, 108271, 108283, 108284, 
107980, 107966, 108269, 108282, 107979
38652, 105524, 105616, 105620, 105528, 105525, 105617, 105621, 105529, 108271, 108283, 108284, 107980, 108274, 108286, 108287, 
107983, 107969, 108272, 108285, 107982
38653, 105525, 105617, 105621, 105529, 105526, 105618, 105622, 105530, 108274, 108286, 108287, 107983, 108277, 108289, 108290, 
107986, 107972, 108275, 108288, 107985
38654, 105526, 105618, 105622, 105530, 34251, 34274, 34275, 34252, 108277, 108289, 108290, 107986, 34714, 34715, 34716, 
34668, 107975, 108278, 108291, 107988
38655, 16410, 16433, 16434, 16411, 105527, 105619, 105623, 105531, 16874, 16875, 16876, 16828, 108281, 108293, 108294, 
107990, 107976, 108279, 108292, 107989
38656, 105527, 105619, 105623, 105531, 105528, 105620, 105624, 105532, 108281, 108293, 108294, 107990, 108284, 108296, 108297, 
107993, 107979, 108282, 108295, 107992
38657, 105528, 105620, 105624, 105532, 105529, 105621, 105625, 105533, 108284, 108296, 108297, 107993, 108287, 108299, 108300, 
107996, 107982, 108285, 108298, 107995
38658, 105529, 105621, 105625, 105533, 105530, 105622, 105626, 105534, 108287, 108299, 108300, 107996, 108290, 108302, 108303, 
107999, 107985, 108288, 108301, 107998
38659, 105530, 105622, 105626, 105534, 34252, 34275, 34276, 34253, 108290, 108302, 108303, 107999, 34716, 34717, 34718, 
34670, 107988, 108291, 108304, 108001
38660, 16411, 16434, 16435, 16412, 105531, 105623, 105627, 105535, 16876, 16877, 16878, 16830, 108294, 108306, 108307, 
108003, 107989, 108292, 108305, 108002
38661, 105531, 105623, 105627, 105535, 105532, 105624, 105628, 105536, 108294, 108306, 108307, 108003, 108297, 108309, 108310, 
108006, 107992, 108295, 108308, 108005
38662, 105532, 105624, 105628, 105536, 105533, 105625, 105629, 105537, 108297, 108309, 108310, 108006, 108300, 108312, 108313, 
108009, 107995, 108298, 108311, 108008
38663, 105533, 105625, 105629, 105537, 105534, 105626, 105630, 105538, 108300, 108312, 108313, 108009, 108303, 108315, 108316, 
108012, 107998, 108301, 108314, 108011
38664, 105534, 105626, 105630, 105538, 34253, 34276, 34277, 34254, 108303, 108315, 108316, 108012, 34718, 34719, 34720, 
34672, 108001, 108304, 108317, 108014
38665, 16412, 16435, 16436, 16413, 105535, 105627, 105631, 105539, 16878, 16879, 16880, 16832, 108307, 108319, 108320, 
108016, 108002, 108305, 108318, 108015
38666, 105535, 105627, 105631, 105539, 105536, 105628, 105632, 105540, 108307, 108319, 108320, 108016, 108310, 108322, 108323, 
108019, 108005, 108308, 108321, 108018
38667, 105536, 105628, 105632, 105540, 105537, 105629, 105633, 105541, 108310, 108322, 108323, 108019, 108313, 108325, 108326, 
108022, 108008, 108311, 108324, 108021
38668, 105537, 105629, 105633, 105541, 105538, 105630, 105634, 105542, 108313, 108325, 108326, 108022, 108316, 108328, 108329, 
108025, 108011, 108314, 108327, 108024
38669, 105538, 105630, 105634, 105542, 34254, 34277, 34278, 34255, 108316, 108328, 108329, 108025, 34720, 34721, 34722, 
34674, 108014, 108317, 108330, 108027
38670, 16413, 16436, 1493, 1492, 105539, 105631, 33976, 33972, 16880, 16881, 1504, 16834, 108320, 108331, 34055, 
108028, 108015, 108318, 34056, 34047
38671, 105539, 105631, 33976, 33972, 105540, 105632, 33977, 33973, 108320, 108331, 34055, 108028, 108323, 108332, 34057, 
108029, 108018, 108321, 34058, 34049
38672, 105540, 105632, 33977, 33973, 105541, 105633, 33978, 33974, 108323, 108332, 34057, 108029, 108326, 108333, 34059, 
108030, 108021, 108324, 34060, 34051
38673, 105541, 105633, 33978, 33974, 105542, 105634, 33979, 33975, 108326, 108333, 34059, 108030, 108329, 108334, 34061, 
108031, 108024, 108327, 34062, 34053
38674, 105542, 105634, 33979, 33975, 34255, 34278, 3533, 3532, 108329, 108334, 34061, 108031, 34722, 34723, 3544, 
34676, 108027, 108330, 34063, 34054
38675, 1249, 1250, 16437, 16414, 33076, 33080, 105635, 105543, 1261, 16882, 16883, 16835, 33164, 108336, 108337, 
108033, 33156, 33165, 108335, 108032
38676, 33076, 33080, 105635, 105543, 33077, 33081, 105636, 105544, 33164, 108336, 108337, 108033, 33166, 108339, 108340, 
108036, 33158, 33167, 108338, 108035
38677, 33077, 33081, 105636, 105544, 33078, 33082, 105637, 105545, 33166, 108339, 108340, 108036, 33168, 108342, 108343, 
108039, 33160, 33169, 108341, 108038
38678, 33078, 33082, 105637, 105545, 33079, 33083, 105638, 105546, 33168, 108342, 108343, 108039, 33170, 108345, 108346, 
108042, 33162, 33171, 108344, 108041
38679, 33079, 33083, 105638, 105546, 3398, 3399, 34279, 34256, 33170, 108345, 108346, 108042, 3410, 34724, 34725, 
34677, 33163, 33172, 108347, 108044
38680, 16414, 16437, 16438, 16415, 105543, 105635, 105639, 105547, 16883, 16884, 16885, 16837, 108337, 108349, 108350, 
108046, 108032, 108335, 108348, 108045
38681, 105543, 105635, 105639, 105547, 105544, 105636, 105640, 105548, 108337, 108349, 108350, 108046, 108340, 108352, 108353, 
108049, 108035, 108338, 108351, 108048
38682, 105544, 105636, 105640, 105548, 105545, 105637, 105641, 105549, 108340, 108352, 108353, 108049, 108343, 108355, 108356, 
108052, 108038, 108341, 108354, 108051
38683, 105545, 105637, 105641, 105549, 105546, 105638, 105642, 105550, 108343, 108355, 108356, 108052, 108346, 108358, 108359, 
108055, 108041, 108344, 108357, 108054
38684, 105546, 105638, 105642, 105550, 34256, 34279, 34280, 34257, 108346, 108358, 108359, 108055, 34725, 34726, 34727, 
34679, 108044, 108347, 108360, 108057
38685, 16415, 16438, 16439, 16416, 105547, 105639, 105643, 105551, 16885, 16886, 16887, 16839, 108350, 108362, 108363, 
108059, 108045, 108348, 108361, 108058
38686, 105547, 105639, 105643, 105551, 105548, 105640, 105644, 105552, 108350, 108362, 108363, 108059, 108353, 108365, 108366, 
108062, 108048, 108351, 108364, 108061
38687, 105548, 105640, 105644, 105552, 105549, 105641, 105645, 105553, 108353, 108365, 108366, 108062, 108356, 108368, 108369, 
108065, 108051, 108354, 108367, 108064
38688, 105549, 105641, 105645, 105553, 105550, 105642, 105646, 105554, 108356, 108368, 108369, 108065, 108359, 108371, 108372, 
108068, 108054, 108357, 108370, 108067
38689, 105550, 105642, 105646, 105554, 34257, 34280, 34281, 34258, 108359, 108371, 108372, 108068, 34727, 34728, 34729, 
34681, 108057, 108360, 108373, 108070
38690, 16416, 16439, 16440, 16417, 105551, 105643, 105647, 105555, 16887, 16888, 16889, 16841, 108363, 108375, 108376, 
108072, 108058, 108361, 108374, 108071
38691, 105551, 105643, 105647, 105555, 105552, 105644, 105648, 105556, 108363, 108375, 108376, 108072, 108366, 108378, 108379, 
108075, 108061, 108364, 108377, 108074
38692, 105552, 105644, 105648, 105556, 105553, 105645, 105649, 105557, 108366, 108378, 108379, 108075, 108369, 108381, 108382, 
108078, 108064, 108367, 108380, 108077
38693, 105553, 105645, 105649, 105557, 105554, 105646, 105650, 105558, 108369, 108381, 108382, 108078, 108372, 108384, 108385, 
108081, 108067, 108370, 108383, 108080
38694, 105554, 105646, 105650, 105558, 34258, 34281, 34282, 34259, 108372, 108384, 108385, 108081, 34729, 34730, 34731, 
34683, 108070, 108373, 108386, 108083
38695, 16417, 16440, 16441, 16418, 105555, 105647, 105651, 105559, 16889, 16890, 16891, 16843, 108376, 108388, 108389, 
108085, 108071, 108374, 108387, 108084
38696, 105555, 105647, 105651, 105559, 105556, 105648, 105652, 105560, 108376, 108388, 108389, 108085, 108379, 108391, 108392, 
108088, 108074, 108377, 108390, 108087
38697, 105556, 105648, 105652, 105560, 105557, 105649, 105653, 105561, 108379, 108391, 108392, 108088, 108382, 108394, 108395, 
108091, 108077, 108380, 108393, 108090
38698, 105557, 105649, 105653, 105561, 105558, 105650, 105654, 105562, 108382, 108394, 108395, 108091, 108385, 108397, 108398, 
108094, 108080, 108383, 108396, 108093
38699, 105558, 105650, 105654, 105562, 34259, 34282, 34283, 34260, 108385, 108397, 108398, 108094, 34731, 34732, 34733, 
34685, 108083, 108386, 108399, 108096
38700, 16418, 16441, 16442, 16419, 105559, 105651, 105655, 105563, 16891, 16892, 16893, 16845, 108389, 108401, 108402, 
108098, 108084, 108387, 108400, 108097
38701, 105559, 105651, 105655, 105563, 105560, 105652, 105656, 105564, 108389, 108401, 108402, 108098, 108392, 108404, 108405, 
108101, 108087, 108390, 108403, 108100
38702, 105560, 105652, 105656, 105564, 105561, 105653, 105657, 105565, 108392, 108404, 108405, 108101, 108395, 108407, 108408, 
108104, 108090, 108393, 108406, 108103
38703, 105561, 105653, 105657, 105565, 105562, 105654, 105658, 105566, 108395, 108407, 108408, 108104, 108398, 108410, 108411, 
108107, 108093, 108396, 108409, 108106
38704, 105562, 105654, 105658, 105566, 34260, 34283, 34284, 34261, 108398, 108410, 108411, 108107, 34733, 34734, 34735, 
34687, 108096, 108399, 108412, 108109
38705, 16419, 16442, 16443, 16420, 105563, 105655, 105659, 105567, 16893, 16894, 16895, 16847, 108402, 108414, 108415, 
108111, 108097, 108400, 108413, 108110
38706, 105563, 105655, 105659, 105567, 105564, 105656, 105660, 105568, 108402, 108414, 108415, 108111, 108405, 108417, 108418, 
108114, 108100, 108403, 108416, 108113
38707, 105564, 105656, 105660, 105568, 105565, 105657, 105661, 105569, 108405, 108417, 108418, 108114, 108408, 108420, 108421, 
108117, 108103, 108406, 108419, 108116
38708, 105565, 105657, 105661, 105569, 105566, 105658, 105662, 105570, 108408, 108420, 108421, 108117, 108411, 108423, 108424, 
108120, 108106, 108409, 108422, 108119
38709, 105566, 105658, 105662, 105570, 34261, 34284, 34285, 34262, 108411, 108423, 108424, 108120, 34735, 34736, 34737, 
34689, 108109, 108412, 108425, 108122
38710, 16420, 16443, 16444, 16421, 105567, 105659, 105663, 105571, 16895, 16896, 16897, 16849, 108415, 108427, 108428, 
108124, 108110, 108413, 108426, 108123
38711, 105567, 105659, 105663, 105571, 105568, 105660, 105664, 105572, 108415, 108427, 108428, 108124, 108418, 108430, 108431, 
108127, 108113, 108416, 108429, 108126
38712, 105568, 105660, 105664, 105572, 105569, 105661, 105665, 105573, 108418, 108430, 108431, 108127, 108421, 108433, 108434, 
108130, 108116, 108419, 108432, 108129
38713, 105569, 105661, 105665, 105573, 105570, 105662, 105666, 105574, 108421, 108433, 108434, 108130, 108424, 108436, 108437, 
108133, 108119, 108422, 108435, 108132
38714, 105570, 105662, 105666, 105574, 34262, 34285, 34286, 34263, 108424, 108436, 108437, 108133, 34737, 34738, 34739, 
34691, 108122, 108425, 108438, 108135
38715, 16421, 16444, 16445, 16422, 105571, 105663, 105667, 105575, 16897, 16898, 16899, 16851, 108428, 108440, 108441, 
108137, 108123, 108426, 108439, 108136
38716, 105571, 105663, 105667, 105575, 105572, 105664, 105668, 105576, 108428, 108440, 108441, 108137, 108431, 108443, 108444, 
108140, 108126, 108429, 108442, 108139
38717, 105572, 105664, 105668, 105576, 105573, 105665, 105669, 105577, 108431, 108443, 108444, 108140, 108434, 108446, 108447, 
108143, 108129, 108432, 108445, 108142
38718, 105573, 105665, 105669, 105577, 105574, 105666, 105670, 105578, 108434, 108446, 108447, 108143, 108437, 108449, 108450, 
108146, 108132, 108435, 108448, 108145
38719, 105574, 105666, 105670, 105578, 34263, 34286, 34287, 34264, 108437, 108449, 108450, 108146, 34739, 34740, 34741, 
34693, 108135, 108438, 108451, 108148
38720, 16422, 16445, 16446, 16423, 105575, 105667, 105671, 105579, 16899, 16900, 16901, 16853, 108441, 108453, 108454, 
108150, 108136, 108439, 108452, 108149
38721, 105575, 105667, 105671, 105579, 105576, 105668, 105672, 105580, 108441, 108453, 108454, 108150, 108444, 108456, 108457, 
108153, 108139, 108442, 108455, 108152
38722, 105576, 105668, 105672, 105580, 105577, 105669, 105673, 105581, 108444, 108456, 108457, 108153, 108447, 108459, 108460, 
108156, 108142, 108445, 108458, 108155
38723, 105577, 105669, 105673, 105581, 105578, 105670, 105674, 105582, 108447, 108459, 108460, 108156, 108450, 108462, 108463, 
108159, 108145, 108448, 108461, 108158
38724, 105578, 105670, 105674, 105582, 34264, 34287, 34288, 34265, 108450, 108462, 108463, 108159, 34741, 34742, 34743, 
34695, 108148, 108451, 108464, 108161
38725, 16423, 16446, 16447, 16424, 105579, 105671, 105675, 105583, 16901, 16902, 16903, 16855, 108454, 108466, 108467, 
108163, 108149, 108452, 108465, 108162
38726, 105579, 105671, 105675, 105583, 105580, 105672, 105676, 105584, 108454, 108466, 108467, 108163, 108457, 108469, 108470, 
108166, 108152, 108455, 108468, 108165
38727, 105580, 105672, 105676, 105584, 105581, 105673, 105677, 105585, 108457, 108469, 108470, 108166, 108460, 108472, 108473, 
108169, 108155, 108458, 108471, 108168
38728, 105581, 105673, 105677, 105585, 105582, 105674, 105678, 105586, 108460, 108472, 108473, 108169, 108463, 108475, 108476, 
108172, 108158, 108461, 108474, 108171
38729, 105582, 105674, 105678, 105586, 34265, 34288, 34289, 34266, 108463, 108475, 108476, 108172, 34743, 34744, 34745, 
34697, 108161, 108464, 108477, 108174
38730, 16424, 16447, 16448, 16425, 105583, 105675, 105679, 105587, 16903, 16904, 16905, 16857, 108467, 108479, 108480, 
108176, 108162, 108465, 108478, 108175
38731, 105583, 105675, 105679, 105587, 105584, 105676, 105680, 105588, 108467, 108479, 108480, 108176, 108470, 108482, 108483, 
108179, 108165, 108468, 108481, 108178
38732, 105584, 105676, 105680, 105588, 105585, 105677, 105681, 105589, 108470, 108482, 108483, 108179, 108473, 108485, 108486, 
108182, 108168, 108471, 108484, 108181
38733, 105585, 105677, 105681, 105589, 105586, 105678, 105682, 105590, 108473, 108485, 108486, 108182, 108476, 108488, 108489, 
108185, 108171, 108474, 108487, 108184
38734, 105586, 105678, 105682, 105590, 34266, 34289, 34290, 34267, 108476, 108488, 108489, 108185, 34745, 34746, 34747, 
34699, 108174, 108477, 108490, 108187
38735, 16425, 16448, 16449, 16426, 105587, 105679, 105683, 105591, 16905, 16906, 16907, 16859, 108480, 108492, 108493, 
108189, 108175, 108478, 108491, 108188
38736, 105587, 105679, 105683, 105591, 105588, 105680, 105684, 105592, 108480, 108492, 108493, 108189, 108483, 108495, 108496, 
108192, 108178, 108481, 108494, 108191
38737, 105588, 105680, 105684, 105592, 105589, 105681, 105685, 105593, 108483, 108495, 108496, 108192, 108486, 108498, 108499, 
108195, 108181, 108484, 108497, 108194
38738, 105589, 105681, 105685, 105593, 105590, 105682, 105686, 105594, 108486, 108498, 108499, 108195, 108489, 108501, 108502, 
108198, 108184, 108487, 108500, 108197
38739, 105590, 105682, 105686, 105594, 34267, 34290, 34291, 34268, 108489, 108501, 108502, 108198, 34747, 34748, 34749, 
34701, 108187, 108490, 108503, 108200
38740, 16426, 16449, 16450, 16427, 105591, 105683, 105687, 105595, 16907, 16908, 16909, 16861, 108493, 108505, 108506, 
108202, 108188, 108491, 108504, 108201
38741, 105591, 105683, 105687, 105595, 105592, 105684, 105688, 105596, 108493, 108505, 108506, 108202, 108496, 108508, 108509, 
108205, 108191, 108494, 108507, 108204
38742, 105592, 105684, 105688, 105596, 105593, 105685, 105689, 105597, 108496, 108508, 108509, 108205, 108499, 108511, 108512, 
108208, 108194, 108497, 108510, 108207
38743, 105593, 105685, 105689, 105597, 105594, 105686, 105690, 105598, 108499, 108511, 108512, 108208, 108502, 108514, 108515, 
108211, 108197, 108500, 108513, 108210
38744, 105594, 105686, 105690, 105598, 34268, 34291, 34292, 34269, 108502, 108514, 108515, 108211, 34749, 34750, 34751, 
34703, 108200, 108503, 108516, 108213
38745, 16427, 16450, 16451, 16428, 105595, 105687, 105691, 105599, 16909, 16910, 16911, 16863, 108506, 108518, 108519, 
108215, 108201, 108504, 108517, 108214
38746, 105595, 105687, 105691, 105599, 105596, 105688, 105692, 105600, 108506, 108518, 108519, 108215, 108509, 108521, 108522, 
108218, 108204, 108507, 108520, 108217
38747, 105596, 105688, 105692, 105600, 105597, 105689, 105693, 105601, 108509, 108521, 108522, 108218, 108512, 108524, 108525, 
108221, 108207, 108510, 108523, 108220
38748, 105597, 105689, 105693, 105601, 105598, 105690, 105694, 105602, 108512, 108524, 108525, 108221, 108515, 108527, 108528, 
108224, 108210, 108513, 108526, 108223
38749, 105598, 105690, 105694, 105602, 34269, 34292, 34293, 34270, 108515, 108527, 108528, 108224, 34751, 34752, 34753, 
34705, 108213, 108516, 108529, 108226
38750, 16428, 16451, 16452, 16429, 105599, 105691, 105695, 105603, 16911, 16912, 16913, 16865, 108519, 108531, 108532, 
108228, 108214, 108517, 108530, 108227
38751, 105599, 105691, 105695, 105603, 105600, 105692, 105696, 105604, 108519, 108531, 108532, 108228, 108522, 108534, 108535, 
108231, 108217, 108520, 108533, 108230
38752, 105600, 105692, 105696, 105604, 105601, 105693, 105697, 105605, 108522, 108534, 108535, 108231, 108525, 108537, 108538, 
108234, 108220, 108523, 108536, 108233
38753, 105601, 105693, 105697, 105605, 105602, 105694, 105698, 105606, 108525, 108537, 108538, 108234, 108528, 108540, 108541, 
108237, 108223, 108526, 108539, 108236
38754, 105602, 105694, 105698, 105606, 34270, 34293, 34294, 34271, 108528, 108540, 108541, 108237, 34753, 34754, 34755, 
34707, 108226, 108529, 108542, 108239
38755, 16429, 16452, 16453, 16430, 105603, 105695, 105699, 105607, 16913, 16914, 16915, 16867, 108532, 108544, 108545, 
108241, 108227, 108530, 108543, 108240
38756, 105603, 105695, 105699, 105607, 105604, 105696, 105700, 105608, 108532, 108544, 108545, 108241, 108535, 108547, 108548, 
108244, 108230, 108533, 108546, 108243
38757, 105604, 105696, 105700, 105608, 105605, 105697, 105701, 105609, 108535, 108547, 108548, 108244, 108538, 108550, 108551, 
108247, 108233, 108536, 108549, 108246
38758, 105605, 105697, 105701, 105609, 105606, 105698, 105702, 105610, 108538, 108550, 108551, 108247, 108541, 108553, 108554, 
108250, 108236, 108539, 108552, 108249
38759, 105606, 105698, 105702, 105610, 34271, 34294, 34295, 34272, 108541, 108553, 108554, 108250, 34755, 34756, 34757, 
34709, 108239, 108542, 108555, 108252
38760, 16430, 16453, 16454, 16431, 105607, 105699, 105703, 105611, 16915, 16916, 16917, 16869, 108545, 108557, 108558, 
108254, 108240, 108543, 108556, 108253
38761, 105607, 105699, 105703, 105611, 105608, 105700, 105704, 105612, 108545, 108557, 108558, 108254, 108548, 108560, 108561, 
108257, 108243, 108546, 108559, 108256
38762, 105608, 105700, 105704, 105612, 105609, 105701, 105705, 105613, 108548, 108560, 108561, 108257, 108551, 108563, 108564, 
108260, 108246, 108549, 108562, 108259
38763, 105609, 105701, 105705, 105613, 105610, 105702, 105706, 105614, 108551, 108563, 108564, 108260, 108554, 108566, 108567, 
108263, 108249, 108552, 108565, 108262
38764, 105610, 105702, 105706, 105614, 34272, 34295, 34296, 34273, 108554, 108566, 108567, 108263, 34757, 34758, 34759, 
34711, 108252, 108555, 108568, 108265
38765, 16431, 16454, 16455, 16432, 105611, 105703, 105707, 105615, 16917, 16918, 16919, 16871, 108558, 108570, 108571, 
108267, 108253, 108556, 108569, 108266
38766, 105611, 105703, 105707, 105615, 105612, 105704, 105708, 105616, 108558, 108570, 108571, 108267, 108561, 108573, 108574, 
108270, 108256, 108559, 108572, 108269
38767, 105612, 105704, 105708, 105616, 105613, 105705, 105709, 105617, 108561, 108573, 108574, 108270, 108564, 108576, 108577, 
108273, 108259, 108562, 108575, 108272
38768, 105613, 105705, 105709, 105617, 105614, 105706, 105710, 105618, 108564, 108576, 108577, 108273, 108567, 108579, 108580, 
108276, 108262, 108565, 108578, 108275
38769, 105614, 105706, 105710, 105618, 34273, 34296, 34297, 34274, 108567, 108579, 108580, 108276, 34759, 34760, 34761, 
34713, 108265, 108568, 108581, 108278
38770, 16432, 16455, 16456, 16433, 105615, 105707, 105711, 105619, 16919, 16920, 16921, 16873, 108571, 108583, 108584, 
108280, 108266, 108569, 108582, 108279
38771, 105615, 105707, 105711, 105619, 105616, 105708, 105712, 105620, 108571, 108583, 108584, 108280, 108574, 108586, 108587, 
108283, 108269, 108572, 108585, 108282
38772, 105616, 105708, 105712, 105620, 105617, 105709, 105713, 105621, 108574, 108586, 108587, 108283, 108577, 108589, 108590, 
108286, 108272, 108575, 108588, 108285
38773, 105617, 105709, 105713, 105621, 105618, 105710, 105714, 105622, 108577, 108589, 108590, 108286, 108580, 108592, 108593, 
108289, 108275, 108578, 108591, 108288
38774, 105618, 105710, 105714, 105622, 34274, 34297, 34298, 34275, 108580, 108592, 108593, 108289, 34761, 34762, 34763, 
34715, 108278, 108581, 108594, 108291
38775, 16433, 16456, 16457, 16434, 105619, 105711, 105715, 105623, 16921, 16922, 16923, 16875, 108584, 108596, 108597, 
108293, 108279, 108582, 108595, 108292
38776, 105619, 105711, 105715, 105623, 105620, 105712, 105716, 105624, 108584, 108596, 108597, 108293, 108587, 108599, 108600, 
108296, 108282, 108585, 108598, 108295
38777, 105620, 105712, 105716, 105624, 105621, 105713, 105717, 105625, 108587, 108599, 108600, 108296, 108590, 108602, 108603, 
108299, 108285, 108588, 108601, 108298
38778, 105621, 105713, 105717, 105625, 105622, 105714, 105718, 105626, 108590, 108602, 108603, 108299, 108593, 108605, 108606, 
108302, 108288, 108591, 108604, 108301
38779, 105622, 105714, 105718, 105626, 34275, 34298, 34299, 34276, 108593, 108605, 108606, 108302, 34763, 34764, 34765, 
34717, 108291, 108594, 108607, 108304
38780, 16434, 16457, 16458, 16435, 105623, 105715, 105719, 105627, 16923, 16924, 16925, 16877, 108597, 108609, 108610, 
108306, 108292, 108595, 108608, 108305
38781, 105623, 105715, 105719, 105627, 105624, 105716, 105720, 105628, 108597, 108609, 108610, 108306, 108600, 108612, 108613, 
108309, 108295, 108598, 108611, 108308
38782, 105624, 105716, 105720, 105628, 105625, 105717, 105721, 105629, 108600, 108612, 108613, 108309, 108603, 108615, 108616, 
108312, 108298, 108601, 108614, 108311
38783, 105625, 105717, 105721, 105629, 105626, 105718, 105722, 105630, 108603, 108615, 108616, 108312, 108606, 108618, 108619, 
108315, 108301, 108604, 108617, 108314
38784, 105626, 105718, 105722, 105630, 34276, 34299, 34300, 34277, 108606, 108618, 108619, 108315, 34765, 34766, 34767, 
34719, 108304, 108607, 108620, 108317
38785, 16435, 16458, 16459, 16436, 105627, 105719, 105723, 105631, 16925, 16926, 16927, 16879, 108610, 108622, 108623, 
108319, 108305, 108608, 108621, 108318
38786, 105627, 105719, 105723, 105631, 105628, 105720, 105724, 105632, 108610, 108622, 108623, 108319, 108613, 108625, 108626, 
108322, 108308, 108611, 108624, 108321
38787, 105628, 105720, 105724, 105632, 105629, 105721, 105725, 105633, 108613, 108625, 108626, 108322, 108616, 108628, 108629, 
108325, 108311, 108614, 108627, 108324
38788, 105629, 105721, 105725, 105633, 105630, 105722, 105726, 105634, 108616, 108628, 108629, 108325, 108619, 108631, 108632, 
108328, 108314, 108617, 108630, 108327
38789, 105630, 105722, 105726, 105634, 34277, 34300, 34301, 34278, 108619, 108631, 108632, 108328, 34767, 34768, 34769, 
34721, 108317, 108620, 108633, 108330
38790, 16436, 16459, 1494, 1493, 105631, 105723, 33980, 33976, 16927, 16928, 1505, 16881, 108623, 108634, 34064, 
108331, 108318, 108621, 34065, 34056
38791, 105631, 105723, 33980, 33976, 105632, 105724, 33981, 33977, 108623, 108634, 34064, 108331, 108626, 108635, 34066, 
108332, 108321, 108624, 34067, 34058
38792, 105632, 105724, 33981, 33977, 105633, 105725, 33982, 33978, 108626, 108635, 34066, 108332, 108629, 108636, 34068, 
108333, 108324, 108627, 34069, 34060
38793, 105633, 105725, 33982, 33978, 105634, 105726, 33983, 33979, 108629, 108636, 34068, 108333, 108632, 108637, 34070, 
108334, 108327, 108630, 34071, 34062
38794, 105634, 105726, 33983, 33979, 34278, 34301, 3534, 3533, 108632, 108637, 34070, 108334, 34769, 34770, 3545, 
34723, 108330, 108633, 34072, 34063
38795, 1250, 1251, 16460, 16437, 33080, 33084, 105727, 105635, 1262, 16929, 16930, 16882, 33173, 108639, 108640, 
108336, 33165, 33174, 108638, 108335
38796, 33080, 33084, 105727, 105635, 33081, 33085, 105728, 105636, 33173, 108639, 108640, 108336, 33175, 108642, 108643, 
108339, 33167, 33176, 108641, 108338
38797, 33081, 33085, 105728, 105636, 33082, 33086, 105729, 105637, 33175, 108642, 108643, 108339, 33177, 108645, 108646, 
108342, 33169, 33178, 108644, 108341
38798, 33082, 33086, 105729, 105637, 33083, 33087, 105730, 105638, 33177, 108645, 108646, 108342, 33179, 108648, 108649, 
108345, 33171, 33180, 108647, 108344
38799, 33083, 33087, 105730, 105638, 3399, 3400, 34302, 34279, 33179, 108648, 108649, 108345, 3411, 34771, 34772, 
34724, 33172, 33181, 108650, 108347
38800, 16437, 16460, 16461, 16438, 105635, 105727, 105731, 105639, 16930, 16931, 16932, 16884, 108640, 108652, 108653, 
108349, 108335, 108638, 108651, 108348
38801, 105635, 105727, 105731, 105639, 105636, 105728, 105732, 105640, 108640, 108652, 108653, 108349, 108643, 108655, 108656, 
108352, 108338, 108641, 108654, 108351
38802, 105636, 105728, 105732, 105640, 105637, 105729, 105733, 105641, 108643, 108655, 108656, 108352, 108646, 108658, 108659, 
108355, 108341, 108644, 108657, 108354
38803, 105637, 105729, 105733, 105641, 105638, 105730, 105734, 105642, 108646, 108658, 108659, 108355, 108649, 108661, 108662, 
108358, 108344, 108647, 108660, 108357
38804, 105638, 105730, 105734, 105642, 34279, 34302, 34303, 34280, 108649, 108661, 108662, 108358, 34772, 34773, 34774, 
34726, 108347, 108650, 108663, 108360
38805, 16438, 16461, 16462, 16439, 105639, 105731, 105735, 105643, 16932, 16933, 16934, 16886, 108653, 108665, 108666, 
108362, 108348, 108651, 108664, 108361
38806, 105639, 105731, 105735, 105643, 105640, 105732, 105736, 105644, 108653, 108665, 108666, 108362, 108656, 108668, 108669, 
108365, 108351, 108654, 108667, 108364
38807, 105640, 105732, 105736, 105644, 105641, 105733, 105737, 105645, 108656, 108668, 108669, 108365, 108659, 108671, 108672, 
108368, 108354, 108657, 108670, 108367
38808, 105641, 105733, 105737, 105645, 105642, 105734, 105738, 105646, 108659, 108671, 108672, 108368, 108662, 108674, 108675, 
108371, 108357, 108660, 108673, 108370
38809, 105642, 105734, 105738, 105646, 34280, 34303, 34304, 34281, 108662, 108674, 108675, 108371, 34774, 34775, 34776, 
34728, 108360, 108663, 108676, 108373
38810, 16439, 16462, 16463, 16440, 105643, 105735, 105739, 105647, 16934, 16935, 16936, 16888, 108666, 108678, 108679, 
108375, 108361, 108664, 108677, 108374
38811, 105643, 105735, 105739, 105647, 105644, 105736, 105740, 105648, 108666, 108678, 108679, 108375, 108669, 108681, 108682, 
108378, 108364, 108667, 108680, 108377
38812, 105644, 105736, 105740, 105648, 105645, 105737, 105741, 105649, 108669, 108681, 108682, 108378, 108672, 108684, 108685, 
108381, 108367, 108670, 108683, 108380
38813, 105645, 105737, 105741, 105649, 105646, 105738, 105742, 105650, 108672, 108684, 108685, 108381, 108675, 108687, 108688, 
108384, 108370, 108673, 108686, 108383
38814, 105646, 105738, 105742, 105650, 34281, 34304, 34305, 34282, 108675, 108687, 108688, 108384, 34776, 34777, 34778, 
34730, 108373, 108676, 108689, 108386
38815, 16440, 16463, 16464, 16441, 105647, 105739, 105743, 105651, 16936, 16937, 16938, 16890, 108679, 108691, 108692, 
108388, 108374, 108677, 108690, 108387
38816, 105647, 105739, 105743, 105651, 105648, 105740, 105744, 105652, 108679, 108691, 108692, 108388, 108682, 108694, 108695, 
108391, 108377, 108680, 108693, 108390
38817, 105648, 105740, 105744, 105652, 105649, 105741, 105745, 105653, 108682, 108694, 108695, 108391, 108685, 108697, 108698, 
108394, 108380, 108683, 108696, 108393
38818, 105649, 105741, 105745, 105653, 105650, 105742, 105746, 105654, 108685, 108697, 108698, 108394, 108688, 108700, 108701, 
108397, 108383, 108686, 108699, 108396
38819, 105650, 105742, 105746, 105654, 34282, 34305, 34306, 34283, 108688, 108700, 108701, 108397, 34778, 34779, 34780, 
34732, 108386, 108689, 108702, 108399
38820, 16441, 16464, 16465, 16442, 105651, 105743, 105747, 105655, 16938, 16939, 16940, 16892, 108692, 108704, 108705, 
108401, 108387, 108690, 108703, 108400
38821, 105651, 105743, 105747, 105655, 105652, 105744, 105748, 105656, 108692, 108704, 108705, 108401, 108695, 108707, 108708, 
108404, 108390, 108693, 108706, 108403
38822, 105652, 105744, 105748, 105656, 105653, 105745, 105749, 105657, 108695, 108707, 108708, 108404, 108698, 108710, 108711, 
108407, 108393, 108696, 108709, 108406
38823, 105653, 105745, 105749, 105657, 105654, 105746, 105750, 105658, 108698, 108710, 108711, 108407, 108701, 108713, 108714, 
108410, 108396, 108699, 108712, 108409
38824, 105654, 105746, 105750, 105658, 34283, 34306, 34307, 34284, 108701, 108713, 108714, 108410, 34780, 34781, 34782, 
34734, 108399, 108702, 108715, 108412
38825, 16442, 16465, 16466, 16443, 105655, 105747, 105751, 105659, 16940, 16941, 16942, 16894, 108705, 108717, 108718, 
108414, 108400, 108703, 108716, 108413
38826, 105655, 105747, 105751, 105659, 105656, 105748, 105752, 105660, 108705, 108717, 108718, 108414, 108708, 108720, 108721, 
108417, 108403, 108706, 108719, 108416
38827, 105656, 105748, 105752, 105660, 105657, 105749, 105753, 105661, 108708, 108720, 108721, 108417, 108711, 108723, 108724, 
108420, 108406, 108709, 108722, 108419
38828, 105657, 105749, 105753, 105661, 105658, 105750, 105754, 105662, 108711, 108723, 108724, 108420, 108714, 108726, 108727, 
108423, 108409, 108712, 108725, 108422
38829, 105658, 105750, 105754, 105662, 34284, 34307, 34308, 34285, 108714, 108726, 108727, 108423, 34782, 34783, 34784, 
34736, 108412, 108715, 108728, 108425
38830, 16443, 16466, 16467, 16444, 105659, 105751, 105755, 105663, 16942, 16943, 16944, 16896, 108718, 108730, 108731, 
108427, 108413, 108716, 108729, 108426
38831, 105659, 105751, 105755, 105663, 105660, 105752, 105756, 105664, 108718, 108730, 108731, 108427, 108721, 108733, 108734, 
108430, 108416, 108719, 108732, 108429
38832, 105660, 105752, 105756, 105664, 105661, 105753, 105757, 105665, 108721, 108733, 108734, 108430, 108724, 108736, 108737, 
108433, 108419, 108722, 108735, 108432
38833, 105661, 105753, 105757, 105665, 105662, 105754, 105758, 105666, 108724, 108736, 108737, 108433, 108727, 108739, 108740, 
108436, 108422, 108725, 108738, 108435
38834, 105662, 105754, 105758, 105666, 34285, 34308, 34309, 34286, 108727, 108739, 108740, 108436, 34784, 34785, 34786, 
34738, 108425, 108728, 108741, 108438
38835, 16444, 16467, 16468, 16445, 105663, 105755, 105759, 105667, 16944, 16945, 16946, 16898, 108731, 108743, 108744, 
108440, 108426, 108729, 108742, 108439
38836, 105663, 105755, 105759, 105667, 105664, 105756, 105760, 105668, 108731, 108743, 108744, 108440, 108734, 108746, 108747, 
108443, 108429, 108732, 108745, 108442
38837, 105664, 105756, 105760, 105668, 105665, 105757, 105761, 105669, 108734, 108746, 108747, 108443, 108737, 108749, 108750, 
108446, 108432, 108735, 108748, 108445
38838, 105665, 105757, 105761, 105669, 105666, 105758, 105762, 105670, 108737, 108749, 108750, 108446, 108740, 108752, 108753, 
108449, 108435, 108738, 108751, 108448
38839, 105666, 105758, 105762, 105670, 34286, 34309, 34310, 34287, 108740, 108752, 108753, 108449, 34786, 34787, 34788, 
34740, 108438, 108741, 108754, 108451
38840, 16445, 16468, 16469, 16446, 105667, 105759, 105763, 105671, 16946, 16947, 16948, 16900, 108744, 108756, 108757, 
108453, 108439, 108742, 108755, 108452
38841, 105667, 105759, 105763, 105671, 105668, 105760, 105764, 105672, 108744, 108756, 108757, 108453, 108747, 108759, 108760, 
108456, 108442, 108745, 108758, 108455
38842, 105668, 105760, 105764, 105672, 105669, 105761, 105765, 105673, 108747, 108759, 108760, 108456, 108750, 108762, 108763, 
108459, 108445, 108748, 108761, 108458
38843, 105669, 105761, 105765, 105673, 105670, 105762, 105766, 105674, 108750, 108762, 108763, 108459, 108753, 108765, 108766, 
108462, 108448, 108751, 108764, 108461
38844, 105670, 105762, 105766, 105674, 34287, 34310, 34311, 34288, 108753, 108765, 108766, 108462, 34788, 34789, 34790, 
34742, 108451, 108754, 108767, 108464
38845, 16446, 16469, 16470, 16447, 105671, 105763, 105767, 105675, 16948, 16949, 16950, 16902, 108757, 108769, 108770, 
108466, 108452, 108755, 108768, 108465
38846, 105671, 105763, 105767, 105675, 105672, 105764, 105768, 105676, 108757, 108769, 108770, 108466, 108760, 108772, 108773, 
108469, 108455, 108758, 108771, 108468
38847, 105672, 105764, 105768, 105676, 105673, 105765, 105769, 105677, 108760, 108772, 108773, 108469, 108763, 108775, 108776, 
108472, 108458, 108761, 108774, 108471
38848, 105673, 105765, 105769, 105677, 105674, 105766, 105770, 105678, 108763, 108775, 108776, 108472, 108766, 108778, 108779, 
108475, 108461, 108764, 108777, 108474
38849, 105674, 105766, 105770, 105678, 34288, 34311, 34312, 34289, 108766, 108778, 108779, 108475, 34790, 34791, 34792, 
34744, 108464, 108767, 108780, 108477
38850, 16447, 16470, 16471, 16448, 105675, 105767, 105771, 105679, 16950, 16951, 16952, 16904, 108770, 108782, 108783, 
108479, 108465, 108768, 108781, 108478
38851, 105675, 105767, 105771, 105679, 105676, 105768, 105772, 105680, 108770, 108782, 108783, 108479, 108773, 108785, 108786, 
108482, 108468, 108771, 108784, 108481
38852, 105676, 105768, 105772, 105680, 105677, 105769, 105773, 105681, 108773, 108785, 108786, 108482, 108776, 108788, 108789, 
108485, 108471, 108774, 108787, 108484
38853, 105677, 105769, 105773, 105681, 105678, 105770, 105774, 105682, 108776, 108788, 108789, 108485, 108779, 108791, 108792, 
108488, 108474, 108777, 108790, 108487
38854, 105678, 105770, 105774, 105682, 34289, 34312, 34313, 34290, 108779, 108791, 108792, 108488, 34792, 34793, 34794, 
34746, 108477, 108780, 108793, 108490
38855, 16448, 16471, 16472, 16449, 105679, 105771, 105775, 105683, 16952, 16953, 16954, 16906, 108783, 108795, 108796, 
108492, 108478, 108781, 108794, 108491
38856, 105679, 105771, 105775, 105683, 105680, 105772, 105776, 105684, 108783, 108795, 108796, 108492, 108786, 108798, 108799, 
108495, 108481, 108784, 108797, 108494
38857, 105680, 105772, 105776, 105684, 105681, 105773, 105777, 105685, 108786, 108798, 108799, 108495, 108789, 108801, 108802, 
108498, 108484, 108787, 108800, 108497
38858, 105681, 105773, 105777, 105685, 105682, 105774, 105778, 105686, 108789, 108801, 108802, 108498, 108792, 108804, 108805, 
108501, 108487, 108790, 108803, 108500
38859, 105682, 105774, 105778, 105686, 34290, 34313, 34314, 34291, 108792, 108804, 108805, 108501, 34794, 34795, 34796, 
34748, 108490, 108793, 108806, 108503
38860, 16449, 16472, 16473, 16450, 105683, 105775, 105779, 105687, 16954, 16955, 16956, 16908, 108796, 108808, 108809, 
108505, 108491, 108794, 108807, 108504
38861, 105683, 105775, 105779, 105687, 105684, 105776, 105780, 105688, 108796, 108808, 108809, 108505, 108799, 108811, 108812, 
108508, 108494, 108797, 108810, 108507
38862, 105684, 105776, 105780, 105688, 105685, 105777, 105781, 105689, 108799, 108811, 108812, 108508, 108802, 108814, 108815, 
108511, 108497, 108800, 108813, 108510
38863, 105685, 105777, 105781, 105689, 105686, 105778, 105782, 105690, 108802, 108814, 108815, 108511, 108805, 108817, 108818, 
108514, 108500, 108803, 108816, 108513
38864, 105686, 105778, 105782, 105690, 34291, 34314, 34315, 34292, 108805, 108817, 108818, 108514, 34796, 34797, 34798, 
34750, 108503, 108806, 108819, 108516
38865, 16450, 16473, 16474, 16451, 105687, 105779, 105783, 105691, 16956, 16957, 16958, 16910, 108809, 108821, 108822, 
108518, 108504, 108807, 108820, 108517
38866, 105687, 105779, 105783, 105691, 105688, 105780, 105784, 105692, 108809, 108821, 108822, 108518, 108812, 108824, 108825, 
108521, 108507, 108810, 108823, 108520
38867, 105688, 105780, 105784, 105692, 105689, 105781, 105785, 105693, 108812, 108824, 108825, 108521, 108815, 108827, 108828, 
108524, 108510, 108813, 108826, 108523
38868, 105689, 105781, 105785, 105693, 105690, 105782, 105786, 105694, 108815, 108827, 108828, 108524, 108818, 108830, 108831, 
108527, 108513, 108816, 108829, 108526
38869, 105690, 105782, 105786, 105694, 34292, 34315, 34316, 34293, 108818, 108830, 108831, 108527, 34798, 34799, 34800, 
34752, 108516, 108819, 108832, 108529
38870, 16451, 16474, 16475, 16452, 105691, 105783, 105787, 105695, 16958, 16959, 16960, 16912, 108822, 108834, 108835, 
108531, 108517, 108820, 108833, 108530
38871, 105691, 105783, 105787, 105695, 105692, 105784, 105788, 105696, 108822, 108834, 108835, 108531, 108825, 108837, 108838, 
108534, 108520, 108823, 108836, 108533
38872, 105692, 105784, 105788, 105696, 105693, 105785, 105789, 105697, 108825, 108837, 108838, 108534, 108828, 108840, 108841, 
108537, 108523, 108826, 108839, 108536
38873, 105693, 105785, 105789, 105697, 105694, 105786, 105790, 105698, 108828, 108840, 108841, 108537, 108831, 108843, 108844, 
108540, 108526, 108829, 108842, 108539
38874, 105694, 105786, 105790, 105698, 34293, 34316, 34317, 34294, 108831, 108843, 108844, 108540, 34800, 34801, 34802, 
34754, 108529, 108832, 108845, 108542
38875, 16452, 16475, 16476, 16453, 105695, 105787, 105791, 105699, 16960, 16961, 16962, 16914, 108835, 108847, 108848, 
108544, 108530, 108833, 108846, 108543
38876, 105695, 105787, 105791, 105699, 105696, 105788, 105792, 105700, 108835, 108847, 108848, 108544, 108838, 108850, 108851, 
108547, 108533, 108836, 108849, 108546
38877, 105696, 105788, 105792, 105700, 105697, 105789, 105793, 105701, 108838, 108850, 108851, 108547, 108841, 108853, 108854, 
108550, 108536, 108839, 108852, 108549
38878, 105697, 105789, 105793, 105701, 105698, 105790, 105794, 105702, 108841, 108853, 108854, 108550, 108844, 108856, 108857, 
108553, 108539, 108842, 108855, 108552
38879, 105698, 105790, 105794, 105702, 34294, 34317, 34318, 34295, 108844, 108856, 108857, 108553, 34802, 34803, 34804, 
34756, 108542, 108845, 108858, 108555
38880, 16453, 16476, 16477, 16454, 105699, 105791, 105795, 105703, 16962, 16963, 16964, 16916, 108848, 108860, 108861, 
108557, 108543, 108846, 108859, 108556
38881, 105699, 105791, 105795, 105703, 105700, 105792, 105796, 105704, 108848, 108860, 108861, 108557, 108851, 108863, 108864, 
108560, 108546, 108849, 108862, 108559
38882, 105700, 105792, 105796, 105704, 105701, 105793, 105797, 105705, 108851, 108863, 108864, 108560, 108854, 108866, 108867, 
108563, 108549, 108852, 108865, 108562
38883, 105701, 105793, 105797, 105705, 105702, 105794, 105798, 105706, 108854, 108866, 108867, 108563, 108857, 108869, 108870, 
108566, 108552, 108855, 108868, 108565
38884, 105702, 105794, 105798, 105706, 34295, 34318, 34319, 34296, 108857, 108869, 108870, 108566, 34804, 34805, 34806, 
34758, 108555, 108858, 108871, 108568
38885, 16454, 16477, 16478, 16455, 105703, 105795, 105799, 105707, 16964, 16965, 16966, 16918, 108861, 108873, 108874, 
108570, 108556, 108859, 108872, 108569
38886, 105703, 105795, 105799, 105707, 105704, 105796, 105800, 105708, 108861, 108873, 108874, 108570, 108864, 108876, 108877, 
108573, 108559, 108862, 108875, 108572
38887, 105704, 105796, 105800, 105708, 105705, 105797, 105801, 105709, 108864, 108876, 108877, 108573, 108867, 108879, 108880, 
108576, 108562, 108865, 108878, 108575
38888, 105705, 105797, 105801, 105709, 105706, 105798, 105802, 105710, 108867, 108879, 108880, 108576, 108870, 108882, 108883, 
108579, 108565, 108868, 108881, 108578
38889, 105706, 105798, 105802, 105710, 34296, 34319, 34320, 34297, 108870, 108882, 108883, 108579, 34806, 34807, 34808, 
34760, 108568, 108871, 108884, 108581
38890, 16455, 16478, 16479, 16456, 105707, 105799, 105803, 105711, 16966, 16967, 16968, 16920, 108874, 108886, 108887, 
108583, 108569, 108872, 108885, 108582
38891, 105707, 105799, 105803, 105711, 105708, 105800, 105804, 105712, 108874, 108886, 108887, 108583, 108877, 108889, 108890, 
108586, 108572, 108875, 108888, 108585
38892, 105708, 105800, 105804, 105712, 105709, 105801, 105805, 105713, 108877, 108889, 108890, 108586, 108880, 108892, 108893, 
108589, 108575, 108878, 108891, 108588
38893, 105709, 105801, 105805, 105713, 105710, 105802, 105806, 105714, 108880, 108892, 108893, 108589, 108883, 108895, 108896, 
108592, 108578, 108881, 108894, 108591
38894, 105710, 105802, 105806, 105714, 34297, 34320, 34321, 34298, 108883, 108895, 108896, 108592, 34808, 34809, 34810, 
34762, 108581, 108884, 108897, 108594
38895, 16456, 16479, 16480, 16457, 105711, 105803, 105807, 105715, 16968, 16969, 16970, 16922, 108887, 108899, 108900, 
108596, 108582, 108885, 108898, 108595
38896, 105711, 105803, 105807, 105715, 105712, 105804, 105808, 105716, 108887, 108899, 108900, 108596, 108890, 108902, 108903, 
108599, 108585, 108888, 108901, 108598
38897, 105712, 105804, 105808, 105716, 105713, 105805, 105809, 105717, 108890, 108902, 108903, 108599, 108893, 108905, 108906, 
108602, 108588, 108891, 108904, 108601
38898, 105713, 105805, 105809, 105717, 105714, 105806, 105810, 105718, 108893, 108905, 108906, 108602, 108896, 108908, 108909, 
108605, 108591, 108894, 108907, 108604
38899, 105714, 105806, 105810, 105718, 34298, 34321, 34322, 34299, 108896, 108908, 108909, 108605, 34810, 34811, 34812, 
34764, 108594, 108897, 108910, 108607
38900, 16457, 16480, 16481, 16458, 105715, 105807, 105811, 105719, 16970, 16971, 16972, 16924, 108900, 108912, 108913, 
108609, 108595, 108898, 108911, 108608
38901, 105715, 105807, 105811, 105719, 105716, 105808, 105812, 105720, 108900, 108912, 108913, 108609, 108903, 108915, 108916, 
108612, 108598, 108901, 108914, 108611
38902, 105716, 105808, 105812, 105720, 105717, 105809, 105813, 105721, 108903, 108915, 108916, 108612, 108906, 108918, 108919, 
108615, 108601, 108904, 108917, 108614
38903, 105717, 105809, 105813, 105721, 105718, 105810, 105814, 105722, 108906, 108918, 108919, 108615, 108909, 108921, 108922, 
108618, 108604, 108907, 108920, 108617
38904, 105718, 105810, 105814, 105722, 34299, 34322, 34323, 34300, 108909, 108921, 108922, 108618, 34812, 34813, 34814, 
34766, 108607, 108910, 108923, 108620
38905, 16458, 16481, 16482, 16459, 105719, 105811, 105815, 105723, 16972, 16973, 16974, 16926, 108913, 108925, 108926, 
108622, 108608, 108911, 108924, 108621
38906, 105719, 105811, 105815, 105723, 105720, 105812, 105816, 105724, 108913, 108925, 108926, 108622, 108916, 108928, 108929, 
108625, 108611, 108914, 108927, 108624
38907, 105720, 105812, 105816, 105724, 105721, 105813, 105817, 105725, 108916, 108928, 108929, 108625, 108919, 108931, 108932, 
108628, 108614, 108917, 108930, 108627
38908, 105721, 105813, 105817, 105725, 105722, 105814, 105818, 105726, 108919, 108931, 108932, 108628, 108922, 108934, 108935, 
108631, 108617, 108920, 108933, 108630
38909, 105722, 105814, 105818, 105726, 34300, 34323, 34324, 34301, 108922, 108934, 108935, 108631, 34814, 34815, 34816, 
34768, 108620, 108923, 108936, 108633
38910, 16459, 16482, 1495, 1494, 105723, 105815, 33984, 33980, 16974, 16975, 1506, 16928, 108926, 108937, 34073, 
108634, 108621, 108924, 34074, 34065
38911, 105723, 105815, 33984, 33980, 105724, 105816, 33985, 33981, 108926, 108937, 34073, 108634, 108929, 108938, 34075, 
108635, 108624, 108927, 34076, 34067
38912, 105724, 105816, 33985, 33981, 105725, 105817, 33986, 33982, 108929, 108938, 34075, 108635, 108932, 108939, 34077, 
108636, 108627, 108930, 34078, 34069
38913, 105725, 105817, 33986, 33982, 105726, 105818, 33987, 33983, 108932, 108939, 34077, 108636, 108935, 108940, 34079, 
108637, 108630, 108933, 34080, 34071
38914, 105726, 105818, 33987, 33983, 34301, 34324, 3535, 3534, 108935, 108940, 34079, 108637, 34816, 34817, 3546, 
34770, 108633, 108936, 34081, 34072
38915, 1251, 1252, 16483, 16460, 33084, 33088, 105819, 105727, 1263, 16976, 16977, 16929, 33182, 108942, 108943, 
108639, 33174, 33183, 108941, 108638
38916, 33084, 33088, 105819, 105727, 33085, 33089, 105820, 105728, 33182, 108942, 108943, 108639, 33184, 108945, 108946, 
108642, 33176, 33185, 108944, 108641
38917, 33085, 33089, 105820, 105728, 33086, 33090, 105821, 105729, 33184, 108945, 108946, 108642, 33186, 108948, 108949, 
108645, 33178, 33187, 108947, 108644
38918, 33086, 33090, 105821, 105729, 33087, 33091, 105822, 105730, 33186, 108948, 108949, 108645, 33188, 108951, 108952, 
108648, 33180, 33189, 108950, 108647
38919, 33087, 33091, 105822, 105730, 3400, 3401, 34325, 34302, 33188, 108951, 108952, 108648, 3412, 34818, 34819, 
34771, 33181, 33190, 108953, 108650
38920, 16460, 16483, 16484, 16461, 105727, 105819, 105823, 105731, 16977, 16978, 16979, 16931, 108943, 108955, 108956, 
108652, 108638, 108941, 108954, 108651
38921, 105727, 105819, 105823, 105731, 105728, 105820, 105824, 105732, 108943, 108955, 108956, 108652, 108946, 108958, 108959, 
108655, 108641, 108944, 108957, 108654
38922, 105728, 105820, 105824, 105732, 105729, 105821, 105825, 105733, 108946, 108958, 108959, 108655, 108949, 108961, 108962, 
108658, 108644, 108947, 108960, 108657
38923, 105729, 105821, 105825, 105733, 105730, 105822, 105826, 105734, 108949, 108961, 108962, 108658, 108952, 108964, 108965, 
108661, 108647, 108950, 108963, 108660
38924, 105730, 105822, 105826, 105734, 34302, 34325, 34326, 34303, 108952, 108964, 108965, 108661, 34819, 34820, 34821, 
34773, 108650, 108953, 108966, 108663
38925, 16461, 16484, 16485, 16462, 105731, 105823, 105827, 105735, 16979, 16980, 16981, 16933, 108956, 108968, 108969, 
108665, 108651, 108954, 108967, 108664
38926, 105731, 105823, 105827, 105735, 105732, 105824, 105828, 105736, 108956, 108968, 108969, 108665, 108959, 108971, 108972, 
108668, 108654, 108957, 108970, 108667
38927, 105732, 105824, 105828, 105736, 105733, 105825, 105829, 105737, 108959, 108971, 108972, 108668, 108962, 108974, 108975, 
108671, 108657, 108960, 108973, 108670
38928, 105733, 105825, 105829, 105737, 105734, 105826, 105830, 105738, 108962, 108974, 108975, 108671, 108965, 108977, 108978, 
108674, 108660, 108963, 108976, 108673
38929, 105734, 105826, 105830, 105738, 34303, 34326, 34327, 34304, 108965, 108977, 108978, 108674, 34821, 34822, 34823, 
34775, 108663, 108966, 108979, 108676
38930, 16462, 16485, 16486, 16463, 105735, 105827, 105831, 105739, 16981, 16982, 16983, 16935, 108969, 108981, 108982, 
108678, 108664, 108967, 108980, 108677
38931, 105735, 105827, 105831, 105739, 105736, 105828, 105832, 105740, 108969, 108981, 108982, 108678, 108972, 108984, 108985, 
108681, 108667, 108970, 108983, 108680
38932, 105736, 105828, 105832, 105740, 105737, 105829, 105833, 105741, 108972, 108984, 108985, 108681, 108975, 108987, 108988, 
108684, 108670, 108973, 108986, 108683
38933, 105737, 105829, 105833, 105741, 105738, 105830, 105834, 105742, 108975, 108987, 108988, 108684, 108978, 108990, 108991, 
108687, 108673, 108976, 108989, 108686
38934, 105738, 105830, 105834, 105742, 34304, 34327, 34328, 34305, 108978, 108990, 108991, 108687, 34823, 34824, 34825, 
34777, 108676, 108979, 108992, 108689
38935, 16463, 16486, 16487, 16464, 105739, 105831, 105835, 105743, 16983, 16984, 16985, 16937, 108982, 108994, 108995, 
108691, 108677, 108980, 108993, 108690
38936, 105739, 105831, 105835, 105743, 105740, 105832, 105836, 105744, 108982, 108994, 108995, 108691, 108985, 108997, 108998, 
108694, 108680, 108983, 108996, 108693
38937, 105740, 105832, 105836, 105744, 105741, 105833, 105837, 105745, 108985, 108997, 108998, 108694, 108988, 109000, 109001, 
108697, 108683, 108986, 108999, 108696
38938, 105741, 105833, 105837, 105745, 105742, 105834, 105838, 105746, 108988, 109000, 109001, 108697, 108991, 109003, 109004, 
108700, 108686, 108989, 109002, 108699
38939, 105742, 105834, 105838, 105746, 34305, 34328, 34329, 34306, 108991, 109003, 109004, 108700, 34825, 34826, 34827, 
34779, 108689, 108992, 109005, 108702
38940, 16464, 16487, 16488, 16465, 105743, 105835, 105839, 105747, 16985, 16986, 16987, 16939, 108995, 109007, 109008, 
108704, 108690, 108993, 109006, 108703
38941, 105743, 105835, 105839, 105747, 105744, 105836, 105840, 105748, 108995, 109007, 109008, 108704, 108998, 109010, 109011, 
108707, 108693, 108996, 109009, 108706
38942, 105744, 105836, 105840, 105748, 105745, 105837, 105841, 105749, 108998, 109010, 109011, 108707, 109001, 109013, 109014, 
108710, 108696, 108999, 109012, 108709
38943, 105745, 105837, 105841, 105749, 105746, 105838, 105842, 105750, 109001, 109013, 109014, 108710, 109004, 109016, 109017, 
108713, 108699, 109002, 109015, 108712
38944, 105746, 105838, 105842, 105750, 34306, 34329, 34330, 34307, 109004, 109016, 109017, 108713, 34827, 34828, 34829, 
34781, 108702, 109005, 109018, 108715
38945, 16465, 16488, 16489, 16466, 105747, 105839, 105843, 105751, 16987, 16988, 16989, 16941, 109008, 109020, 109021, 
108717, 108703, 109006, 109019, 108716
38946, 105747, 105839, 105843, 105751, 105748, 105840, 105844, 105752, 109008, 109020, 109021, 108717, 109011, 109023, 109024, 
108720, 108706, 109009, 109022, 108719
38947, 105748, 105840, 105844, 105752, 105749, 105841, 105845, 105753, 109011, 109023, 109024, 108720, 109014, 109026, 109027, 
108723, 108709, 109012, 109025, 108722
38948, 105749, 105841, 105845, 105753, 105750, 105842, 105846, 105754, 109014, 109026, 109027, 108723, 109017, 109029, 109030, 
108726, 108712, 109015, 109028, 108725
38949, 105750, 105842, 105846, 105754, 34307, 34330, 34331, 34308, 109017, 109029, 109030, 108726, 34829, 34830, 34831, 
34783, 108715, 109018, 109031, 108728
38950, 16466, 16489, 16490, 16467, 105751, 105843, 105847, 105755, 16989, 16990, 16991, 16943, 109021, 109033, 109034, 
108730, 108716, 109019, 109032, 108729
38951, 105751, 105843, 105847, 105755, 105752, 105844, 105848, 105756, 109021, 109033, 109034, 108730, 109024, 109036, 109037, 
108733, 108719, 109022, 109035, 108732
38952, 105752, 105844, 105848, 105756, 105753, 105845, 105849, 105757, 109024, 109036, 109037, 108733, 109027, 109039, 109040, 
108736, 108722, 109025, 109038, 108735
38953, 105753, 105845, 105849, 105757, 105754, 105846, 105850, 105758, 109027, 109039, 109040, 108736, 109030, 109042, 109043, 
108739, 108725, 109028, 109041, 108738
38954, 105754, 105846, 105850, 105758, 34308, 34331, 34332, 34309, 109030, 109042, 109043, 108739, 34831, 34832, 34833, 
34785, 108728, 109031, 109044, 108741
38955, 16467, 16490, 16491, 16468, 105755, 105847, 105851, 105759, 16991, 16992, 16993, 16945, 109034, 109046, 109047, 
108743, 108729, 109032, 109045, 108742
38956, 105755, 105847, 105851, 105759, 105756, 105848, 105852, 105760, 109034, 109046, 109047, 108743, 109037, 109049, 109050, 
108746, 108732, 109035, 109048, 108745
38957, 105756, 105848, 105852, 105760, 105757, 105849, 105853, 105761, 109037, 109049, 109050, 108746, 109040, 109052, 109053, 
108749, 108735, 109038, 109051, 108748
38958, 105757, 105849, 105853, 105761, 105758, 105850, 105854, 105762, 109040, 109052, 109053, 108749, 109043, 109055, 109056, 
108752, 108738, 109041, 109054, 108751
38959, 105758, 105850, 105854, 105762, 34309, 34332, 34333, 34310, 109043, 109055, 109056, 108752, 34833, 34834, 34835, 
34787, 108741, 109044, 109057, 108754
38960, 16468, 16491, 16492, 16469, 105759, 105851, 105855, 105763, 16993, 16994, 16995, 16947, 109047, 109059, 109060, 
108756, 108742, 109045, 109058, 108755
38961, 105759, 105851, 105855, 105763, 105760, 105852, 105856, 105764, 109047, 109059, 109060, 108756, 109050, 109062, 109063, 
108759, 108745, 109048, 109061, 108758
38962, 105760, 105852, 105856, 105764, 105761, 105853, 105857, 105765, 109050, 109062, 109063, 108759, 109053, 109065, 109066, 
108762, 108748, 109051, 109064, 108761
38963, 105761, 105853, 105857, 105765, 105762, 105854, 105858, 105766, 109053, 109065, 109066, 108762, 109056, 109068, 109069, 
108765, 108751, 109054, 109067, 108764
38964, 105762, 105854, 105858, 105766, 34310, 34333, 34334, 34311, 109056, 109068, 109069, 108765, 34835, 34836, 34837, 
34789, 108754, 109057, 109070, 108767
38965, 16469, 16492, 16493, 16470, 105763, 105855, 105859, 105767, 16995, 16996, 16997, 16949, 109060, 109072, 109073, 
108769, 108755, 109058, 109071, 108768
38966, 105763, 105855, 105859, 105767, 105764, 105856, 105860, 105768, 109060, 109072, 109073, 108769, 109063, 109075, 109076, 
108772, 108758, 109061, 109074, 108771
38967, 105764, 105856, 105860, 105768, 105765, 105857, 105861, 105769, 109063, 109075, 109076, 108772, 109066, 109078, 109079, 
108775, 108761, 109064, 109077, 108774
38968, 105765, 105857, 105861, 105769, 105766, 105858, 105862, 105770, 109066, 109078, 109079, 108775, 109069, 109081, 109082, 
108778, 108764, 109067, 109080, 108777
38969, 105766, 105858, 105862, 105770, 34311, 34334, 34335, 34312, 109069, 109081, 109082, 108778, 34837, 34838, 34839, 
34791, 108767, 109070, 109083, 108780
38970, 16470, 16493, 16494, 16471, 105767, 105859, 105863, 105771, 16997, 16998, 16999, 16951, 109073, 109085, 109086, 
108782, 108768, 109071, 109084, 108781
38971, 105767, 105859, 105863, 105771, 105768, 105860, 105864, 105772, 109073, 109085, 109086, 108782, 109076, 109088, 109089, 
108785, 108771, 109074, 109087, 108784
38972, 105768, 105860, 105864, 105772, 105769, 105861, 105865, 105773, 109076, 109088, 109089, 108785, 109079, 109091, 109092, 
108788, 108774, 109077, 109090, 108787
38973, 105769, 105861, 105865, 105773, 105770, 105862, 105866, 105774, 109079, 109091, 109092, 108788, 109082, 109094, 109095, 
108791, 108777, 109080, 109093, 108790
38974, 105770, 105862, 105866, 105774, 34312, 34335, 34336, 34313, 109082, 109094, 109095, 108791, 34839, 34840, 34841, 
34793, 108780, 109083, 109096, 108793
38975, 16471, 16494, 16495, 16472, 105771, 105863, 105867, 105775, 16999, 17000, 17001, 16953, 109086, 109098, 109099, 
108795, 108781, 109084, 109097, 108794
38976, 105771, 105863, 105867, 105775, 105772, 105864, 105868, 105776, 109086, 109098, 109099, 108795, 109089, 109101, 109102, 
108798, 108784, 109087, 109100, 108797
38977, 105772, 105864, 105868, 105776, 105773, 105865, 105869, 105777, 109089, 109101, 109102, 108798, 109092, 109104, 109105, 
108801, 108787, 109090, 109103, 108800
38978, 105773, 105865, 105869, 105777, 105774, 105866, 105870, 105778, 109092, 109104, 109105, 108801, 109095, 109107, 109108, 
108804, 108790, 109093, 109106, 108803
38979, 105774, 105866, 105870, 105778, 34313, 34336, 34337, 34314, 109095, 109107, 109108, 108804, 34841, 34842, 34843, 
34795, 108793, 109096, 109109, 108806
38980, 16472, 16495, 16496, 16473, 105775, 105867, 105871, 105779, 17001, 17002, 17003, 16955, 109099, 109111, 109112, 
108808, 108794, 109097, 109110, 108807
38981, 105775, 105867, 105871, 105779, 105776, 105868, 105872, 105780, 109099, 109111, 109112, 108808, 109102, 109114, 109115, 
108811, 108797, 109100, 109113, 108810
38982, 105776, 105868, 105872, 105780, 105777, 105869, 105873, 105781, 109102, 109114, 109115, 108811, 109105, 109117, 109118, 
108814, 108800, 109103, 109116, 108813
38983, 105777, 105869, 105873, 105781, 105778, 105870, 105874, 105782, 109105, 109117, 109118, 108814, 109108, 109120, 109121, 
108817, 108803, 109106, 109119, 108816
38984, 105778, 105870, 105874, 105782, 34314, 34337, 34338, 34315, 109108, 109120, 109121, 108817, 34843, 34844, 34845, 
34797, 108806, 109109, 109122, 108819
38985, 16473, 16496, 16497, 16474, 105779, 105871, 105875, 105783, 17003, 17004, 17005, 16957, 109112, 109124, 109125, 
108821, 108807, 109110, 109123, 108820
38986, 105779, 105871, 105875, 105783, 105780, 105872, 105876, 105784, 109112, 109124, 109125, 108821, 109115, 109127, 109128, 
108824, 108810, 109113, 109126, 108823
38987, 105780, 105872, 105876, 105784, 105781, 105873, 105877, 105785, 109115, 109127, 109128, 108824, 109118, 109130, 109131, 
108827, 108813, 109116, 109129, 108826
38988, 105781, 105873, 105877, 105785, 105782, 105874, 105878, 105786, 109118, 109130, 109131, 108827, 109121, 109133, 109134, 
108830, 108816, 109119, 109132, 108829
38989, 105782, 105874, 105878, 105786, 34315, 34338, 34339, 34316, 109121, 109133, 109134, 108830, 34845, 34846, 34847, 
34799, 108819, 109122, 109135, 108832
38990, 16474, 16497, 16498, 16475, 105783, 105875, 105879, 105787, 17005, 17006, 17007, 16959, 109125, 109137, 109138, 
108834, 108820, 109123, 109136, 108833
38991, 105783, 105875, 105879, 105787, 105784, 105876, 105880, 105788, 109125, 109137, 109138, 108834, 109128, 109140, 109141, 
108837, 108823, 109126, 109139, 108836
38992, 105784, 105876, 105880, 105788, 105785, 105877, 105881, 105789, 109128, 109140, 109141, 108837, 109131, 109143, 109144, 
108840, 108826, 109129, 109142, 108839
38993, 105785, 105877, 105881, 105789, 105786, 105878, 105882, 105790, 109131, 109143, 109144, 108840, 109134, 109146, 109147, 
108843, 108829, 109132, 109145, 108842
38994, 105786, 105878, 105882, 105790, 34316, 34339, 34340, 34317, 109134, 109146, 109147, 108843, 34847, 34848, 34849, 
34801, 108832, 109135, 109148, 108845
38995, 16475, 16498, 16499, 16476, 105787, 105879, 105883, 105791, 17007, 17008, 17009, 16961, 109138, 109150, 109151, 
108847, 108833, 109136, 109149, 108846
38996, 105787, 105879, 105883, 105791, 105788, 105880, 105884, 105792, 109138, 109150, 109151, 108847, 109141, 109153, 109154, 
108850, 108836, 109139, 109152, 108849
38997, 105788, 105880, 105884, 105792, 105789, 105881, 105885, 105793, 109141, 109153, 109154, 108850, 109144, 109156, 109157, 
108853, 108839, 109142, 109155, 108852
38998, 105789, 105881, 105885, 105793, 105790, 105882, 105886, 105794, 109144, 109156, 109157, 108853, 109147, 109159, 109160, 
108856, 108842, 109145, 109158, 108855
38999, 105790, 105882, 105886, 105794, 34317, 34340, 34341, 34318, 109147, 109159, 109160, 108856, 34849, 34850, 34851, 
34803, 108845, 109148, 109161, 108858
39000, 16476, 16499, 16500, 16477, 105791, 105883, 105887, 105795, 17009, 17010, 17011, 16963, 109151, 109163, 109164, 
108860, 108846, 109149, 109162, 108859
39001, 105791, 105883, 105887, 105795, 105792, 105884, 105888, 105796, 109151, 109163, 109164, 108860, 109154, 109166, 109167, 
108863, 108849, 109152, 109165, 108862
39002, 105792, 105884, 105888, 105796, 105793, 105885, 105889, 105797, 109154, 109166, 109167, 108863, 109157, 109169, 109170, 
108866, 108852, 109155, 109168, 108865
39003, 105793, 105885, 105889, 105797, 105794, 105886, 105890, 105798, 109157, 109169, 109170, 108866, 109160, 109172, 109173, 
108869, 108855, 109158, 109171, 108868
39004, 105794, 105886, 105890, 105798, 34318, 34341, 34342, 34319, 109160, 109172, 109173, 108869, 34851, 34852, 34853, 
34805, 108858, 109161, 109174, 108871
39005, 16477, 16500, 16501, 16478, 105795, 105887, 105891, 105799, 17011, 17012, 17013, 16965, 109164, 109176, 109177, 
108873, 108859, 109162, 109175, 108872
39006, 105795, 105887, 105891, 105799, 105796, 105888, 105892, 105800, 109164, 109176, 109177, 108873, 109167, 109179, 109180, 
108876, 108862, 109165, 109178, 108875
39007, 105796, 105888, 105892, 105800, 105797, 105889, 105893, 105801, 109167, 109179, 109180, 108876, 109170, 109182, 109183, 
108879, 108865, 109168, 109181, 108878
39008, 105797, 105889, 105893, 105801, 105798, 105890, 105894, 105802, 109170, 109182, 109183, 108879, 109173, 109185, 109186, 
108882, 108868, 109171, 109184, 108881
39009, 105798, 105890, 105894, 105802, 34319, 34342, 34343, 34320, 109173, 109185, 109186, 108882, 34853, 34854, 34855, 
34807, 108871, 109174, 109187, 108884
39010, 16478, 16501, 16502, 16479, 105799, 105891, 105895, 105803, 17013, 17014, 17015, 16967, 109177, 109189, 109190, 
108886, 108872, 109175, 109188, 108885
39011, 105799, 105891, 105895, 105803, 105800, 105892, 105896, 105804, 109177, 109189, 109190, 108886, 109180, 109192, 109193, 
108889, 108875, 109178, 109191, 108888
39012, 105800, 105892, 105896, 105804, 105801, 105893, 105897, 105805, 109180, 109192, 109193, 108889, 109183, 109195, 109196, 
108892, 108878, 109181, 109194, 108891
39013, 105801, 105893, 105897, 105805, 105802, 105894, 105898, 105806, 109183, 109195, 109196, 108892, 109186, 109198, 109199, 
