82490, 1.5958333333333, 1.25, 0.16666666666667
82491, 1.6166666666667, 1.225, 0.16666666666667
82492, 1.6166666666667, 1.2, 0.14583333333333
82493, 1.5958333333333, 1.2, 0.16666666666667
82494, 1.6166666666667, 1.175, 0.16666666666667
82495, 1.6166666666667, 1.15, 0.14583333333333
82496, 1.5958333333333, 1.15, 0.16666666666667
82497, 1.6166666666667, 1.125, 0.16666666666667
82498, 1.6166666666667, 1.1, 0.14583333333333
82499, 1.5958333333333, 1.1, 0.16666666666667
82500, 1.6166666666667, 1.075, 0.16666666666667
82501, 1.6166666666667, 1.05, 0.14583333333333
82502, 1.5958333333333, 1.05, 0.16666666666667
82503, 1.6166666666667, 1.025, 0.16666666666667
82504, 1.6166666666667, 1, 0.14583333333333
82505, 1.5958333333333, 1, 0.16666666666667
82506, 1.6166666666667, 0.975, 0.16666666666667
82507, 1.6166666666667, 0.95, 0.14583333333333
82508, 1.5958333333333, 0.95, 0.16666666666667
82509, 1.6166666666667, 0.925, 0.16666666666667
82510, 1.6166666666667, 0.9, 0.14583333333333
82511, 1.5958333333333, 0.9, 0.16666666666667
82512, 1.6166666666667, 0.875, 0.16666666666667
82513, 1.6166666666667, 0.85, 0.14583333333333
82514, 1.5958333333333, 0.85, 0.16666666666667
82515, 1.6166666666667, 0.825, 0.16666666666667
82516, 1.6166666666667, 0.8, 0.14583333333333
82517, 1.5958333333333, 0.8, 0.16666666666667
82518, 1.6166666666667, 0.775, 0.16666666666667
82519, 1.6166666666667, 0.75, 0.14583333333333
82520, 1.5958333333333, 0.75, 0.16666666666667
82521, 1.6166666666667, 0.725, 0.16666666666667
82522, 1.6166666666667, 0.7, 0.14583333333333
82523, 1.5958333333333, 0.7, 0.16666666666667
82524, 1.6166666666667, 0.675, 0.16666666666667
82525, 1.6166666666667, 0.65, 0.14583333333333
82526, 1.5958333333333, 0.65, 0.16666666666667
82527, 1.6166666666667, 0.625, 0.16666666666667
82528, 1.6166666666667, 0.6, 0.14583333333333
82529, 1.5958333333333, 0.6, 0.16666666666667
82530, 1.6166666666667, 0.575, 0.16666666666667
82531, 1.6166666666667, 0.55, 0.14583333333333
82532, 1.5958333333333, 0.55, 0.16666666666667
82533, 1.6166666666667, 0.525, 0.16666666666667
82534, 1.6166666666667, 0.5, 0.14583333333333
82535, 1.5958333333333, 0.5, 0.16666666666667
82536, 1.6166666666667, 0.475, 0.16666666666667
82537, 1.6166666666667, 0.45, 0.14583333333333
82538, 1.5958333333333, 0.45, 0.16666666666667
82539, 1.6166666666667, 0.425, 0.16666666666667
82540, 1.6166666666667, 0.4, 0.14583333333333
82541, 1.5958333333333, 0.4, 0.16666666666667
82542, 1.6166666666667, 0.375, 0.16666666666667
82543, 1.6166666666667, 0.35, 0.14583333333333
82544, 1.5958333333333, 0.35, 0.16666666666667
82545, 1.6166666666667, 0.325, 0.16666666666667
82546, 1.6166666666667, 0.3, 0.14583333333333
82547, 1.5958333333333, 0.3, 0.16666666666667
82548, 1.6166666666667, 0.275, 0.16666666666667
82549, 1.6166666666667, 0.25, 0.14583333333333
82550, 1.5958333333333, 0.25, 0.16666666666667
82551, 1.6166666666667, 0.225, 0.16666666666667
82552, 1.6166666666667, 0.2, 0.14583333333333
82553, 1.5958333333333, 0.2, 0.16666666666667
82554, 1.6166666666667, 0.175, 0.16666666666667
82555, 1.6583333333333, 1.325, 0.16666666666667
82556, 1.6583333333333, 1.3, 0.14583333333333
82557, 1.6375, 1.3, 0.16666666666667
82558, 1.6583333333333, 1.275, 0.16666666666667
82559, 1.6583333333333, 1.25, 0.14583333333333
82560, 1.6375, 1.25, 0.16666666666667
82561, 1.6583333333333, 1.225, 0.16666666666667
82562, 1.6583333333333, 1.2, 0.14583333333333
82563, 1.6375, 1.2, 0.16666666666667
82564, 1.6583333333333, 1.175, 0.16666666666667
82565, 1.6583333333333, 1.15, 0.14583333333333
82566, 1.6375, 1.15, 0.16666666666667
82567, 1.6583333333333, 1.125, 0.16666666666667
82568, 1.6583333333333, 1.1, 0.14583333333333
82569, 1.6375, 1.1, 0.16666666666667
82570, 1.6583333333333, 1.075, 0.16666666666667
82571, 1.6583333333333, 1.05, 0.14583333333333
82572, 1.6375, 1.05, 0.16666666666667
82573, 1.6583333333333, 1.025, 0.16666666666667
82574, 1.6583333333333, 1, 0.14583333333333
82575, 1.6375, 1, 0.16666666666667
82576, 1.6583333333333, 0.975, 0.16666666666667
82577, 1.6583333333333, 0.95, 0.14583333333333
82578, 1.6375, 0.95, 0.16666666666667
82579, 1.6583333333333, 0.925, 0.16666666666667
82580, 1.6583333333333, 0.9, 0.14583333333333
82581, 1.6375, 0.9, 0.16666666666667
82582, 1.6583333333333, 0.875, 0.16666666666667
82583, 1.6583333333333, 0.85, 0.14583333333333
82584, 1.6375, 0.85, 0.16666666666667
82585, 1.6583333333333, 0.825, 0.16666666666667
82586, 1.6583333333333, 0.8, 0.14583333333333
82587, 1.6375, 0.8, 0.16666666666667
82588, 1.6583333333333, 0.775, 0.16666666666667
82589, 1.6583333333333, 0.75, 0.14583333333333
82590, 1.6375, 0.75, 0.16666666666667
82591, 1.6583333333333, 0.725, 0.16666666666667
82592, 1.6583333333333, 0.7, 0.14583333333333
82593, 1.6375, 0.7, 0.16666666666667
82594, 1.6583333333333, 0.675, 0.16666666666667
82595, 1.6583333333333, 0.65, 0.14583333333333
82596, 1.6375, 0.65, 0.16666666666667
82597, 1.6583333333333, 0.625, 0.16666666666667
82598, 1.6583333333333, 0.6, 0.14583333333333
82599, 1.6375, 0.6, 0.16666666666667
82600, 1.6583333333333, 0.575, 0.16666666666667
82601, 1.6583333333333, 0.55, 0.14583333333333
82602, 1.6375, 0.55, 0.16666666666667
82603, 1.6583333333333, 0.525, 0.16666666666667
82604, 1.6583333333333, 0.5, 0.14583333333333
82605, 1.6375, 0.5, 0.16666666666667
82606, 1.6583333333333, 0.475, 0.16666666666667
82607, 1.6583333333333, 0.45, 0.14583333333333
82608, 1.6375, 0.45, 0.16666666666667
82609, 1.6583333333333, 0.425, 0.16666666666667
82610, 1.6583333333333, 0.4, 0.14583333333333
82611, 1.6375, 0.4, 0.16666666666667
82612, 1.6583333333333, 0.375, 0.16666666666667
82613, 1.6583333333333, 0.35, 0.14583333333333
82614, 1.6375, 0.35, 0.16666666666667
82615, 1.6583333333333, 0.325, 0.16666666666667
82616, 1.6583333333333, 0.3, 0.14583333333333
82617, 1.6375, 0.3, 0.16666666666667
82618, 1.6583333333333, 0.275, 0.16666666666667
82619, 1.6583333333333, 0.25, 0.14583333333333
82620, 1.6375, 0.25, 0.16666666666667
82621, 1.6583333333333, 0.225, 0.16666666666667
82622, 1.6583333333333, 0.2, 0.14583333333333
82623, 1.6375, 0.2, 0.16666666666667
82624, 1.6583333333333, 0.175, 0.16666666666667
82625, 1.7, 1.325, 0.16666666666667
82626, 1.7, 1.3, 0.14583333333333
82627, 1.6791666666667, 1.3, 0.16666666666667
82628, 1.7, 1.275, 0.16666666666667
82629, 1.7, 1.25, 0.14583333333333
82630, 1.6791666666667, 1.25, 0.16666666666667
82631, 1.7, 1.225, 0.16666666666667
82632, 1.7, 1.2, 0.14583333333333
82633, 1.6791666666667, 1.2, 0.16666666666667
82634, 1.7, 1.175, 0.16666666666667
82635, 1.7, 1.15, 0.14583333333333
82636, 1.6791666666667, 1.15, 0.16666666666667
82637, 1.7, 1.125, 0.16666666666667
82638, 1.7, 1.1, 0.14583333333333
82639, 1.6791666666667, 1.1, 0.16666666666667
82640, 1.7, 1.075, 0.16666666666667
82641, 1.7, 1.05, 0.14583333333333
82642, 1.6791666666667, 1.05, 0.16666666666667
82643, 1.7, 1.025, 0.16666666666667
82644, 1.7, 1, 0.14583333333333
82645, 1.6791666666667, 1, 0.16666666666667
82646, 1.7, 0.975, 0.16666666666667
82647, 1.7, 0.95, 0.14583333333333
82648, 1.6791666666667, 0.95, 0.16666666666667
82649, 1.7, 0.925, 0.16666666666667
82650, 1.7, 0.9, 0.14583333333333
82651, 1.6791666666667, 0.9, 0.16666666666667
82652, 1.7, 0.875, 0.16666666666667
82653, 1.7, 0.85, 0.14583333333333
82654, 1.6791666666667, 0.85, 0.16666666666667
82655, 1.7, 0.825, 0.16666666666667
82656, 1.7, 0.8, 0.14583333333333
82657, 1.6791666666667, 0.8, 0.16666666666667
82658, 1.7, 0.775, 0.16666666666667
82659, 1.7, 0.75, 0.14583333333333
82660, 1.6791666666667, 0.75, 0.16666666666667
82661, 1.7, 0.725, 0.16666666666667
82662, 1.7, 0.7, 0.14583333333333
82663, 1.6791666666667, 0.7, 0.16666666666667
82664, 1.7, 0.675, 0.16666666666667
82665, 1.7, 0.65, 0.14583333333333
82666, 1.6791666666667, 0.65, 0.16666666666667
82667, 1.7, 0.625, 0.16666666666667
82668, 1.7, 0.6, 0.14583333333333
82669, 1.6791666666667, 0.6, 0.16666666666667
82670, 1.7, 0.575, 0.16666666666667
82671, 1.7, 0.55, 0.14583333333333
82672, 1.6791666666667, 0.55, 0.16666666666667
82673, 1.7, 0.525, 0.16666666666667
82674, 1.7, 0.5, 0.14583333333333
82675, 1.6791666666667, 0.5, 0.16666666666667
82676, 1.7, 0.475, 0.16666666666667
82677, 1.7, 0.45, 0.14583333333333
82678, 1.6791666666667, 0.45, 0.16666666666667
82679, 1.7, 0.425, 0.16666666666667
82680, 1.7, 0.4, 0.14583333333333
82681, 1.6791666666667, 0.4, 0.16666666666667
82682, 1.7, 0.375, 0.16666666666667
82683, 1.7, 0.35, 0.14583333333333
82684, 1.6791666666667, 0.35, 0.16666666666667
82685, 1.7, 0.325, 0.16666666666667
82686, 1.7, 0.3, 0.14583333333333
82687, 1.6791666666667, 0.3, 0.16666666666667
82688, 1.7, 0.275, 0.16666666666667
82689, 1.7, 0.25, 0.14583333333333
82690, 1.6791666666667, 0.25, 0.16666666666667
82691, 1.7, 0.225, 0.16666666666667
82692, 1.7, 0.2, 0.14583333333333
82693, 1.6791666666667, 0.2, 0.16666666666667
82694, 1.7, 0.175, 0.16666666666667
82695, 1.7416666666667, 1.325, 0.16666666666667
82696, 1.7416666666667, 1.3, 0.14583333333333
82697, 1.7208333333333, 1.3, 0.16666666666667
82698, 1.7416666666667, 1.275, 0.16666666666667
82699, 1.7416666666667, 1.25, 0.14583333333333
82700, 1.7208333333333, 1.25, 0.16666666666667
82701, 1.7416666666667, 1.225, 0.16666666666667
82702, 1.7416666666667, 1.2, 0.14583333333333
82703, 1.7208333333333, 1.2, 0.16666666666667
82704, 1.7416666666667, 1.175, 0.16666666666667
82705, 1.7416666666667, 1.15, 0.14583333333333
82706, 1.7208333333333, 1.15, 0.16666666666667
82707, 1.7416666666667, 1.125, 0.16666666666667
82708, 1.7416666666667, 1.1, 0.14583333333333
82709, 1.7208333333333, 1.1, 0.16666666666667
82710, 1.7416666666667, 1.075, 0.16666666666667
82711, 1.7416666666667, 1.05, 0.14583333333333
82712, 1.7208333333333, 1.05, 0.16666666666667
82713, 1.7416666666667, 1.025, 0.16666666666667
82714, 1.7416666666667, 1, 0.14583333333333
82715, 1.7208333333333, 1, 0.16666666666667
82716, 1.7416666666667, 0.975, 0.16666666666667
82717, 1.7416666666667, 0.95, 0.14583333333333
82718, 1.7208333333333, 0.95, 0.16666666666667
82719, 1.7416666666667, 0.925, 0.16666666666667
82720, 1.7416666666667, 0.9, 0.14583333333333
82721, 1.7208333333333, 0.9, 0.16666666666667
82722, 1.7416666666667, 0.875, 0.16666666666667
82723, 1.7416666666667, 0.85, 0.14583333333333
82724, 1.7208333333333, 0.85, 0.16666666666667
82725, 1.7416666666667, 0.825, 0.16666666666667
82726, 1.7416666666667, 0.8, 0.14583333333333
82727, 1.7208333333333, 0.8, 0.16666666666667
82728, 1.7416666666667, 0.775, 0.16666666666667
82729, 1.7416666666667, 0.75, 0.14583333333333
82730, 1.7208333333333, 0.75, 0.16666666666667
82731, 1.7416666666667, 0.725, 0.16666666666667
82732, 1.7416666666667, 0.7, 0.14583333333333
82733, 1.7208333333333, 0.7, 0.16666666666667
82734, 1.7416666666667, 0.675, 0.16666666666667
82735, 1.7416666666667, 0.65, 0.14583333333333
82736, 1.7208333333333, 0.65, 0.16666666666667
82737, 1.7416666666667, 0.625, 0.16666666666667
82738, 1.7416666666667, 0.6, 0.14583333333333
82739, 1.7208333333333, 0.6, 0.16666666666667
82740, 1.7416666666667, 0.575, 0.16666666666667
82741, 1.7416666666667, 0.55, 0.14583333333333
82742, 1.7208333333333, 0.55, 0.16666666666667
82743, 1.7416666666667, 0.525, 0.16666666666667
82744, 1.7416666666667, 0.5, 0.14583333333333
82745, 1.7208333333333, 0.5, 0.16666666666667
82746, 1.7416666666667, 0.475, 0.16666666666667
82747, 1.7416666666667, 0.45, 0.14583333333333
82748, 1.7208333333333, 0.45, 0.16666666666667
82749, 1.7416666666667, 0.425, 0.16666666666667
82750, 1.7416666666667, 0.4, 0.14583333333333
82751, 1.7208333333333, 0.4, 0.16666666666667
82752, 1.7416666666667, 0.375, 0.16666666666667
82753, 1.7416666666667, 0.35, 0.14583333333333
82754, 1.7208333333333, 0.35, 0.16666666666667
82755, 1.7416666666667, 0.325, 0.16666666666667
82756, 1.7416666666667, 0.3, 0.14583333333333
82757, 1.7208333333333, 0.3, 0.16666666666667
82758, 1.7416666666667, 0.275, 0.16666666666667
82759, 1.7416666666667, 0.25, 0.14583333333333
82760, 1.7208333333333, 0.25, 0.16666666666667
82761, 1.7416666666667, 0.225, 0.16666666666667
82762, 1.7416666666667, 0.2, 0.14583333333333
82763, 1.7208333333333, 0.2, 0.16666666666667
82764, 1.7416666666667, 0.175, 0.16666666666667
82765, 1.7833333333333, 1.325, 0.16666666666667
82766, 1.7833333333333, 1.3, 0.14583333333333
82767, 1.7625, 1.3, 0.16666666666667
82768, 1.7833333333333, 1.275, 0.16666666666667
82769, 1.7833333333333, 1.25, 0.14583333333333
82770, 1.7625, 1.25, 0.16666666666667
82771, 1.7833333333333, 1.225, 0.16666666666667
82772, 1.7833333333333, 1.2, 0.14583333333333
82773, 1.7625, 1.2, 0.16666666666667
82774, 1.7833333333333, 1.175, 0.16666666666667
82775, 1.7833333333333, 1.15, 0.14583333333333
82776, 1.7625, 1.15, 0.16666666666667
82777, 1.7833333333333, 1.125, 0.16666666666667
82778, 1.7833333333333, 1.1, 0.14583333333333
82779, 1.7625, 1.1, 0.16666666666667
82780, 1.7833333333333, 1.075, 0.16666666666667
82781, 1.7833333333333, 1.05, 0.14583333333333
82782, 1.7625, 1.05, 0.16666666666667
82783, 1.7833333333333, 1.025, 0.16666666666667
82784, 1.7833333333333, 1, 0.14583333333333
82785, 1.7625, 1, 0.16666666666667
82786, 1.7833333333333, 0.975, 0.16666666666667
82787, 1.7833333333333, 0.95, 0.14583333333333
82788, 1.7625, 0.95, 0.16666666666667
82789, 1.7833333333333, 0.925, 0.16666666666667
82790, 1.7833333333333, 0.9, 0.14583333333333
82791, 1.7625, 0.9, 0.16666666666667
82792, 1.7833333333333, 0.875, 0.16666666666667
82793, 1.7833333333333, 0.85, 0.14583333333333
82794, 1.7625, 0.85, 0.16666666666667
82795, 1.7833333333333, 0.825, 0.16666666666667
82796, 1.7833333333333, 0.8, 0.14583333333333
82797, 1.7625, 0.8, 0.16666666666667
82798, 1.7833333333333, 0.775, 0.16666666666667
82799, 1.7833333333333, 0.75, 0.14583333333333
82800, 1.7625, 0.75, 0.16666666666667
82801, 1.7833333333333, 0.725, 0.16666666666667
82802, 1.7833333333333, 0.7, 0.14583333333333
82803, 1.7625, 0.7, 0.16666666666667
82804, 1.7833333333333, 0.675, 0.16666666666667
82805, 1.7833333333333, 0.65, 0.14583333333333
82806, 1.7625, 0.65, 0.16666666666667
82807, 1.7833333333333, 0.625, 0.16666666666667
82808, 1.7833333333333, 0.6, 0.14583333333333
82809, 1.7625, 0.6, 0.16666666666667
82810, 1.7833333333333, 0.575, 0.16666666666667
82811, 1.7833333333333, 0.55, 0.14583333333333
82812, 1.7625, 0.55, 0.16666666666667
82813, 1.7833333333333, 0.525, 0.16666666666667
82814, 1.7833333333333, 0.5, 0.14583333333333
82815, 1.7625, 0.5, 0.16666666666667
82816, 1.7833333333333, 0.475, 0.16666666666667
82817, 1.7833333333333, 0.45, 0.14583333333333
82818, 1.7625, 0.45, 0.16666666666667
82819, 1.7833333333333, 0.425, 0.16666666666667
82820, 1.7833333333333, 0.4, 0.14583333333333
82821, 1.7625, 0.4, 0.16666666666667
82822, 1.7833333333333, 0.375, 0.16666666666667
82823, 1.7833333333333, 0.35, 0.14583333333333
82824, 1.7625, 0.35, 0.16666666666667
82825, 1.7833333333333, 0.325, 0.16666666666667
82826, 1.7833333333333, 0.3, 0.14583333333333
82827, 1.7625, 0.3, 0.16666666666667
82828, 1.7833333333333, 0.275, 0.16666666666667
82829, 1.7833333333333, 0.25, 0.14583333333333
82830, 1.7625, 0.25, 0.16666666666667
82831, 1.7833333333333, 0.225, 0.16666666666667
82832, 1.7833333333333, 0.2, 0.14583333333333
82833, 1.7625, 0.2, 0.16666666666667
82834, 1.7833333333333, 0.175, 0.16666666666667
82835, 1.825, 1.325, 0.16666666666667
82836, 1.825, 1.3, 0.14583333333333
82837, 1.8041666666667, 1.3, 0.16666666666667
82838, 1.825, 1.275, 0.16666666666667
82839, 1.825, 1.25, 0.14583333333333
82840, 1.8041666666667, 1.25, 0.16666666666667
82841, 1.825, 1.225, 0.16666666666667
82842, 1.825, 1.2, 0.14583333333333
82843, 1.8041666666667, 1.2, 0.16666666666667
82844, 1.825, 1.175, 0.16666666666667
82845, 1.825, 1.15, 0.14583333333333
82846, 1.8041666666667, 1.15, 0.16666666666667
82847, 1.825, 1.125, 0.16666666666667
82848, 1.825, 1.1, 0.14583333333333
82849, 1.8041666666667, 1.1, 0.16666666666667
82850, 1.825, 1.075, 0.16666666666667
82851, 1.825, 1.05, 0.14583333333333
82852, 1.8041666666667, 1.05, 0.16666666666667
82853, 1.825, 1.025, 0.16666666666667
82854, 1.825, 1, 0.14583333333333
82855, 1.8041666666667, 1, 0.16666666666667
82856, 1.825, 0.975, 0.16666666666667
82857, 1.825, 0.95, 0.14583333333333
82858, 1.8041666666667, 0.95, 0.16666666666667
82859, 1.825, 0.925, 0.16666666666667
82860, 1.825, 0.9, 0.14583333333333
82861, 1.8041666666667, 0.9, 0.16666666666667
82862, 1.825, 0.875, 0.16666666666667
82863, 1.825, 0.85, 0.14583333333333
82864, 1.8041666666667, 0.85, 0.16666666666667
82865, 1.825, 0.825, 0.16666666666667
82866, 1.825, 0.8, 0.14583333333333
82867, 1.8041666666667, 0.8, 0.16666666666667
82868, 1.825, 0.775, 0.16666666666667
82869, 1.825, 0.75, 0.14583333333333
82870, 1.8041666666667, 0.75, 0.16666666666667
82871, 1.825, 0.725, 0.16666666666667
82872, 1.825, 0.7, 0.14583333333333
82873, 1.8041666666667, 0.7, 0.16666666666667
82874, 1.825, 0.675, 0.16666666666667
82875, 1.825, 0.65, 0.14583333333333
82876, 1.8041666666667, 0.65, 0.16666666666667
82877, 1.825, 0.625, 0.16666666666667
82878, 1.825, 0.6, 0.14583333333333
82879, 1.8041666666667, 0.6, 0.16666666666667
82880, 1.825, 0.575, 0.16666666666667
82881, 1.825, 0.55, 0.14583333333333
82882, 1.8041666666667, 0.55, 0.16666666666667
82883, 1.825, 0.525, 0.16666666666667
82884, 1.825, 0.5, 0.14583333333333
82885, 1.8041666666667, 0.5, 0.16666666666667
82886, 1.825, 0.475, 0.16666666666667
82887, 1.825, 0.45, 0.14583333333333
82888, 1.8041666666667, 0.45, 0.16666666666667
82889, 1.825, 0.425, 0.16666666666667
82890, 1.825, 0.4, 0.14583333333333
82891, 1.8041666666667, 0.4, 0.16666666666667
82892, 1.825, 0.375, 0.16666666666667
82893, 1.825, 0.35, 0.14583333333333
82894, 1.8041666666667, 0.35, 0.16666666666667
82895, 1.825, 0.325, 0.16666666666667
82896, 1.825, 0.3, 0.14583333333333
82897, 1.8041666666667, 0.3, 0.16666666666667
82898, 1.825, 0.275, 0.16666666666667
82899, 1.825, 0.25, 0.14583333333333
82900, 1.8041666666667, 0.25, 0.16666666666667
82901, 1.825, 0.225, 0.16666666666667
82902, 1.825, 0.2, 0.14583333333333
82903, 1.8041666666667, 0.2, 0.16666666666667
82904, 1.825, 0.175, 0.16666666666667
82905, 1.8666666666667, 1.325, 0.16666666666667
82906, 1.8666666666667, 1.3, 0.14583333333333
82907, 1.8458333333333, 1.3, 0.16666666666667
82908, 1.8666666666667, 1.275, 0.16666666666667
82909, 1.8666666666667, 1.25, 0.14583333333333
82910, 1.8458333333333, 1.25, 0.16666666666667
82911, 1.8666666666667, 1.225, 0.16666666666667
82912, 1.8666666666667, 1.2, 0.14583333333333
82913, 1.8458333333333, 1.2, 0.16666666666667
82914, 1.8666666666667, 1.175, 0.16666666666667
82915, 1.8666666666667, 1.15, 0.14583333333333
82916, 1.8458333333333, 1.15, 0.16666666666667
82917, 1.8666666666667, 1.125, 0.16666666666667
82918, 1.8666666666667, 1.1, 0.14583333333333
82919, 1.8458333333333, 1.1, 0.16666666666667
82920, 1.8666666666667, 1.075, 0.16666666666667
82921, 1.8666666666667, 1.05, 0.14583333333333
82922, 1.8458333333333, 1.05, 0.16666666666667
82923, 1.8666666666667, 1.025, 0.16666666666667
82924, 1.8666666666667, 1, 0.14583333333333
82925, 1.8458333333333, 1, 0.16666666666667
82926, 1.8666666666667, 0.975, 0.16666666666667
82927, 1.8666666666667, 0.95, 0.14583333333333
82928, 1.8458333333333, 0.95, 0.16666666666667
82929, 1.8666666666667, 0.925, 0.16666666666667
82930, 1.8666666666667, 0.9, 0.14583333333333
82931, 1.8458333333333, 0.9, 0.16666666666667
82932, 1.8666666666667, 0.875, 0.16666666666667
82933, 1.8666666666667, 0.85, 0.14583333333333
82934, 1.8458333333333, 0.85, 0.16666666666667
82935, 1.8666666666667, 0.825, 0.16666666666667
82936, 1.8666666666667, 0.8, 0.14583333333333
82937, 1.8458333333333, 0.8, 0.16666666666667
82938, 1.8666666666667, 0.775, 0.16666666666667
82939, 1.8666666666667, 0.75, 0.14583333333333
82940, 1.8458333333333, 0.75, 0.16666666666667
82941, 1.8666666666667, 0.725, 0.16666666666667
82942, 1.8666666666667, 0.7, 0.14583333333333
82943, 1.8458333333333, 0.7, 0.16666666666667
82944, 1.8666666666667, 0.675, 0.16666666666667
82945, 1.8666666666667, 0.65, 0.14583333333333
82946, 1.8458333333333, 0.65, 0.16666666666667
82947, 1.8666666666667, 0.625, 0.16666666666667
82948, 1.8666666666667, 0.6, 0.14583333333333
82949, 1.8458333333333, 0.6, 0.16666666666667
82950, 1.8666666666667, 0.575, 0.16666666666667
82951, 1.8666666666667, 0.55, 0.14583333333333
82952, 1.8458333333333, 0.55, 0.16666666666667
82953, 1.8666666666667, 0.525, 0.16666666666667
82954, 1.8666666666667, 0.5, 0.14583333333333
82955, 1.8458333333333, 0.5, 0.16666666666667
82956, 1.8666666666667, 0.475, 0.16666666666667
82957, 1.8666666666667, 0.45, 0.14583333333333
82958, 1.8458333333333, 0.45, 0.16666666666667
82959, 1.8666666666667, 0.425, 0.16666666666667
82960, 1.8666666666667, 0.4, 0.14583333333333
82961, 1.8458333333333, 0.4, 0.16666666666667
82962, 1.8666666666667, 0.375, 0.16666666666667
82963, 1.8666666666667, 0.35, 0.14583333333333
82964, 1.8458333333333, 0.35, 0.16666666666667
82965, 1.8666666666667, 0.325, 0.16666666666667
82966, 1.8666666666667, 0.3, 0.14583333333333
82967, 1.8458333333333, 0.3, 0.16666666666667
82968, 1.8666666666667, 0.275, 0.16666666666667
82969, 1.8666666666667, 0.25, 0.14583333333333
82970, 1.8458333333333, 0.25, 0.16666666666667
82971, 1.8666666666667, 0.225, 0.16666666666667
82972, 1.8666666666667, 0.2, 0.14583333333333
82973, 1.8458333333333, 0.2, 0.16666666666667
82974, 1.8666666666667, 0.175, 0.16666666666667
82975, 1.9083333333333, 1.325, 0.16666666666667
82976, 1.9083333333333, 1.3, 0.14583333333333
82977, 1.8875, 1.3, 0.16666666666667
82978, 1.9083333333333, 1.275, 0.16666666666667
82979, 1.9083333333333, 1.25, 0.14583333333333
82980, 1.8875, 1.25, 0.16666666666667
82981, 1.9083333333333, 1.225, 0.16666666666667
82982, 1.9083333333333, 1.2, 0.14583333333333
82983, 1.8875, 1.2, 0.16666666666667
82984, 1.9083333333333, 1.175, 0.16666666666667
82985, 1.9083333333333, 1.15, 0.14583333333333
82986, 1.8875, 1.15, 0.16666666666667
82987, 1.9083333333333, 1.125, 0.16666666666667
82988, 1.9083333333333, 1.1, 0.14583333333333
82989, 1.8875, 1.1, 0.16666666666667
82990, 1.9083333333333, 1.075, 0.16666666666667
82991, 1.9083333333333, 1.05, 0.14583333333333
82992, 1.8875, 1.05, 0.16666666666667
82993, 1.9083333333333, 1.025, 0.16666666666667
82994, 1.9083333333333, 1, 0.14583333333333
82995, 1.8875, 1, 0.16666666666667
82996, 1.9083333333333, 0.975, 0.16666666666667
82997, 1.9083333333333, 0.95, 0.14583333333333
82998, 1.8875, 0.95, 0.16666666666667
82999, 1.9083333333333, 0.925, 0.16666666666667
83000, 1.9083333333333, 0.9, 0.14583333333333
83001, 1.8875, 0.9, 0.16666666666667
83002, 1.9083333333333, 0.875, 0.16666666666667
83003, 1.9083333333333, 0.85, 0.14583333333333
83004, 1.8875, 0.85, 0.16666666666667
83005, 1.9083333333333, 0.825, 0.16666666666667
83006, 1.9083333333333, 0.8, 0.14583333333333
83007, 1.8875, 0.8, 0.16666666666667
83008, 1.9083333333333, 0.775, 0.16666666666667
83009, 1.9083333333333, 0.75, 0.14583333333333
83010, 1.8875, 0.75, 0.16666666666667
83011, 1.9083333333333, 0.725, 0.16666666666667
83012, 1.9083333333333, 0.7, 0.14583333333333
83013, 1.8875, 0.7, 0.16666666666667
83014, 1.9083333333333, 0.675, 0.16666666666667
83015, 1.9083333333333, 0.65, 0.14583333333333
83016, 1.8875, 0.65, 0.16666666666667
83017, 1.9083333333333, 0.625, 0.16666666666667
83018, 1.9083333333333, 0.6, 0.14583333333333
83019, 1.8875, 0.6, 0.16666666666667
83020, 1.9083333333333, 0.575, 0.16666666666667
83021, 1.9083333333333, 0.55, 0.14583333333333
83022, 1.8875, 0.55, 0.16666666666667
83023, 1.9083333333333, 0.525, 0.16666666666667
83024, 1.9083333333333, 0.5, 0.14583333333333
83025, 1.8875, 0.5, 0.16666666666667
83026, 1.9083333333333, 0.475, 0.16666666666667
83027, 1.9083333333333, 0.45, 0.14583333333333
83028, 1.8875, 0.45, 0.16666666666667
83029, 1.9083333333333, 0.425, 0.16666666666667
83030, 1.9083333333333, 0.4, 0.14583333333333
83031, 1.8875, 0.4, 0.16666666666667
83032, 1.9083333333333, 0.375, 0.16666666666667
83033, 1.9083333333333, 0.35, 0.14583333333333
83034, 1.8875, 0.35, 0.16666666666667
83035, 1.9083333333333, 0.325, 0.16666666666667
83036, 1.9083333333333, 0.3, 0.14583333333333
83037, 1.8875, 0.3, 0.16666666666667
83038, 1.9083333333333, 0.275, 0.16666666666667
83039, 1.9083333333333, 0.25, 0.14583333333333
83040, 1.8875, 0.25, 0.16666666666667
83041, 1.9083333333333, 0.225, 0.16666666666667
83042, 1.9083333333333, 0.2, 0.14583333333333
83043, 1.8875, 0.2, 0.16666666666667
83044, 1.9083333333333, 0.175, 0.16666666666667
83045, 1.95, 1.325, 0.16666666666667
83046, 1.95, 1.3, 0.14583333333333
83047, 1.9291666666667, 1.3, 0.16666666666667
83048, 1.95, 1.275, 0.16666666666667
83049, 1.95, 1.25, 0.14583333333333
83050, 1.9291666666667, 1.25, 0.16666666666667
83051, 1.95, 1.225, 0.16666666666667
83052, 1.95, 1.2, 0.14583333333333
83053, 1.9291666666667, 1.2, 0.16666666666667
83054, 1.95, 1.175, 0.16666666666667
83055, 1.95, 1.15, 0.14583333333333
83056, 1.9291666666667, 1.15, 0.16666666666667
83057, 1.95, 1.125, 0.16666666666667
83058, 1.95, 1.1, 0.14583333333333
83059, 1.9291666666667, 1.1, 0.16666666666667
83060, 1.95, 1.075, 0.16666666666667
83061, 1.95, 1.05, 0.14583333333333
83062, 1.9291666666667, 1.05, 0.16666666666667
83063, 1.95, 1.025, 0.16666666666667
83064, 1.95, 1, 0.14583333333333
83065, 1.9291666666667, 1, 0.16666666666667
83066, 1.95, 0.975, 0.16666666666667
83067, 1.95, 0.95, 0.14583333333333
83068, 1.9291666666667, 0.95, 0.16666666666667
83069, 1.95, 0.925, 0.16666666666667
83070, 1.95, 0.9, 0.14583333333333
83071, 1.9291666666667, 0.9, 0.16666666666667
83072, 1.95, 0.875, 0.16666666666667
83073, 1.95, 0.85, 0.14583333333333
83074, 1.9291666666667, 0.85, 0.16666666666667
83075, 1.95, 0.825, 0.16666666666667
83076, 1.95, 0.8, 0.14583333333333
83077, 1.9291666666667, 0.8, 0.16666666666667
83078, 1.95, 0.775, 0.16666666666667
83079, 1.95, 0.75, 0.14583333333333
83080, 1.9291666666667, 0.75, 0.16666666666667
83081, 1.95, 0.725, 0.16666666666667
83082, 1.95, 0.7, 0.14583333333333
83083, 1.9291666666667, 0.7, 0.16666666666667
83084, 1.95, 0.675, 0.16666666666667
83085, 1.95, 0.65, 0.14583333333333
83086, 1.9291666666667, 0.65, 0.16666666666667
83087, 1.95, 0.625, 0.16666666666667
83088, 1.95, 0.6, 0.14583333333333
83089, 1.9291666666667, 0.6, 0.16666666666667
83090, 1.95, 0.575, 0.16666666666667
83091, 1.95, 0.55, 0.14583333333333
83092, 1.9291666666667, 0.55, 0.16666666666667
83093, 1.95, 0.525, 0.16666666666667
83094, 1.95, 0.5, 0.14583333333333
83095, 1.9291666666667, 0.5, 0.16666666666667
83096, 1.95, 0.475, 0.16666666666667
83097, 1.95, 0.45, 0.14583333333333
83098, 1.9291666666667, 0.45, 0.16666666666667
83099, 1.95, 0.425, 0.16666666666667
83100, 1.95, 0.4, 0.14583333333333
83101, 1.9291666666667, 0.4, 0.16666666666667
83102, 1.95, 0.375, 0.16666666666667
83103, 1.95, 0.35, 0.14583333333333
83104, 1.9291666666667, 0.35, 0.16666666666667
83105, 1.95, 0.325, 0.16666666666667
83106, 1.95, 0.3, 0.14583333333333
83107, 1.9291666666667, 0.3, 0.16666666666667
83108, 1.95, 0.275, 0.16666666666667
83109, 1.95, 0.25, 0.14583333333333
83110, 1.9291666666667, 0.25, 0.16666666666667
83111, 1.95, 0.225, 0.16666666666667
83112, 1.95, 0.2, 0.14583333333333
83113, 1.9291666666667, 0.2, 0.16666666666667
83114, 1.95, 0.175, 0.16666666666667
83115, 1.9916666666667, 1.325, 0.16666666666667
83116, 1.9916666666667, 1.3, 0.14583333333333
83117, 1.9708333333333, 1.3, 0.16666666666667
83118, 1.9916666666667, 1.275, 0.16666666666667
83119, 1.9916666666667, 1.25, 0.14583333333333
83120, 1.9708333333333, 1.25, 0.16666666666667
83121, 1.9916666666667, 1.225, 0.16666666666667
83122, 1.9916666666667, 1.2, 0.14583333333333
83123, 1.9708333333333, 1.2, 0.16666666666667
83124, 1.9916666666667, 1.175, 0.16666666666667
83125, 1.9916666666667, 1.15, 0.14583333333333
83126, 1.9708333333333, 1.15, 0.16666666666667
83127, 1.9916666666667, 1.125, 0.16666666666667
83128, 1.9916666666667, 1.1, 0.14583333333333
83129, 1.9708333333333, 1.1, 0.16666666666667
83130, 1.9916666666667, 1.075, 0.16666666666667
83131, 1.9916666666667, 1.05, 0.14583333333333
83132, 1.9708333333333, 1.05, 0.16666666666667
83133, 1.9916666666667, 1.025, 0.16666666666667
83134, 1.9916666666667, 1, 0.14583333333333
83135, 1.9708333333333, 1, 0.16666666666667
83136, 1.9916666666667, 0.975, 0.16666666666667
83137, 1.9916666666667, 0.95, 0.14583333333333
83138, 1.9708333333333, 0.95, 0.16666666666667
83139, 1.9916666666667, 0.925, 0.16666666666667
83140, 1.9916666666667, 0.9, 0.14583333333333
83141, 1.9708333333333, 0.9, 0.16666666666667
83142, 1.9916666666667, 0.875, 0.16666666666667
83143, 1.9916666666667, 0.85, 0.14583333333333
83144, 1.9708333333333, 0.85, 0.16666666666667
83145, 1.9916666666667, 0.825, 0.16666666666667
83146, 1.9916666666667, 0.8, 0.14583333333333
83147, 1.9708333333333, 0.8, 0.16666666666667
83148, 1.9916666666667, 0.775, 0.16666666666667
83149, 1.9916666666667, 0.75, 0.14583333333333
83150, 1.9708333333333, 0.75, 0.16666666666667
83151, 1.9916666666667, 0.725, 0.16666666666667
83152, 1.9916666666667, 0.7, 0.14583333333333
83153, 1.9708333333333, 0.7, 0.16666666666667
83154, 1.9916666666667, 0.675, 0.16666666666667
83155, 1.9916666666667, 0.65, 0.14583333333333
83156, 1.9708333333333, 0.65, 0.16666666666667
83157, 1.9916666666667, 0.625, 0.16666666666667
83158, 1.9916666666667, 0.6, 0.14583333333333
83159, 1.9708333333333, 0.6, 0.16666666666667
83160, 1.9916666666667, 0.575, 0.16666666666667
83161, 1.9916666666667, 0.55, 0.14583333333333
83162, 1.9708333333333, 0.55, 0.16666666666667
83163, 1.9916666666667, 0.525, 0.16666666666667
83164, 1.9916666666667, 0.5, 0.14583333333333
83165, 1.9708333333333, 0.5, 0.16666666666667
83166, 1.9916666666667, 0.475, 0.16666666666667
83167, 1.9916666666667, 0.45, 0.14583333333333
83168, 1.9708333333333, 0.45, 0.16666666666667
83169, 1.9916666666667, 0.425, 0.16666666666667
83170, 1.9916666666667, 0.4, 0.14583333333333
83171, 1.9708333333333, 0.4, 0.16666666666667
83172, 1.9916666666667, 0.375, 0.16666666666667
83173, 1.9916666666667, 0.35, 0.14583333333333
83174, 1.9708333333333, 0.35, 0.16666666666667
83175, 1.9916666666667, 0.325, 0.16666666666667
83176, 1.9916666666667, 0.3, 0.14583333333333
83177, 1.9708333333333, 0.3, 0.16666666666667
83178, 1.9916666666667, 0.275, 0.16666666666667
83179, 1.9916666666667, 0.25, 0.14583333333333
83180, 1.9708333333333, 0.25, 0.16666666666667
83181, 1.9916666666667, 0.225, 0.16666666666667
83182, 1.9916666666667, 0.2, 0.14583333333333
83183, 1.9708333333333, 0.2, 0.16666666666667
83184, 1.9916666666667, 0.175, 0.16666666666667
83185, 2.0333333333333, 1.325, 0.16666666666667
83186, 2.0333333333333, 1.3, 0.14583333333333
83187, 2.0125, 1.3, 0.16666666666667
83188, 2.0333333333333, 1.275, 0.16666666666667
83189, 2.0333333333333, 1.25, 0.14583333333333
83190, 2.0125, 1.25, 0.16666666666667
83191, 2.0333333333333, 1.225, 0.16666666666667
83192, 2.0333333333333, 1.2, 0.14583333333333
83193, 2.0125, 1.2, 0.16666666666667
83194, 2.0333333333333, 1.175, 0.16666666666667
83195, 2.0333333333333, 1.15, 0.14583333333333
83196, 2.0125, 1.15, 0.16666666666667
83197, 2.0333333333333, 1.125, 0.16666666666667
83198, 2.0333333333333, 1.1, 0.14583333333333
83199, 2.0125, 1.1, 0.16666666666667
83200, 2.0333333333333, 1.075, 0.16666666666667
83201, 2.0333333333333, 1.05, 0.14583333333333
83202, 2.0125, 1.05, 0.16666666666667
83203, 2.0333333333333, 1.025, 0.16666666666667
83204, 2.0333333333333, 1, 0.14583333333333
83205, 2.0125, 1, 0.16666666666667
83206, 2.0333333333333, 0.975, 0.16666666666667
83207, 2.0333333333333, 0.95, 0.14583333333333
83208, 2.0125, 0.95, 0.16666666666667
83209, 2.0333333333333, 0.925, 0.16666666666667
83210, 2.0333333333333, 0.9, 0.14583333333333
83211, 2.0125, 0.9, 0.16666666666667
83212, 2.0333333333333, 0.875, 0.16666666666667
83213, 2.0333333333333, 0.85, 0.14583333333333
83214, 2.0125, 0.85, 0.16666666666667
83215, 2.0333333333333, 0.825, 0.16666666666667
83216, 2.0333333333333, 0.8, 0.14583333333333
83217, 2.0125, 0.8, 0.16666666666667
83218, 2.0333333333333, 0.775, 0.16666666666667
83219, 2.0333333333333, 0.75, 0.14583333333333
83220, 2.0125, 0.75, 0.16666666666667
83221, 2.0333333333333, 0.725, 0.16666666666667
83222, 2.0333333333333, 0.7, 0.14583333333333
83223, 2.0125, 0.7, 0.16666666666667
83224, 2.0333333333333, 0.675, 0.16666666666667
83225, 2.0333333333333, 0.65, 0.14583333333333
83226, 2.0125, 0.65, 0.16666666666667
83227, 2.0333333333333, 0.625, 0.16666666666667
83228, 2.0333333333333, 0.6, 0.14583333333333
83229, 2.0125, 0.6, 0.16666666666667
83230, 2.0333333333333, 0.575, 0.16666666666667
83231, 2.0333333333333, 0.55, 0.14583333333333
83232, 2.0125, 0.55, 0.16666666666667
83233, 2.0333333333333, 0.525, 0.16666666666667
83234, 2.0333333333333, 0.5, 0.14583333333333
83235, 2.0125, 0.5, 0.16666666666667
83236, 2.0333333333333, 0.475, 0.16666666666667
83237, 2.0333333333333, 0.45, 0.14583333333333
83238, 2.0125, 0.45, 0.16666666666667
83239, 2.0333333333333, 0.425, 0.16666666666667
83240, 2.0333333333333, 0.4, 0.14583333333333
83241, 2.0125, 0.4, 0.16666666666667
83242, 2.0333333333333, 0.375, 0.16666666666667
83243, 2.0333333333333, 0.35, 0.14583333333333
83244, 2.0125, 0.35, 0.16666666666667
83245, 2.0333333333333, 0.325, 0.16666666666667
83246, 2.0333333333333, 0.3, 0.14583333333333
83247, 2.0125, 0.3, 0.16666666666667
83248, 2.0333333333333, 0.275, 0.16666666666667
83249, 2.0333333333333, 0.25, 0.14583333333333
83250, 2.0125, 0.25, 0.16666666666667
83251, 2.0333333333333, 0.225, 0.16666666666667
83252, 2.0333333333333, 0.2, 0.14583333333333
83253, 2.0125, 0.2, 0.16666666666667
83254, 2.0333333333333, 0.175, 0.16666666666667
83255, 2.075, 1.325, 0.16666666666667
83256, 2.075, 1.3, 0.14583333333333
83257, 2.0541666666667, 1.3, 0.16666666666667
83258, 2.075, 1.275, 0.16666666666667
83259, 2.075, 1.25, 0.14583333333333
83260, 2.0541666666667, 1.25, 0.16666666666667
83261, 2.075, 1.225, 0.16666666666667
83262, 2.075, 1.2, 0.14583333333333
83263, 2.0541666666667, 1.2, 0.16666666666667
83264, 2.075, 1.175, 0.16666666666667
83265, 2.075, 1.15, 0.14583333333333
83266, 2.0541666666667, 1.15, 0.16666666666667
83267, 2.075, 1.125, 0.16666666666667
83268, 2.075, 1.1, 0.14583333333333
83269, 2.0541666666667, 1.1, 0.16666666666667
83270, 2.075, 1.075, 0.16666666666667
83271, 2.075, 1.05, 0.14583333333333
83272, 2.0541666666667, 1.05, 0.16666666666667
83273, 2.075, 1.025, 0.16666666666667
83274, 2.075, 1, 0.14583333333333
83275, 2.0541666666667, 1, 0.16666666666667
83276, 2.075, 0.975, 0.16666666666667
83277, 2.075, 0.95, 0.14583333333333
83278, 2.0541666666667, 0.95, 0.16666666666667
83279, 2.075, 0.925, 0.16666666666667
83280, 2.075, 0.9, 0.14583333333333
83281, 2.0541666666667, 0.9, 0.16666666666667
83282, 2.075, 0.875, 0.16666666666667
83283, 2.075, 0.85, 0.14583333333333
83284, 2.0541666666667, 0.85, 0.16666666666667
83285, 2.075, 0.825, 0.16666666666667
83286, 2.075, 0.8, 0.14583333333333
83287, 2.0541666666667, 0.8, 0.16666666666667
83288, 2.075, 0.775, 0.16666666666667
83289, 2.075, 0.75, 0.14583333333333
83290, 2.0541666666667, 0.75, 0.16666666666667
83291, 2.075, 0.725, 0.16666666666667
83292, 2.075, 0.7, 0.14583333333333
83293, 2.0541666666667, 0.7, 0.16666666666667
83294, 2.075, 0.675, 0.16666666666667
83295, 2.075, 0.65, 0.14583333333333
83296, 2.0541666666667, 0.65, 0.16666666666667
83297, 2.075, 0.625, 0.16666666666667
83298, 2.075, 0.6, 0.14583333333333
83299, 2.0541666666667, 0.6, 0.16666666666667
83300, 2.075, 0.575, 0.16666666666667
83301, 2.075, 0.55, 0.14583333333333
83302, 2.0541666666667, 0.55, 0.16666666666667
83303, 2.075, 0.525, 0.16666666666667
83304, 2.075, 0.5, 0.14583333333333
83305, 2.0541666666667, 0.5, 0.16666666666667
83306, 2.075, 0.475, 0.16666666666667
83307, 2.075, 0.45, 0.14583333333333
83308, 2.0541666666667, 0.45, 0.16666666666667
83309, 2.075, 0.425, 0.16666666666667
83310, 2.075, 0.4, 0.14583333333333
83311, 2.0541666666667, 0.4, 0.16666666666667
83312, 2.075, 0.375, 0.16666666666667
83313, 2.075, 0.35, 0.14583333333333
83314, 2.0541666666667, 0.35, 0.16666666666667
83315, 2.075, 0.325, 0.16666666666667
83316, 2.075, 0.3, 0.14583333333333
83317, 2.0541666666667, 0.3, 0.16666666666667
83318, 2.075, 0.275, 0.16666666666667
83319, 2.075, 0.25, 0.14583333333333
83320, 2.0541666666667, 0.25, 0.16666666666667
83321, 2.075, 0.225, 0.16666666666667
83322, 2.075, 0.2, 0.14583333333333
83323, 2.0541666666667, 0.2, 0.16666666666667
83324, 2.075, 0.175, 0.16666666666667
83325, 2.1166666666667, 1.325, 0.16666666666667
83326, 2.1166666666667, 1.3, 0.14583333333333
83327, 2.0958333333333, 1.3, 0.16666666666667
83328, 2.1166666666667, 1.275, 0.16666666666667
83329, 2.1166666666667, 1.25, 0.14583333333333
83330, 2.0958333333333, 1.25, 0.16666666666667
83331, 2.1166666666667, 1.225, 0.16666666666667
83332, 2.1166666666667, 1.2, 0.14583333333333
83333, 2.0958333333333, 1.2, 0.16666666666667
83334, 2.1166666666667, 1.175, 0.16666666666667
83335, 2.1166666666667, 1.15, 0.14583333333333
83336, 2.0958333333333, 1.15, 0.16666666666667
83337, 2.1166666666667, 1.125, 0.16666666666667
83338, 2.1166666666667, 1.1, 0.14583333333333
83339, 2.0958333333333, 1.1, 0.16666666666667
83340, 2.1166666666667, 1.075, 0.16666666666667
83341, 2.1166666666667, 1.05, 0.14583333333333
83342, 2.0958333333333, 1.05, 0.16666666666667
83343, 2.1166666666667, 1.025, 0.16666666666667
83344, 2.1166666666667, 1, 0.14583333333333
83345, 2.0958333333333, 1, 0.16666666666667
83346, 2.1166666666667, 0.975, 0.16666666666667
83347, 2.1166666666667, 0.95, 0.14583333333333
83348, 2.0958333333333, 0.95, 0.16666666666667
83349, 2.1166666666667, 0.925, 0.16666666666667
83350, 2.1166666666667, 0.9, 0.14583333333333
83351, 2.0958333333333, 0.9, 0.16666666666667
83352, 2.1166666666667, 0.875, 0.16666666666667
83353, 2.1166666666667, 0.85, 0.14583333333333
83354, 2.0958333333333, 0.85, 0.16666666666667
83355, 2.1166666666667, 0.825, 0.16666666666667
83356, 2.1166666666667, 0.8, 0.14583333333333
83357, 2.0958333333333, 0.8, 0.16666666666667
83358, 2.1166666666667, 0.775, 0.16666666666667
83359, 2.1166666666667, 0.75, 0.14583333333333
83360, 2.0958333333333, 0.75, 0.16666666666667
83361, 2.1166666666667, 0.725, 0.16666666666667
83362, 2.1166666666667, 0.7, 0.14583333333333
83363, 2.0958333333333, 0.7, 0.16666666666667
83364, 2.1166666666667, 0.675, 0.16666666666667
83365, 2.1166666666667, 0.65, 0.14583333333333
83366, 2.0958333333333, 0.65, 0.16666666666667
83367, 2.1166666666667, 0.625, 0.16666666666667
83368, 2.1166666666667, 0.6, 0.14583333333333
83369, 2.0958333333333, 0.6, 0.16666666666667
83370, 2.1166666666667, 0.575, 0.16666666666667
83371, 2.1166666666667, 0.55, 0.14583333333333
83372, 2.0958333333333, 0.55, 0.16666666666667
83373, 2.1166666666667, 0.525, 0.16666666666667
83374, 2.1166666666667, 0.5, 0.14583333333333
83375, 2.0958333333333, 0.5, 0.16666666666667
83376, 2.1166666666667, 0.475, 0.16666666666667
83377, 2.1166666666667, 0.45, 0.14583333333333
83378, 2.0958333333333, 0.45, 0.16666666666667
83379, 2.1166666666667, 0.425, 0.16666666666667
83380, 2.1166666666667, 0.4, 0.14583333333333
83381, 2.0958333333333, 0.4, 0.16666666666667
83382, 2.1166666666667, 0.375, 0.16666666666667
83383, 2.1166666666667, 0.35, 0.14583333333333
83384, 2.0958333333333, 0.35, 0.16666666666667
83385, 2.1166666666667, 0.325, 0.16666666666667
83386, 2.1166666666667, 0.3, 0.14583333333333
83387, 2.0958333333333, 0.3, 0.16666666666667
83388, 2.1166666666667, 0.275, 0.16666666666667
83389, 2.1166666666667, 0.25, 0.14583333333333
83390, 2.0958333333333, 0.25, 0.16666666666667
83391, 2.1166666666667, 0.225, 0.16666666666667
83392, 2.1166666666667, 0.2, 0.14583333333333
83393, 2.0958333333333, 0.2, 0.16666666666667
83394, 2.1166666666667, 0.175, 0.16666666666667
83395, 2.1583333333333, 1.325, 0.16666666666667
83396, 2.1583333333333, 1.3, 0.14583333333333
83397, 2.1375, 1.3, 0.16666666666667
83398, 2.1583333333333, 1.275, 0.16666666666667
83399, 2.1583333333333, 1.25, 0.14583333333333
83400, 2.1375, 1.25, 0.16666666666667
83401, 2.1583333333333, 1.225, 0.16666666666667
83402, 2.1583333333333, 1.2, 0.14583333333333
83403, 2.1375, 1.2, 0.16666666666667
83404, 2.1583333333333, 1.175, 0.16666666666667
83405, 2.1583333333333, 1.15, 0.14583333333333
83406, 2.1375, 1.15, 0.16666666666667
83407, 2.1583333333333, 1.125, 0.16666666666667
83408, 2.1583333333333, 1.1, 0.14583333333333
83409, 2.1375, 1.1, 0.16666666666667
83410, 2.1583333333333, 1.075, 0.16666666666667
83411, 2.1583333333333, 1.05, 0.14583333333333
83412, 2.1375, 1.05, 0.16666666666667
83413, 2.1583333333333, 1.025, 0.16666666666667
83414, 2.1583333333333, 1, 0.14583333333333
83415, 2.1375, 1, 0.16666666666667
83416, 2.1583333333333, 0.975, 0.16666666666667
83417, 2.1583333333333, 0.95, 0.14583333333333
83418, 2.1375, 0.95, 0.16666666666667
83419, 2.1583333333333, 0.925, 0.16666666666667
83420, 2.1583333333333, 0.9, 0.14583333333333
83421, 2.1375, 0.9, 0.16666666666667
83422, 2.1583333333333, 0.875, 0.16666666666667
83423, 2.1583333333333, 0.85, 0.14583333333333
83424, 2.1375, 0.85, 0.16666666666667
83425, 2.1583333333333, 0.825, 0.16666666666667
83426, 2.1583333333333, 0.8, 0.14583333333333
83427, 2.1375, 0.8, 0.16666666666667
83428, 2.1583333333333, 0.775, 0.16666666666667
83429, 2.1583333333333, 0.75, 0.14583333333333
83430, 2.1375, 0.75, 0.16666666666667
83431, 2.1583333333333, 0.725, 0.16666666666667
83432, 2.1583333333333, 0.7, 0.14583333333333
83433, 2.1375, 0.7, 0.16666666666667
83434, 2.1583333333333, 0.675, 0.16666666666667
83435, 2.1583333333333, 0.65, 0.14583333333333
83436, 2.1375, 0.65, 0.16666666666667
83437, 2.1583333333333, 0.625, 0.16666666666667
83438, 2.1583333333333, 0.6, 0.14583333333333
83439, 2.1375, 0.6, 0.16666666666667
83440, 2.1583333333333, 0.575, 0.16666666666667
83441, 2.1583333333333, 0.55, 0.14583333333333
83442, 2.1375, 0.55, 0.16666666666667
83443, 2.1583333333333, 0.525, 0.16666666666667
83444, 2.1583333333333, 0.5, 0.14583333333333
83445, 2.1375, 0.5, 0.16666666666667
83446, 2.1583333333333, 0.475, 0.16666666666667
83447, 2.1583333333333, 0.45, 0.14583333333333
83448, 2.1375, 0.45, 0.16666666666667
83449, 2.1583333333333, 0.425, 0.16666666666667
83450, 2.1583333333333, 0.4, 0.14583333333333
83451, 2.1375, 0.4, 0.16666666666667
83452, 2.1583333333333, 0.375, 0.16666666666667
83453, 2.1583333333333, 0.35, 0.14583333333333
83454, 2.1375, 0.35, 0.16666666666667
83455, 2.1583333333333, 0.325, 0.16666666666667
83456, 2.1583333333333, 0.3, 0.14583333333333
83457, 2.1375, 0.3, 0.16666666666667
83458, 2.1583333333333, 0.275, 0.16666666666667
83459, 2.1583333333333, 0.25, 0.14583333333333
83460, 2.1375, 0.25, 0.16666666666667
83461, 2.1583333333333, 0.225, 0.16666666666667
83462, 2.1583333333333, 0.2, 0.14583333333333
83463, 2.1375, 0.2, 0.16666666666667
83464, 2.1583333333333, 0.175, 0.16666666666667
83465, 2.1791666666667, 1.3, 0.16666666666667
83466, 2.1791666666667, 1.25, 0.16666666666667
83467, 2.1791666666667, 1.2, 0.16666666666667
83468, 2.1791666666667, 1.15, 0.16666666666667
83469, 2.1791666666667, 1.1, 0.16666666666667
83470, 2.1791666666667, 1.05, 0.16666666666667
83471, 2.1791666666667, 1, 0.16666666666667
83472, 2.1791666666667, 0.95, 0.16666666666667
83473, 2.1791666666667, 0.9, 0.16666666666667
83474, 2.1791666666667, 0.85, 0.16666666666667
83475, 2.1791666666667, 0.8, 0.16666666666667
83476, 2.1791666666667, 0.75, 0.16666666666667
83477, 2.1791666666667, 0.7, 0.16666666666667
83478, 2.1791666666667, 0.65, 0.16666666666667
83479, 2.1791666666667, 0.6, 0.16666666666667
83480, 2.1791666666667, 0.55, 0.16666666666667
83481, 2.1791666666667, 0.5, 0.16666666666667
83482, 2.1791666666667, 0.45, 0.16666666666667
83483, 2.1791666666667, 0.4, 0.16666666666667
83484, 2.1791666666667, 0.35, 0.16666666666667
83485, 2.1791666666667, 0.3, 0.16666666666667
83486, 2.1791666666667, 0.25, 0.16666666666667
83487, 2.1791666666667, 0.2, 0.16666666666667
83488, 1.2416666666667, 1.325, 0.20833333333333
83489, 1.2416666666667, 1.3, 0.1875
83490, 1.2208333333333, 1.3, 0.20833333333333
83491, 1.2416666666667, 1.275, 0.20833333333333
83492, 1.2416666666667, 1.25, 0.1875
83493, 1.2208333333333, 1.25, 0.20833333333333
83494, 1.2416666666667, 1.225, 0.20833333333333
83495, 1.2416666666667, 1.2, 0.1875
83496, 1.2208333333333, 1.2, 0.20833333333333
83497, 1.2416666666667, 1.175, 0.20833333333333
83498, 1.2416666666667, 1.15, 0.1875
83499, 1.2208333333333, 1.15, 0.20833333333333
83500, 1.2416666666667, 1.125, 0.20833333333333
83501, 1.2416666666667, 1.1, 0.1875
83502, 1.2208333333333, 1.1, 0.20833333333333
83503, 1.2416666666667, 1.075, 0.20833333333333
83504, 1.2416666666667, 1.05, 0.1875
83505, 1.2208333333333, 1.05, 0.20833333333333
83506, 1.2416666666667, 1.025, 0.20833333333333
83507, 1.2416666666667, 1, 0.1875
83508, 1.2208333333333, 1, 0.20833333333333
83509, 1.2416666666667, 0.975, 0.20833333333333
83510, 1.2416666666667, 0.95, 0.1875
83511, 1.2208333333333, 0.95, 0.20833333333333
83512, 1.2416666666667, 0.925, 0.20833333333333
83513, 1.2416666666667, 0.9, 0.1875
83514, 1.2208333333333, 0.9, 0.20833333333333
83515, 1.2416666666667, 0.875, 0.20833333333333
83516, 1.2416666666667, 0.85, 0.1875
83517, 1.2208333333333, 0.85, 0.20833333333333
83518, 1.2416666666667, 0.825, 0.20833333333333
83519, 1.2416666666667, 0.8, 0.1875
83520, 1.2208333333333, 0.8, 0.20833333333333
83521, 1.2416666666667, 0.775, 0.20833333333333
83522, 1.2416666666667, 0.75, 0.1875
83523, 1.2208333333333, 0.75, 0.20833333333333
83524, 1.2416666666667, 0.725, 0.20833333333333
83525, 1.2416666666667, 0.7, 0.1875
83526, 1.2208333333333, 0.7, 0.20833333333333
83527, 1.2416666666667, 0.675, 0.20833333333333
83528, 1.2416666666667, 0.65, 0.1875
83529, 1.2208333333333, 0.65, 0.20833333333333
83530, 1.2416666666667, 0.625, 0.20833333333333
83531, 1.2416666666667, 0.6, 0.1875
83532, 1.2208333333333, 0.6, 0.20833333333333
83533, 1.2416666666667, 0.575, 0.20833333333333
83534, 1.2416666666667, 0.55, 0.1875
83535, 1.2208333333333, 0.55, 0.20833333333333
83536, 1.2416666666667, 0.525, 0.20833333333333
83537, 1.2416666666667, 0.5, 0.1875
83538, 1.2208333333333, 0.5, 0.20833333333333
83539, 1.2416666666667, 0.475, 0.20833333333333
83540, 1.2416666666667, 0.45, 0.1875
83541, 1.2208333333333, 0.45, 0.20833333333333
83542, 1.2416666666667, 0.425, 0.20833333333333
83543, 1.2416666666667, 0.4, 0.1875
83544, 1.2208333333333, 0.4, 0.20833333333333
83545, 1.2416666666667, 0.375, 0.20833333333333
83546, 1.2416666666667, 0.35, 0.1875
83547, 1.2208333333333, 0.35, 0.20833333333333
83548, 1.2416666666667, 0.325, 0.20833333333333
83549, 1.2416666666667, 0.3, 0.1875
83550, 1.2208333333333, 0.3, 0.20833333333333
83551, 1.2416666666667, 0.275, 0.20833333333333
83552, 1.2416666666667, 0.25, 0.1875
83553, 1.2208333333333, 0.25, 0.20833333333333
83554, 1.2416666666667, 0.225, 0.20833333333333
83555, 1.2416666666667, 0.2, 0.1875
83556, 1.2208333333333, 0.2, 0.20833333333333
83557, 1.2416666666667, 0.175, 0.20833333333333
83558, 1.2833333333333, 1.325, 0.20833333333333
83559, 1.2833333333333, 1.3, 0.1875
83560, 1.2625, 1.3, 0.20833333333333
83561, 1.2833333333333, 1.275, 0.20833333333333
83562, 1.2833333333333, 1.25, 0.1875
83563, 1.2625, 1.25, 0.20833333333333
83564, 1.2833333333333, 1.225, 0.20833333333333
83565, 1.2833333333333, 1.2, 0.1875
83566, 1.2625, 1.2, 0.20833333333333
83567, 1.2833333333333, 1.175, 0.20833333333333
83568, 1.2833333333333, 1.15, 0.1875
83569, 1.2625, 1.15, 0.20833333333333
83570, 1.2833333333333, 1.125, 0.20833333333333
83571, 1.2833333333333, 1.1, 0.1875
83572, 1.2625, 1.1, 0.20833333333333
83573, 1.2833333333333, 1.075, 0.20833333333333
83574, 1.2833333333333, 1.05, 0.1875
83575, 1.2625, 1.05, 0.20833333333333
83576, 1.2833333333333, 1.025, 0.20833333333333
83577, 1.2833333333333, 1, 0.1875
83578, 1.2625, 1, 0.20833333333333
83579, 1.2833333333333, 0.975, 0.20833333333333
83580, 1.2833333333333, 0.95, 0.1875
83581, 1.2625, 0.95, 0.20833333333333
83582, 1.2833333333333, 0.925, 0.20833333333333
83583, 1.2833333333333, 0.9, 0.1875
83584, 1.2625, 0.9, 0.20833333333333
83585, 1.2833333333333, 0.875, 0.20833333333333
83586, 1.2833333333333, 0.85, 0.1875
83587, 1.2625, 0.85, 0.20833333333333
83588, 1.2833333333333, 0.825, 0.20833333333333
83589, 1.2833333333333, 0.8, 0.1875
83590, 1.2625, 0.8, 0.20833333333333
83591, 1.2833333333333, 0.775, 0.20833333333333
83592, 1.2833333333333, 0.75, 0.1875
83593, 1.2625, 0.75, 0.20833333333333
83594, 1.2833333333333, 0.725, 0.20833333333333
83595, 1.2833333333333, 0.7, 0.1875
83596, 1.2625, 0.7, 0.20833333333333
83597, 1.2833333333333, 0.675, 0.20833333333333
83598, 1.2833333333333, 0.65, 0.1875
83599, 1.2625, 0.65, 0.20833333333333
83600, 1.2833333333333, 0.625, 0.20833333333333
83601, 1.2833333333333, 0.6, 0.1875
83602, 1.2625, 0.6, 0.20833333333333
83603, 1.2833333333333, 0.575, 0.20833333333333
83604, 1.2833333333333, 0.55, 0.1875
83605, 1.2625, 0.55, 0.20833333333333
83606, 1.2833333333333, 0.525, 0.20833333333333
83607, 1.2833333333333, 0.5, 0.1875
83608, 1.2625, 0.5, 0.20833333333333
83609, 1.2833333333333, 0.475, 0.20833333333333
83610, 1.2833333333333, 0.45, 0.1875
83611, 1.2625, 0.45, 0.20833333333333
83612, 1.2833333333333, 0.425, 0.20833333333333
83613, 1.2833333333333, 0.4, 0.1875
83614, 1.2625, 0.4, 0.20833333333333
83615, 1.2833333333333, 0.375, 0.20833333333333
83616, 1.2833333333333, 0.35, 0.1875
83617, 1.2625, 0.35, 0.20833333333333
83618, 1.2833333333333, 0.325, 0.20833333333333
83619, 1.2833333333333, 0.3, 0.1875
83620, 1.2625, 0.3, 0.20833333333333
83621, 1.2833333333333, 0.275, 0.20833333333333
83622, 1.2833333333333, 0.25, 0.1875
83623, 1.2625, 0.25, 0.20833333333333
83624, 1.2833333333333, 0.225, 0.20833333333333
83625, 1.2833333333333, 0.2, 0.1875
83626, 1.2625, 0.2, 0.20833333333333
83627, 1.2833333333333, 0.175, 0.20833333333333
83628, 1.325, 1.325, 0.20833333333333
83629, 1.325, 1.3, 0.1875
83630, 1.3041666666667, 1.3, 0.20833333333333
83631, 1.325, 1.275, 0.20833333333333
83632, 1.325, 1.25, 0.1875
83633, 1.3041666666667, 1.25, 0.20833333333333
83634, 1.325, 1.225, 0.20833333333333
83635, 1.325, 1.2, 0.1875
83636, 1.3041666666667, 1.2, 0.20833333333333
83637, 1.325, 1.175, 0.20833333333333
83638, 1.325, 1.15, 0.1875
83639, 1.3041666666667, 1.15, 0.20833333333333
83640, 1.325, 1.125, 0.20833333333333
83641, 1.325, 1.1, 0.1875
83642, 1.3041666666667, 1.1, 0.20833333333333
83643, 1.325, 1.075, 0.20833333333333
83644, 1.325, 1.05, 0.1875
83645, 1.3041666666667, 1.05, 0.20833333333333
83646, 1.325, 1.025, 0.20833333333333
83647, 1.325, 1, 0.1875
83648, 1.3041666666667, 1, 0.20833333333333
83649, 1.325, 0.975, 0.20833333333333
83650, 1.325, 0.95, 0.1875
83651, 1.3041666666667, 0.95, 0.20833333333333
83652, 1.325, 0.925, 0.20833333333333
83653, 1.325, 0.9, 0.1875
83654, 1.3041666666667, 0.9, 0.20833333333333
83655, 1.325, 0.875, 0.20833333333333
83656, 1.325, 0.85, 0.1875
83657, 1.3041666666667, 0.85, 0.20833333333333
83658, 1.325, 0.825, 0.20833333333333
83659, 1.325, 0.8, 0.1875
83660, 1.3041666666667, 0.8, 0.20833333333333
83661, 1.325, 0.775, 0.20833333333333
83662, 1.325, 0.75, 0.1875
83663, 1.3041666666667, 0.75, 0.20833333333333
83664, 1.325, 0.725, 0.20833333333333
83665, 1.325, 0.7, 0.1875
83666, 1.3041666666667, 0.7, 0.20833333333333
83667, 1.325, 0.675, 0.20833333333333
83668, 1.325, 0.65, 0.1875
83669, 1.3041666666667, 0.65, 0.20833333333333
83670, 1.325, 0.625, 0.20833333333333
83671, 1.325, 0.6, 0.1875
83672, 1.3041666666667, 0.6, 0.20833333333333
83673, 1.325, 0.575, 0.20833333333333
83674, 1.325, 0.55, 0.1875
83675, 1.3041666666667, 0.55, 0.20833333333333
83676, 1.325, 0.525, 0.20833333333333
83677, 1.325, 0.5, 0.1875
83678, 1.3041666666667, 0.5, 0.20833333333333
83679, 1.325, 0.475, 0.20833333333333
83680, 1.325, 0.45, 0.1875
83681, 1.3041666666667, 0.45, 0.20833333333333
83682, 1.325, 0.425, 0.20833333333333
83683, 1.325, 0.4, 0.1875
83684, 1.3041666666667, 0.4, 0.20833333333333
83685, 1.325, 0.375, 0.20833333333333
83686, 1.325, 0.35, 0.1875
83687, 1.3041666666667, 0.35, 0.20833333333333
83688, 1.325, 0.325, 0.20833333333333
83689, 1.325, 0.3, 0.1875
83690, 1.3041666666667, 0.3, 0.20833333333333
83691, 1.325, 0.275, 0.20833333333333
83692, 1.325, 0.25, 0.1875
83693, 1.3041666666667, 0.25, 0.20833333333333
83694, 1.325, 0.225, 0.20833333333333
83695, 1.325, 0.2, 0.1875
83696, 1.3041666666667, 0.2, 0.20833333333333
83697, 1.325, 0.175, 0.20833333333333
83698, 1.3666666666667, 1.325, 0.20833333333333
83699, 1.3666666666667, 1.3, 0.1875
83700, 1.3458333333333, 1.3, 0.20833333333333
83701, 1.3666666666667, 1.275, 0.20833333333333
83702, 1.3666666666667, 1.25, 0.1875
83703, 1.3458333333333, 1.25, 0.20833333333333
83704, 1.3666666666667, 1.225, 0.20833333333333
83705, 1.3666666666667, 1.2, 0.1875
83706, 1.3458333333333, 1.2, 0.20833333333333
83707, 1.3666666666667, 1.175, 0.20833333333333
83708, 1.3666666666667, 1.15, 0.1875
83709, 1.3458333333333, 1.15, 0.20833333333333
83710, 1.3666666666667, 1.125, 0.20833333333333
83711, 1.3666666666667, 1.1, 0.1875
83712, 1.3458333333333, 1.1, 0.20833333333333
83713, 1.3666666666667, 1.075, 0.20833333333333
83714, 1.3666666666667, 1.05, 0.1875
83715, 1.3458333333333, 1.05, 0.20833333333333
83716, 1.3666666666667, 1.025, 0.20833333333333
83717, 1.3666666666667, 1, 0.1875
83718, 1.3458333333333, 1, 0.20833333333333
83719, 1.3666666666667, 0.975, 0.20833333333333
83720, 1.3666666666667, 0.95, 0.1875
83721, 1.3458333333333, 0.95, 0.20833333333333
83722, 1.3666666666667, 0.925, 0.20833333333333
83723, 1.3666666666667, 0.9, 0.1875
83724, 1.3458333333333, 0.9, 0.20833333333333
83725, 1.3666666666667, 0.875, 0.20833333333333
83726, 1.3666666666667, 0.85, 0.1875
83727, 1.3458333333333, 0.85, 0.20833333333333
83728, 1.3666666666667, 0.825, 0.20833333333333
83729, 1.3666666666667, 0.8, 0.1875
83730, 1.3458333333333, 0.8, 0.20833333333333
83731, 1.3666666666667, 0.775, 0.20833333333333
83732, 1.3666666666667, 0.75, 0.1875
83733, 1.3458333333333, 0.75, 0.20833333333333
83734, 1.3666666666667, 0.725, 0.20833333333333
83735, 1.3666666666667, 0.7, 0.1875
83736, 1.3458333333333, 0.7, 0.20833333333333
83737, 1.3666666666667, 0.675, 0.20833333333333
83738, 1.3666666666667, 0.65, 0.1875
83739, 1.3458333333333, 0.65, 0.20833333333333
83740, 1.3666666666667, 0.625, 0.20833333333333
83741, 1.3666666666667, 0.6, 0.1875
83742, 1.3458333333333, 0.6, 0.20833333333333
83743, 1.3666666666667, 0.575, 0.20833333333333
83744, 1.3666666666667, 0.55, 0.1875
83745, 1.3458333333333, 0.55, 0.20833333333333
83746, 1.3666666666667, 0.525, 0.20833333333333
83747, 1.3666666666667, 0.5, 0.1875
83748, 1.3458333333333, 0.5, 0.20833333333333
83749, 1.3666666666667, 0.475, 0.20833333333333
83750, 1.3666666666667, 0.45, 0.1875
83751, 1.3458333333333, 0.45, 0.20833333333333
83752, 1.3666666666667, 0.425, 0.20833333333333
83753, 1.3666666666667, 0.4, 0.1875
83754, 1.3458333333333, 0.4, 0.20833333333333
83755, 1.3666666666667, 0.375, 0.20833333333333
83756, 1.3666666666667, 0.35, 0.1875
83757, 1.3458333333333, 0.35, 0.20833333333333
83758, 1.3666666666667, 0.325, 0.20833333333333
83759, 1.3666666666667, 0.3, 0.1875
83760, 1.3458333333333, 0.3, 0.20833333333333
83761, 1.3666666666667, 0.275, 0.20833333333333
83762, 1.3666666666667, 0.25, 0.1875
83763, 1.3458333333333, 0.25, 0.20833333333333
83764, 1.3666666666667, 0.225, 0.20833333333333
83765, 1.3666666666667, 0.2, 0.1875
83766, 1.3458333333333, 0.2, 0.20833333333333
83767, 1.3666666666667, 0.175, 0.20833333333333
83768, 1.4083333333333, 1.325, 0.20833333333333
83769, 1.4083333333333, 1.3, 0.1875
83770, 1.3875, 1.3, 0.20833333333333
83771, 1.4083333333333, 1.275, 0.20833333333333
83772, 1.4083333333333, 1.25, 0.1875
83773, 1.3875, 1.25, 0.20833333333333
83774, 1.4083333333333, 1.225, 0.20833333333333
83775, 1.4083333333333, 1.2, 0.1875
83776, 1.3875, 1.2, 0.20833333333333
83777, 1.4083333333333, 1.175, 0.20833333333333
83778, 1.4083333333333, 1.15, 0.1875
83779, 1.3875, 1.15, 0.20833333333333
83780, 1.4083333333333, 1.125, 0.20833333333333
83781, 1.4083333333333, 1.1, 0.1875
83782, 1.3875, 1.1, 0.20833333333333
83783, 1.4083333333333, 1.075, 0.20833333333333
83784, 1.4083333333333, 1.05, 0.1875
83785, 1.3875, 1.05, 0.20833333333333
83786, 1.4083333333333, 1.025, 0.20833333333333
83787, 1.4083333333333, 1, 0.1875
83788, 1.3875, 1, 0.20833333333333
83789, 1.4083333333333, 0.975, 0.20833333333333
83790, 1.4083333333333, 0.95, 0.1875
83791, 1.3875, 0.95, 0.20833333333333
83792, 1.4083333333333, 0.925, 0.20833333333333
83793, 1.4083333333333, 0.9, 0.1875
83794, 1.3875, 0.9, 0.20833333333333
83795, 1.4083333333333, 0.875, 0.20833333333333
83796, 1.4083333333333, 0.85, 0.1875
83797, 1.3875, 0.85, 0.20833333333333
83798, 1.4083333333333, 0.825, 0.20833333333333
83799, 1.4083333333333, 0.8, 0.1875
83800, 1.3875, 0.8, 0.20833333333333
83801, 1.4083333333333, 0.775, 0.20833333333333
83802, 1.4083333333333, 0.75, 0.1875
83803, 1.3875, 0.75, 0.20833333333333
83804, 1.4083333333333, 0.725, 0.20833333333333
83805, 1.4083333333333, 0.7, 0.1875
83806, 1.3875, 0.7, 0.20833333333333
83807, 1.4083333333333, 0.675, 0.20833333333333
83808, 1.4083333333333, 0.65, 0.1875
83809, 1.3875, 0.65, 0.20833333333333
83810, 1.4083333333333, 0.625, 0.20833333333333
83811, 1.4083333333333, 0.6, 0.1875
83812, 1.3875, 0.6, 0.20833333333333
83813, 1.4083333333333, 0.575, 0.20833333333333
83814, 1.4083333333333, 0.55, 0.1875
83815, 1.3875, 0.55, 0.20833333333333
83816, 1.4083333333333, 0.525, 0.20833333333333
83817, 1.4083333333333, 0.5, 0.1875
83818, 1.3875, 0.5, 0.20833333333333
83819, 1.4083333333333, 0.475, 0.20833333333333
83820, 1.4083333333333, 0.45, 0.1875
83821, 1.3875, 0.45, 0.20833333333333
83822, 1.4083333333333, 0.425, 0.20833333333333
83823, 1.4083333333333, 0.4, 0.1875
83824, 1.3875, 0.4, 0.20833333333333
83825, 1.4083333333333, 0.375, 0.20833333333333
83826, 1.4083333333333, 0.35, 0.1875
83827, 1.3875, 0.35, 0.20833333333333
83828, 1.4083333333333, 0.325, 0.20833333333333
83829, 1.4083333333333, 0.3, 0.1875
83830, 1.3875, 0.3, 0.20833333333333
83831, 1.4083333333333, 0.275, 0.20833333333333
83832, 1.4083333333333, 0.25, 0.1875
83833, 1.3875, 0.25, 0.20833333333333
83834, 1.4083333333333, 0.225, 0.20833333333333
83835, 1.4083333333333, 0.2, 0.1875
83836, 1.3875, 0.2, 0.20833333333333
83837, 1.4083333333333, 0.175, 0.20833333333333
83838, 1.45, 1.325, 0.20833333333333
83839, 1.45, 1.3, 0.1875
83840, 1.4291666666667, 1.3, 0.20833333333333
83841, 1.45, 1.275, 0.20833333333333
83842, 1.45, 1.25, 0.1875
83843, 1.4291666666667, 1.25, 0.20833333333333
83844, 1.45, 1.225, 0.20833333333333
83845, 1.45, 1.2, 0.1875
83846, 1.4291666666667, 1.2, 0.20833333333333
83847, 1.45, 1.175, 0.20833333333333
83848, 1.45, 1.15, 0.1875
83849, 1.4291666666667, 1.15, 0.20833333333333
83850, 1.45, 1.125, 0.20833333333333
83851, 1.45, 1.1, 0.1875
83852, 1.4291666666667, 1.1, 0.20833333333333
83853, 1.45, 1.075, 0.20833333333333
83854, 1.45, 1.05, 0.1875
83855, 1.4291666666667, 1.05, 0.20833333333333
83856, 1.45, 1.025, 0.20833333333333
83857, 1.45, 1, 0.1875
83858, 1.4291666666667, 1, 0.20833333333333
83859, 1.45, 0.975, 0.20833333333333
83860, 1.45, 0.95, 0.1875
83861, 1.4291666666667, 0.95, 0.20833333333333
83862, 1.45, 0.925, 0.20833333333333
83863, 1.45, 0.9, 0.1875
83864, 1.4291666666667, 0.9, 0.20833333333333
83865, 1.45, 0.875, 0.20833333333333
83866, 1.45, 0.85, 0.1875
83867, 1.4291666666667, 0.85, 0.20833333333333
83868, 1.45, 0.825, 0.20833333333333
83869, 1.45, 0.8, 0.1875
83870, 1.4291666666667, 0.8, 0.20833333333333
83871, 1.45, 0.775, 0.20833333333333
83872, 1.45, 0.75, 0.1875
83873, 1.4291666666667, 0.75, 0.20833333333333
83874, 1.45, 0.725, 0.20833333333333
83875, 1.45, 0.7, 0.1875
83876, 1.4291666666667, 0.7, 0.20833333333333
83877, 1.45, 0.675, 0.20833333333333
83878, 1.45, 0.65, 0.1875
83879, 1.4291666666667, 0.65, 0.20833333333333
83880, 1.45, 0.625, 0.20833333333333
83881, 1.45, 0.6, 0.1875
83882, 1.4291666666667, 0.6, 0.20833333333333
83883, 1.45, 0.575, 0.20833333333333
83884, 1.45, 0.55, 0.1875
83885, 1.4291666666667, 0.55, 0.20833333333333
83886, 1.45, 0.525, 0.20833333333333
83887, 1.45, 0.5, 0.1875
83888, 1.4291666666667, 0.5, 0.20833333333333
83889, 1.45, 0.475, 0.20833333333333
83890, 1.45, 0.45, 0.1875
83891, 1.4291666666667, 0.45, 0.20833333333333
83892, 1.45, 0.425, 0.20833333333333
83893, 1.45, 0.4, 0.1875
83894, 1.4291666666667, 0.4, 0.20833333333333
83895, 1.45, 0.375, 0.20833333333333
83896, 1.45, 0.35, 0.1875
83897, 1.4291666666667, 0.35, 0.20833333333333
83898, 1.45, 0.325, 0.20833333333333
83899, 1.45, 0.3, 0.1875
83900, 1.4291666666667, 0.3, 0.20833333333333
83901, 1.45, 0.275, 0.20833333333333
83902, 1.45, 0.25, 0.1875
83903, 1.4291666666667, 0.25, 0.20833333333333
83904, 1.45, 0.225, 0.20833333333333
83905, 1.45, 0.2, 0.1875
83906, 1.4291666666667, 0.2, 0.20833333333333
83907, 1.45, 0.175, 0.20833333333333
83908, 1.4916666666667, 1.325, 0.20833333333333
83909, 1.4916666666667, 1.3, 0.1875
83910, 1.4708333333333, 1.3, 0.20833333333333
83911, 1.4916666666667, 1.275, 0.20833333333333
83912, 1.4916666666667, 1.25, 0.1875
83913, 1.4708333333333, 1.25, 0.20833333333333
83914, 1.4916666666667, 1.225, 0.20833333333333
83915, 1.4916666666667, 1.2, 0.1875
83916, 1.4708333333333, 1.2, 0.20833333333333
83917, 1.4916666666667, 1.175, 0.20833333333333
83918, 1.4916666666667, 1.15, 0.1875
83919, 1.4708333333333, 1.15, 0.20833333333333
83920, 1.4916666666667, 1.125, 0.20833333333333
83921, 1.4916666666667, 1.1, 0.1875
83922, 1.4708333333333, 1.1, 0.20833333333333
83923, 1.4916666666667, 1.075, 0.20833333333333
83924, 1.4916666666667, 1.05, 0.1875
83925, 1.4708333333333, 1.05, 0.20833333333333
83926, 1.4916666666667, 1.025, 0.20833333333333
83927, 1.4916666666667, 1, 0.1875
83928, 1.4708333333333, 1, 0.20833333333333
83929, 1.4916666666667, 0.975, 0.20833333333333
83930, 1.4916666666667, 0.95, 0.1875
83931, 1.4708333333333, 0.95, 0.20833333333333
83932, 1.4916666666667, 0.925, 0.20833333333333
83933, 1.4916666666667, 0.9, 0.1875
83934, 1.4708333333333, 0.9, 0.20833333333333
83935, 1.4916666666667, 0.875, 0.20833333333333
83936, 1.4916666666667, 0.85, 0.1875
83937, 1.4708333333333, 0.85, 0.20833333333333
83938, 1.4916666666667, 0.825, 0.20833333333333
83939, 1.4916666666667, 0.8, 0.1875
83940, 1.4708333333333, 0.8, 0.20833333333333
83941, 1.4916666666667, 0.775, 0.20833333333333
83942, 1.4916666666667, 0.75, 0.1875
83943, 1.4708333333333, 0.75, 0.20833333333333
83944, 1.4916666666667, 0.725, 0.20833333333333
83945, 1.4916666666667, 0.7, 0.1875
83946, 1.4708333333333, 0.7, 0.20833333333333
83947, 1.4916666666667, 0.675, 0.20833333333333
83948, 1.4916666666667, 0.65, 0.1875
83949, 1.4708333333333, 0.65, 0.20833333333333
83950, 1.4916666666667, 0.625, 0.20833333333333
83951, 1.4916666666667, 0.6, 0.1875
83952, 1.4708333333333, 0.6, 0.20833333333333
83953, 1.4916666666667, 0.575, 0.20833333333333
83954, 1.4916666666667, 0.55, 0.1875
83955, 1.4708333333333, 0.55, 0.20833333333333
83956, 1.4916666666667, 0.525, 0.20833333333333
83957, 1.4916666666667, 0.5, 0.1875
83958, 1.4708333333333, 0.5, 0.20833333333333
83959, 1.4916666666667, 0.475, 0.20833333333333
83960, 1.4916666666667, 0.45, 0.1875
83961, 1.4708333333333, 0.45, 0.20833333333333
83962, 1.4916666666667, 0.425, 0.20833333333333
83963, 1.4916666666667, 0.4, 0.1875
83964, 1.4708333333333, 0.4, 0.20833333333333
83965, 1.4916666666667, 0.375, 0.20833333333333
83966, 1.4916666666667, 0.35, 0.1875
83967, 1.4708333333333, 0.35, 0.20833333333333
83968, 1.4916666666667, 0.325, 0.20833333333333
83969, 1.4916666666667, 0.3, 0.1875
83970, 1.4708333333333, 0.3, 0.20833333333333
83971, 1.4916666666667, 0.275, 0.20833333333333
83972, 1.4916666666667, 0.25, 0.1875
83973, 1.4708333333333, 0.25, 0.20833333333333
83974, 1.4916666666667, 0.225, 0.20833333333333
83975, 1.4916666666667, 0.2, 0.1875
83976, 1.4708333333333, 0.2, 0.20833333333333
83977, 1.4916666666667, 0.175, 0.20833333333333
83978, 1.5333333333333, 1.325, 0.20833333333333
83979, 1.5333333333333, 1.3, 0.1875
83980, 1.5125, 1.3, 0.20833333333333
83981, 1.5333333333333, 1.275, 0.20833333333333
83982, 1.5333333333333, 1.25, 0.1875
83983, 1.5125, 1.25, 0.20833333333333
83984, 1.5333333333333, 1.225, 0.20833333333333
83985, 1.5333333333333, 1.2, 0.1875
83986, 1.5125, 1.2, 0.20833333333333
83987, 1.5333333333333, 1.175, 0.20833333333333
83988, 1.5333333333333, 1.15, 0.1875
83989, 1.5125, 1.15, 0.20833333333333
83990, 1.5333333333333, 1.125, 0.20833333333333
83991, 1.5333333333333, 1.1, 0.1875
83992, 1.5125, 1.1, 0.20833333333333
83993, 1.5333333333333, 1.075, 0.20833333333333
83994, 1.5333333333333, 1.05, 0.1875
83995, 1.5125, 1.05, 0.20833333333333
83996, 1.5333333333333, 1.025, 0.20833333333333
83997, 1.5333333333333, 1, 0.1875
83998, 1.5125, 1, 0.20833333333333
83999, 1.5333333333333, 0.975, 0.20833333333333
84000, 1.5333333333333, 0.95, 0.1875
84001, 1.5125, 0.95, 0.20833333333333
84002, 1.5333333333333, 0.925, 0.20833333333333
84003, 1.5333333333333, 0.9, 0.1875
84004, 1.5125, 0.9, 0.20833333333333
84005, 1.5333333333333, 0.875, 0.20833333333333
84006, 1.5333333333333, 0.85, 0.1875
84007, 1.5125, 0.85, 0.20833333333333
84008, 1.5333333333333, 0.825, 0.20833333333333
84009, 1.5333333333333, 0.8, 0.1875
84010, 1.5125, 0.8, 0.20833333333333
84011, 1.5333333333333, 0.775, 0.20833333333333
84012, 1.5333333333333, 0.75, 0.1875
84013, 1.5125, 0.75, 0.20833333333333
84014, 1.5333333333333, 0.725, 0.20833333333333
84015, 1.5333333333333, 0.7, 0.1875
84016, 1.5125, 0.7, 0.20833333333333
84017, 1.5333333333333, 0.675, 0.20833333333333
84018, 1.5333333333333, 0.65, 0.1875
84019, 1.5125, 0.65, 0.20833333333333
84020, 1.5333333333333, 0.625, 0.20833333333333
84021, 1.5333333333333, 0.6, 0.1875
84022, 1.5125, 0.6, 0.20833333333333
84023, 1.5333333333333, 0.575, 0.20833333333333
84024, 1.5333333333333, 0.55, 0.1875
84025, 1.5125, 0.55, 0.20833333333333
84026, 1.5333333333333, 0.525, 0.20833333333333
84027, 1.5333333333333, 0.5, 0.1875
84028, 1.5125, 0.5, 0.20833333333333
84029, 1.5333333333333, 0.475, 0.20833333333333
84030, 1.5333333333333, 0.45, 0.1875
84031, 1.5125, 0.45, 0.20833333333333
84032, 1.5333333333333, 0.425, 0.20833333333333
84033, 1.5333333333333, 0.4, 0.1875
84034, 1.5125, 0.4, 0.20833333333333
84035, 1.5333333333333, 0.375, 0.20833333333333
84036, 1.5333333333333, 0.35, 0.1875
84037, 1.5125, 0.35, 0.20833333333333
84038, 1.5333333333333, 0.325, 0.20833333333333
84039, 1.5333333333333, 0.3, 0.1875
84040, 1.5125, 0.3, 0.20833333333333
84041, 1.5333333333333, 0.275, 0.20833333333333
84042, 1.5333333333333, 0.25, 0.1875
84043, 1.5125, 0.25, 0.20833333333333
84044, 1.5333333333333, 0.225, 0.20833333333333
84045, 1.5333333333333, 0.2, 0.1875
84046, 1.5125, 0.2, 0.20833333333333
84047, 1.5333333333333, 0.175, 0.20833333333333
84048, 1.575, 1.325, 0.20833333333333
84049, 1.575, 1.3, 0.1875
84050, 1.5541666666667, 1.3, 0.20833333333333
84051, 1.575, 1.275, 0.20833333333333
84052, 1.575, 1.25, 0.1875
84053, 1.5541666666667, 1.25, 0.20833333333333
84054, 1.575, 1.225, 0.20833333333333
84055, 1.575, 1.2, 0.1875
84056, 1.5541666666667, 1.2, 0.20833333333333
84057, 1.575, 1.175, 0.20833333333333
84058, 1.575, 1.15, 0.1875
84059, 1.5541666666667, 1.15, 0.20833333333333
84060, 1.575, 1.125, 0.20833333333333
84061, 1.575, 1.1, 0.1875
84062, 1.5541666666667, 1.1, 0.20833333333333
84063, 1.575, 1.075, 0.20833333333333
84064, 1.575, 1.05, 0.1875
84065, 1.5541666666667, 1.05, 0.20833333333333
84066, 1.575, 1.025, 0.20833333333333
84067, 1.575, 1, 0.1875
84068, 1.5541666666667, 1, 0.20833333333333
84069, 1.575, 0.975, 0.20833333333333
84070, 1.575, 0.95, 0.1875
84071, 1.5541666666667, 0.95, 0.20833333333333
84072, 1.575, 0.925, 0.20833333333333
84073, 1.575, 0.9, 0.1875
84074, 1.5541666666667, 0.9, 0.20833333333333
84075, 1.575, 0.875, 0.20833333333333
84076, 1.575, 0.85, 0.1875
84077, 1.5541666666667, 0.85, 0.20833333333333
84078, 1.575, 0.825, 0.20833333333333
84079, 1.575, 0.8, 0.1875
84080, 1.5541666666667, 0.8, 0.20833333333333
84081, 1.575, 0.775, 0.20833333333333
84082, 1.575, 0.75, 0.1875
84083, 1.5541666666667, 0.75, 0.20833333333333
84084, 1.575, 0.725, 0.20833333333333
84085, 1.575, 0.7, 0.1875
84086, 1.5541666666667, 0.7, 0.20833333333333
84087, 1.575, 0.675, 0.20833333333333
84088, 1.575, 0.65, 0.1875
84089, 1.5541666666667, 0.65, 0.20833333333333
84090, 1.575, 0.625, 0.20833333333333
84091, 1.575, 0.6, 0.1875
84092, 1.5541666666667, 0.6, 0.20833333333333
84093, 1.575, 0.575, 0.20833333333333
84094, 1.575, 0.55, 0.1875
84095, 1.5541666666667, 0.55, 0.20833333333333
84096, 1.575, 0.525, 0.20833333333333
84097, 1.575, 0.5, 0.1875
84098, 1.5541666666667, 0.5, 0.20833333333333
84099, 1.575, 0.475, 0.20833333333333
84100, 1.575, 0.45, 0.1875
84101, 1.5541666666667, 0.45, 0.20833333333333
84102, 1.575, 0.425, 0.20833333333333
84103, 1.575, 0.4, 0.1875
84104, 1.5541666666667, 0.4, 0.20833333333333
84105, 1.575, 0.375, 0.20833333333333
84106, 1.575, 0.35, 0.1875
84107, 1.5541666666667, 0.35, 0.20833333333333
84108, 1.575, 0.325, 0.20833333333333
84109, 1.575, 0.3, 0.1875
84110, 1.5541666666667, 0.3, 0.20833333333333
84111, 1.575, 0.275, 0.20833333333333
84112, 1.575, 0.25, 0.1875
84113, 1.5541666666667, 0.25, 0.20833333333333
84114, 1.575, 0.225, 0.20833333333333
84115, 1.575, 0.2, 0.1875
84116, 1.5541666666667, 0.2, 0.20833333333333
84117, 1.575, 0.175, 0.20833333333333
84118, 1.6166666666667, 1.325, 0.20833333333333
84119, 1.6166666666667, 1.3, 0.1875
84120, 1.5958333333333, 1.3, 0.20833333333333
84121, 1.6166666666667, 1.275, 0.20833333333333
84122, 1.6166666666667, 1.25, 0.1875
84123, 1.5958333333333, 1.25, 0.20833333333333
84124, 1.6166666666667, 1.225, 0.20833333333333
84125, 1.6166666666667, 1.2, 0.1875
84126, 1.5958333333333, 1.2, 0.20833333333333
84127, 1.6166666666667, 1.175, 0.20833333333333
84128, 1.6166666666667, 1.15, 0.1875
84129, 1.5958333333333, 1.15, 0.20833333333333
84130, 1.6166666666667, 1.125, 0.20833333333333
84131, 1.6166666666667, 1.1, 0.1875
84132, 1.5958333333333, 1.1, 0.20833333333333
84133, 1.6166666666667, 1.075, 0.20833333333333
84134, 1.6166666666667, 1.05, 0.1875
84135, 1.5958333333333, 1.05, 0.20833333333333
84136, 1.6166666666667, 1.025, 0.20833333333333
84137, 1.6166666666667, 1, 0.1875
84138, 1.5958333333333, 1, 0.20833333333333
84139, 1.6166666666667, 0.975, 0.20833333333333
84140, 1.6166666666667, 0.95, 0.1875
84141, 1.5958333333333, 0.95, 0.20833333333333
84142, 1.6166666666667, 0.925, 0.20833333333333
84143, 1.6166666666667, 0.9, 0.1875
84144, 1.5958333333333, 0.9, 0.20833333333333
84145, 1.6166666666667, 0.875, 0.20833333333333
84146, 1.6166666666667, 0.85, 0.1875
84147, 1.5958333333333, 0.85, 0.20833333333333
84148, 1.6166666666667, 0.825, 0.20833333333333
84149, 1.6166666666667, 0.8, 0.1875
84150, 1.5958333333333, 0.8, 0.20833333333333
84151, 1.6166666666667, 0.775, 0.20833333333333
84152, 1.6166666666667, 0.75, 0.1875
84153, 1.5958333333333, 0.75, 0.20833333333333
84154, 1.6166666666667, 0.725, 0.20833333333333
84155, 1.6166666666667, 0.7, 0.1875
84156, 1.5958333333333, 0.7, 0.20833333333333
84157, 1.6166666666667, 0.675, 0.20833333333333
84158, 1.6166666666667, 0.65, 0.1875
84159, 1.5958333333333, 0.65, 0.20833333333333
84160, 1.6166666666667, 0.625, 0.20833333333333
84161, 1.6166666666667, 0.6, 0.1875
84162, 1.5958333333333, 0.6, 0.20833333333333
84163, 1.6166666666667, 0.575, 0.20833333333333
84164, 1.6166666666667, 0.55, 0.1875
84165, 1.5958333333333, 0.55, 0.20833333333333
84166, 1.6166666666667, 0.525, 0.20833333333333
84167, 1.6166666666667, 0.5, 0.1875
84168, 1.5958333333333, 0.5, 0.20833333333333
84169, 1.6166666666667, 0.475, 0.20833333333333
84170, 1.6166666666667, 0.45, 0.1875
84171, 1.5958333333333, 0.45, 0.20833333333333
84172, 1.6166666666667, 0.425, 0.20833333333333
84173, 1.6166666666667, 0.4, 0.1875
84174, 1.5958333333333, 0.4, 0.20833333333333
84175, 1.6166666666667, 0.375, 0.20833333333333
84176, 1.6166666666667, 0.35, 0.1875
84177, 1.5958333333333, 0.35, 0.20833333333333
84178, 1.6166666666667, 0.325, 0.20833333333333
84179, 1.6166666666667, 0.3, 0.1875
84180, 1.5958333333333, 0.3, 0.20833333333333
84181, 1.6166666666667, 0.275, 0.20833333333333
84182, 1.6166666666667, 0.25, 0.1875
84183, 1.5958333333333, 0.25, 0.20833333333333
84184, 1.6166666666667, 0.225, 0.20833333333333
84185, 1.6166666666667, 0.2, 0.1875
84186, 1.5958333333333, 0.2, 0.20833333333333
84187, 1.6166666666667, 0.175, 0.20833333333333
84188, 1.6583333333333, 1.325, 0.20833333333333
84189, 1.6583333333333, 1.3, 0.1875
84190, 1.6375, 1.3, 0.20833333333333
84191, 1.6583333333333, 1.275, 0.20833333333333
84192, 1.6583333333333, 1.25, 0.1875
84193, 1.6375, 1.25, 0.20833333333333
84194, 1.6583333333333, 1.225, 0.20833333333333
84195, 1.6583333333333, 1.2, 0.1875
84196, 1.6375, 1.2, 0.20833333333333
84197, 1.6583333333333, 1.175, 0.20833333333333
84198, 1.6583333333333, 1.15, 0.1875
84199, 1.6375, 1.15, 0.20833333333333
84200, 1.6583333333333, 1.125, 0.20833333333333
84201, 1.6583333333333, 1.1, 0.1875
84202, 1.6375, 1.1, 0.20833333333333
84203, 1.6583333333333, 1.075, 0.20833333333333
84204, 1.6583333333333, 1.05, 0.1875
84205, 1.6375, 1.05, 0.20833333333333
84206, 1.6583333333333, 1.025, 0.20833333333333
84207, 1.6583333333333, 1, 0.1875
84208, 1.6375, 1, 0.20833333333333
84209, 1.6583333333333, 0.975, 0.20833333333333
84210, 1.6583333333333, 0.95, 0.1875
84211, 1.6375, 0.95, 0.20833333333333
84212, 1.6583333333333, 0.925, 0.20833333333333
84213, 1.6583333333333, 0.9, 0.1875
84214, 1.6375, 0.9, 0.20833333333333
84215, 1.6583333333333, 0.875, 0.20833333333333
84216, 1.6583333333333, 0.85, 0.1875
84217, 1.6375, 0.85, 0.20833333333333
84218, 1.6583333333333, 0.825, 0.20833333333333
84219, 1.6583333333333, 0.8, 0.1875
84220, 1.6375, 0.8, 0.20833333333333
84221, 1.6583333333333, 0.775, 0.20833333333333
84222, 1.6583333333333, 0.75, 0.1875
84223, 1.6375, 0.75, 0.20833333333333
84224, 1.6583333333333, 0.725, 0.20833333333333
84225, 1.6583333333333, 0.7, 0.1875
84226, 1.6375, 0.7, 0.20833333333333
84227, 1.6583333333333, 0.675, 0.20833333333333
84228, 1.6583333333333, 0.65, 0.1875
84229, 1.6375, 0.65, 0.20833333333333
84230, 1.6583333333333, 0.625, 0.20833333333333
84231, 1.6583333333333, 0.6, 0.1875
84232, 1.6375, 0.6, 0.20833333333333
84233, 1.6583333333333, 0.575, 0.20833333333333
84234, 1.6583333333333, 0.55, 0.1875
84235, 1.6375, 0.55, 0.20833333333333
84236, 1.6583333333333, 0.525, 0.20833333333333
84237, 1.6583333333333, 0.5, 0.1875
84238, 1.6375, 0.5, 0.20833333333333
84239, 1.6583333333333, 0.475, 0.20833333333333
84240, 1.6583333333333, 0.45, 0.1875
84241, 1.6375, 0.45, 0.20833333333333
84242, 1.6583333333333, 0.425, 0.20833333333333
84243, 1.6583333333333, 0.4, 0.1875
84244, 1.6375, 0.4, 0.20833333333333
84245, 1.6583333333333, 0.375, 0.20833333333333
84246, 1.6583333333333, 0.35, 0.1875
84247, 1.6375, 0.35, 0.20833333333333
84248, 1.6583333333333, 0.325, 0.20833333333333
84249, 1.6583333333333, 0.3, 0.1875
84250, 1.6375, 0.3, 0.20833333333333
84251, 1.6583333333333, 0.275, 0.20833333333333
84252, 1.6583333333333, 0.25, 0.1875
84253, 1.6375, 0.25, 0.20833333333333
84254, 1.6583333333333, 0.225, 0.20833333333333
84255, 1.6583333333333, 0.2, 0.1875
84256, 1.6375, 0.2, 0.20833333333333
84257, 1.6583333333333, 0.175, 0.20833333333333
84258, 1.7, 1.325, 0.20833333333333
84259, 1.7, 1.3, 0.1875
84260, 1.6791666666667, 1.3, 0.20833333333333
84261, 1.7, 1.275, 0.20833333333333
84262, 1.7, 1.25, 0.1875
84263, 1.6791666666667, 1.25, 0.20833333333333
84264, 1.7, 1.225, 0.20833333333333
84265, 1.7, 1.2, 0.1875
84266, 1.6791666666667, 1.2, 0.20833333333333
84267, 1.7, 1.175, 0.20833333333333
84268, 1.7, 1.15, 0.1875
84269, 1.6791666666667, 1.15, 0.20833333333333
84270, 1.7, 1.125, 0.20833333333333
84271, 1.7, 1.1, 0.1875
84272, 1.6791666666667, 1.1, 0.20833333333333
84273, 1.7, 1.075, 0.20833333333333
84274, 1.7, 1.05, 0.1875
84275, 1.6791666666667, 1.05, 0.20833333333333
84276, 1.7, 1.025, 0.20833333333333
84277, 1.7, 1, 0.1875
84278, 1.6791666666667, 1, 0.20833333333333
84279, 1.7, 0.975, 0.20833333333333
84280, 1.7, 0.95, 0.1875
84281, 1.6791666666667, 0.95, 0.20833333333333
84282, 1.7, 0.925, 0.20833333333333
84283, 1.7, 0.9, 0.1875
84284, 1.6791666666667, 0.9, 0.20833333333333
84285, 1.7, 0.875, 0.20833333333333
84286, 1.7, 0.85, 0.1875
84287, 1.6791666666667, 0.85, 0.20833333333333
84288, 1.7, 0.825, 0.20833333333333
84289, 1.7, 0.8, 0.1875
84290, 1.6791666666667, 0.8, 0.20833333333333
84291, 1.7, 0.775, 0.20833333333333
84292, 1.7, 0.75, 0.1875
84293, 1.6791666666667, 0.75, 0.20833333333333
84294, 1.7, 0.725, 0.20833333333333
84295, 1.7, 0.7, 0.1875
84296, 1.6791666666667, 0.7, 0.20833333333333
84297, 1.7, 0.675, 0.20833333333333
84298, 1.7, 0.65, 0.1875
84299, 1.6791666666667, 0.65, 0.20833333333333
84300, 1.7, 0.625, 0.20833333333333
84301, 1.7, 0.6, 0.1875
84302, 1.6791666666667, 0.6, 0.20833333333333
84303, 1.7, 0.575, 0.20833333333333
84304, 1.7, 0.55, 0.1875
84305, 1.6791666666667, 0.55, 0.20833333333333
84306, 1.7, 0.525, 0.20833333333333
84307, 1.7, 0.5, 0.1875
84308, 1.6791666666667, 0.5, 0.20833333333333
84309, 1.7, 0.475, 0.20833333333333
84310, 1.7, 0.45, 0.1875
84311, 1.6791666666667, 0.45, 0.20833333333333
84312, 1.7, 0.425, 0.20833333333333
84313, 1.7, 0.4, 0.1875
84314, 1.6791666666667, 0.4, 0.20833333333333
84315, 1.7, 0.375, 0.20833333333333
84316, 1.7, 0.35, 0.1875
84317, 1.6791666666667, 0.35, 0.20833333333333
84318, 1.7, 0.325, 0.20833333333333
84319, 1.7, 0.3, 0.1875
84320, 1.6791666666667, 0.3, 0.20833333333333
84321, 1.7, 0.275, 0.20833333333333
84322, 1.7, 0.25, 0.1875
84323, 1.6791666666667, 0.25, 0.20833333333333
84324, 1.7, 0.225, 0.20833333333333
84325, 1.7, 0.2, 0.1875
84326, 1.6791666666667, 0.2, 0.20833333333333
84327, 1.7, 0.175, 0.20833333333333
84328, 1.7416666666667, 1.325, 0.20833333333333
84329, 1.7416666666667, 1.3, 0.1875
84330, 1.7208333333333, 1.3, 0.20833333333333
84331, 1.7416666666667, 1.275, 0.20833333333333
84332, 1.7416666666667, 1.25, 0.1875
84333, 1.7208333333333, 1.25, 0.20833333333333
84334, 1.7416666666667, 1.225, 0.20833333333333
84335, 1.7416666666667, 1.2, 0.1875
84336, 1.7208333333333, 1.2, 0.20833333333333
84337, 1.7416666666667, 1.175, 0.20833333333333
84338, 1.7416666666667, 1.15, 0.1875
84339, 1.7208333333333, 1.15, 0.20833333333333
84340, 1.7416666666667, 1.125, 0.20833333333333
84341, 1.7416666666667, 1.1, 0.1875
84342, 1.7208333333333, 1.1, 0.20833333333333
84343, 1.7416666666667, 1.075, 0.20833333333333
84344, 1.7416666666667, 1.05, 0.1875
84345, 1.7208333333333, 1.05, 0.20833333333333
84346, 1.7416666666667, 1.025, 0.20833333333333
84347, 1.7416666666667, 1, 0.1875
84348, 1.7208333333333, 1, 0.20833333333333
84349, 1.7416666666667, 0.975, 0.20833333333333
84350, 1.7416666666667, 0.95, 0.1875
84351, 1.7208333333333, 0.95, 0.20833333333333
84352, 1.7416666666667, 0.925, 0.20833333333333
84353, 1.7416666666667, 0.9, 0.1875
84354, 1.7208333333333, 0.9, 0.20833333333333
84355, 1.7416666666667, 0.875, 0.20833333333333
84356, 1.7416666666667, 0.85, 0.1875
84357, 1.7208333333333, 0.85, 0.20833333333333
84358, 1.7416666666667, 0.825, 0.20833333333333
84359, 1.7416666666667, 0.8, 0.1875
84360, 1.7208333333333, 0.8, 0.20833333333333
84361, 1.7416666666667, 0.775, 0.20833333333333
84362, 1.7416666666667, 0.75, 0.1875
84363, 1.7208333333333, 0.75, 0.20833333333333
84364, 1.7416666666667, 0.725, 0.20833333333333
84365, 1.7416666666667, 0.7, 0.1875
84366, 1.7208333333333, 0.7, 0.20833333333333
84367, 1.7416666666667, 0.675, 0.20833333333333
84368, 1.7416666666667, 0.65, 0.1875
84369, 1.7208333333333, 0.65, 0.20833333333333
84370, 1.7416666666667, 0.625, 0.20833333333333
84371, 1.7416666666667, 0.6, 0.1875
84372, 1.7208333333333, 0.6, 0.20833333333333
84373, 1.7416666666667, 0.575, 0.20833333333333
84374, 1.7416666666667, 0.55, 0.1875
84375, 1.7208333333333, 0.55, 0.20833333333333
84376, 1.7416666666667, 0.525, 0.20833333333333
84377, 1.7416666666667, 0.5, 0.1875
84378, 1.7208333333333, 0.5, 0.20833333333333
84379, 1.7416666666667, 0.475, 0.20833333333333
84380, 1.7416666666667, 0.45, 0.1875
84381, 1.7208333333333, 0.45, 0.20833333333333
84382, 1.7416666666667, 0.425, 0.20833333333333
84383, 1.7416666666667, 0.4, 0.1875
84384, 1.7208333333333, 0.4, 0.20833333333333
84385, 1.7416666666667, 0.375, 0.20833333333333
84386, 1.7416666666667, 0.35, 0.1875
84387, 1.7208333333333, 0.35, 0.20833333333333
84388, 1.7416666666667, 0.325, 0.20833333333333
84389, 1.7416666666667, 0.3, 0.1875
84390, 1.7208333333333, 0.3, 0.20833333333333
84391, 1.7416666666667, 0.275, 0.20833333333333
84392, 1.7416666666667, 0.25, 0.1875
84393, 1.7208333333333, 0.25, 0.20833333333333
84394, 1.7416666666667, 0.225, 0.20833333333333
84395, 1.7416666666667, 0.2, 0.1875
84396, 1.7208333333333, 0.2, 0.20833333333333
84397, 1.7416666666667, 0.175, 0.20833333333333
84398, 1.7833333333333, 1.325, 0.20833333333333
84399, 1.7833333333333, 1.3, 0.1875
84400, 1.7625, 1.3, 0.20833333333333
84401, 1.7833333333333, 1.275, 0.20833333333333
84402, 1.7833333333333, 1.25, 0.1875
84403, 1.7625, 1.25, 0.20833333333333
84404, 1.7833333333333, 1.225, 0.20833333333333
84405, 1.7833333333333, 1.2, 0.1875
84406, 1.7625, 1.2, 0.20833333333333
84407, 1.7833333333333, 1.175, 0.20833333333333
84408, 1.7833333333333, 1.15, 0.1875
84409, 1.7625, 1.15, 0.20833333333333
84410, 1.7833333333333, 1.125, 0.20833333333333
84411, 1.7833333333333, 1.1, 0.1875
84412, 1.7625, 1.1, 0.20833333333333
84413, 1.7833333333333, 1.075, 0.20833333333333
84414, 1.7833333333333, 1.05, 0.1875
84415, 1.7625, 1.05, 0.20833333333333
84416, 1.7833333333333, 1.025, 0.20833333333333
84417, 1.7833333333333, 1, 0.1875
84418, 1.7625, 1, 0.20833333333333
84419, 1.7833333333333, 0.975, 0.20833333333333
84420, 1.7833333333333, 0.95, 0.1875
84421, 1.7625, 0.95, 0.20833333333333
84422, 1.7833333333333, 0.925, 0.20833333333333
84423, 1.7833333333333, 0.9, 0.1875
84424, 1.7625, 0.9, 0.20833333333333
84425, 1.7833333333333, 0.875, 0.20833333333333
84426, 1.7833333333333, 0.85, 0.1875
84427, 1.7625, 0.85, 0.20833333333333
84428, 1.7833333333333, 0.825, 0.20833333333333
84429, 1.7833333333333, 0.8, 0.1875
84430, 1.7625, 0.8, 0.20833333333333
84431, 1.7833333333333, 0.775, 0.20833333333333
84432, 1.7833333333333, 0.75, 0.1875
84433, 1.7625, 0.75, 0.20833333333333
84434, 1.7833333333333, 0.725, 0.20833333333333
84435, 1.7833333333333, 0.7, 0.1875
84436, 1.7625, 0.7, 0.20833333333333
84437, 1.7833333333333, 0.675, 0.20833333333333
84438, 1.7833333333333, 0.65, 0.1875
84439, 1.7625, 0.65, 0.20833333333333
84440, 1.7833333333333, 0.625, 0.20833333333333
84441, 1.7833333333333, 0.6, 0.1875
84442, 1.7625, 0.6, 0.20833333333333
84443, 1.7833333333333, 0.575, 0.20833333333333
84444, 1.7833333333333, 0.55, 0.1875
84445, 1.7625, 0.55, 0.20833333333333
84446, 1.7833333333333, 0.525, 0.20833333333333
84447, 1.7833333333333, 0.5, 0.1875
84448, 1.7625, 0.5, 0.20833333333333
84449, 1.7833333333333, 0.475, 0.20833333333333
84450, 1.7833333333333, 0.45, 0.1875
84451, 1.7625, 0.45, 0.20833333333333
84452, 1.7833333333333, 0.425, 0.20833333333333
84453, 1.7833333333333, 0.4, 0.1875
84454, 1.7625, 0.4, 0.20833333333333
84455, 1.7833333333333, 0.375, 0.20833333333333
84456, 1.7833333333333, 0.35, 0.1875
84457, 1.7625, 0.35, 0.20833333333333
84458, 1.7833333333333, 0.325, 0.20833333333333
84459, 1.7833333333333, 0.3, 0.1875
84460, 1.7625, 0.3, 0.20833333333333
84461, 1.7833333333333, 0.275, 0.20833333333333
84462, 1.7833333333333, 0.25, 0.1875
84463, 1.7625, 0.25, 0.20833333333333
84464, 1.7833333333333, 0.225, 0.20833333333333
84465, 1.7833333333333, 0.2, 0.1875
84466, 1.7625, 0.2, 0.20833333333333
84467, 1.7833333333333, 0.175, 0.20833333333333
84468, 1.825, 1.325, 0.20833333333333
84469, 1.825, 1.3, 0.1875
84470, 1.8041666666667, 1.3, 0.20833333333333
84471, 1.825, 1.275, 0.20833333333333
84472, 1.825, 1.25, 0.1875
84473, 1.8041666666667, 1.25, 0.20833333333333
84474, 1.825, 1.225, 0.20833333333333
84475, 1.825, 1.2, 0.1875
84476, 1.8041666666667, 1.2, 0.20833333333333
84477, 1.825, 1.175, 0.20833333333333
84478, 1.825, 1.15, 0.1875
84479, 1.8041666666667, 1.15, 0.20833333333333
84480, 1.825, 1.125, 0.20833333333333
84481, 1.825, 1.1, 0.1875
84482, 1.8041666666667, 1.1, 0.20833333333333
84483, 1.825, 1.075, 0.20833333333333
84484, 1.825, 1.05, 0.1875
84485, 1.8041666666667, 1.05, 0.20833333333333
84486, 1.825, 1.025, 0.20833333333333
84487, 1.825, 1, 0.1875
84488, 1.8041666666667, 1, 0.20833333333333
84489, 1.825, 0.975, 0.20833333333333
84490, 1.825, 0.95, 0.1875
84491, 1.8041666666667, 0.95, 0.20833333333333
84492, 1.825, 0.925, 0.20833333333333
84493, 1.825, 0.9, 0.1875
84494, 1.8041666666667, 0.9, 0.20833333333333
84495, 1.825, 0.875, 0.20833333333333
84496, 1.825, 0.85, 0.1875
84497, 1.8041666666667, 0.85, 0.20833333333333
84498, 1.825, 0.825, 0.20833333333333
84499, 1.825, 0.8, 0.1875
84500, 1.8041666666667, 0.8, 0.20833333333333
84501, 1.825, 0.775, 0.20833333333333
84502, 1.825, 0.75, 0.1875
84503, 1.8041666666667, 0.75, 0.20833333333333
84504, 1.825, 0.725, 0.20833333333333
84505, 1.825, 0.7, 0.1875
84506, 1.8041666666667, 0.7, 0.20833333333333
84507, 1.825, 0.675, 0.20833333333333
84508, 1.825, 0.65, 0.1875
84509, 1.8041666666667, 0.65, 0.20833333333333
84510, 1.825, 0.625, 0.20833333333333
84511, 1.825, 0.6, 0.1875
84512, 1.8041666666667, 0.6, 0.20833333333333
84513, 1.825, 0.575, 0.20833333333333
84514, 1.825, 0.55, 0.1875
84515, 1.8041666666667, 0.55, 0.20833333333333
84516, 1.825, 0.525, 0.20833333333333
84517, 1.825, 0.5, 0.1875
84518, 1.8041666666667, 0.5, 0.20833333333333
84519, 1.825, 0.475, 0.20833333333333
84520, 1.825, 0.45, 0.1875
84521, 1.8041666666667, 0.45, 0.20833333333333
84522, 1.825, 0.425, 0.20833333333333
84523, 1.825, 0.4, 0.1875
84524, 1.8041666666667, 0.4, 0.20833333333333
84525, 1.825, 0.375, 0.20833333333333
84526, 1.825, 0.35, 0.1875
84527, 1.8041666666667, 0.35, 0.20833333333333
84528, 1.825, 0.325, 0.20833333333333
84529, 1.825, 0.3, 0.1875
84530, 1.8041666666667, 0.3, 0.20833333333333
84531, 1.825, 0.275, 0.20833333333333
84532, 1.825, 0.25, 0.1875
84533, 1.8041666666667, 0.25, 0.20833333333333
84534, 1.825, 0.225, 0.20833333333333
84535, 1.825, 0.2, 0.1875
84536, 1.8041666666667, 0.2, 0.20833333333333
84537, 1.825, 0.175, 0.20833333333333
84538, 1.8666666666667, 1.325, 0.20833333333333
84539, 1.8666666666667, 1.3, 0.1875
84540, 1.8458333333333, 1.3, 0.20833333333333
84541, 1.8666666666667, 1.275, 0.20833333333333
84542, 1.8666666666667, 1.25, 0.1875
84543, 1.8458333333333, 1.25, 0.20833333333333
84544, 1.8666666666667, 1.225, 0.20833333333333
84545, 1.8666666666667, 1.2, 0.1875
84546, 1.8458333333333, 1.2, 0.20833333333333
84547, 1.8666666666667, 1.175, 0.20833333333333
84548, 1.8666666666667, 1.15, 0.1875
84549, 1.8458333333333, 1.15, 0.20833333333333
84550, 1.8666666666667, 1.125, 0.20833333333333
84551, 1.8666666666667, 1.1, 0.1875
84552, 1.8458333333333, 1.1, 0.20833333333333
84553, 1.8666666666667, 1.075, 0.20833333333333
84554, 1.8666666666667, 1.05, 0.1875
84555, 1.8458333333333, 1.05, 0.20833333333333
84556, 1.8666666666667, 1.025, 0.20833333333333
84557, 1.8666666666667, 1, 0.1875
84558, 1.8458333333333, 1, 0.20833333333333
84559, 1.8666666666667, 0.975, 0.20833333333333
84560, 1.8666666666667, 0.95, 0.1875
84561, 1.8458333333333, 0.95, 0.20833333333333
84562, 1.8666666666667, 0.925, 0.20833333333333
84563, 1.8666666666667, 0.9, 0.1875
84564, 1.8458333333333, 0.9, 0.20833333333333
84565, 1.8666666666667, 0.875, 0.20833333333333
84566, 1.8666666666667, 0.85, 0.1875
84567, 1.8458333333333, 0.85, 0.20833333333333
84568, 1.8666666666667, 0.825, 0.20833333333333
84569, 1.8666666666667, 0.8, 0.1875
84570, 1.8458333333333, 0.8, 0.20833333333333
84571, 1.8666666666667, 0.775, 0.20833333333333
84572, 1.8666666666667, 0.75, 0.1875
84573, 1.8458333333333, 0.75, 0.20833333333333
84574, 1.8666666666667, 0.725, 0.20833333333333
84575, 1.8666666666667, 0.7, 0.1875
84576, 1.8458333333333, 0.7, 0.20833333333333
84577, 1.8666666666667, 0.675, 0.20833333333333
84578, 1.8666666666667, 0.65, 0.1875
84579, 1.8458333333333, 0.65, 0.20833333333333
84580, 1.8666666666667, 0.625, 0.20833333333333
84581, 1.8666666666667, 0.6, 0.1875
84582, 1.8458333333333, 0.6, 0.20833333333333
84583, 1.8666666666667, 0.575, 0.20833333333333
84584, 1.8666666666667, 0.55, 0.1875
84585, 1.8458333333333, 0.55, 0.20833333333333
84586, 1.8666666666667, 0.525, 0.20833333333333
84587, 1.8666666666667, 0.5, 0.1875
84588, 1.8458333333333, 0.5, 0.20833333333333
84589, 1.8666666666667, 0.475, 0.20833333333333
84590, 1.8666666666667, 0.45, 0.1875
84591, 1.8458333333333, 0.45, 0.20833333333333
84592, 1.8666666666667, 0.425, 0.20833333333333
84593, 1.8666666666667, 0.4, 0.1875
84594, 1.8458333333333, 0.4, 0.20833333333333
84595, 1.8666666666667, 0.375, 0.20833333333333
84596, 1.8666666666667, 0.35, 0.1875
84597, 1.8458333333333, 0.35, 0.20833333333333
84598, 1.8666666666667, 0.325, 0.20833333333333
84599, 1.8666666666667, 0.3, 0.1875
84600, 1.8458333333333, 0.3, 0.20833333333333
84601, 1.8666666666667, 0.275, 0.20833333333333
84602, 1.8666666666667, 0.25, 0.1875
84603, 1.8458333333333, 0.25, 0.20833333333333
84604, 1.8666666666667, 0.225, 0.20833333333333
84605, 1.8666666666667, 0.2, 0.1875
84606, 1.8458333333333, 0.2, 0.20833333333333
84607, 1.8666666666667, 0.175, 0.20833333333333
84608, 1.9083333333333, 1.325, 0.20833333333333
84609, 1.9083333333333, 1.3, 0.1875
84610, 1.8875, 1.3, 0.20833333333333
84611, 1.9083333333333, 1.275, 0.20833333333333
84612, 1.9083333333333, 1.25, 0.1875
84613, 1.8875, 1.25, 0.20833333333333
84614, 1.9083333333333, 1.225, 0.20833333333333
84615, 1.9083333333333, 1.2, 0.1875
84616, 1.8875, 1.2, 0.20833333333333
84617, 1.9083333333333, 1.175, 0.20833333333333
84618, 1.9083333333333, 1.15, 0.1875
84619, 1.8875, 1.15, 0.20833333333333
84620, 1.9083333333333, 1.125, 0.20833333333333
84621, 1.9083333333333, 1.1, 0.1875
84622, 1.8875, 1.1, 0.20833333333333
84623, 1.9083333333333, 1.075, 0.20833333333333
84624, 1.9083333333333, 1.05, 0.1875
84625, 1.8875, 1.05, 0.20833333333333
84626, 1.9083333333333, 1.025, 0.20833333333333
84627, 1.9083333333333, 1, 0.1875
84628, 1.8875, 1, 0.20833333333333
84629, 1.9083333333333, 0.975, 0.20833333333333
84630, 1.9083333333333, 0.95, 0.1875
84631, 1.8875, 0.95, 0.20833333333333
84632, 1.9083333333333, 0.925, 0.20833333333333
84633, 1.9083333333333, 0.9, 0.1875
84634, 1.8875, 0.9, 0.20833333333333
84635, 1.9083333333333, 0.875, 0.20833333333333
84636, 1.9083333333333, 0.85, 0.1875
84637, 1.8875, 0.85, 0.20833333333333
84638, 1.9083333333333, 0.825, 0.20833333333333
84639, 1.9083333333333, 0.8, 0.1875
84640, 1.8875, 0.8, 0.20833333333333
84641, 1.9083333333333, 0.775, 0.20833333333333
84642, 1.9083333333333, 0.75, 0.1875
84643, 1.8875, 0.75, 0.20833333333333
84644, 1.9083333333333, 0.725, 0.20833333333333
84645, 1.9083333333333, 0.7, 0.1875
84646, 1.8875, 0.7, 0.20833333333333
84647, 1.9083333333333, 0.675, 0.20833333333333
84648, 1.9083333333333, 0.65, 0.1875
84649, 1.8875, 0.65, 0.20833333333333
84650, 1.9083333333333, 0.625, 0.20833333333333
84651, 1.9083333333333, 0.6, 0.1875
84652, 1.8875, 0.6, 0.20833333333333
84653, 1.9083333333333, 0.575, 0.20833333333333
84654, 1.9083333333333, 0.55, 0.1875
84655, 1.8875, 0.55, 0.20833333333333
84656, 1.9083333333333, 0.525, 0.20833333333333
84657, 1.9083333333333, 0.5, 0.1875
84658, 1.8875, 0.5, 0.20833333333333
84659, 1.9083333333333, 0.475, 0.20833333333333
84660, 1.9083333333333, 0.45, 0.1875
84661, 1.8875, 0.45, 0.20833333333333
84662, 1.9083333333333, 0.425, 0.20833333333333
84663, 1.9083333333333, 0.4, 0.1875
84664, 1.8875, 0.4, 0.20833333333333
84665, 1.9083333333333, 0.375, 0.20833333333333
84666, 1.9083333333333, 0.35, 0.1875
84667, 1.8875, 0.35, 0.20833333333333
84668, 1.9083333333333, 0.325, 0.20833333333333
84669, 1.9083333333333, 0.3, 0.1875
84670, 1.8875, 0.3, 0.20833333333333
84671, 1.9083333333333, 0.275, 0.20833333333333
84672, 1.9083333333333, 0.25, 0.1875
84673, 1.8875, 0.25, 0.20833333333333
84674, 1.9083333333333, 0.225, 0.20833333333333
84675, 1.9083333333333, 0.2, 0.1875
84676, 1.8875, 0.2, 0.20833333333333
84677, 1.9083333333333, 0.175, 0.20833333333333
84678, 1.95, 1.325, 0.20833333333333
84679, 1.95, 1.3, 0.1875
84680, 1.9291666666667, 1.3, 0.20833333333333
84681, 1.95, 1.275, 0.20833333333333
84682, 1.95, 1.25, 0.1875
84683, 1.9291666666667, 1.25, 0.20833333333333
84684, 1.95, 1.225, 0.20833333333333
84685, 1.95, 1.2, 0.1875
84686, 1.9291666666667, 1.2, 0.20833333333333
84687, 1.95, 1.175, 0.20833333333333
84688, 1.95, 1.15, 0.1875
84689, 1.9291666666667, 1.15, 0.20833333333333
84690, 1.95, 1.125, 0.20833333333333
84691, 1.95, 1.1, 0.1875
84692, 1.9291666666667, 1.1, 0.20833333333333
84693, 1.95, 1.075, 0.20833333333333
84694, 1.95, 1.05, 0.1875
84695, 1.9291666666667, 1.05, 0.20833333333333
84696, 1.95, 1.025, 0.20833333333333
84697, 1.95, 1, 0.1875
84698, 1.9291666666667, 1, 0.20833333333333
84699, 1.95, 0.975, 0.20833333333333
84700, 1.95, 0.95, 0.1875
84701, 1.9291666666667, 0.95, 0.20833333333333
84702, 1.95, 0.925, 0.20833333333333
84703, 1.95, 0.9, 0.1875
84704, 1.9291666666667, 0.9, 0.20833333333333
84705, 1.95, 0.875, 0.20833333333333
84706, 1.95, 0.85, 0.1875
84707, 1.9291666666667, 0.85, 0.20833333333333
84708, 1.95, 0.825, 0.20833333333333
84709, 1.95, 0.8, 0.1875
84710, 1.9291666666667, 0.8, 0.20833333333333
84711, 1.95, 0.775, 0.20833333333333
84712, 1.95, 0.75, 0.1875
84713, 1.9291666666667, 0.75, 0.20833333333333
84714, 1.95, 0.725, 0.20833333333333
84715, 1.95, 0.7, 0.1875
84716, 1.9291666666667, 0.7, 0.20833333333333
84717, 1.95, 0.675, 0.20833333333333
84718, 1.95, 0.65, 0.1875
84719, 1.9291666666667, 0.65, 0.20833333333333
84720, 1.95, 0.625, 0.20833333333333
84721, 1.95, 0.6, 0.1875
84722, 1.9291666666667, 0.6, 0.20833333333333
84723, 1.95, 0.575, 0.20833333333333
84724, 1.95, 0.55, 0.1875
84725, 1.9291666666667, 0.55, 0.20833333333333
84726, 1.95, 0.525, 0.20833333333333
84727, 1.95, 0.5, 0.1875
84728, 1.9291666666667, 0.5, 0.20833333333333
84729, 1.95, 0.475, 0.20833333333333
84730, 1.95, 0.45, 0.1875
84731, 1.9291666666667, 0.45, 0.20833333333333
84732, 1.95, 0.425, 0.20833333333333
84733, 1.95, 0.4, 0.1875
84734, 1.9291666666667, 0.4, 0.20833333333333
84735, 1.95, 0.375, 0.20833333333333
84736, 1.95, 0.35, 0.1875
84737, 1.9291666666667, 0.35, 0.20833333333333
84738, 1.95, 0.325, 0.20833333333333
84739, 1.95, 0.3, 0.1875
84740, 1.9291666666667, 0.3, 0.20833333333333
84741, 1.95, 0.275, 0.20833333333333
84742, 1.95, 0.25, 0.1875
84743, 1.9291666666667, 0.25, 0.20833333333333
84744, 1.95, 0.225, 0.20833333333333
84745, 1.95, 0.2, 0.1875
84746, 1.9291666666667, 0.2, 0.20833333333333
84747, 1.95, 0.175, 0.20833333333333
84748, 1.9916666666667, 1.325, 0.20833333333333
84749, 1.9916666666667, 1.3, 0.1875
84750, 1.9708333333333, 1.3, 0.20833333333333
84751, 1.9916666666667, 1.275, 0.20833333333333
84752, 1.9916666666667, 1.25, 0.1875
84753, 1.9708333333333, 1.25, 0.20833333333333
84754, 1.9916666666667, 1.225, 0.20833333333333
84755, 1.9916666666667, 1.2, 0.1875
84756, 1.9708333333333, 1.2, 0.20833333333333
84757, 1.9916666666667, 1.175, 0.20833333333333
84758, 1.9916666666667, 1.15, 0.1875
84759, 1.9708333333333, 1.15, 0.20833333333333
84760, 1.9916666666667, 1.125, 0.20833333333333
84761, 1.9916666666667, 1.1, 0.1875
84762, 1.9708333333333, 1.1, 0.20833333333333
84763, 1.9916666666667, 1.075, 0.20833333333333
84764, 1.9916666666667, 1.05, 0.1875
84765, 1.9708333333333, 1.05, 0.20833333333333
84766, 1.9916666666667, 1.025, 0.20833333333333
84767, 1.9916666666667, 1, 0.1875
84768, 1.9708333333333, 1, 0.20833333333333
84769, 1.9916666666667, 0.975, 0.20833333333333
84770, 1.9916666666667, 0.95, 0.1875
84771, 1.9708333333333, 0.95, 0.20833333333333
84772, 1.9916666666667, 0.925, 0.20833333333333
84773, 1.9916666666667, 0.9, 0.1875
84774, 1.9708333333333, 0.9, 0.20833333333333
84775, 1.9916666666667, 0.875, 0.20833333333333
84776, 1.9916666666667, 0.85, 0.1875
84777, 1.9708333333333, 0.85, 0.20833333333333
84778, 1.9916666666667, 0.825, 0.20833333333333
84779, 1.9916666666667, 0.8, 0.1875
84780, 1.9708333333333, 0.8, 0.20833333333333
84781, 1.9916666666667, 0.775, 0.20833333333333
84782, 1.9916666666667, 0.75, 0.1875
84783, 1.9708333333333, 0.75, 0.20833333333333
84784, 1.9916666666667, 0.725, 0.20833333333333
84785, 1.9916666666667, 0.7, 0.1875
84786, 1.9708333333333, 0.7, 0.20833333333333
84787, 1.9916666666667, 0.675, 0.20833333333333
84788, 1.9916666666667, 0.65, 0.1875
84789, 1.9708333333333, 0.65, 0.20833333333333
84790, 1.9916666666667, 0.625, 0.20833333333333
84791, 1.9916666666667, 0.6, 0.1875
84792, 1.9708333333333, 0.6, 0.20833333333333
84793, 1.9916666666667, 0.575, 0.20833333333333
84794, 1.9916666666667, 0.55, 0.1875
84795, 1.9708333333333, 0.55, 0.20833333333333
84796, 1.9916666666667, 0.525, 0.20833333333333
84797, 1.9916666666667, 0.5, 0.1875
84798, 1.9708333333333, 0.5, 0.20833333333333
84799, 1.9916666666667, 0.475, 0.20833333333333
84800, 1.9916666666667, 0.45, 0.1875
84801, 1.9708333333333, 0.45, 0.20833333333333
84802, 1.9916666666667, 0.425, 0.20833333333333
84803, 1.9916666666667, 0.4, 0.1875
84804, 1.9708333333333, 0.4, 0.20833333333333
84805, 1.9916666666667, 0.375, 0.20833333333333
84806, 1.9916666666667, 0.35, 0.1875
84807, 1.9708333333333, 0.35, 0.20833333333333
84808, 1.9916666666667, 0.325, 0.20833333333333
84809, 1.9916666666667, 0.3, 0.1875
84810, 1.9708333333333, 0.3, 0.20833333333333
84811, 1.9916666666667, 0.275, 0.20833333333333
84812, 1.9916666666667, 0.25, 0.1875
84813, 1.9708333333333, 0.25, 0.20833333333333
84814, 1.9916666666667, 0.225, 0.20833333333333
84815, 1.9916666666667, 0.2, 0.1875
84816, 1.9708333333333, 0.2, 0.20833333333333
84817, 1.9916666666667, 0.175, 0.20833333333333
84818, 2.0333333333333, 1.325, 0.20833333333333
84819, 2.0333333333333, 1.3, 0.1875
84820, 2.0125, 1.3, 0.20833333333333
84821, 2.0333333333333, 1.275, 0.20833333333333
84822, 2.0333333333333, 1.25, 0.1875
84823, 2.0125, 1.25, 0.20833333333333
84824, 2.0333333333333, 1.225, 0.20833333333333
84825, 2.0333333333333, 1.2, 0.1875
84826, 2.0125, 1.2, 0.20833333333333
84827, 2.0333333333333, 1.175, 0.20833333333333
84828, 2.0333333333333, 1.15, 0.1875
84829, 2.0125, 1.15, 0.20833333333333
84830, 2.0333333333333, 1.125, 0.20833333333333
84831, 2.0333333333333, 1.1, 0.1875
84832, 2.0125, 1.1, 0.20833333333333
84833, 2.0333333333333, 1.075, 0.20833333333333
84834, 2.0333333333333, 1.05, 0.1875
84835, 2.0125, 1.05, 0.20833333333333
84836, 2.0333333333333, 1.025, 0.20833333333333
84837, 2.0333333333333, 1, 0.1875
84838, 2.0125, 1, 0.20833333333333
84839, 2.0333333333333, 0.975, 0.20833333333333
84840, 2.0333333333333, 0.95, 0.1875
84841, 2.0125, 0.95, 0.20833333333333
84842, 2.0333333333333, 0.925, 0.20833333333333
84843, 2.0333333333333, 0.9, 0.1875
84844, 2.0125, 0.9, 0.20833333333333
84845, 2.0333333333333, 0.875, 0.20833333333333
84846, 2.0333333333333, 0.85, 0.1875
84847, 2.0125, 0.85, 0.20833333333333
84848, 2.0333333333333, 0.825, 0.20833333333333
84849, 2.0333333333333, 0.8, 0.1875
84850, 2.0125, 0.8, 0.20833333333333
84851, 2.0333333333333, 0.775, 0.20833333333333
84852, 2.0333333333333, 0.75, 0.1875
84853, 2.0125, 0.75, 0.20833333333333
84854, 2.0333333333333, 0.725, 0.20833333333333
84855, 2.0333333333333, 0.7, 0.1875
84856, 2.0125, 0.7, 0.20833333333333
84857, 2.0333333333333, 0.675, 0.20833333333333
84858, 2.0333333333333, 0.65, 0.1875
84859, 2.0125, 0.65, 0.20833333333333
84860, 2.0333333333333, 0.625, 0.20833333333333
84861, 2.0333333333333, 0.6, 0.1875
84862, 2.0125, 0.6, 0.20833333333333
84863, 2.0333333333333, 0.575, 0.20833333333333
84864, 2.0333333333333, 0.55, 0.1875
84865, 2.0125, 0.55, 0.20833333333333
84866, 2.0333333333333, 0.525, 0.20833333333333
84867, 2.0333333333333, 0.5, 0.1875
84868, 2.0125, 0.5, 0.20833333333333
84869, 2.0333333333333, 0.475, 0.20833333333333
84870, 2.0333333333333, 0.45, 0.1875
84871, 2.0125, 0.45, 0.20833333333333
84872, 2.0333333333333, 0.425, 0.20833333333333
84873, 2.0333333333333, 0.4, 0.1875
84874, 2.0125, 0.4, 0.20833333333333
84875, 2.0333333333333, 0.375, 0.20833333333333
84876, 2.0333333333333, 0.35, 0.1875
