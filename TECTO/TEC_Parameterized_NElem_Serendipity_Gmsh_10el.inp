27663, 99624, 99625, 99648, 99647
35897, 21476, 21477, 21500, 21499, 27132, 27133, 27156, 27155, 21965, 22011, 22012, 22009, 27621, 27667, 27668, 
27665, 99625, 99626, 99649, 99648
35898, 21477, 21478, 21501, 21500, 27133, 27134, 27157, 27156, 21967, 22013, 22014, 22011, 27623, 27669, 27670, 
27667, 99626, 99627, 99650, 99649
35899, 21478, 21479, 21502, 21501, 27134, 27135, 27158, 27157, 21969, 22015, 22016, 22013, 27625, 27671, 27672, 
27669, 99627, 99628, 99651, 99650
35900, 21479, 21480, 21503, 21502, 27135, 27136, 27159, 27158, 21971, 22017, 22018, 22015, 27627, 27673, 27674, 
27671, 99628, 99629, 99652, 99651
35901, 21480, 21481, 21504, 21503, 27136, 27137, 27160, 27159, 21973, 22019, 22020, 22017, 27629, 27675, 27676, 
27673, 99629, 99630, 99653, 99652
35902, 21481, 1944, 1945, 21504, 27137, 2679, 2680, 27160, 21974, 1956, 22021, 22019, 27630, 2691, 27677, 
27675, 99630, 26906, 26907, 99653
35903, 1617, 21482, 1653, 33, 2657, 27138, 2551, 61, 21976, 22022, 1676, 1629, 27632, 27678, 2574, 
2669, 26896, 99631, 26840, 2549
35904, 21482, 21483, 1654, 1653, 27138, 27139, 2552, 2551, 21978, 22023, 1677, 22022, 27634, 27679, 2575, 
27678, 99631, 99632, 26841, 26840
35905, 21483, 21484, 1655, 1654, 27139, 27140, 2553, 2552, 21980, 22024, 1678, 22023, 27636, 27680, 2576, 
27679, 99632, 99633, 26842, 26841
35906, 21484, 21485, 1656, 1655, 27140, 27141, 2554, 2553, 21982, 22025, 1679, 22024, 27638, 27681, 2577, 
27680, 99633, 99634, 26843, 26842
35907, 21485, 21486, 1657, 1656, 27141, 27142, 2555, 2554, 21984, 22026, 1680, 22025, 27640, 27682, 2578, 
27681, 99634, 99635, 26844, 26843
35908, 21486, 21487, 1658, 1657, 27142, 27143, 2556, 2555, 21986, 22027, 1681, 22026, 27642, 27683, 2579, 
27682, 99635, 99636, 26845, 26844
35909, 21487, 21488, 1659, 1658, 27143, 27144, 2557, 2556, 21988, 22028, 1682, 22027, 27644, 27684, 2580, 
27683, 99636, 99637, 26846, 26845
35910, 21488, 21489, 1660, 1659, 27144, 27145, 2558, 2557, 21990, 22029, 1683, 22028, 27646, 27685, 2581, 
27684, 99637, 99638, 26847, 26846
35911, 21489, 21490, 1661, 1660, 27145, 27146, 2559, 2558, 21992, 22030, 1684, 22029, 27648, 27686, 2582, 
27685, 99638, 99639, 26848, 26847
35912, 21490, 21491, 1662, 1661, 27146, 27147, 2560, 2559, 21994, 22031, 1685, 22030, 27650, 27687, 2583, 
27686, 99639, 99640, 26849, 26848
35913, 21491, 21492, 1663, 1662, 27147, 27148, 2561, 2560, 21996, 22032, 1686, 22031, 27652, 27688, 2584, 
27687, 99640, 99641, 26850, 26849
35914, 21492, 21493, 1664, 1663, 27148, 27149, 2562, 2561, 21998, 22033, 1687, 22032, 27654, 27689, 2585, 
27688, 99641, 99642, 26851, 26850
35915, 21493, 21494, 1665, 1664, 27149, 27150, 2563, 2562, 22000, 22034, 1688, 22033, 27656, 27690, 2586, 
27689, 99642, 99643, 26852, 26851
35916, 21494, 21495, 1666, 1665, 27150, 27151, 2564, 2563, 22002, 22035, 1689, 22034, 27658, 27691, 2587, 
27690, 99643, 99644, 26853, 26852
35917, 21495, 21496, 1667, 1666, 27151, 27152, 2565, 2564, 22004, 22036, 1690, 22035, 27660, 27692, 2588, 
27691, 99644, 99645, 26854, 26853
35918, 21496, 21497, 1668, 1667, 27152, 27153, 2566, 2565, 22006, 22037, 1691, 22036, 27662, 27693, 2589, 
27692, 99645, 99646, 26855, 26854
35919, 21497, 21498, 1669, 1668, 27153, 27154, 2567, 2566, 22008, 22038, 1692, 22037, 27664, 27694, 2590, 
27693, 99646, 99647, 26856, 26855
35920, 21498, 21499, 1670, 1669, 27154, 27155, 2568, 2567, 22010, 22039, 1693, 22038, 27666, 27695, 2591, 
27694, 99647, 99648, 26857, 26856
35921, 21499, 21500, 1671, 1670, 27155, 27156, 2569, 2568, 22012, 22040, 1694, 22039, 27668, 27696, 2592, 
27695, 99648, 99649, 26858, 26857
35922, 21500, 21501, 1672, 1671, 27156, 27157, 2570, 2569, 22014, 22041, 1695, 22040, 27670, 27697, 2593, 
27696, 99649, 99650, 26859, 26858
35923, 21501, 21502, 1673, 1672, 27157, 27158, 2571, 2570, 22016, 22042, 1696, 22041, 27672, 27698, 2594, 
27697, 99650, 99651, 26860, 26859
35924, 21502, 21503, 1674, 1673, 27158, 27159, 2572, 2571, 22018, 22043, 1697, 22042, 27674, 27699, 2595, 
27698, 99651, 99652, 26861, 26860
35925, 21503, 21504, 1675, 1674, 27159, 27160, 2573, 2572, 22020, 22044, 1698, 22043, 27676, 27700, 2596, 
27699, 99652, 99653, 26862, 26861
35926, 21504, 1945, 37, 1675, 27160, 2680, 62, 2573, 22021, 1957, 1699, 22044, 27677, 2692, 2597, 
27700, 99653, 26907, 2550, 26862
*ELEMENT, type=C3D20, ELSET=Volume18
35927, 35, 1794, 2600, 63, 69, 2887, 3081, 73, 1817, 26863, 2623, 2598, 2910, 31174, 3104, 
3078, 2885, 29426, 31151, 3077
35928, 1794, 1795, 2601, 2600, 2887, 2888, 3082, 3081, 1818, 26864, 2624, 26863, 2911, 31175, 3105, 
31174, 29426, 29427, 31152, 31151
35929, 1795, 1796, 2602, 2601, 2888, 2889, 3083, 3082, 1819, 26865, 2625, 26864, 2912, 31176, 3106, 
31175, 29427, 29428, 31153, 31152
35930, 1796, 1797, 2603, 2602, 2889, 2890, 3084, 3083, 1820, 26866, 2626, 26865, 2913, 31177, 3107, 
31176, 29428, 29429, 31154, 31153
35931, 1797, 1798, 2604, 2603, 2890, 2891, 3085, 3084, 1821, 26867, 2627, 26866, 2914, 31178, 3108, 
31177, 29429, 29430, 31155, 31154
35932, 1798, 1799, 2605, 2604, 2891, 2892, 3086, 3085, 1822, 26868, 2628, 26867, 2915, 31179, 3109, 
31178, 29430, 29431, 31156, 31155
35933, 1799, 1800, 2606, 2605, 2892, 2893, 3087, 3086, 1823, 26869, 2629, 26868, 2916, 31180, 3110, 
31179, 29431, 29432, 31157, 31156
35934, 1800, 1801, 2607, 2606, 2893, 2894, 3088, 3087, 1824, 26870, 2630, 26869, 2917, 31181, 3111, 
31180, 29432, 29433, 31158, 31157
35935, 1801, 1802, 2608, 2607, 2894, 2895, 3089, 3088, 1825, 26871, 2631, 26870, 2918, 31182, 3112, 
31181, 29433, 29434, 31159, 31158
35936, 1802, 1803, 2609, 2608, 2895, 2896, 3090, 3089, 1826, 26872, 2632, 26871, 2919, 31183, 3113, 
31182, 29434, 29435, 31160, 31159
35937, 1803, 1804, 2610, 2609, 2896, 2897, 3091, 3090, 1827, 26873, 2633, 26872, 2920, 31184, 3114, 
31183, 29435, 29436, 31161, 31160
35938, 1804, 1805, 2611, 2610, 2897, 2898, 3092, 3091, 1828, 26874, 2634, 26873, 2921, 31185, 3115, 
31184, 29436, 29437, 31162, 31161
35939, 1805, 1806, 2612, 2611, 2898, 2899, 3093, 3092, 1829, 26875, 2635, 26874, 2922, 31186, 3116, 
31185, 29437, 29438, 31163, 31162
35940, 1806, 1807, 2613, 2612, 2899, 2900, 3094, 3093, 1830, 26876, 2636, 26875, 2923, 31187, 3117, 
31186, 29438, 29439, 31164, 31163
35941, 1807, 1808, 2614, 2613, 2900, 2901, 3095, 3094, 1831, 26877, 2637, 26876, 2924, 31188, 3118, 
31187, 29439, 29440, 31165, 31164
35942, 1808, 1809, 2615, 2614, 2901, 2902, 3096, 3095, 1832, 26878, 2638, 26877, 2925, 31189, 3119, 
31188, 29440, 29441, 31166, 31165
35943, 1809, 1810, 2616, 2615, 2902, 2903, 3097, 3096, 1833, 26879, 2639, 26878, 2926, 31190, 3120, 
31189, 29441, 29442, 31167, 31166
35944, 1810, 1811, 2617, 2616, 2903, 2904, 3098, 3097, 1834, 26880, 2640, 26879, 2927, 31191, 3121, 
31190, 29442, 29443, 31168, 31167
35945, 1811, 1812, 2618, 2617, 2904, 2905, 3099, 3098, 1835, 26881, 2641, 26880, 2928, 31192, 3122, 
31191, 29443, 29444, 31169, 31168
35946, 1812, 1813, 2619, 2618, 2905, 2906, 3100, 3099, 1836, 26882, 2642, 26881, 2929, 31193, 3123, 
31192, 29444, 29445, 31170, 31169
35947, 1813, 1814, 2620, 2619, 2906, 2907, 3101, 3100, 1837, 26883, 2643, 26882, 2930, 31194, 3124, 
31193, 29445, 29446, 31171, 31170
35948, 1814, 1815, 2621, 2620, 2907, 2908, 3102, 3101, 1838, 26884, 2644, 26883, 2931, 31195, 3125, 
31194, 29446, 29447, 31172, 31171
35949, 1815, 1816, 2622, 2621, 2908, 2909, 3103, 3102, 1839, 26885, 2645, 26884, 2932, 31196, 3126, 
31195, 29447, 29448, 31173, 31172
35950, 1816, 39, 64, 2622, 2909, 70, 74, 3103, 1840, 2599, 2646, 26885, 2933, 3080, 3127, 
31196, 29448, 2886, 3079, 31173
*ELEMENT, type=C3D20, ELSET=Volume19
35951, 9, 541, 2456, 59, 65, 2695, 3132, 75, 564, 26002, 2479, 2454, 2718, 31220, 3155, 
3129, 2693, 27701, 31197, 3128
35952, 541, 542, 2457, 2456, 2695, 2696, 3133, 3132, 565, 26003, 2480, 26002, 2719, 31221, 3156, 
31220, 27701, 27702, 31198, 31197
35953, 542, 543, 2458, 2457, 2696, 2697, 3134, 3133, 566, 26004, 2481, 26003, 2720, 31222, 3157, 
31221, 27702, 27703, 31199, 31198
35954, 543, 544, 2459, 2458, 2697, 2698, 3135, 3134, 567, 26005, 2482, 26004, 2721, 31223, 3158, 
31222, 27703, 27704, 31200, 31199
35955, 544, 545, 2460, 2459, 2698, 2699, 3136, 3135, 568, 26006, 2483, 26005, 2722, 31224, 3159, 
31223, 27704, 27705, 31201, 31200
35956, 545, 546, 2461, 2460, 2699, 2700, 3137, 3136, 569, 26007, 2484, 26006, 2723, 31225, 3160, 
31224, 27705, 27706, 31202, 31201
35957, 546, 547, 2462, 2461, 2700, 2701, 3138, 3137, 570, 26008, 2485, 26007, 2724, 31226, 3161, 
31225, 27706, 27707, 31203, 31202
35958, 547, 548, 2463, 2462, 2701, 2702, 3139, 3138, 571, 26009, 2486, 26008, 2725, 31227, 3162, 
31226, 27707, 27708, 31204, 31203
35959, 548, 549, 2464, 2463, 2702, 2703, 3140, 3139, 572, 26010, 2487, 26009, 2726, 31228, 3163, 
31227, 27708, 27709, 31205, 31204
35960, 549, 550, 2465, 2464, 2703, 2704, 3141, 3140, 573, 26011, 2488, 26010, 2727, 31229, 3164, 
31228, 27709, 27710, 31206, 31205
35961, 550, 551, 2466, 2465, 2704, 2705, 3142, 3141, 574, 26012, 2489, 26011, 2728, 31230, 3165, 
31229, 27710, 27711, 31207, 31206
35962, 551, 552, 2467, 2466, 2705, 2706, 3143, 3142, 575, 26013, 2490, 26012, 2729, 31231, 3166, 
31230, 27711, 27712, 31208, 31207
35963, 552, 553, 2468, 2467, 2706, 2707, 3144, 3143, 576, 26014, 2491, 26013, 2730, 31232, 3167, 
31231, 27712, 27713, 31209, 31208
35964, 553, 554, 2469, 2468, 2707, 2708, 3145, 3144, 577, 26015, 2492, 26014, 2731, 31233, 3168, 
31232, 27713, 27714, 31210, 31209
35965, 554, 555, 2470, 2469, 2708, 2709, 3146, 3145, 578, 26016, 2493, 26015, 2732, 31234, 3169, 
31233, 27714, 27715, 31211, 31210
35966, 555, 556, 2471, 2470, 2709, 2710, 3147, 3146, 579, 26017, 2494, 26016, 2733, 31235, 3170, 
31234, 27715, 27716, 31212, 31211
35967, 556, 557, 2472, 2471, 2710, 2711, 3148, 3147, 580, 26018, 2495, 26017, 2734, 31236, 3171, 
31235, 27716, 27717, 31213, 31212
35968, 557, 558, 2473, 2472, 2711, 2712, 3149, 3148, 581, 26019, 2496, 26018, 2735, 31237, 3172, 
31236, 27717, 27718, 31214, 31213
35969, 558, 559, 2474, 2473, 2712, 2713, 3150, 3149, 582, 26020, 2497, 26019, 2736, 31238, 3173, 
31237, 27718, 27719, 31215, 31214
35970, 559, 560, 2475, 2474, 2713, 2714, 3151, 3150, 583, 26021, 2498, 26020, 2737, 31239, 3174, 
31238, 27719, 27720, 31216, 31215
35971, 560, 561, 2476, 2475, 2714, 2715, 3152, 3151, 584, 26022, 2499, 26021, 2738, 31240, 3175, 
31239, 27720, 27721, 31217, 31216
35972, 561, 562, 2477, 2476, 2715, 2716, 3153, 3152, 585, 26023, 2500, 26022, 2739, 31241, 3176, 
31240, 27721, 27722, 31218, 31217
35973, 562, 563, 2478, 2477, 2716, 2717, 3154, 3153, 586, 26024, 2501, 26023, 2740, 31242, 3177, 
31241, 27722, 27723, 31219, 31218
35974, 563, 13, 60, 2478, 2717, 66, 76, 3154, 587, 2455, 2502, 26024, 2741, 3131, 3178, 
31242, 27723, 2694, 3130, 31219
*ELEMENT, type=C3D20, ELSET=Volume20
35975, 22, 1150, 13908, 1023, 3188, 31996, 99654, 31243, 1161, 14161, 14162, 1046, 32041, 100667, 100668, 
31335, 3192, 32040, 100666, 31336
35976, 3188, 31996, 99654, 31243, 3189, 31997, 99655, 31244, 32041, 100667, 100668, 31335, 32043, 100670, 100671, 
31337, 3193, 32042, 100669, 31338
35977, 3189, 31997, 99655, 31244, 3190, 31998, 99656, 31245, 32043, 100670, 100671, 31337, 32045, 100673, 100674, 
31339, 3194, 32044, 100672, 31340
35978, 3190, 31998, 99656, 31245, 3191, 31999, 99657, 31246, 32045, 100673, 100674, 31339, 32047, 100676, 100677, 
31341, 3195, 32046, 100675, 31342
35979, 3191, 31999, 99657, 31246, 78, 3332, 32143, 3197, 32047, 100676, 100677, 31341, 3343, 32396, 32397, 
3220, 3196, 32048, 100678, 31343
35980, 1150, 1151, 13909, 13908, 31996, 32000, 99658, 99654, 1162, 14163, 14164, 14161, 32050, 100680, 100681, 
100667, 32040, 32049, 100679, 100666
35981, 31996, 32000, 99658, 99654, 31997, 32001, 99659, 99655, 32050, 100680, 100681, 100667, 32052, 100683, 100684, 
100670, 32042, 32051, 100682, 100669
35982, 31997, 32001, 99659, 99655, 31998, 32002, 99660, 99656, 32052, 100683, 100684, 100670, 32054, 100686, 100687, 
100673, 32044, 32053, 100685, 100672
35983, 31998, 32002, 99660, 99656, 31999, 32003, 99661, 99657, 32054, 100686, 100687, 100673, 32056, 100689, 100690, 
100676, 32046, 32055, 100688, 100675
35984, 31999, 32003, 99661, 99657, 3332, 3333, 32144, 32143, 32056, 100689, 100690, 100676, 3344, 32398, 32399, 
32396, 32048, 32057, 100691, 100678
35985, 1151, 1152, 13910, 13909, 32000, 32004, 99662, 99658, 1163, 14165, 14166, 14163, 32059, 100693, 100694, 
100680, 32049, 32058, 100692, 100679
35986, 32000, 32004, 99662, 99658, 32001, 32005, 99663, 99659, 32059, 100693, 100694, 100680, 32061, 100696, 100697, 
100683, 32051, 32060, 100695, 100682
35987, 32001, 32005, 99663, 99659, 32002, 32006, 99664, 99660, 32061, 100696, 100697, 100683, 32063, 100699, 100700, 
100686, 32053, 32062, 100698, 100685
35988, 32002, 32006, 99664, 99660, 32003, 32007, 99665, 99661, 32063, 100699, 100700, 100686, 32065, 100702, 100703, 
100689, 32055, 32064, 100701, 100688
35989, 32003, 32007, 99665, 99661, 3333, 3334, 32145, 32144, 32065, 100702, 100703, 100689, 3345, 32400, 32401, 
32398, 32057, 32066, 100704, 100691
35990, 1152, 1153, 13911, 13910, 32004, 32008, 99666, 99662, 1164, 14167, 14168, 14165, 32068, 100706, 100707, 
100693, 32058, 32067, 100705, 100692
35991, 32004, 32008, 99666, 99662, 32005, 32009, 99667, 99663, 32068, 100706, 100707, 100693, 32070, 100709, 100710, 
100696, 32060, 32069, 100708, 100695
35992, 32005, 32009, 99667, 99663, 32006, 32010, 99668, 99664, 32070, 100709, 100710, 100696, 32072, 100712, 100713, 
100699, 32062, 32071, 100711, 100698
35993, 32006, 32010, 99668, 99664, 32007, 32011, 99669, 99665, 32072, 100712, 100713, 100699, 32074, 100715, 100716, 
100702, 32064, 32073, 100714, 100701
35994, 32007, 32011, 99669, 99665, 3334, 3335, 32146, 32145, 32074, 100715, 100716, 100702, 3346, 32402, 32403, 
32400, 32066, 32075, 100717, 100704
35995, 1153, 1154, 13912, 13911, 32008, 32012, 99670, 99666, 1165, 14169, 14170, 14167, 32077, 100719, 100720, 
100706, 32067, 32076, 100718, 100705
35996, 32008, 32012, 99670, 99666, 32009, 32013, 99671, 99667, 32077, 100719, 100720, 100706, 32079, 100722, 100723, 
100709, 32069, 32078, 100721, 100708
35997, 32009, 32013, 99671, 99667, 32010, 32014, 99672, 99668, 32079, 100722, 100723, 100709, 32081, 100725, 100726, 
100712, 32071, 32080, 100724, 100711
35998, 32010, 32014, 99672, 99668, 32011, 32015, 99673, 99669, 32081, 100725, 100726, 100712, 32083, 100728, 100729, 
100715, 32073, 32082, 100727, 100714
35999, 32011, 32015, 99673, 99669, 3335, 3336, 32147, 32146, 32083, 100728, 100729, 100715, 3347, 32404, 32405, 
32402, 32075, 32084, 100730, 100717
36000, 1154, 1155, 13913, 13912, 32012, 32016, 99674, 99670, 1166, 14171, 14172, 14169, 32086, 100732, 100733, 
100719, 32076, 32085, 100731, 100718
36001, 32012, 32016, 99674, 99670, 32013, 32017, 99675, 99671, 32086, 100732, 100733, 100719, 32088, 100735, 100736, 
100722, 32078, 32087, 100734, 100721
36002, 32013, 32017, 99675, 99671, 32014, 32018, 99676, 99672, 32088, 100735, 100736, 100722, 32090, 100738, 100739, 
100725, 32080, 32089, 100737, 100724
36003, 32014, 32018, 99676, 99672, 32015, 32019, 99677, 99673, 32090, 100738, 100739, 100725, 32092, 100741, 100742, 
100728, 32082, 32091, 100740, 100727
36004, 32015, 32019, 99677, 99673, 3336, 3337, 32148, 32147, 32092, 100741, 100742, 100728, 3348, 32406, 32407, 
32404, 32084, 32093, 100743, 100730
36005, 1155, 1156, 13914, 13913, 32016, 32020, 99678, 99674, 1167, 14173, 14174, 14171, 32095, 100745, 100746, 
100732, 32085, 32094, 100744, 100731
36006, 32016, 32020, 99678, 99674, 32017, 32021, 99679, 99675, 32095, 100745, 100746, 100732, 32097, 100748, 100749, 
100735, 32087, 32096, 100747, 100734
36007, 32017, 32021, 99679, 99675, 32018, 32022, 99680, 99676, 32097, 100748, 100749, 100735, 32099, 100751, 100752, 
100738, 32089, 32098, 100750, 100737
36008, 32018, 32022, 99680, 99676, 32019, 32023, 99681, 99677, 32099, 100751, 100752, 100738, 32101, 100754, 100755, 
100741, 32091, 32100, 100753, 100740
36009, 32019, 32023, 99681, 99677, 3337, 3338, 32149, 32148, 32101, 100754, 100755, 100741, 3349, 32408, 32409, 
32406, 32093, 32102, 100756, 100743
36010, 1156, 1157, 13915, 13914, 32020, 32024, 99682, 99678, 1168, 14175, 14176, 14173, 32104, 100758, 100759, 
100745, 32094, 32103, 100757, 100744
36011, 32020, 32024, 99682, 99678, 32021, 32025, 99683, 99679, 32104, 100758, 100759, 100745, 32106, 100761, 100762, 
100748, 32096, 32105, 100760, 100747
36012, 32021, 32025, 99683, 99679, 32022, 32026, 99684, 99680, 32106, 100761, 100762, 100748, 32108, 100764, 100765, 
100751, 32098, 32107, 100763, 100750
36013, 32022, 32026, 99684, 99680, 32023, 32027, 99685, 99681, 32108, 100764, 100765, 100751, 32110, 100767, 100768, 
100754, 32100, 32109, 100766, 100753
36014, 32023, 32027, 99685, 99681, 3338, 3339, 32150, 32149, 32110, 100767, 100768, 100754, 3350, 32410, 32411, 
32408, 32102, 32111, 100769, 100756
36015, 1157, 1158, 13916, 13915, 32024, 32028, 99686, 99682, 1169, 14177, 14178, 14175, 32113, 100771, 100772, 
100758, 32103, 32112, 100770, 100757
36016, 32024, 32028, 99686, 99682, 32025, 32029, 99687, 99683, 32113, 100771, 100772, 100758, 32115, 100774, 100775, 
100761, 32105, 32114, 100773, 100760
36017, 32025, 32029, 99687, 99683, 32026, 32030, 99688, 99684, 32115, 100774, 100775, 100761, 32117, 100777, 100778, 
100764, 32107, 32116, 100776, 100763
36018, 32026, 32030, 99688, 99684, 32027, 32031, 99689, 99685, 32117, 100777, 100778, 100764, 32119, 100780, 100781, 
100767, 32109, 32118, 100779, 100766
36019, 32027, 32031, 99689, 99685, 3339, 3340, 32151, 32150, 32119, 100780, 100781, 100767, 3351, 32412, 32413, 
32410, 32111, 32120, 100782, 100769
36020, 1158, 1159, 13917, 13916, 32028, 32032, 99690, 99686, 1170, 14179, 14180, 14177, 32122, 100784, 100785, 
100771, 32112, 32121, 100783, 100770
36021, 32028, 32032, 99690, 99686, 32029, 32033, 99691, 99687, 32122, 100784, 100785, 100771, 32124, 100787, 100788, 
100774, 32114, 32123, 100786, 100773
36022, 32029, 32033, 99691, 99687, 32030, 32034, 99692, 99688, 32124, 100787, 100788, 100774, 32126, 100790, 100791, 
100777, 32116, 32125, 100789, 100776
36023, 32030, 32034, 99692, 99688, 32031, 32035, 99693, 99689, 32126, 100790, 100791, 100777, 32128, 100793, 100794, 
100780, 32118, 32127, 100792, 100779
36024, 32031, 32035, 99693, 99689, 3340, 3341, 32152, 32151, 32128, 100793, 100794, 100780, 3352, 32414, 32415, 
32412, 32120, 32129, 100795, 100782
36025, 1159, 1160, 13918, 13917, 32032, 32036, 99694, 99690, 1171, 14181, 14182, 14179, 32131, 100797, 100798, 
100784, 32121, 32130, 100796, 100783
36026, 32032, 32036, 99694, 99690, 32033, 32037, 99695, 99691, 32131, 100797, 100798, 100784, 32133, 100800, 100801, 
100787, 32123, 32132, 100799, 100786
36027, 32033, 32037, 99695, 99691, 32034, 32038, 99696, 99692, 32133, 100800, 100801, 100787, 32135, 100803, 100804, 
100790, 32125, 32134, 100802, 100789
36028, 32034, 32038, 99696, 99692, 32035, 32039, 99697, 99693, 32135, 100803, 100804, 100790, 32137, 100806, 100807, 
100793, 32127, 32136, 100805, 100792
36029, 32035, 32039, 99697, 99693, 3341, 3342, 32153, 32152, 32137, 100806, 100807, 100793, 3353, 32416, 32417, 
32414, 32129, 32138, 100808, 100795
36030, 1160, 24, 1103, 13918, 32036, 3276, 31693, 99694, 1172, 1126, 14183, 14181, 32139, 31786, 100809, 
100797, 32130, 3280, 31785, 100796
36031, 32036, 3276, 31693, 99694, 32037, 3277, 31694, 99695, 32139, 31786, 100809, 100797, 32140, 31788, 100810, 
100800, 32132, 3281, 31787, 100799
36032, 32037, 3277, 31694, 99695, 32038, 3278, 31695, 99696, 32140, 31788, 100810, 100800, 32141, 31790, 100811, 
100803, 32134, 3282, 31789, 100802
36033, 32038, 3278, 31695, 99696, 32039, 3279, 31696, 99697, 32141, 31790, 100811, 100803, 32142, 31792, 100812, 
100806, 32136, 3283, 31791, 100805
36034, 32039, 3279, 31696, 99697, 3342, 80, 3285, 32153, 32142, 31792, 100812, 100806, 3354, 3308, 32418, 
32416, 32138, 3284, 31793, 100808
36035, 1023, 13908, 13919, 1024, 31243, 99654, 99698, 31247, 14162, 14184, 14185, 1047, 100668, 100814, 100815, 
31344, 31336, 100666, 100813, 31345
36036, 31243, 99654, 99698, 31247, 31244, 99655, 99699, 31248, 100668, 100814, 100815, 31344, 100671, 100817, 100818, 
31346, 31338, 100669, 100816, 31347
36037, 31244, 99655, 99699, 31248, 31245, 99656, 99700, 31249, 100671, 100817, 100818, 31346, 100674, 100820, 100821, 
31348, 31340, 100672, 100819, 31349
36038, 31245, 99656, 99700, 31249, 31246, 99657, 99701, 31250, 100674, 100820, 100821, 31348, 100677, 100823, 100824, 
31350, 31342, 100675, 100822, 31351
36039, 31246, 99657, 99701, 31250, 3197, 32143, 32154, 3198, 100677, 100823, 100824, 31350, 32397, 32419, 32420, 
3221, 31343, 100678, 100825, 31352
36040, 13908, 13909, 13920, 13919, 99654, 99658, 99702, 99698, 14164, 14186, 14187, 14184, 100681, 100827, 100828, 
100814, 100666, 100679, 100826, 100813
36041, 99654, 99658, 99702, 99698, 99655, 99659, 99703, 99699, 100681, 100827, 100828, 100814, 100684, 100830, 100831, 
100817, 100669, 100682, 100829, 100816
36042, 99655, 99659, 99703, 99699, 99656, 99660, 99704, 99700, 100684, 100830, 100831, 100817, 100687, 100833, 100834, 
100820, 100672, 100685, 100832, 100819
36043, 99656, 99660, 99704, 99700, 99657, 99661, 99705, 99701, 100687, 100833, 100834, 100820, 100690, 100836, 100837, 
100823, 100675, 100688, 100835, 100822
36044, 99657, 99661, 99705, 99701, 32143, 32144, 32155, 32154, 100690, 100836, 100837, 100823, 32399, 32421, 32422, 
32419, 100678, 100691, 100838, 100825
36045, 13909, 13910, 13921, 13920, 99658, 99662, 99706, 99702, 14166, 14188, 14189, 14186, 100694, 100840, 100841, 
100827, 100679, 100692, 100839, 100826
36046, 99658, 99662, 99706, 99702, 99659, 99663, 99707, 99703, 100694, 100840, 100841, 100827, 100697, 100843, 100844, 
100830, 100682, 100695, 100842, 100829
36047, 99659, 99663, 99707, 99703, 99660, 99664, 99708, 99704, 100697, 100843, 100844, 100830, 100700, 100846, 100847, 
100833, 100685, 100698, 100845, 100832
36048, 99660, 99664, 99708, 99704, 99661, 99665, 99709, 99705, 100700, 100846, 100847, 100833, 100703, 100849, 100850, 
100836, 100688, 100701, 100848, 100835
36049, 99661, 99665, 99709, 99705, 32144, 32145, 32156, 32155, 100703, 100849, 100850, 100836, 32401, 32423, 32424, 
32421, 100691, 100704, 100851, 100838
36050, 13910, 13911, 13922, 13921, 99662, 99666, 99710, 99706, 14168, 14190, 14191, 14188, 100707, 100853, 100854, 
100840, 100692, 100705, 100852, 100839
36051, 99662, 99666, 99710, 99706, 99663, 99667, 99711, 99707, 100707, 100853, 100854, 100840, 100710, 100856, 100857, 
100843, 100695, 100708, 100855, 100842
36052, 99663, 99667, 99711, 99707, 99664, 99668, 99712, 99708, 100710, 100856, 100857, 100843, 100713, 100859, 100860, 
100846, 100698, 100711, 100858, 100845
36053, 99664, 99668, 99712, 99708, 99665, 99669, 99713, 99709, 100713, 100859, 100860, 100846, 100716, 100862, 100863, 
100849, 100701, 100714, 100861, 100848
36054, 99665, 99669, 99713, 99709, 32145, 32146, 32157, 32156, 100716, 100862, 100863, 100849, 32403, 32425, 32426, 
32423, 100704, 100717, 100864, 100851
36055, 13911, 13912, 13923, 13922, 99666, 99670, 99714, 99710, 14170, 14192, 14193, 14190, 100720, 100866, 100867, 
100853, 100705, 100718, 100865, 100852
36056, 99666, 99670, 99714, 99710, 99667, 99671, 99715, 99711, 100720, 100866, 100867, 100853, 100723, 100869, 100870, 
100856, 100708, 100721, 100868, 100855
36057, 99667, 99671, 99715, 99711, 99668, 99672, 99716, 99712, 100723, 100869, 100870, 100856, 100726, 100872, 100873, 
100859, 100711, 100724, 100871, 100858
36058, 99668, 99672, 99716, 99712, 99669, 99673, 99717, 99713, 100726, 100872, 100873, 100859, 100729, 100875, 100876, 
100862, 100714, 100727, 100874, 100861
36059, 99669, 99673, 99717, 99713, 32146, 32147, 32158, 32157, 100729, 100875, 100876, 100862, 32405, 32427, 32428, 
32425, 100717, 100730, 100877, 100864
36060, 13912, 13913, 13924, 13923, 99670, 99674, 99718, 99714, 14172, 14194, 14195, 14192, 100733, 100879, 100880, 
100866, 100718, 100731, 100878, 100865
36061, 99670, 99674, 99718, 99714, 99671, 99675, 99719, 99715, 100733, 100879, 100880, 100866, 100736, 100882, 100883, 
100869, 100721, 100734, 100881, 100868
36062, 99671, 99675, 99719, 99715, 99672, 99676, 99720, 99716, 100736, 100882, 100883, 100869, 100739, 100885, 100886, 
100872, 100724, 100737, 100884, 100871
36063, 99672, 99676, 99720, 99716, 99673, 99677, 99721, 99717, 100739, 100885, 100886, 100872, 100742, 100888, 100889, 
100875, 100727, 100740, 100887, 100874
36064, 99673, 99677, 99721, 99717, 32147, 32148, 32159, 32158, 100742, 100888, 100889, 100875, 32407, 32429, 32430, 
32427, 100730, 100743, 100890, 100877
36065, 13913, 13914, 13925, 13924, 99674, 99678, 99722, 99718, 14174, 14196, 14197, 14194, 100746, 100892, 100893, 
100879, 100731, 100744, 100891, 100878
36066, 99674, 99678, 99722, 99718, 99675, 99679, 99723, 99719, 100746, 100892, 100893, 100879, 100749, 100895, 100896, 
100882, 100734, 100747, 100894, 100881
36067, 99675, 99679, 99723, 99719, 99676, 99680, 99724, 99720, 100749, 100895, 100896, 100882, 100752, 100898, 100899, 
100885, 100737, 100750, 100897, 100884
36068, 99676, 99680, 99724, 99720, 99677, 99681, 99725, 99721, 100752, 100898, 100899, 100885, 100755, 100901, 100902, 
100888, 100740, 100753, 100900, 100887
36069, 99677, 99681, 99725, 99721, 32148, 32149, 32160, 32159, 100755, 100901, 100902, 100888, 32409, 32431, 32432, 
32429, 100743, 100756, 100903, 100890
36070, 13914, 13915, 13926, 13925, 99678, 99682, 99726, 99722, 14176, 14198, 14199, 14196, 100759, 100905, 100906, 
100892, 100744, 100757, 100904, 100891
36071, 99678, 99682, 99726, 99722, 99679, 99683, 99727, 99723, 100759, 100905, 100906, 100892, 100762, 100908, 100909, 
100895, 100747, 100760, 100907, 100894
36072, 99679, 99683, 99727, 99723, 99680, 99684, 99728, 99724, 100762, 100908, 100909, 100895, 100765, 100911, 100912, 
100898, 100750, 100763, 100910, 100897
36073, 99680, 99684, 99728, 99724, 99681, 99685, 99729, 99725, 100765, 100911, 100912, 100898, 100768, 100914, 100915, 
100901, 100753, 100766, 100913, 100900
36074, 99681, 99685, 99729, 99725, 32149, 32150, 32161, 32160, 100768, 100914, 100915, 100901, 32411, 32433, 32434, 
32431, 100756, 100769, 100916, 100903
36075, 13915, 13916, 13927, 13926, 99682, 99686, 99730, 99726, 14178, 14200, 14201, 14198, 100772, 100918, 100919, 
100905, 100757, 100770, 100917, 100904
36076, 99682, 99686, 99730, 99726, 99683, 99687, 99731, 99727, 100772, 100918, 100919, 100905, 100775, 100921, 100922, 
100908, 100760, 100773, 100920, 100907
36077, 99683, 99687, 99731, 99727, 99684, 99688, 99732, 99728, 100775, 100921, 100922, 100908, 100778, 100924, 100925, 
100911, 100763, 100776, 100923, 100910
36078, 99684, 99688, 99732, 99728, 99685, 99689, 99733, 99729, 100778, 100924, 100925, 100911, 100781, 100927, 100928, 
100914, 100766, 100779, 100926, 100913
36079, 99685, 99689, 99733, 99729, 32150, 32151, 32162, 32161, 100781, 100927, 100928, 100914, 32413, 32435, 32436, 
32433, 100769, 100782, 100929, 100916
36080, 13916, 13917, 13928, 13927, 99686, 99690, 99734, 99730, 14180, 14202, 14203, 14200, 100785, 100931, 100932, 
100918, 100770, 100783, 100930, 100917
36081, 99686, 99690, 99734, 99730, 99687, 99691, 99735, 99731, 100785, 100931, 100932, 100918, 100788, 100934, 100935, 
100921, 100773, 100786, 100933, 100920
36082, 99687, 99691, 99735, 99731, 99688, 99692, 99736, 99732, 100788, 100934, 100935, 100921, 100791, 100937, 100938, 
100924, 100776, 100789, 100936, 100923
36083, 99688, 99692, 99736, 99732, 99689, 99693, 99737, 99733, 100791, 100937, 100938, 100924, 100794, 100940, 100941, 
100927, 100779, 100792, 100939, 100926
36084, 99689, 99693, 99737, 99733, 32151, 32152, 32163, 32162, 100794, 100940, 100941, 100927, 32415, 32437, 32438, 
32435, 100782, 100795, 100942, 100929
36085, 13917, 13918, 13929, 13928, 99690, 99694, 99738, 99734, 14182, 14204, 14205, 14202, 100798, 100944, 100945, 
100931, 100783, 100796, 100943, 100930
36086, 99690, 99694, 99738, 99734, 99691, 99695, 99739, 99735, 100798, 100944, 100945, 100931, 100801, 100947, 100948, 
100934, 100786, 100799, 100946, 100933
36087, 99691, 99695, 99739, 99735, 99692, 99696, 99740, 99736, 100801, 100947, 100948, 100934, 100804, 100950, 100951, 
100937, 100789, 100802, 100949, 100936
36088, 99692, 99696, 99740, 99736, 99693, 99697, 99741, 99737, 100804, 100950, 100951, 100937, 100807, 100953, 100954, 
100940, 100792, 100805, 100952, 100939
36089, 99693, 99697, 99741, 99737, 32152, 32153, 32164, 32163, 100807, 100953, 100954, 100940, 32417, 32439, 32440, 
32437, 100795, 100808, 100955, 100942
36090, 13918, 1103, 1104, 13929, 99694, 31693, 31697, 99738, 14183, 1127, 14206, 14204, 100809, 31795, 100956, 
100944, 100796, 31785, 31794, 100943
36091, 99694, 31693, 31697, 99738, 99695, 31694, 31698, 99739, 100809, 31795, 100956, 100944, 100810, 31797, 100957, 
100947, 100799, 31787, 31796, 100946
36092, 99695, 31694, 31698, 99739, 99696, 31695, 31699, 99740, 100810, 31797, 100957, 100947, 100811, 31799, 100958, 
100950, 100802, 31789, 31798, 100949
36093, 99696, 31695, 31699, 99740, 99697, 31696, 31700, 99741, 100811, 31799, 100958, 100950, 100812, 31801, 100959, 
100953, 100805, 31791, 31800, 100952
36094, 99697, 31696, 31700, 99741, 32153, 3285, 3286, 32164, 100812, 31801, 100959, 100953, 32418, 3309, 32441, 
32439, 100808, 31793, 31802, 100955
36095, 1024, 13919, 13930, 1025, 31247, 99698, 99742, 31251, 14185, 14207, 14208, 1048, 100815, 100961, 100962, 
31353, 31345, 100813, 100960, 31354
36096, 31247, 99698, 99742, 31251, 31248, 99699, 99743, 31252, 100815, 100961, 100962, 31353, 100818, 100964, 100965, 
31355, 31347, 100816, 100963, 31356
36097, 31248, 99699, 99743, 31252, 31249, 99700, 99744, 31253, 100818, 100964, 100965, 31355, 100821, 100967, 100968, 
31357, 31349, 100819, 100966, 31358
36098, 31249, 99700, 99744, 31253, 31250, 99701, 99745, 31254, 100821, 100967, 100968, 31357, 100824, 100970, 100971, 
31359, 31351, 100822, 100969, 31360
36099, 31250, 99701, 99745, 31254, 3198, 32154, 32165, 3199, 100824, 100970, 100971, 31359, 32420, 32442, 32443, 
3222, 31352, 100825, 100972, 31361
36100, 13919, 13920, 13931, 13930, 99698, 99702, 99746, 99742, 14187, 14209, 14210, 14207, 100828, 100974, 100975, 
100961, 100813, 100826, 100973, 100960
36101, 99698, 99702, 99746, 99742, 99699, 99703, 99747, 99743, 100828, 100974, 100975, 100961, 100831, 100977, 100978, 
100964, 100816, 100829, 100976, 100963
36102, 99699, 99703, 99747, 99743, 99700, 99704, 99748, 99744, 100831, 100977, 100978, 100964, 100834, 100980, 100981, 
100967, 100819, 100832, 100979, 100966
36103, 99700, 99704, 99748, 99744, 99701, 99705, 99749, 99745, 100834, 100980, 100981, 100967, 100837, 100983, 100984, 
100970, 100822, 100835, 100982, 100969
36104, 99701, 99705, 99749, 99745, 32154, 32155, 32166, 32165, 100837, 100983, 100984, 100970, 32422, 32444, 32445, 
32442, 100825, 100838, 100985, 100972
36105, 13920, 13921, 13932, 13931, 99702, 99706, 99750, 99746, 14189, 14211, 14212, 14209, 100841, 100987, 100988, 
100974, 100826, 100839, 100986, 100973
36106, 99702, 99706, 99750, 99746, 99703, 99707, 99751, 99747, 100841, 100987, 100988, 100974, 100844, 100990, 100991, 
100977, 100829, 100842, 100989, 100976
36107, 99703, 99707, 99751, 99747, 99704, 99708, 99752, 99748, 100844, 100990, 100991, 100977, 100847, 100993, 100994, 
100980, 100832, 100845, 100992, 100979
36108, 99704, 99708, 99752, 99748, 99705, 99709, 99753, 99749, 100847, 100993, 100994, 100980, 100850, 100996, 100997, 
100983, 100835, 100848, 100995, 100982
36109, 99705, 99709, 99753, 99749, 32155, 32156, 32167, 32166, 100850, 100996, 100997, 100983, 32424, 32446, 32447, 
32444, 100838, 100851, 100998, 100985
36110, 13921, 13922, 13933, 13932, 99706, 99710, 99754, 99750, 14191, 14213, 14214, 14211, 100854, 101000, 101001, 
100987, 100839, 100852, 100999, 100986
36111, 99706, 99710, 99754, 99750, 99707, 99711, 99755, 99751, 100854, 101000, 101001, 100987, 100857, 101003, 101004, 
100990, 100842, 100855, 101002, 100989
36112, 99707, 99711, 99755, 99751, 99708, 99712, 99756, 99752, 100857, 101003, 101004, 100990, 100860, 101006, 101007, 
100993, 100845, 100858, 101005, 100992
36113, 99708, 99712, 99756, 99752, 99709, 99713, 99757, 99753, 100860, 101006, 101007, 100993, 100863, 101009, 101010, 
100996, 100848, 100861, 101008, 100995
36114, 99709, 99713, 99757, 99753, 32156, 32157, 32168, 32167, 100863, 101009, 101010, 100996, 32426, 32448, 32449, 
32446, 100851, 100864, 101011, 100998
36115, 13922, 13923, 13934, 13933, 99710, 99714, 99758, 99754, 14193, 14215, 14216, 14213, 100867, 101013, 101014, 
101000, 100852, 100865, 101012, 100999
36116, 99710, 99714, 99758, 99754, 99711, 99715, 99759, 99755, 100867, 101013, 101014, 101000, 100870, 101016, 101017, 
101003, 100855, 100868, 101015, 101002
36117, 99711, 99715, 99759, 99755, 99712, 99716, 99760, 99756, 100870, 101016, 101017, 101003, 100873, 101019, 101020, 
101006, 100858, 100871, 101018, 101005
36118, 99712, 99716, 99760, 99756, 99713, 99717, 99761, 99757, 100873, 101019, 101020, 101006, 100876, 101022, 101023, 
101009, 100861, 100874, 101021, 101008
36119, 99713, 99717, 99761, 99757, 32157, 32158, 32169, 32168, 100876, 101022, 101023, 101009, 32428, 32450, 32451, 
32448, 100864, 100877, 101024, 101011
36120, 13923, 13924, 13935, 13934, 99714, 99718, 99762, 99758, 14195, 14217, 14218, 14215, 100880, 101026, 101027, 
101013, 100865, 100878, 101025, 101012
36121, 99714, 99718, 99762, 99758, 99715, 99719, 99763, 99759, 100880, 101026, 101027, 101013, 100883, 101029, 101030, 
101016, 100868, 100881, 101028, 101015
36122, 99715, 99719, 99763, 99759, 99716, 99720, 99764, 99760, 100883, 101029, 101030, 101016, 100886, 101032, 101033, 
101019, 100871, 100884, 101031, 101018
36123, 99716, 99720, 99764, 99760, 99717, 99721, 99765, 99761, 100886, 101032, 101033, 101019, 100889, 101035, 101036, 
101022, 100874, 100887, 101034, 101021
36124, 99717, 99721, 99765, 99761, 32158, 32159, 32170, 32169, 100889, 101035, 101036, 101022, 32430, 32452, 32453, 
32450, 100877, 100890, 101037, 101024
36125, 13924, 13925, 13936, 13935, 99718, 99722, 99766, 99762, 14197, 14219, 14220, 14217, 100893, 101039, 101040, 
101026, 100878, 100891, 101038, 101025
36126, 99718, 99722, 99766, 99762, 99719, 99723, 99767, 99763, 100893, 101039, 101040, 101026, 100896, 101042, 101043, 
101029, 100881, 100894, 101041, 101028
36127, 99719, 99723, 99767, 99763, 99720, 99724, 99768, 99764, 100896, 101042, 101043, 101029, 100899, 101045, 101046, 
101032, 100884, 100897, 101044, 101031
36128, 99720, 99724, 99768, 99764, 99721, 99725, 99769, 99765, 100899, 101045, 101046, 101032, 100902, 101048, 101049, 
101035, 100887, 100900, 101047, 101034
36129, 99721, 99725, 99769, 99765, 32159, 32160, 32171, 32170, 100902, 101048, 101049, 101035, 32432, 32454, 32455, 
32452, 100890, 100903, 101050, 101037
36130, 13925, 13926, 13937, 13936, 99722, 99726, 99770, 99766, 14199, 14221, 14222, 14219, 100906, 101052, 101053, 
101039, 100891, 100904, 101051, 101038
36131, 99722, 99726, 99770, 99766, 99723, 99727, 99771, 99767, 100906, 101052, 101053, 101039, 100909, 101055, 101056, 
101042, 100894, 100907, 101054, 101041
36132, 99723, 99727, 99771, 99767, 99724, 99728, 99772, 99768, 100909, 101055, 101056, 101042, 100912, 101058, 101059, 
101045, 100897, 100910, 101057, 101044
36133, 99724, 99728, 99772, 99768, 99725, 99729, 99773, 99769, 100912, 101058, 101059, 101045, 100915, 101061, 101062, 
101048, 100900, 100913, 101060, 101047
36134, 99725, 99729, 99773, 99769, 32160, 32161, 32172, 32171, 100915, 101061, 101062, 101048, 32434, 32456, 32457, 
32454, 100903, 100916, 101063, 101050
36135, 13926, 13927, 13938, 13937, 99726, 99730, 99774, 99770, 14201, 14223, 14224, 14221, 100919, 101065, 101066, 
101052, 100904, 100917, 101064, 101051
36136, 99726, 99730, 99774, 99770, 99727, 99731, 99775, 99771, 100919, 101065, 101066, 101052, 100922, 101068, 101069, 
101055, 100907, 100920, 101067, 101054
36137, 99727, 99731, 99775, 99771, 99728, 99732, 99776, 99772, 100922, 101068, 101069, 101055, 100925, 101071, 101072, 
101058, 100910, 100923, 101070, 101057
36138, 99728, 99732, 99776, 99772, 99729, 99733, 99777, 99773, 100925, 101071, 101072, 101058, 100928, 101074, 101075, 
101061, 100913, 100926, 101073, 101060
36139, 99729, 99733, 99777, 99773, 32161, 32162, 32173, 32172, 100928, 101074, 101075, 101061, 32436, 32458, 32459, 
32456, 100916, 100929, 101076, 101063
36140, 13927, 13928, 13939, 13938, 99730, 99734, 99778, 99774, 14203, 14225, 14226, 14223, 100932, 101078, 101079, 
101065, 100917, 100930, 101077, 101064
36141, 99730, 99734, 99778, 99774, 99731, 99735, 99779, 99775, 100932, 101078, 101079, 101065, 100935, 101081, 101082, 
101068, 100920, 100933, 101080, 101067
36142, 99731, 99735, 99779, 99775, 99732, 99736, 99780, 99776, 100935, 101081, 101082, 101068, 100938, 101084, 101085, 
101071, 100923, 100936, 101083, 101070
36143, 99732, 99736, 99780, 99776, 99733, 99737, 99781, 99777, 100938, 101084, 101085, 101071, 100941, 101087, 101088, 
101074, 100926, 100939, 101086, 101073
36144, 99733, 99737, 99781, 99777, 32162, 32163, 32174, 32173, 100941, 101087, 101088, 101074, 32438, 32460, 32461, 
32458, 100929, 100942, 101089, 101076
36145, 13928, 13929, 13940, 13939, 99734, 99738, 99782, 99778, 14205, 14227, 14228, 14225, 100945, 101091, 101092, 
101078, 100930, 100943, 101090, 101077
36146, 99734, 99738, 99782, 99778, 99735, 99739, 99783, 99779, 100945, 101091, 101092, 101078, 100948, 101094, 101095, 
101081, 100933, 100946, 101093, 101080
36147, 99735, 99739, 99783, 99779, 99736, 99740, 99784, 99780, 100948, 101094, 101095, 101081, 100951, 101097, 101098, 
101084, 100936, 100949, 101096, 101083
36148, 99736, 99740, 99784, 99780, 99737, 99741, 99785, 99781, 100951, 101097, 101098, 101084, 100954, 101100, 101101, 
101087, 100939, 100952, 101099, 101086
36149, 99737, 99741, 99785, 99781, 32163, 32164, 32175, 32174, 100954, 101100, 101101, 101087, 32440, 32462, 32463, 
32460, 100942, 100955, 101102, 101089
36150, 13929, 1104, 1105, 13940, 99738, 31697, 31701, 99782, 14206, 1128, 14229, 14227, 100956, 31804, 101103, 
101091, 100943, 31794, 31803, 101090
36151, 99738, 31697, 31701, 99782, 99739, 31698, 31702, 99783, 100956, 31804, 101103, 101091, 100957, 31806, 101104, 
101094, 100946, 31796, 31805, 101093
36152, 99739, 31698, 31702, 99783, 99740, 31699, 31703, 99784, 100957, 31806, 101104, 101094, 100958, 31808, 101105, 
101097, 100949, 31798, 31807, 101096
36153, 99740, 31699, 31703, 99784, 99741, 31700, 31704, 99785, 100958, 31808, 101105, 101097, 100959, 31810, 101106, 
101100, 100952, 31800, 31809, 101099
36154, 99741, 31700, 31704, 99785, 32164, 3286, 3287, 32175, 100959, 31810, 101106, 101100, 32441, 3310, 32464, 
32462, 100955, 31802, 31811, 101102
36155, 1025, 13930, 13941, 1026, 31251, 99742, 99786, 31255, 14208, 14230, 14231, 1049, 100962, 101108, 101109, 
31362, 31354, 100960, 101107, 31363
36156, 31251, 99742, 99786, 31255, 31252, 99743, 99787, 31256, 100962, 101108, 101109, 31362, 100965, 101111, 101112, 
31364, 31356, 100963, 101110, 31365
36157, 31252, 99743, 99787, 31256, 31253, 99744, 99788, 31257, 100965, 101111, 101112, 31364, 100968, 101114, 101115, 
31366, 31358, 100966, 101113, 31367
36158, 31253, 99744, 99788, 31257, 31254, 99745, 99789, 31258, 100968, 101114, 101115, 31366, 100971, 101117, 101118, 
31368, 31360, 100969, 101116, 31369
36159, 31254, 99745, 99789, 31258, 3199, 32165, 32176, 3200, 100971, 101117, 101118, 31368, 32443, 32465, 32466, 
3223, 31361, 100972, 101119, 31370
36160, 13930, 13931, 13942, 13941, 99742, 99746, 99790, 99786, 14210, 14232, 14233, 14230, 100975, 101121, 101122, 
101108, 100960, 100973, 101120, 101107
36161, 99742, 99746, 99790, 99786, 99743, 99747, 99791, 99787, 100975, 101121, 101122, 101108, 100978, 101124, 101125, 
101111, 100963, 100976, 101123, 101110
36162, 99743, 99747, 99791, 99787, 99744, 99748, 99792, 99788, 100978, 101124, 101125, 101111, 100981, 101127, 101128, 
101114, 100966, 100979, 101126, 101113
36163, 99744, 99748, 99792, 99788, 99745, 99749, 99793, 99789, 100981, 101127, 101128, 101114, 100984, 101130, 101131, 
101117, 100969, 100982, 101129, 101116
36164, 99745, 99749, 99793, 99789, 32165, 32166, 32177, 32176, 100984, 101130, 101131, 101117, 32445, 32467, 32468, 
32465, 100972, 100985, 101132, 101119
36165, 13931, 13932, 13943, 13942, 99746, 99750, 99794, 99790, 14212, 14234, 14235, 14232, 100988, 101134, 101135, 
101121, 100973, 100986, 101133, 101120
36166, 99746, 99750, 99794, 99790, 99747, 99751, 99795, 99791, 100988, 101134, 101135, 101121, 100991, 101137, 101138, 
101124, 100976, 100989, 101136, 101123
36167, 99747, 99751, 99795, 99791, 99748, 99752, 99796, 99792, 100991, 101137, 101138, 101124, 100994, 101140, 101141, 
101127, 100979, 100992, 101139, 101126
36168, 99748, 99752, 99796, 99792, 99749, 99753, 99797, 99793, 100994, 101140, 101141, 101127, 100997, 101143, 101144, 
101130, 100982, 100995, 101142, 101129
36169, 99749, 99753, 99797, 99793, 32166, 32167, 32178, 32177, 100997, 101143, 101144, 101130, 32447, 32469, 32470, 
32467, 100985, 100998, 101145, 101132
36170, 13932, 13933, 13944, 13943, 99750, 99754, 99798, 99794, 14214, 14236, 14237, 14234, 101001, 101147, 101148, 
101134, 100986, 100999, 101146, 101133
36171, 99750, 99754, 99798, 99794, 99751, 99755, 99799, 99795, 101001, 101147, 101148, 101134, 101004, 101150, 101151, 
101137, 100989, 101002, 101149, 101136
36172, 99751, 99755, 99799, 99795, 99752, 99756, 99800, 99796, 101004, 101150, 101151, 101137, 101007, 101153, 101154, 
101140, 100992, 101005, 101152, 101139
36173, 99752, 99756, 99800, 99796, 99753, 99757, 99801, 99797, 101007, 101153, 101154, 101140, 101010, 101156, 101157, 
101143, 100995, 101008, 101155, 101142
36174, 99753, 99757, 99801, 99797, 32167, 32168, 32179, 32178, 101010, 101156, 101157, 101143, 32449, 32471, 32472, 
32469, 100998, 101011, 101158, 101145
36175, 13933, 13934, 13945, 13944, 99754, 99758, 99802, 99798, 14216, 14238, 14239, 14236, 101014, 101160, 101161, 
101147, 100999, 101012, 101159, 101146
36176, 99754, 99758, 99802, 99798, 99755, 99759, 99803, 99799, 101014, 101160, 101161, 101147, 101017, 101163, 101164, 
101150, 101002, 101015, 101162, 101149
36177, 99755, 99759, 99803, 99799, 99756, 99760, 99804, 99800, 101017, 101163, 101164, 101150, 101020, 101166, 101167, 
101153, 101005, 101018, 101165, 101152
36178, 99756, 99760, 99804, 99800, 99757, 99761, 99805, 99801, 101020, 101166, 101167, 101153, 101023, 101169, 101170, 
101156, 101008, 101021, 101168, 101155
36179, 99757, 99761, 99805, 99801, 32168, 32169, 32180, 32179, 101023, 101169, 101170, 101156, 32451, 32473, 32474, 
32471, 101011, 101024, 101171, 101158
36180, 13934, 13935, 13946, 13945, 99758, 99762, 99806, 99802, 14218, 14240, 14241, 14238, 101027, 101173, 101174, 
101160, 101012, 101025, 101172, 101159
36181, 99758, 99762, 99806, 99802, 99759, 99763, 99807, 99803, 101027, 101173, 101174, 101160, 101030, 101176, 101177, 
101163, 101015, 101028, 101175, 101162
36182, 99759, 99763, 99807, 99803, 99760, 99764, 99808, 99804, 101030, 101176, 101177, 101163, 101033, 101179, 101180, 
101166, 101018, 101031, 101178, 101165
36183, 99760, 99764, 99808, 99804, 99761, 99765, 99809, 99805, 101033, 101179, 101180, 101166, 101036, 101182, 101183, 
101169, 101021, 101034, 101181, 101168
36184, 99761, 99765, 99809, 99805, 32169, 32170, 32181, 32180, 101036, 101182, 101183, 101169, 32453, 32475, 32476, 
32473, 101024, 101037, 101184, 101171
36185, 13935, 13936, 13947, 13946, 99762, 99766, 99810, 99806, 14220, 14242, 14243, 14240, 101040, 101186, 101187, 
101173, 101025, 101038, 101185, 101172
36186, 99762, 99766, 99810, 99806, 99763, 99767, 99811, 99807, 101040, 101186, 101187, 101173, 101043, 101189, 101190, 
101176, 101028, 101041, 101188, 101175
36187, 99763, 99767, 99811, 99807, 99764, 99768, 99812, 99808, 101043, 101189, 101190, 101176, 101046, 101192, 101193, 
101179, 101031, 101044, 101191, 101178
36188, 99764, 99768, 99812, 99808, 99765, 99769, 99813, 99809, 101046, 101192, 101193, 101179, 101049, 101195, 101196, 
101182, 101034, 101047, 101194, 101181
36189, 99765, 99769, 99813, 99809, 32170, 32171, 32182, 32181, 101049, 101195, 101196, 101182, 32455, 32477, 32478, 
32475, 101037, 101050, 101197, 101184
36190, 13936, 13937, 13948, 13947, 99766, 99770, 99814, 99810, 14222, 14244, 14245, 14242, 101053, 101199, 101200, 
101186, 101038, 101051, 101198, 101185
36191, 99766, 99770, 99814, 99810, 99767, 99771, 99815, 99811, 101053, 101199, 101200, 101186, 101056, 101202, 101203, 
101189, 101041, 101054, 101201, 101188
36192, 99767, 99771, 99815, 99811, 99768, 99772, 99816, 99812, 101056, 101202, 101203, 101189, 101059, 101205, 101206, 
101192, 101044, 101057, 101204, 101191
36193, 99768, 99772, 99816, 99812, 99769, 99773, 99817, 99813, 101059, 101205, 101206, 101192, 101062, 101208, 101209, 
101195, 101047, 101060, 101207, 101194
36194, 99769, 99773, 99817, 99813, 32171, 32172, 32183, 32182, 101062, 101208, 101209, 101195, 32457, 32479, 32480, 
32477, 101050, 101063, 101210, 101197
36195, 13937, 13938, 13949, 13948, 99770, 99774, 99818, 99814, 14224, 14246, 14247, 14244, 101066, 101212, 101213, 
101199, 101051, 101064, 101211, 101198
36196, 99770, 99774, 99818, 99814, 99771, 99775, 99819, 99815, 101066, 101212, 101213, 101199, 101069, 101215, 101216, 
101202, 101054, 101067, 101214, 101201
36197, 99771, 99775, 99819, 99815, 99772, 99776, 99820, 99816, 101069, 101215, 101216, 101202, 101072, 101218, 101219, 
101205, 101057, 101070, 101217, 101204
36198, 99772, 99776, 99820, 99816, 99773, 99777, 99821, 99817, 101072, 101218, 101219, 101205, 101075, 101221, 101222, 
101208, 101060, 101073, 101220, 101207
36199, 99773, 99777, 99821, 99817, 32172, 32173, 32184, 32183, 101075, 101221, 101222, 101208, 32459, 32481, 32482, 
32479, 101063, 101076, 101223, 101210
36200, 13938, 13939, 13950, 13949, 99774, 99778, 99822, 99818, 14226, 14248, 14249, 14246, 101079, 101225, 101226, 
101212, 101064, 101077, 101224, 101211
36201, 99774, 99778, 99822, 99818, 99775, 99779, 99823, 99819, 101079, 101225, 101226, 101212, 101082, 101228, 101229, 
101215, 101067, 101080, 101227, 101214
36202, 99775, 99779, 99823, 99819, 99776, 99780, 99824, 99820, 101082, 101228, 101229, 101215, 101085, 101231, 101232, 
101218, 101070, 101083, 101230, 101217
36203, 99776, 99780, 99824, 99820, 99777, 99781, 99825, 99821, 101085, 101231, 101232, 101218, 101088, 101234, 101235, 
101221, 101073, 101086, 101233, 101220
36204, 99777, 99781, 99825, 99821, 32173, 32174, 32185, 32184, 101088, 101234, 101235, 101221, 32461, 32483, 32484, 
32481, 101076, 101089, 101236, 101223
36205, 13939, 13940, 13951, 13950, 99778, 99782, 99826, 99822, 14228, 14250, 14251, 14248, 101092, 101238, 101239, 
101225, 101077, 101090, 101237, 101224
36206, 99778, 99782, 99826, 99822, 99779, 99783, 99827, 99823, 101092, 101238, 101239, 101225, 101095, 101241, 101242, 
101228, 101080, 101093, 101240, 101227
36207, 99779, 99783, 99827, 99823, 99780, 99784, 99828, 99824, 101095, 101241, 101242, 101228, 101098, 101244, 101245, 
101231, 101083, 101096, 101243, 101230
36208, 99780, 99784, 99828, 99824, 99781, 99785, 99829, 99825, 101098, 101244, 101245, 101231, 101101, 101247, 101248, 
101234, 101086, 101099, 101246, 101233
36209, 99781, 99785, 99829, 99825, 32174, 32175, 32186, 32185, 101101, 101247, 101248, 101234, 32463, 32485, 32486, 
32483, 101089, 101102, 101249, 101236
36210, 13940, 1105, 1106, 13951, 99782, 31701, 31705, 99826, 14229, 1129, 14252, 14250, 101103, 31813, 101250, 
101238, 101090, 31803, 31812, 101237
36211, 99782, 31701, 31705, 99826, 99783, 31702, 31706, 99827, 101103, 31813, 101250, 101238, 101104, 31815, 101251, 
101241, 101093, 31805, 31814, 101240
36212, 99783, 31702, 31706, 99827, 99784, 31703, 31707, 99828, 101104, 31815, 101251, 101241, 101105, 31817, 101252, 
101244, 101096, 31807, 31816, 101243
36213, 99784, 31703, 31707, 99828, 99785, 31704, 31708, 99829, 101105, 31817, 101252, 101244, 101106, 31819, 101253, 
101247, 101099, 31809, 31818, 101246
36214, 99785, 31704, 31708, 99829, 32175, 3287, 3288, 32186, 101106, 31819, 101253, 101247, 32464, 3311, 32487, 
32485, 101102, 31811, 31820, 101249
36215, 1026, 13941, 13952, 1027, 31255, 99786, 99830, 31259, 14231, 14253, 14254, 1050, 101109, 101255, 101256, 
31371, 31363, 101107, 101254, 31372
36216, 31255, 99786, 99830, 31259, 31256, 99787, 99831, 31260, 101109, 101255, 101256, 31371, 101112, 101258, 101259, 
31373, 31365, 101110, 101257, 31374
36217, 31256, 99787, 99831, 31260, 31257, 99788, 99832, 31261, 101112, 101258, 101259, 31373, 101115, 101261, 101262, 
31375, 31367, 101113, 101260, 31376
36218, 31257, 99788, 99832, 31261, 31258, 99789, 99833, 31262, 101115, 101261, 101262, 31375, 101118, 101264, 101265, 
31377, 31369, 101116, 101263, 31378
36219, 31258, 99789, 99833, 31262, 3200, 32176, 32187, 3201, 101118, 101264, 101265, 31377, 32466, 32488, 32489, 
3224, 31370, 101119, 101266, 31379
36220, 13941, 13942, 13953, 13952, 99786, 99790, 99834, 99830, 14233, 14255, 14256, 14253, 101122, 101268, 101269, 
101255, 101107, 101120, 101267, 101254
36221, 99786, 99790, 99834, 99830, 99787, 99791, 99835, 99831, 101122, 101268, 101269, 101255, 101125, 101271, 101272, 
101258, 101110, 101123, 101270, 101257
36222, 99787, 99791, 99835, 99831, 99788, 99792, 99836, 99832, 101125, 101271, 101272, 101258, 101128, 101274, 101275, 
101261, 101113, 101126, 101273, 101260
36223, 99788, 99792, 99836, 99832, 99789, 99793, 99837, 99833, 101128, 101274, 101275, 101261, 101131, 101277, 101278, 
101264, 101116, 101129, 101276, 101263
36224, 99789, 99793, 99837, 99833, 32176, 32177, 32188, 32187, 101131, 101277, 101278, 101264, 32468, 32490, 32491, 
32488, 101119, 101132, 101279, 101266
36225, 13942, 13943, 13954, 13953, 99790, 99794, 99838, 99834, 14235, 14257, 14258, 14255, 101135, 101281, 101282, 
101268, 101120, 101133, 101280, 101267
36226, 99790, 99794, 99838, 99834, 99791, 99795, 99839, 99835, 101135, 101281, 101282, 101268, 101138, 101284, 101285, 
101271, 101123, 101136, 101283, 101270
36227, 99791, 99795, 99839, 99835, 99792, 99796, 99840, 99836, 101138, 101284, 101285, 101271, 101141, 101287, 101288, 
101274, 101126, 101139, 101286, 101273
36228, 99792, 99796, 99840, 99836, 99793, 99797, 99841, 99837, 101141, 101287, 101288, 101274, 101144, 101290, 101291, 
101277, 101129, 101142, 101289, 101276
36229, 99793, 99797, 99841, 99837, 32177, 32178, 32189, 32188, 101144, 101290, 101291, 101277, 32470, 32492, 32493, 
32490, 101132, 101145, 101292, 101279
36230, 13943, 13944, 13955, 13954, 99794, 99798, 99842, 99838, 14237, 14259, 14260, 14257, 101148, 101294, 101295, 
101281, 101133, 101146, 101293, 101280
36231, 99794, 99798, 99842, 99838, 99795, 99799, 99843, 99839, 101148, 101294, 101295, 101281, 101151, 101297, 101298, 
101284, 101136, 101149, 101296, 101283
36232, 99795, 99799, 99843, 99839, 99796, 99800, 99844, 99840, 101151, 101297, 101298, 101284, 101154, 101300, 101301, 
101287, 101139, 101152, 101299, 101286
36233, 99796, 99800, 99844, 99840, 99797, 99801, 99845, 99841, 101154, 101300, 101301, 101287, 101157, 101303, 101304, 
101290, 101142, 101155, 101302, 101289
36234, 99797, 99801, 99845, 99841, 32178, 32179, 32190, 32189, 101157, 101303, 101304, 101290, 32472, 32494, 32495, 
32492, 101145, 101158, 101305, 101292
36235, 13944, 13945, 13956, 13955, 99798, 99802, 99846, 99842, 14239, 14261, 14262, 14259, 101161, 101307, 101308, 
101294, 101146, 101159, 101306, 101293
36236, 99798, 99802, 99846, 99842, 99799, 99803, 99847, 99843, 101161, 101307, 101308, 101294, 101164, 101310, 101311, 
101297, 101149, 101162, 101309, 101296
36237, 99799, 99803, 99847, 99843, 99800, 99804, 99848, 99844, 101164, 101310, 101311, 101297, 101167, 101313, 101314, 
101300, 101152, 101165, 101312, 101299
36238, 99800, 99804, 99848, 99844, 99801, 99805, 99849, 99845, 101167, 101313, 101314, 101300, 101170, 101316, 101317, 
101303, 101155, 101168, 101315, 101302
36239, 99801, 99805, 99849, 99845, 32179, 32180, 32191, 32190, 101170, 101316, 101317, 101303, 32474, 32496, 32497, 
32494, 101158, 101171, 101318, 101305
36240, 13945, 13946, 13957, 13956, 99802, 99806, 99850, 99846, 14241, 14263, 14264, 14261, 101174, 101320, 101321, 
101307, 101159, 101172, 101319, 101306
36241, 99802, 99806, 99850, 99846, 99803, 99807, 99851, 99847, 101174, 101320, 101321, 101307, 101177, 101323, 101324, 
101310, 101162, 101175, 101322, 101309
36242, 99803, 99807, 99851, 99847, 99804, 99808, 99852, 99848, 101177, 101323, 101324, 101310, 101180, 101326, 101327, 
101313, 101165, 101178, 101325, 101312
36243, 99804, 99808, 99852, 99848, 99805, 99809, 99853, 99849, 101180, 101326, 101327, 101313, 101183, 101329, 101330, 
101316, 101168, 101181, 101328, 101315
36244, 99805, 99809, 99853, 99849, 32180, 32181, 32192, 32191, 101183, 101329, 101330, 101316, 32476, 32498, 32499, 
32496, 101171, 101184, 101331, 101318
36245, 13946, 13947, 13958, 13957, 99806, 99810, 99854, 99850, 14243, 14265, 14266, 14263, 101187, 101333, 101334, 
101320, 101172, 101185, 101332, 101319
36246, 99806, 99810, 99854, 99850, 99807, 99811, 99855, 99851, 101187, 101333, 101334, 101320, 101190, 101336, 101337, 
101323, 101175, 101188, 101335, 101322
36247, 99807, 99811, 99855, 99851, 99808, 99812, 99856, 99852, 101190, 101336, 101337, 101323, 101193, 101339, 101340, 
101326, 101178, 101191, 101338, 101325
36248, 99808, 99812, 99856, 99852, 99809, 99813, 99857, 99853, 101193, 101339, 101340, 101326, 101196, 101342, 101343, 
101329, 101181, 101194, 101341, 101328
36249, 99809, 99813, 99857, 99853, 32181, 32182, 32193, 32192, 101196, 101342, 101343, 101329, 32478, 32500, 32501, 
32498, 101184, 101197, 101344, 101331
36250, 13947, 13948, 13959, 13958, 99810, 99814, 99858, 99854, 14245, 14267, 14268, 14265, 101200, 101346, 101347, 
101333, 101185, 101198, 101345, 101332
36251, 99810, 99814, 99858, 99854, 99811, 99815, 99859, 99855, 101200, 101346, 101347, 101333, 101203, 101349, 101350, 
101336, 101188, 101201, 101348, 101335
36252, 99811, 99815, 99859, 99855, 99812, 99816, 99860, 99856, 101203, 101349, 101350, 101336, 101206, 101352, 101353, 
101339, 101191, 101204, 101351, 101338
36253, 99812, 99816, 99860, 99856, 99813, 99817, 99861, 99857, 101206, 101352, 101353, 101339, 101209, 101355, 101356, 
101342, 101194, 101207, 101354, 101341
36254, 99813, 99817, 99861, 99857, 32182, 32183, 32194, 32193, 101209, 101355, 101356, 101342, 32480, 32502, 32503, 
32500, 101197, 101210, 101357, 101344
36255, 13948, 13949, 13960, 13959, 99814, 99818, 99862, 99858, 14247, 14269, 14270, 14267, 101213, 101359, 101360, 
101346, 101198, 101211, 101358, 101345
36256, 99814, 99818, 99862, 99858, 99815, 99819, 99863, 99859, 101213, 101359, 101360, 101346, 101216, 101362, 101363, 
101349, 101201, 101214, 101361, 101348
36257, 99815, 99819, 99863, 99859, 99816, 99820, 99864, 99860, 101216, 101362, 101363, 101349, 101219, 101365, 101366, 
101352, 101204, 101217, 101364, 101351
36258, 99816, 99820, 99864, 99860, 99817, 99821, 99865, 99861, 101219, 101365, 101366, 101352, 101222, 101368, 101369, 
101355, 101207, 101220, 101367, 101354
36259, 99817, 99821, 99865, 99861, 32183, 32184, 32195, 32194, 101222, 101368, 101369, 101355, 32482, 32504, 32505, 
32502, 101210, 101223, 101370, 101357
36260, 13949, 13950, 13961, 13960, 99818, 99822, 99866, 99862, 14249, 14271, 14272, 14269, 101226, 101372, 101373, 
101359, 101211, 101224, 101371, 101358
36261, 99818, 99822, 99866, 99862, 99819, 99823, 99867, 99863, 101226, 101372, 101373, 101359, 101229, 101375, 101376, 
101362, 101214, 101227, 101374, 101361
36262, 99819, 99823, 99867, 99863, 99820, 99824, 99868, 99864, 101229, 101375, 101376, 101362, 101232, 101378, 101379, 
101365, 101217, 101230, 101377, 101364
36263, 99820, 99824, 99868, 99864, 99821, 99825, 99869, 99865, 101232, 101378, 101379, 101365, 101235, 101381, 101382, 
101368, 101220, 101233, 101380, 101367
36264, 99821, 99825, 99869, 99865, 32184, 32185, 32196, 32195, 101235, 101381, 101382, 101368, 32484, 32506, 32507, 
32504, 101223, 101236, 101383, 101370
36265, 13950, 13951, 13962, 13961, 99822, 99826, 99870, 99866, 14251, 14273, 14274, 14271, 101239, 101385, 101386, 
101372, 101224, 101237, 101384, 101371
36266, 99822, 99826, 99870, 99866, 99823, 99827, 99871, 99867, 101239, 101385, 101386, 101372, 101242, 101388, 101389, 
101375, 101227, 101240, 101387, 101374
36267, 99823, 99827, 99871, 99867, 99824, 99828, 99872, 99868, 101242, 101388, 101389, 101375, 101245, 101391, 101392, 
101378, 101230, 101243, 101390, 101377
36268, 99824, 99828, 99872, 99868, 99825, 99829, 99873, 99869, 101245, 101391, 101392, 101378, 101248, 101394, 101395, 
101381, 101233, 101246, 101393, 101380
36269, 99825, 99829, 99873, 99869, 32185, 32186, 32197, 32196, 101248, 101394, 101395, 101381, 32486, 32508, 32509, 
32506, 101236, 101249, 101396, 101383
36270, 13951, 1106, 1107, 13962, 99826, 31705, 31709, 99870, 14252, 1130, 14275, 14273, 101250, 31822, 101397, 
101385, 101237, 31812, 31821, 101384
36271, 99826, 31705, 31709, 99870, 99827, 31706, 31710, 99871, 101250, 31822, 101397, 101385, 101251, 31824, 101398, 
101388, 101240, 31814, 31823, 101387
36272, 99827, 31706, 31710, 99871, 99828, 31707, 31711, 99872, 101251, 31824, 101398, 101388, 101252, 31826, 101399, 
101391, 101243, 31816, 31825, 101390
36273, 99828, 31707, 31711, 99872, 99829, 31708, 31712, 99873, 101252, 31826, 101399, 101391, 101253, 31828, 101400, 
101394, 101246, 31818, 31827, 101393
36274, 99829, 31708, 31712, 99873, 32186, 3288, 3289, 32197, 101253, 31828, 101400, 101394, 32487, 3312, 32510, 
32508, 101249, 31820, 31829, 101396
36275, 1027, 13952, 13963, 1028, 31259, 99830, 99874, 31263, 14254, 14276, 14277, 1051, 101256, 101402, 101403, 
31380, 31372, 101254, 101401, 31381
36276, 31259, 99830, 99874, 31263, 31260, 99831, 99875, 31264, 101256, 101402, 101403, 31380, 101259, 101405, 101406, 
31382, 31374, 101257, 101404, 31383
36277, 31260, 99831, 99875, 31264, 31261, 99832, 99876, 31265, 101259, 101405, 101406, 31382, 101262, 101408, 101409, 
31384, 31376, 101260, 101407, 31385
36278, 31261, 99832, 99876, 31265, 31262, 99833, 99877, 31266, 101262, 101408, 101409, 31384, 101265, 101411, 101412, 
31386, 31378, 101263, 101410, 31387
36279, 31262, 99833, 99877, 31266, 3201, 32187, 32198, 3202, 101265, 101411, 101412, 31386, 32489, 32511, 32512, 
3225, 31379, 101266, 101413, 31388
36280, 13952, 13953, 13964, 13963, 99830, 99834, 99878, 99874, 14256, 14278, 14279, 14276, 101269, 101415, 101416, 
101402, 101254, 101267, 101414, 101401
36281, 99830, 99834, 99878, 99874, 99831, 99835, 99879, 99875, 101269, 101415, 101416, 101402, 101272, 101418, 101419, 
101405, 101257, 101270, 101417, 101404
36282, 99831, 99835, 99879, 99875, 99832, 99836, 99880, 99876, 101272, 101418, 101419, 101405, 101275, 101421, 101422, 
101408, 101260, 101273, 101420, 101407
36283, 99832, 99836, 99880, 99876, 99833, 99837, 99881, 99877, 101275, 101421, 101422, 101408, 101278, 101424, 101425, 
101411, 101263, 101276, 101423, 101410
36284, 99833, 99837, 99881, 99877, 32187, 32188, 32199, 32198, 101278, 101424, 101425, 101411, 32491, 32513, 32514, 
32511, 101266, 101279, 101426, 101413
36285, 13953, 13954, 13965, 13964, 99834, 99838, 99882, 99878, 14258, 14280, 14281, 14278, 101282, 101428, 101429, 
101415, 101267, 101280, 101427, 101414
36286, 99834, 99838, 99882, 99878, 99835, 99839, 99883, 99879, 101282, 101428, 101429, 101415, 101285, 101431, 101432, 
101418, 101270, 101283, 101430, 101417
36287, 99835, 99839, 99883, 99879, 99836, 99840, 99884, 99880, 101285, 101431, 101432, 101418, 101288, 101434, 101435, 
101421, 101273, 101286, 101433, 101420
36288, 99836, 99840, 99884, 99880, 99837, 99841, 99885, 99881, 101288, 101434, 101435, 101421, 101291, 101437, 101438, 
101424, 101276, 101289, 101436, 101423
36289, 99837, 99841, 99885, 99881, 32188, 32189, 32200, 32199, 101291, 101437, 101438, 101424, 32493, 32515, 32516, 
32513, 101279, 101292, 101439, 101426
36290, 13954, 13955, 13966, 13965, 99838, 99842, 99886, 99882, 14260, 14282, 14283, 14280, 101295, 101441, 101442, 
101428, 101280, 101293, 101440, 101427
36291, 99838, 99842, 99886, 99882, 99839, 99843, 99887, 99883, 101295, 101441, 101442, 101428, 101298, 101444, 101445, 
101431, 101283, 101296, 101443, 101430
36292, 99839, 99843, 99887, 99883, 99840, 99844, 99888, 99884, 101298, 101444, 101445, 101431, 101301, 101447, 101448, 
101434, 101286, 101299, 101446, 101433
36293, 99840, 99844, 99888, 99884, 99841, 99845, 99889, 99885, 101301, 101447, 101448, 101434, 101304, 101450, 101451, 
101437, 101289, 101302, 101449, 101436
36294, 99841, 99845, 99889, 99885, 32189, 32190, 32201, 32200, 101304, 101450, 101451, 101437, 32495, 32517, 32518, 
32515, 101292, 101305, 101452, 101439
36295, 13955, 13956, 13967, 13966, 99842, 99846, 99890, 99886, 14262, 14284, 14285, 14282, 101308, 101454, 101455, 
101441, 101293, 101306, 101453, 101440
36296, 99842, 99846, 99890, 99886, 99843, 99847, 99891, 99887, 101308, 101454, 101455, 101441, 101311, 101457, 101458, 
101444, 101296, 101309, 101456, 101443
36297, 99843, 99847, 99891, 99887, 99844, 99848, 99892, 99888, 101311, 101457, 101458, 101444, 101314, 101460, 101461, 
101447, 101299, 101312, 101459, 101446
36298, 99844, 99848, 99892, 99888, 99845, 99849, 99893, 99889, 101314, 101460, 101461, 101447, 101317, 101463, 101464, 
101450, 101302, 101315, 101462, 101449
36299, 99845, 99849, 99893, 99889, 32190, 32191, 32202, 32201, 101317, 101463, 101464, 101450, 32497, 32519, 32520, 
32517, 101305, 101318, 101465, 101452
36300, 13956, 13957, 13968, 13967, 99846, 99850, 99894, 99890, 14264, 14286, 14287, 14284, 101321, 101467, 101468, 
101454, 101306, 101319, 101466, 101453
36301, 99846, 99850, 99894, 99890, 99847, 99851, 99895, 99891, 101321, 101467, 101468, 101454, 101324, 101470, 101471, 
101457, 101309, 101322, 101469, 101456
36302, 99847, 99851, 99895, 99891, 99848, 99852, 99896, 99892, 101324, 101470, 101471, 101457, 101327, 101473, 101474, 
101460, 101312, 101325, 101472, 101459
36303, 99848, 99852, 99896, 99892, 99849, 99853, 99897, 99893, 101327, 101473, 101474, 101460, 101330, 101476, 101477, 
101463, 101315, 101328, 101475, 101462
36304, 99849, 99853, 99897, 99893, 32191, 32192, 32203, 32202, 101330, 101476, 101477, 101463, 32499, 32521, 32522, 
32519, 101318, 101331, 101478, 101465
36305, 13957, 13958, 13969, 13968, 99850, 99854, 99898, 99894, 14266, 14288, 14289, 14286, 101334, 101480, 101481, 
101467, 101319, 101332, 101479, 101466
36306, 99850, 99854, 99898, 99894, 99851, 99855, 99899, 99895, 101334, 101480, 101481, 101467, 101337, 101483, 101484, 
101470, 101322, 101335, 101482, 101469
36307, 99851, 99855, 99899, 99895, 99852, 99856, 99900, 99896, 101337, 101483, 101484, 101470, 101340, 101486, 101487, 
101473, 101325, 101338, 101485, 101472
36308, 99852, 99856, 99900, 99896, 99853, 99857, 99901, 99897, 101340, 101486, 101487, 101473, 101343, 101489, 101490, 
101476, 101328, 101341, 101488, 101475
36309, 99853, 99857, 99901, 99897, 32192, 32193, 32204, 32203, 101343, 101489, 101490, 101476, 32501, 32523, 32524, 
32521, 101331, 101344, 101491, 101478
36310, 13958, 13959, 13970, 13969, 99854, 99858, 99902, 99898, 14268, 14290, 14291, 14288, 101347, 101493, 101494, 
101480, 101332, 101345, 101492, 101479
36311, 99854, 99858, 99902, 99898, 99855, 99859, 99903, 99899, 101347, 101493, 101494, 101480, 101350, 101496, 101497, 
101483, 101335, 101348, 101495, 101482
36312, 99855, 99859, 99903, 99899, 99856, 99860, 99904, 99900, 101350, 101496, 101497, 101483, 101353, 101499, 101500, 
101486, 101338, 101351, 101498, 101485
36313, 99856, 99860, 99904, 99900, 99857, 99861, 99905, 99901, 101353, 101499, 101500, 101486, 101356, 101502, 101503, 
101489, 101341, 101354, 101501, 101488
36314, 99857, 99861, 99905, 99901, 32193, 32194, 32205, 32204, 101356, 101502, 101503, 101489, 32503, 32525, 32526, 
32523, 101344, 101357, 101504, 101491
36315, 13959, 13960, 13971, 13970, 99858, 99862, 99906, 99902, 14270, 14292, 14293, 14290, 101360, 101506, 101507, 
101493, 101345, 101358, 101505, 101492
36316, 99858, 99862, 99906, 99902, 99859, 99863, 99907, 99903, 101360, 101506, 101507, 101493, 101363, 101509, 101510, 
101496, 101348, 101361, 101508, 101495
36317, 99859, 99863, 99907, 99903, 99860, 99864, 99908, 99904, 101363, 101509, 101510, 101496, 101366, 101512, 101513, 
101499, 101351, 101364, 101511, 101498
36318, 99860, 99864, 99908, 99904, 99861, 99865, 99909, 99905, 101366, 101512, 101513, 101499, 101369, 101515, 101516, 
101502, 101354, 101367, 101514, 101501
36319, 99861, 99865, 99909, 99905, 32194, 32195, 32206, 32205, 101369, 101515, 101516, 101502, 32505, 32527, 32528, 
32525, 101357, 101370, 101517, 101504
36320, 13960, 13961, 13972, 13971, 99862, 99866, 99910, 99906, 14272, 14294, 14295, 14292, 101373, 101519, 101520, 
101506, 101358, 101371, 101518, 101505
36321, 99862, 99866, 99910, 99906, 99863, 99867, 99911, 99907, 101373, 101519, 101520, 101506, 101376, 101522, 101523, 
101509, 101361, 101374, 101521, 101508
36322, 99863, 99867, 99911, 99907, 99864, 99868, 99912, 99908, 101376, 101522, 101523, 101509, 101379, 101525, 101526, 
101512, 101364, 101377, 101524, 101511
36323, 99864, 99868, 99912, 99908, 99865, 99869, 99913, 99909, 101379, 101525, 101526, 101512, 101382, 101528, 101529, 
101515, 101367, 101380, 101527, 101514
36324, 99865, 99869, 99913, 99909, 32195, 32196, 32207, 32206, 101382, 101528, 101529, 101515, 32507, 32529, 32530, 
32527, 101370, 101383, 101530, 101517
36325, 13961, 13962, 13973, 13972, 99866, 99870, 99914, 99910, 14274, 14296, 14297, 14294, 101386, 101532, 101533, 
101519, 101371, 101384, 101531, 101518
36326, 99866, 99870, 99914, 99910, 99867, 99871, 99915, 99911, 101386, 101532, 101533, 101519, 101389, 101535, 101536, 
101522, 101374, 101387, 101534, 101521
36327, 99867, 99871, 99915, 99911, 99868, 99872, 99916, 99912, 101389, 101535, 101536, 101522, 101392, 101538, 101539, 
101525, 101377, 101390, 101537, 101524
36328, 99868, 99872, 99916, 99912, 99869, 99873, 99917, 99913, 101392, 101538, 101539, 101525, 101395, 101541, 101542, 
101528, 101380, 101393, 101540, 101527
36329, 99869, 99873, 99917, 99913, 32196, 32197, 32208, 32207, 101395, 101541, 101542, 101528, 32509, 32531, 32532, 
32529, 101383, 101396, 101543, 101530
36330, 13962, 1107, 1108, 13973, 99870, 31709, 31713, 99914, 14275, 1131, 14298, 14296, 101397, 31831, 101544, 
101532, 101384, 31821, 31830, 101531
36331, 99870, 31709, 31713, 99914, 99871, 31710, 31714, 99915, 101397, 31831, 101544, 101532, 101398, 31833, 101545, 
101535, 101387, 31823, 31832, 101534
36332, 99871, 31710, 31714, 99915, 99872, 31711, 31715, 99916, 101398, 31833, 101545, 101535, 101399, 31835, 101546, 
101538, 101390, 31825, 31834, 101537
36333, 99872, 31711, 31715, 99916, 99873, 31712, 31716, 99917, 101399, 31835, 101546, 101538, 101400, 31837, 101547, 
101541, 101393, 31827, 31836, 101540
36334, 99873, 31712, 31716, 99917, 32197, 3289, 3290, 32208, 101400, 31837, 101547, 101541, 32510, 3313, 32533, 
32531, 101396, 31829, 31838, 101543
36335, 1028, 13963, 13974, 1029, 31263, 99874, 99918, 31267, 14277, 14299, 14300, 1052, 101403, 101549, 101550, 
31389, 31381, 101401, 101548, 31390
36336, 31263, 99874, 99918, 31267, 31264, 99875, 99919, 31268, 101403, 101549, 101550, 31389, 101406, 101552, 101553, 
31391, 31383, 101404, 101551, 31392
36337, 31264, 99875, 99919, 31268, 31265, 99876, 99920, 31269, 101406, 101552, 101553, 31391, 101409, 101555, 101556, 
31393, 31385, 101407, 101554, 31394
36338, 31265, 99876, 99920, 31269, 31266, 99877, 99921, 31270, 101409, 101555, 101556, 31393, 101412, 101558, 101559, 
31395, 31387, 101410, 101557, 31396
36339, 31266, 99877, 99921, 31270, 3202, 32198, 32209, 3203, 101412, 101558, 101559, 31395, 32512, 32534, 32535, 
3226, 31388, 101413, 101560, 31397
36340, 13963, 13964, 13975, 13974, 99874, 99878, 99922, 99918, 14279, 14301, 14302, 14299, 101416, 101562, 101563, 
101549, 101401, 101414, 101561, 101548
36341, 99874, 99878, 99922, 99918, 99875, 99879, 99923, 99919, 101416, 101562, 101563, 101549, 101419, 101565, 101566, 
101552, 101404, 101417, 101564, 101551
36342, 99875, 99879, 99923, 99919, 99876, 99880, 99924, 99920, 101419, 101565, 101566, 101552, 101422, 101568, 101569, 
101555, 101407, 101420, 101567, 101554
36343, 99876, 99880, 99924, 99920, 99877, 99881, 99925, 99921, 101422, 101568, 101569, 101555, 101425, 101571, 101572, 
101558, 101410, 101423, 101570, 101557
36344, 99877, 99881, 99925, 99921, 32198, 32199, 32210, 32209, 101425, 101571, 101572, 101558, 32514, 32536, 32537, 
32534, 101413, 101426, 101573, 101560
36345, 13964, 13965, 13976, 13975, 99878, 99882, 99926, 99922, 14281, 14303, 14304, 14301, 101429, 101575, 101576, 
101562, 101414, 101427, 101574, 101561
36346, 99878, 99882, 99926, 99922, 99879, 99883, 99927, 99923, 101429, 101575, 101576, 101562, 101432, 101578, 101579, 
101565, 101417, 101430, 101577, 101564
36347, 99879, 99883, 99927, 99923, 99880, 99884, 99928, 99924, 101432, 101578, 101579, 101565, 101435, 101581, 101582, 
101568, 101420, 101433, 101580, 101567
36348, 99880, 99884, 99928, 99924, 99881, 99885, 99929, 99925, 101435, 101581, 101582, 101568, 101438, 101584, 101585, 
101571, 101423, 101436, 101583, 101570
36349, 99881, 99885, 99929, 99925, 32199, 32200, 32211, 32210, 101438, 101584, 101585, 101571, 32516, 32538, 32539, 
32536, 101426, 101439, 101586, 101573
36350, 13965, 13966, 13977, 13976, 99882, 99886, 99930, 99926, 14283, 14305, 14306, 14303, 101442, 101588, 101589, 
101575, 101427, 101440, 101587, 101574
36351, 99882, 99886, 99930, 99926, 99883, 99887, 99931, 99927, 101442, 101588, 101589, 101575, 101445, 101591, 101592, 
101578, 101430, 101443, 101590, 101577
36352, 99883, 99887, 99931, 99927, 99884, 99888, 99932, 99928, 101445, 101591, 101592, 101578, 101448, 101594, 101595, 
101581, 101433, 101446, 101593, 101580
36353, 99884, 99888, 99932, 99928, 99885, 99889, 99933, 99929, 101448, 101594, 101595, 101581, 101451, 101597, 101598, 
101584, 101436, 101449, 101596, 101583
36354, 99885, 99889, 99933, 99929, 32200, 32201, 32212, 32211, 101451, 101597, 101598, 101584, 32518, 32540, 32541, 
32538, 101439, 101452, 101599, 101586
36355, 13966, 13967, 13978, 13977, 99886, 99890, 99934, 99930, 14285, 14307, 14308, 14305, 101455, 101601, 101602, 
101588, 101440, 101453, 101600, 101587
36356, 99886, 99890, 99934, 99930, 99887, 99891, 99935, 99931, 101455, 101601, 101602, 101588, 101458, 101604, 101605, 
101591, 101443, 101456, 101603, 101590
36357, 99887, 99891, 99935, 99931, 99888, 99892, 99936, 99932, 101458, 101604, 101605, 101591, 101461, 101607, 101608, 
101594, 101446, 101459, 101606, 101593
36358, 99888, 99892, 99936, 99932, 99889, 99893, 99937, 99933, 101461, 101607, 101608, 101594, 101464, 101610, 101611, 
101597, 101449, 101462, 101609, 101596
36359, 99889, 99893, 99937, 99933, 32201, 32202, 32213, 32212, 101464, 101610, 101611, 101597, 32520, 32542, 32543, 
32540, 101452, 101465, 101612, 101599
36360, 13967, 13968, 13979, 13978, 99890, 99894, 99938, 99934, 14287, 14309, 14310, 14307, 101468, 101614, 101615, 
101601, 101453, 101466, 101613, 101600
36361, 99890, 99894, 99938, 99934, 99891, 99895, 99939, 99935, 101468, 101614, 101615, 101601, 101471, 101617, 101618, 
101604, 101456, 101469, 101616, 101603
36362, 99891, 99895, 99939, 99935, 99892, 99896, 99940, 99936, 101471, 101617, 101618, 101604, 101474, 101620, 101621, 
101607, 101459, 101472, 101619, 101606
36363, 99892, 99896, 99940, 99936, 99893, 99897, 99941, 99937, 101474, 101620, 101621, 101607, 101477, 101623, 101624, 
101610, 101462, 101475, 101622, 101609
36364, 99893, 99897, 99941, 99937, 32202, 32203, 32214, 32213, 101477, 101623, 101624, 101610, 32522, 32544, 32545, 
32542, 101465, 101478, 101625, 101612
36365, 13968, 13969, 13980, 13979, 99894, 99898, 99942, 99938, 14289, 14311, 14312, 14309, 101481, 101627, 101628, 
101614, 101466, 101479, 101626, 101613
36366, 99894, 99898, 99942, 99938, 99895, 99899, 99943, 99939, 101481, 101627, 101628, 101614, 101484, 101630, 101631, 
101617, 101469, 101482, 101629, 101616
36367, 99895, 99899, 99943, 99939, 99896, 99900, 99944, 99940, 101484, 101630, 101631, 101617, 101487, 101633, 101634, 
101620, 101472, 101485, 101632, 101619
36368, 99896, 99900, 99944, 99940, 99897, 99901, 99945, 99941, 101487, 101633, 101634, 101620, 101490, 101636, 101637, 
101623, 101475, 101488, 101635, 101622
36369, 99897, 99901, 99945, 99941, 32203, 32204, 32215, 32214, 101490, 101636, 101637, 101623, 32524, 32546, 32547, 
32544, 101478, 101491, 101638, 101625
36370, 13969, 13970, 13981, 13980, 99898, 99902, 99946, 99942, 14291, 14313, 14314, 14311, 101494, 101640, 101641, 
101627, 101479, 101492, 101639, 101626
36371, 99898, 99902, 99946, 99942, 99899, 99903, 99947, 99943, 101494, 101640, 101641, 101627, 101497, 101643, 101644, 
101630, 101482, 101495, 101642, 101629
36372, 99899, 99903, 99947, 99943, 99900, 99904, 99948, 99944, 101497, 101643, 101644, 101630, 101500, 101646, 101647, 
101633, 101485, 101498, 101645, 101632
36373, 99900, 99904, 99948, 99944, 99901, 99905, 99949, 99945, 101500, 101646, 101647, 101633, 101503, 101649, 101650, 
101636, 101488, 101501, 101648, 101635
36374, 99901, 99905, 99949, 99945, 32204, 32205, 32216, 32215, 101503, 101649, 101650, 101636, 32526, 32548, 32549, 
32546, 101491, 101504, 101651, 101638
36375, 13970, 13971, 13982, 13981, 99902, 99906, 99950, 99946, 14293, 14315, 14316, 14313, 101507, 101653, 101654, 
101640, 101492, 101505, 101652, 101639
36376, 99902, 99906, 99950, 99946, 99903, 99907, 99951, 99947, 101507, 101653, 101654, 101640, 101510, 101656, 101657, 
101643, 101495, 101508, 101655, 101642
36377, 99903, 99907, 99951, 99947, 99904, 99908, 99952, 99948, 101510, 101656, 101657, 101643, 101513, 101659, 101660, 
101646, 101498, 101511, 101658, 101645
36378, 99904, 99908, 99952, 99948, 99905, 99909, 99953, 99949, 101513, 101659, 101660, 101646, 101516, 101662, 101663, 
101649, 101501, 101514, 101661, 101648
36379, 99905, 99909, 99953, 99949, 32205, 32206, 32217, 32216, 101516, 101662, 101663, 101649, 32528, 32550, 32551, 
32548, 101504, 101517, 101664, 101651
36380, 13971, 13972, 13983, 13982, 99906, 99910, 99954, 99950, 14295, 14317, 14318, 14315, 101520, 101666, 101667, 
101653, 101505, 101518, 101665, 101652
36381, 99906, 99910, 99954, 99950, 99907, 99911, 99955, 99951, 101520, 101666, 101667, 101653, 101523, 101669, 101670, 
101656, 101508, 101521, 101668, 101655
36382, 99907, 99911, 99955, 99951, 99908, 99912, 99956, 99952, 101523, 101669, 101670, 101656, 101526, 101672, 101673, 
101659, 101511, 101524, 101671, 101658
36383, 99908, 99912, 99956, 99952, 99909, 99913, 99957, 99953, 101526, 101672, 101673, 101659, 101529, 101675, 101676, 
101662, 101514, 101527, 101674, 101661
36384, 99909, 99913, 99957, 99953, 32206, 32207, 32218, 32217, 101529, 101675, 101676, 101662, 32530, 32552, 32553, 
32550, 101517, 101530, 101677, 101664
36385, 13972, 13973, 13984, 13983, 99910, 99914, 99958, 99954, 14297, 14319, 14320, 14317, 101533, 101679, 101680, 
101666, 101518, 101531, 101678, 101665
36386, 99910, 99914, 99958, 99954, 99911, 99915, 99959, 99955, 101533, 101679, 101680, 101666, 101536, 101682, 101683, 
101669, 101521, 101534, 101681, 101668
36387, 99911, 99915, 99959, 99955, 99912, 99916, 99960, 99956, 101536, 101682, 101683, 101669, 101539, 101685, 101686, 
101672, 101524, 101537, 101684, 101671
36388, 99912, 99916, 99960, 99956, 99913, 99917, 99961, 99957, 101539, 101685, 101686, 101672, 101542, 101688, 101689, 
101675, 101527, 101540, 101687, 101674
36389, 99913, 99917, 99961, 99957, 32207, 32208, 32219, 32218, 101542, 101688, 101689, 101675, 32532, 32554, 32555, 
32552, 101530, 101543, 101690, 101677
36390, 13973, 1108, 1109, 13984, 99914, 31713, 31717, 99958, 14298, 1132, 14321, 14319, 101544, 31840, 101691, 
101679, 101531, 31830, 31839, 101678
36391, 99914, 31713, 31717, 99958, 99915, 31714, 31718, 99959, 101544, 31840, 101691, 101679, 101545, 31842, 101692, 
101682, 101534, 31832, 31841, 101681
36392, 99915, 31714, 31718, 99959, 99916, 31715, 31719, 99960, 101545, 31842, 101692, 101682, 101546, 31844, 101693, 
101685, 101537, 31834, 31843, 101684
36393, 99916, 31715, 31719, 99960, 99917, 31716, 31720, 99961, 101546, 31844, 101693, 101685, 101547, 31846, 101694, 
101688, 101540, 31836, 31845, 101687
36394, 99917, 31716, 31720, 99961, 32208, 3290, 3291, 32219, 101547, 31846, 101694, 101688, 32533, 3314, 32556, 
32554, 101543, 31838, 31847, 101690
36395, 1029, 13974, 13985, 1030, 31267, 99918, 99962, 31271, 14300, 14322, 14323, 1053, 101550, 101696, 101697, 
31398, 31390, 101548, 101695, 31399
36396, 31267, 99918, 99962, 31271, 31268, 99919, 99963, 31272, 101550, 101696, 101697, 31398, 101553, 101699, 101700, 
31400, 31392, 101551, 101698, 31401
36397, 31268, 99919, 99963, 31272, 31269, 99920, 99964, 31273, 101553, 101699, 101700, 31400, 101556, 101702, 101703, 
31402, 31394, 101554, 101701, 31403
36398, 31269, 99920, 99964, 31273, 31270, 99921, 99965, 31274, 101556, 101702, 101703, 31402, 101559, 101705, 101706, 
31404, 31396, 101557, 101704, 31405
36399, 31270, 99921, 99965, 31274, 3203, 32209, 32220, 3204, 101559, 101705, 101706, 31404, 32535, 32557, 32558, 
3227, 31397, 101560, 101707, 31406
36400, 13974, 13975, 13986, 13985, 99918, 99922, 99966, 99962, 14302, 14324, 14325, 14322, 101563, 101709, 101710, 
101696, 101548, 101561, 101708, 101695
36401, 99918, 99922, 99966, 99962, 99919, 99923, 99967, 99963, 101563, 101709, 101710, 101696, 101566, 101712, 101713, 
101699, 101551, 101564, 101711, 101698
36402, 99919, 99923, 99967, 99963, 99920, 99924, 99968, 99964, 101566, 101712, 101713, 101699, 101569, 101715, 101716, 
101702, 101554, 101567, 101714, 101701
36403, 99920, 99924, 99968, 99964, 99921, 99925, 99969, 99965, 101569, 101715, 101716, 101702, 101572, 101718, 101719, 
101705, 101557, 101570, 101717, 101704
36404, 99921, 99925, 99969, 99965, 32209, 32210, 32221, 32220, 101572, 101718, 101719, 101705, 32537, 32559, 32560, 
32557, 101560, 101573, 101720, 101707
36405, 13975, 13976, 13987, 13986, 99922, 99926, 99970, 99966, 14304, 14326, 14327, 14324, 101576, 101722, 101723, 
101709, 101561, 101574, 101721, 101708
36406, 99922, 99926, 99970, 99966, 99923, 99927, 99971, 99967, 101576, 101722, 101723, 101709, 101579, 101725, 101726, 
101712, 101564, 101577, 101724, 101711
36407, 99923, 99927, 99971, 99967, 99924, 99928, 99972, 99968, 101579, 101725, 101726, 101712, 101582, 101728, 101729, 
101715, 101567, 101580, 101727, 101714
36408, 99924, 99928, 99972, 99968, 99925, 99929, 99973, 99969, 101582, 101728, 101729, 101715, 101585, 101731, 101732, 
101718, 101570, 101583, 101730, 101717
36409, 99925, 99929, 99973, 99969, 32210, 32211, 32222, 32221, 101585, 101731, 101732, 101718, 32539, 32561, 32562, 
32559, 101573, 101586, 101733, 101720
36410, 13976, 13977, 13988, 13987, 99926, 99930, 99974, 99970, 14306, 14328, 14329, 14326, 101589, 101735, 101736, 
101722, 101574, 101587, 101734, 101721
36411, 99926, 99930, 99974, 99970, 99927, 99931, 99975, 99971, 101589, 101735, 101736, 101722, 101592, 101738, 101739, 
101725, 101577, 101590, 101737, 101724
36412, 99927, 99931, 99975, 99971, 99928, 99932, 99976, 99972, 101592, 101738, 101739, 101725, 101595, 101741, 101742, 
101728, 101580, 101593, 101740, 101727
36413, 99928, 99932, 99976, 99972, 99929, 99933, 99977, 99973, 101595, 101741, 101742, 101728, 101598, 101744, 101745, 
101731, 101583, 101596, 101743, 101730
36414, 99929, 99933, 99977, 99973, 32211, 32212, 32223, 32222, 101598, 101744, 101745, 101731, 32541, 32563, 32564, 
32561, 101586, 101599, 101746, 101733
36415, 13977, 13978, 13989, 13988, 99930, 99934, 99978, 99974, 14308, 14330, 14331, 14328, 101602, 101748, 101749, 
101735, 101587, 101600, 101747, 101734
36416, 99930, 99934, 99978, 99974, 99931, 99935, 99979, 99975, 101602, 101748, 101749, 101735, 101605, 101751, 101752, 
101738, 101590, 101603, 101750, 101737
36417, 99931, 99935, 99979, 99975, 99932, 99936, 99980, 99976, 101605, 101751, 101752, 101738, 101608, 101754, 101755, 
101741, 101593, 101606, 101753, 101740
36418, 99932, 99936, 99980, 99976, 99933, 99937, 99981, 99977, 101608, 101754, 101755, 101741, 101611, 101757, 101758, 
101744, 101596, 101609, 101756, 101743
36419, 99933, 99937, 99981, 99977, 32212, 32213, 32224, 32223, 101611, 101757, 101758, 101744, 32543, 32565, 32566, 
32563, 101599, 101612, 101759, 101746
36420, 13978, 13979, 13990, 13989, 99934, 99938, 99982, 99978, 14310, 14332, 14333, 14330, 101615, 101761, 101762, 
101748, 101600, 101613, 101760, 101747
36421, 99934, 99938, 99982, 99978, 99935, 99939, 99983, 99979, 101615, 101761, 101762, 101748, 101618, 101764, 101765, 
101751, 101603, 101616, 101763, 101750
36422, 99935, 99939, 99983, 99979, 99936, 99940, 99984, 99980, 101618, 101764, 101765, 101751, 101621, 101767, 101768, 
101754, 101606, 101619, 101766, 101753
36423, 99936, 99940, 99984, 99980, 99937, 99941, 99985, 99981, 101621, 101767, 101768, 101754, 101624, 101770, 101771, 
101757, 101609, 101622, 101769, 101756
36424, 99937, 99941, 99985, 99981, 32213, 32214, 32225, 32224, 101624, 101770, 101771, 101757, 32545, 32567, 32568, 
32565, 101612, 101625, 101772, 101759
36425, 13979, 13980, 13991, 13990, 99938, 99942, 99986, 99982, 14312, 14334, 14335, 14332, 101628, 101774, 101775, 
101761, 101613, 101626, 101773, 101760
36426, 99938, 99942, 99986, 99982, 99939, 99943, 99987, 99983, 101628, 101774, 101775, 101761, 101631, 101777, 101778, 
101764, 101616, 101629, 101776, 101763
36427, 99939, 99943, 99987, 99983, 99940, 99944, 99988, 99984, 101631, 101777, 101778, 101764, 101634, 101780, 101781, 
101767, 101619, 101632, 101779, 101766
36428, 99940, 99944, 99988, 99984, 99941, 99945, 99989, 99985, 101634, 101780, 101781, 101767, 101637, 101783, 101784, 
101770, 101622, 101635, 101782, 101769
36429, 99941, 99945, 99989, 99985, 32214, 32215, 32226, 32225, 101637, 101783, 101784, 101770, 32547, 32569, 32570, 
32567, 101625, 101638, 101785, 101772
36430, 13980, 13981, 13992, 13991, 99942, 99946, 99990, 99986, 14314, 14336, 14337, 14334, 101641, 101787, 101788, 
101774, 101626, 101639, 101786, 101773
36431, 99942, 99946, 99990, 99986, 99943, 99947, 99991, 99987, 101641, 101787, 101788, 101774, 101644, 101790, 101791, 
101777, 101629, 101642, 101789, 101776
36432, 99943, 99947, 99991, 99987, 99944, 99948, 99992, 99988, 101644, 101790, 101791, 101777, 101647, 101793, 101794, 
101780, 101632, 101645, 101792, 101779
36433, 99944, 99948, 99992, 99988, 99945, 99949, 99993, 99989, 101647, 101793, 101794, 101780, 101650, 101796, 101797, 
101783, 101635, 101648, 101795, 101782
36434, 99945, 99949, 99993, 99989, 32215, 32216, 32227, 32226, 101650, 101796, 101797, 101783, 32549, 32571, 32572, 
32569, 101638, 101651, 101798, 101785
36435, 13981, 13982, 13993, 13992, 99946, 99950, 99994, 99990, 14316, 14338, 14339, 14336, 101654, 101800, 101801, 
101787, 101639, 101652, 101799, 101786
36436, 99946, 99950, 99994, 99990, 99947, 99951, 99995, 99991, 101654, 101800, 101801, 101787, 101657, 101803, 101804, 
101790, 101642, 101655, 101802, 101789
36437, 99947, 99951, 99995, 99991, 99948, 99952, 99996, 99992, 101657, 101803, 101804, 101790, 101660, 101806, 101807, 
101793, 101645, 101658, 101805, 101792
36438, 99948, 99952, 99996, 99992, 99949, 99953, 99997, 99993, 101660, 101806, 101807, 101793, 101663, 101809, 101810, 
101796, 101648, 101661, 101808, 101795
36439, 99949, 99953, 99997, 99993, 32216, 32217, 32228, 32227, 101663, 101809, 101810, 101796, 32551, 32573, 32574, 
32571, 101651, 101664, 101811, 101798
36440, 13982, 13983, 13994, 13993, 99950, 99954, 99998, 99994, 14318, 14340, 14341, 14338, 101667, 101813, 101814, 
101800, 101652, 101665, 101812, 101799
36441, 99950, 99954, 99998, 99994, 99951, 99955, 99999, 99995, 101667, 101813, 101814, 101800, 101670, 101816, 101817, 
101803, 101655, 101668, 101815, 101802
36442, 99951, 99955, 99999, 99995, 99952, 99956, 100000, 99996, 101670, 101816, 101817, 101803, 101673, 101819, 101820, 
101806, 101658, 101671, 101818, 101805
36443, 99952, 99956, 100000, 99996, 99953, 99957, 100001, 99997, 101673, 101819, 101820, 101806, 101676, 101822, 101823, 
101809, 101661, 101674, 101821, 101808
36444, 99953, 99957, 100001, 99997, 32217, 32218, 32229, 32228, 101676, 101822, 101823, 101809, 32553, 32575, 32576, 
32573, 101664, 101677, 101824, 101811
36445, 13983, 13984, 13995, 13994, 99954, 99958, 100002, 99998, 14320, 14342, 14343, 14340, 101680, 101826, 101827, 
101813, 101665, 101678, 101825, 101812
36446, 99954, 99958, 100002, 99998, 99955, 99959, 100003, 99999, 101680, 101826, 101827, 101813, 101683, 101829, 101830, 
101816, 101668, 101681, 101828, 101815
36447, 99955, 99959, 100003, 99999, 99956, 99960, 100004, 100000, 101683, 101829, 101830, 101816, 101686, 101832, 101833, 
101819, 101671, 101684, 101831, 101818
36448, 99956, 99960, 100004, 100000, 99957, 99961, 100005, 100001, 101686, 101832, 101833, 101819, 101689, 101835, 101836, 
101822, 101674, 101687, 101834, 101821
36449, 99957, 99961, 100005, 100001, 32218, 32219, 32230, 32229, 101689, 101835, 101836, 101822, 32555, 32577, 32578, 
32575, 101677, 101690, 101837, 101824
36450, 13984, 1109, 1110, 13995, 99958, 31717, 31721, 100002, 14321, 1133, 14344, 14342, 101691, 31849, 101838, 
101826, 101678, 31839, 31848, 101825
36451, 99958, 31717, 31721, 100002, 99959, 31718, 31722, 100003, 101691, 31849, 101838, 101826, 101692, 31851, 101839, 
101829, 101681, 31841, 31850, 101828
36452, 99959, 31718, 31722, 100003, 99960, 31719, 31723, 100004, 101692, 31851, 101839, 101829, 101693, 31853, 101840, 
101832, 101684, 31843, 31852, 101831
36453, 99960, 31719, 31723, 100004, 99961, 31720, 31724, 100005, 101693, 31853, 101840, 101832, 101694, 31855, 101841, 
101835, 101687, 31845, 31854, 101834
36454, 99961, 31720, 31724, 100005, 32219, 3291, 3292, 32230, 101694, 31855, 101841, 101835, 32556, 3315, 32579, 
32577, 101690, 31847, 31856, 101837
36455, 1030, 13985, 13996, 1031, 31271, 99962, 100006, 31275, 14323, 14345, 14346, 1054, 101697, 101843, 101844, 
31407, 31399, 101695, 101842, 31408
36456, 31271, 99962, 100006, 31275, 31272, 99963, 100007, 31276, 101697, 101843, 101844, 31407, 101700, 101846, 101847, 
31409, 31401, 101698, 101845, 31410
36457, 31272, 99963, 100007, 31276, 31273, 99964, 100008, 31277, 101700, 101846, 101847, 31409, 101703, 101849, 101850, 
31411, 31403, 101701, 101848, 31412
36458, 31273, 99964, 100008, 31277, 31274, 99965, 100009, 31278, 101703, 101849, 101850, 31411, 101706, 101852, 101853, 
31413, 31405, 101704, 101851, 31414
36459, 31274, 99965, 100009, 31278, 3204, 32220, 32231, 3205, 101706, 101852, 101853, 31413, 32558, 32580, 32581, 
3228, 31406, 101707, 101854, 31415
36460, 13985, 13986, 13997, 13996, 99962, 99966, 100010, 100006, 14325, 14347, 14348, 14345, 101710, 101856, 101857, 
101843, 101695, 101708, 101855, 101842
36461, 99962, 99966, 100010, 100006, 99963, 99967, 100011, 100007, 101710, 101856, 101857, 101843, 101713, 101859, 101860, 
101846, 101698, 101711, 101858, 101845
36462, 99963, 99967, 100011, 100007, 99964, 99968, 100012, 100008, 101713, 101859, 101860, 101846, 101716, 101862, 101863, 
101849, 101701, 101714, 101861, 101848
36463, 99964, 99968, 100012, 100008, 99965, 99969, 100013, 100009, 101716, 101862, 101863, 101849, 101719, 101865, 101866, 
101852, 101704, 101717, 101864, 101851
36464, 99965, 99969, 100013, 100009, 32220, 32221, 32232, 32231, 101719, 101865, 101866, 101852, 32560, 32582, 32583, 
32580, 101707, 101720, 101867, 101854
36465, 13986, 13987, 13998, 13997, 99966, 99970, 100014, 100010, 14327, 14349, 14350, 14347, 101723, 101869, 101870, 
101856, 101708, 101721, 101868, 101855
36466, 99966, 99970, 100014, 100010, 99967, 99971, 100015, 100011, 101723, 101869, 101870, 101856, 101726, 101872, 101873, 
101859, 101711, 101724, 101871, 101858
36467, 99967, 99971, 100015, 100011, 99968, 99972, 100016, 100012, 101726, 101872, 101873, 101859, 101729, 101875, 101876, 
101862, 101714, 101727, 101874, 101861
36468, 99968, 99972, 100016, 100012, 99969, 99973, 100017, 100013, 101729, 101875, 101876, 101862, 101732, 101878, 101879, 
101865, 101717, 101730, 101877, 101864
36469, 99969, 99973, 100017, 100013, 32221, 32222, 32233, 32232, 101732, 101878, 101879, 101865, 32562, 32584, 32585, 
32582, 101720, 101733, 101880, 101867
36470, 13987, 13988, 13999, 13998, 99970, 99974, 100018, 100014, 14329, 14351, 14352, 14349, 101736, 101882, 101883, 
101869, 101721, 101734, 101881, 101868
36471, 99970, 99974, 100018, 100014, 99971, 99975, 100019, 100015, 101736, 101882, 101883, 101869, 101739, 101885, 101886, 
101872, 101724, 101737, 101884, 101871
36472, 99971, 99975, 100019, 100015, 99972, 99976, 100020, 100016, 101739, 101885, 101886, 101872, 101742, 101888, 101889, 
101875, 101727, 101740, 101887, 101874
36473, 99972, 99976, 100020, 100016, 99973, 99977, 100021, 100017, 101742, 101888, 101889, 101875, 101745, 101891, 101892, 
101878, 101730, 101743, 101890, 101877
36474, 99973, 99977, 100021, 100017, 32222, 32223, 32234, 32233, 101745, 101891, 101892, 101878, 32564, 32586, 32587, 
32584, 101733, 101746, 101893, 101880
36475, 13988, 13989, 14000, 13999, 99974, 99978, 100022, 100018, 14331, 14353, 14354, 14351, 101749, 101895, 101896, 
101882, 101734, 101747, 101894, 101881
36476, 99974, 99978, 100022, 100018, 99975, 99979, 100023, 100019, 101749, 101895, 101896, 101882, 101752, 101898, 101899, 
101885, 101737, 101750, 101897, 101884
36477, 99975, 99979, 100023, 100019, 99976, 99980, 100024, 100020, 101752, 101898, 101899, 101885, 101755, 101901, 101902, 
101888, 101740, 101753, 101900, 101887
36478, 99976, 99980, 100024, 100020, 99977, 99981, 100025, 100021, 101755, 101901, 101902, 101888, 101758, 101904, 101905, 
101891, 101743, 101756, 101903, 101890
36479, 99977, 99981, 100025, 100021, 32223, 32224, 32235, 32234, 101758, 101904, 101905, 101891, 32566, 32588, 32589, 
32586, 101746, 101759, 101906, 101893
36480, 13989, 13990, 14001, 14000, 99978, 99982, 100026, 100022, 14333, 14355, 14356, 14353, 101762, 101908, 101909, 
101895, 101747, 101760, 101907, 101894
36481, 99978, 99982, 100026, 100022, 99979, 99983, 100027, 100023, 101762, 101908, 101909, 101895, 101765, 101911, 101912, 
101898, 101750, 101763, 101910, 101897
36482, 99979, 99983, 100027, 100023, 99980, 99984, 100028, 100024, 101765, 101911, 101912, 101898, 101768, 101914, 101915, 
101901, 101753, 101766, 101913, 101900
36483, 99980, 99984, 100028, 100024, 99981, 99985, 100029, 100025, 101768, 101914, 101915, 101901, 101771, 101917, 101918, 
101904, 101756, 101769, 101916, 101903
36484, 99981, 99985, 100029, 100025, 32224, 32225, 32236, 32235, 101771, 101917, 101918, 101904, 32568, 32590, 32591, 
32588, 101759, 101772, 101919, 101906
36485, 13990, 13991, 14002, 14001, 99982, 99986, 100030, 100026, 14335, 14357, 14358, 14355, 101775, 101921, 101922, 
101908, 101760, 101773, 101920, 101907
36486, 99982, 99986, 100030, 100026, 99983, 99987, 100031, 100027, 101775, 101921, 101922, 101908, 101778, 101924, 101925, 
101911, 101763, 101776, 101923, 101910
36487, 99983, 99987, 100031, 100027, 99984, 99988, 100032, 100028, 101778, 101924, 101925, 101911, 101781, 101927, 101928, 
101914, 101766, 101779, 101926, 101913
36488, 99984, 99988, 100032, 100028, 99985, 99989, 100033, 100029, 101781, 101927, 101928, 101914, 101784, 101930, 101931, 
101917, 101769, 101782, 101929, 101916
36489, 99985, 99989, 100033, 100029, 32225, 32226, 32237, 32236, 101784, 101930, 101931, 101917, 32570, 32592, 32593, 
32590, 101772, 101785, 101932, 101919
36490, 13991, 13992, 14003, 14002, 99986, 99990, 100034, 100030, 14337, 14359, 14360, 14357, 101788, 101934, 101935, 
101921, 101773, 101786, 101933, 101920
36491, 99986, 99990, 100034, 100030, 99987, 99991, 100035, 100031, 101788, 101934, 101935, 101921, 101791, 101937, 101938, 
101924, 101776, 101789, 101936, 101923
36492, 99987, 99991, 100035, 100031, 99988, 99992, 100036, 100032, 101791, 101937, 101938, 101924, 101794, 101940, 101941, 
101927, 101779, 101792, 101939, 101926
36493, 99988, 99992, 100036, 100032, 99989, 99993, 100037, 100033, 101794, 101940, 101941, 101927, 101797, 101943, 101944, 
101930, 101782, 101795, 101942, 101929
36494, 99989, 99993, 100037, 100033, 32226, 32227, 32238, 32237, 101797, 101943, 101944, 101930, 32572, 32594, 32595, 
32592, 101785, 101798, 101945, 101932
36495, 13992, 13993, 14004, 14003, 99990, 99994, 100038, 100034, 14339, 14361, 14362, 14359, 101801, 101947, 101948, 
101934, 101786, 101799, 101946, 101933
36496, 99990, 99994, 100038, 100034, 99991, 99995, 100039, 100035, 101801, 101947, 101948, 101934, 101804, 101950, 101951, 
101937, 101789, 101802, 101949, 101936
36497, 99991, 99995, 100039, 100035, 99992, 99996, 100040, 100036, 101804, 101950, 101951, 101937, 101807, 101953, 101954, 
101940, 101792, 101805, 101952, 101939
36498, 99992, 99996, 100040, 100036, 99993, 99997, 100041, 100037, 101807, 101953, 101954, 101940, 101810, 101956, 101957, 
101943, 101795, 101808, 101955, 101942
36499, 99993, 99997, 100041, 100037, 32227, 32228, 32239, 32238, 101810, 101956, 101957, 101943, 32574, 32596, 32597, 
32594, 101798, 101811, 101958, 101945
36500, 13993, 13994, 14005, 14004, 99994, 99998, 100042, 100038, 14341, 14363, 14364, 14361, 101814, 101960, 101961, 
101947, 101799, 101812, 101959, 101946
36501, 99994, 99998, 100042, 100038, 99995, 99999, 100043, 100039, 101814, 101960, 101961, 101947, 101817, 101963, 101964, 
101950, 101802, 101815, 101962, 101949
36502, 99995, 99999, 100043, 100039, 99996, 100000, 100044, 100040, 101817, 101963, 101964, 101950, 101820, 101966, 101967, 
101953, 101805, 101818, 101965, 101952
36503, 99996, 100000, 100044, 100040, 99997, 100001, 100045, 100041, 101820, 101966, 101967, 101953, 101823, 101969, 101970, 
101956, 101808, 101821, 101968, 101955
36504, 99997, 100001, 100045, 100041, 32228, 32229, 32240, 32239, 101823, 101969, 101970, 101956, 32576, 32598, 32599, 
32596, 101811, 101824, 101971, 101958
36505, 13994, 13995, 14006, 14005, 99998, 100002, 100046, 100042, 14343, 14365, 14366, 14363, 101827, 101973, 101974, 
101960, 101812, 101825, 101972, 101959
36506, 99998, 100002, 100046, 100042, 99999, 100003, 100047, 100043, 101827, 101973, 101974, 101960, 101830, 101976, 101977, 
101963, 101815, 101828, 101975, 101962
36507, 99999, 100003, 100047, 100043, 100000, 100004, 100048, 100044, 101830, 101976, 101977, 101963, 101833, 101979, 101980, 
101966, 101818, 101831, 101978, 101965
36508, 100000, 100004, 100048, 100044, 100001, 100005, 100049, 100045, 101833, 101979, 101980, 101966, 101836, 101982, 101983, 
101969, 101821, 101834, 101981, 101968
36509, 100001, 100005, 100049, 100045, 32229, 32230, 32241, 32240, 101836, 101982, 101983, 101969, 32578, 32600, 32601, 
32598, 101824, 101837, 101984, 101971
36510, 13995, 1110, 1111, 14006, 100002, 31721, 31725, 100046, 14344, 1134, 14367, 14365, 101838, 31858, 101985, 
101973, 101825, 31848, 31857, 101972
36511, 100002, 31721, 31725, 100046, 100003, 31722, 31726, 100047, 101838, 31858, 101985, 101973, 101839, 31860, 101986, 
101976, 101828, 31850, 31859, 101975
36512, 100003, 31722, 31726, 100047, 100004, 31723, 31727, 100048, 101839, 31860, 101986, 101976, 101840, 31862, 101987, 
101979, 101831, 31852, 31861, 101978
36513, 100004, 31723, 31727, 100048, 100005, 31724, 31728, 100049, 101840, 31862, 101987, 101979, 101841, 31864, 101988, 
101982, 101834, 31854, 31863, 101981
36514, 100005, 31724, 31728, 100049, 32230, 3292, 3293, 32241, 101841, 31864, 101988, 101982, 32579, 3316, 32602, 
32600, 101837, 31856, 31865, 101984
36515, 1031, 13996, 14007, 1032, 31275, 100006, 100050, 31279, 14346, 14368, 14369, 1055, 101844, 101990, 101991, 
31416, 31408, 101842, 101989, 31417
36516, 31275, 100006, 100050, 31279, 31276, 100007, 100051, 31280, 101844, 101990, 101991, 31416, 101847, 101993, 101994, 
31418, 31410, 101845, 101992, 31419
36517, 31276, 100007, 100051, 31280, 31277, 100008, 100052, 31281, 101847, 101993, 101994, 31418, 101850, 101996, 101997, 
31420, 31412, 101848, 101995, 31421
36518, 31277, 100008, 100052, 31281, 31278, 100009, 100053, 31282, 101850, 101996, 101997, 31420, 101853, 101999, 102000, 
31422, 31414, 101851, 101998, 31423
36519, 31278, 100009, 100053, 31282, 3205, 32231, 32242, 3206, 101853, 101999, 102000, 31422, 32581, 32603, 32604, 
3229, 31415, 101854, 102001, 31424
36520, 13996, 13997, 14008, 14007, 100006, 100010, 100054, 100050, 14348, 14370, 14371, 14368, 101857, 102003, 102004, 
101990, 101842, 101855, 102002, 101989
36521, 100006, 100010, 100054, 100050, 100007, 100011, 100055, 100051, 101857, 102003, 102004, 101990, 101860, 102006, 102007, 
101993, 101845, 101858, 102005, 101992
36522, 100007, 100011, 100055, 100051, 100008, 100012, 100056, 100052, 101860, 102006, 102007, 101993, 101863, 102009, 102010, 
101996, 101848, 101861, 102008, 101995
36523, 100008, 100012, 100056, 100052, 100009, 100013, 100057, 100053, 101863, 102009, 102010, 101996, 101866, 102012, 102013, 
101999, 101851, 101864, 102011, 101998
36524, 100009, 100013, 100057, 100053, 32231, 32232, 32243, 32242, 101866, 102012, 102013, 101999, 32583, 32605, 32606, 
32603, 101854, 101867, 102014, 102001
36525, 13997, 13998, 14009, 14008, 100010, 100014, 100058, 100054, 14350, 14372, 14373, 14370, 101870, 102016, 102017, 
102003, 101855, 101868, 102015, 102002
36526, 100010, 100014, 100058, 100054, 100011, 100015, 100059, 100055, 101870, 102016, 102017, 102003, 101873, 102019, 102020, 
102006, 101858, 101871, 102018, 102005
36527, 100011, 100015, 100059, 100055, 100012, 100016, 100060, 100056, 101873, 102019, 102020, 102006, 101876, 102022, 102023, 
102009, 101861, 101874, 102021, 102008
36528, 100012, 100016, 100060, 100056, 100013, 100017, 100061, 100057, 101876, 102022, 102023, 102009, 101879, 102025, 102026, 
102012, 101864, 101877, 102024, 102011
36529, 100013, 100017, 100061, 100057, 32232, 32233, 32244, 32243, 101879, 102025, 102026, 102012, 32585, 32607, 32608, 
32605, 101867, 101880, 102027, 102014
36530, 13998, 13999, 14010, 14009, 100014, 100018, 100062, 100058, 14352, 14374, 14375, 14372, 101883, 102029, 102030, 
102016, 101868, 101881, 102028, 102015
36531, 100014, 100018, 100062, 100058, 100015, 100019, 100063, 100059, 101883, 102029, 102030, 102016, 101886, 102032, 102033, 
102019, 101871, 101884, 102031, 102018
36532, 100015, 100019, 100063, 100059, 100016, 100020, 100064, 100060, 101886, 102032, 102033, 102019, 101889, 102035, 102036, 
102022, 101874, 101887, 102034, 102021
36533, 100016, 100020, 100064, 100060, 100017, 100021, 100065, 100061, 101889, 102035, 102036, 102022, 101892, 102038, 102039, 
102025, 101877, 101890, 102037, 102024
36534, 100017, 100021, 100065, 100061, 32233, 32234, 32245, 32244, 101892, 102038, 102039, 102025, 32587, 32609, 32610, 
32607, 101880, 101893, 102040, 102027
36535, 13999, 14000, 14011, 14010, 100018, 100022, 100066, 100062, 14354, 14376, 14377, 14374, 101896, 102042, 102043, 
102029, 101881, 101894, 102041, 102028
36536, 100018, 100022, 100066, 100062, 100019, 100023, 100067, 100063, 101896, 102042, 102043, 102029, 101899, 102045, 102046, 
102032, 101884, 101897, 102044, 102031
36537, 100019, 100023, 100067, 100063, 100020, 100024, 100068, 100064, 101899, 102045, 102046, 102032, 101902, 102048, 102049, 
102035, 101887, 101900, 102047, 102034
36538, 100020, 100024, 100068, 100064, 100021, 100025, 100069, 100065, 101902, 102048, 102049, 102035, 101905, 102051, 102052, 
102038, 101890, 101903, 102050, 102037
36539, 100021, 100025, 100069, 100065, 32234, 32235, 32246, 32245, 101905, 102051, 102052, 102038, 32589, 32611, 32612, 
32609, 101893, 101906, 102053, 102040
36540, 14000, 14001, 14012, 14011, 100022, 100026, 100070, 100066, 14356, 14378, 14379, 14376, 101909, 102055, 102056, 
102042, 101894, 101907, 102054, 102041
36541, 100022, 100026, 100070, 100066, 100023, 100027, 100071, 100067, 101909, 102055, 102056, 102042, 101912, 102058, 102059, 
102045, 101897, 101910, 102057, 102044
36542, 100023, 100027, 100071, 100067, 100024, 100028, 100072, 100068, 101912, 102058, 102059, 102045, 101915, 102061, 102062, 
102048, 101900, 101913, 102060, 102047
36543, 100024, 100028, 100072, 100068, 100025, 100029, 100073, 100069, 101915, 102061, 102062, 102048, 101918, 102064, 102065, 
102051, 101903, 101916, 102063, 102050
