77573, 1.575, 0.375, 0.041666666666667
77574, 1.575, 0.35, 0.020833333333333
77575, 1.5541666666667, 0.35, 0.041666666666667
77576, 1.575, 0.325, 0.041666666666667
77577, 1.575, 0.3, 0.020833333333333
77578, 1.5541666666667, 0.3, 0.041666666666667
77579, 1.575, 0.275, 0.041666666666667
77580, 1.575, 0.25, 0.020833333333333
77581, 1.5541666666667, 0.25, 0.041666666666667
77582, 1.575, 0.225, 0.041666666666667
77583, 1.575, 0.2, 0.020833333333333
77584, 1.5541666666667, 0.2, 0.041666666666667
77585, 1.575, 0.175, 0.041666666666667
77586, 1.6166666666667, 1.325, 0.041666666666667
77587, 1.6166666666667, 1.3, 0.020833333333333
77588, 1.5958333333333, 1.3, 0.041666666666667
77589, 1.6166666666667, 1.275, 0.041666666666667
77590, 1.6166666666667, 1.25, 0.020833333333333
77591, 1.5958333333333, 1.25, 0.041666666666667
77592, 1.6166666666667, 1.225, 0.041666666666667
77593, 1.6166666666667, 1.2, 0.020833333333333
77594, 1.5958333333333, 1.2, 0.041666666666667
77595, 1.6166666666667, 1.175, 0.041666666666667
77596, 1.6166666666667, 1.15, 0.020833333333333
77597, 1.5958333333333, 1.15, 0.041666666666667
77598, 1.6166666666667, 1.125, 0.041666666666667
77599, 1.6166666666667, 1.1, 0.020833333333333
77600, 1.5958333333333, 1.1, 0.041666666666667
77601, 1.6166666666667, 1.075, 0.041666666666667
77602, 1.6166666666667, 1.05, 0.020833333333333
77603, 1.5958333333333, 1.05, 0.041666666666667
77604, 1.6166666666667, 1.025, 0.041666666666667
77605, 1.6166666666667, 1, 0.020833333333333
77606, 1.5958333333333, 1, 0.041666666666667
77607, 1.6166666666667, 0.975, 0.041666666666667
77608, 1.6166666666667, 0.95, 0.020833333333333
77609, 1.5958333333333, 0.95, 0.041666666666667
77610, 1.6166666666667, 0.925, 0.041666666666667
77611, 1.6166666666667, 0.9, 0.020833333333333
77612, 1.5958333333333, 0.9, 0.041666666666667
77613, 1.6166666666667, 0.875, 0.041666666666667
77614, 1.6166666666667, 0.85, 0.020833333333333
77615, 1.5958333333333, 0.85, 0.041666666666667
77616, 1.6166666666667, 0.825, 0.041666666666667
77617, 1.6166666666667, 0.8, 0.020833333333333
77618, 1.5958333333333, 0.8, 0.041666666666667
77619, 1.6166666666667, 0.775, 0.041666666666667
77620, 1.6166666666667, 0.75, 0.020833333333333
77621, 1.5958333333333, 0.75, 0.041666666666667
77622, 1.6166666666667, 0.725, 0.041666666666667
77623, 1.6166666666667, 0.7, 0.020833333333333
77624, 1.5958333333333, 0.7, 0.041666666666667
77625, 1.6166666666667, 0.675, 0.041666666666667
77626, 1.6166666666667, 0.65, 0.020833333333333
77627, 1.5958333333333, 0.65, 0.041666666666667
77628, 1.6166666666667, 0.625, 0.041666666666667
77629, 1.6166666666667, 0.6, 0.020833333333333
77630, 1.5958333333333, 0.6, 0.041666666666667
77631, 1.6166666666667, 0.575, 0.041666666666667
77632, 1.6166666666667, 0.55, 0.020833333333333
77633, 1.5958333333333, 0.55, 0.041666666666667
77634, 1.6166666666667, 0.525, 0.041666666666667
77635, 1.6166666666667, 0.5, 0.020833333333333
77636, 1.5958333333333, 0.5, 0.041666666666667
77637, 1.6166666666667, 0.475, 0.041666666666667
77638, 1.6166666666667, 0.45, 0.020833333333333
77639, 1.5958333333333, 0.45, 0.041666666666667
77640, 1.6166666666667, 0.425, 0.041666666666667
77641, 1.6166666666667, 0.4, 0.020833333333333
77642, 1.5958333333333, 0.4, 0.041666666666667
77643, 1.6166666666667, 0.375, 0.041666666666667
77644, 1.6166666666667, 0.35, 0.020833333333333
77645, 1.5958333333333, 0.35, 0.041666666666667
77646, 1.6166666666667, 0.325, 0.041666666666667
77647, 1.6166666666667, 0.3, 0.020833333333333
77648, 1.5958333333333, 0.3, 0.041666666666667
77649, 1.6166666666667, 0.275, 0.041666666666667
77650, 1.6166666666667, 0.25, 0.020833333333333
77651, 1.5958333333333, 0.25, 0.041666666666667
77652, 1.6166666666667, 0.225, 0.041666666666667
77653, 1.6166666666667, 0.2, 0.020833333333333
77654, 1.5958333333333, 0.2, 0.041666666666667
77655, 1.6166666666667, 0.175, 0.041666666666667
77656, 1.6583333333333, 1.325, 0.041666666666667
77657, 1.6583333333333, 1.3, 0.020833333333333
77658, 1.6375, 1.3, 0.041666666666667
77659, 1.6583333333333, 1.275, 0.041666666666667
77660, 1.6583333333333, 1.25, 0.020833333333333
77661, 1.6375, 1.25, 0.041666666666667
77662, 1.6583333333333, 1.225, 0.041666666666667
77663, 1.6583333333333, 1.2, 0.020833333333333
77664, 1.6375, 1.2, 0.041666666666667
77665, 1.6583333333333, 1.175, 0.041666666666667
77666, 1.6583333333333, 1.15, 0.020833333333333
77667, 1.6375, 1.15, 0.041666666666667
77668, 1.6583333333333, 1.125, 0.041666666666667
77669, 1.6583333333333, 1.1, 0.020833333333333
77670, 1.6375, 1.1, 0.041666666666667
77671, 1.6583333333333, 1.075, 0.041666666666667
77672, 1.6583333333333, 1.05, 0.020833333333333
77673, 1.6375, 1.05, 0.041666666666667
77674, 1.6583333333333, 1.025, 0.041666666666667
77675, 1.6583333333333, 1, 0.020833333333333
77676, 1.6375, 1, 0.041666666666667
77677, 1.6583333333333, 0.975, 0.041666666666667
77678, 1.6583333333333, 0.95, 0.020833333333333
77679, 1.6375, 0.95, 0.041666666666667
77680, 1.6583333333333, 0.925, 0.041666666666667
77681, 1.6583333333333, 0.9, 0.020833333333333
77682, 1.6375, 0.9, 0.041666666666667
77683, 1.6583333333333, 0.875, 0.041666666666667
77684, 1.6583333333333, 0.85, 0.020833333333333
77685, 1.6375, 0.85, 0.041666666666667
77686, 1.6583333333333, 0.825, 0.041666666666667
77687, 1.6583333333333, 0.8, 0.020833333333333
77688, 1.6375, 0.8, 0.041666666666667
77689, 1.6583333333333, 0.775, 0.041666666666667
77690, 1.6583333333333, 0.75, 0.020833333333333
77691, 1.6375, 0.75, 0.041666666666667
77692, 1.6583333333333, 0.725, 0.041666666666667
77693, 1.6583333333333, 0.7, 0.020833333333333
77694, 1.6375, 0.7, 0.041666666666667
77695, 1.6583333333333, 0.675, 0.041666666666667
77696, 1.6583333333333, 0.65, 0.020833333333333
77697, 1.6375, 0.65, 0.041666666666667
77698, 1.6583333333333, 0.625, 0.041666666666667
77699, 1.6583333333333, 0.6, 0.020833333333333
77700, 1.6375, 0.6, 0.041666666666667
77701, 1.6583333333333, 0.575, 0.041666666666667
77702, 1.6583333333333, 0.55, 0.020833333333333
77703, 1.6375, 0.55, 0.041666666666667
77704, 1.6583333333333, 0.525, 0.041666666666667
77705, 1.6583333333333, 0.5, 0.020833333333333
77706, 1.6375, 0.5, 0.041666666666667
77707, 1.6583333333333, 0.475, 0.041666666666667
77708, 1.6583333333333, 0.45, 0.020833333333333
77709, 1.6375, 0.45, 0.041666666666667
77710, 1.6583333333333, 0.425, 0.041666666666667
77711, 1.6583333333333, 0.4, 0.020833333333333
77712, 1.6375, 0.4, 0.041666666666667
77713, 1.6583333333333, 0.375, 0.041666666666667
77714, 1.6583333333333, 0.35, 0.020833333333333
77715, 1.6375, 0.35, 0.041666666666667
77716, 1.6583333333333, 0.325, 0.041666666666667
77717, 1.6583333333333, 0.3, 0.020833333333333
77718, 1.6375, 0.3, 0.041666666666667
77719, 1.6583333333333, 0.275, 0.041666666666667
77720, 1.6583333333333, 0.25, 0.020833333333333
77721, 1.6375, 0.25, 0.041666666666667
77722, 1.6583333333333, 0.225, 0.041666666666667
77723, 1.6583333333333, 0.2, 0.020833333333333
77724, 1.6375, 0.2, 0.041666666666667
77725, 1.6583333333333, 0.175, 0.041666666666667
77726, 1.7, 1.325, 0.041666666666667
77727, 1.7, 1.3, 0.020833333333333
77728, 1.6791666666667, 1.3, 0.041666666666667
77729, 1.7, 1.275, 0.041666666666667
77730, 1.7, 1.25, 0.020833333333333
77731, 1.6791666666667, 1.25, 0.041666666666667
77732, 1.7, 1.225, 0.041666666666667
77733, 1.7, 1.2, 0.020833333333333
77734, 1.6791666666667, 1.2, 0.041666666666667
77735, 1.7, 1.175, 0.041666666666667
77736, 1.7, 1.15, 0.020833333333333
77737, 1.6791666666667, 1.15, 0.041666666666667
77738, 1.7, 1.125, 0.041666666666667
77739, 1.7, 1.1, 0.020833333333333
77740, 1.6791666666667, 1.1, 0.041666666666667
77741, 1.7, 1.075, 0.041666666666667
77742, 1.7, 1.05, 0.020833333333333
77743, 1.6791666666667, 1.05, 0.041666666666667
77744, 1.7, 1.025, 0.041666666666667
77745, 1.7, 1, 0.020833333333333
77746, 1.6791666666667, 1, 0.041666666666667
77747, 1.7, 0.975, 0.041666666666667
77748, 1.7, 0.95, 0.020833333333333
77749, 1.6791666666667, 0.95, 0.041666666666667
77750, 1.7, 0.925, 0.041666666666667
77751, 1.7, 0.9, 0.020833333333333
77752, 1.6791666666667, 0.9, 0.041666666666667
77753, 1.7, 0.875, 0.041666666666667
77754, 1.7, 0.85, 0.020833333333333
77755, 1.6791666666667, 0.85, 0.041666666666667
77756, 1.7, 0.825, 0.041666666666667
77757, 1.7, 0.8, 0.020833333333333
77758, 1.6791666666667, 0.8, 0.041666666666667
77759, 1.7, 0.775, 0.041666666666667
77760, 1.7, 0.75, 0.020833333333333
77761, 1.6791666666667, 0.75, 0.041666666666667
77762, 1.7, 0.725, 0.041666666666667
77763, 1.7, 0.7, 0.020833333333333
77764, 1.6791666666667, 0.7, 0.041666666666667
77765, 1.7, 0.675, 0.041666666666667
77766, 1.7, 0.65, 0.020833333333333
77767, 1.6791666666667, 0.65, 0.041666666666667
77768, 1.7, 0.625, 0.041666666666667
77769, 1.7, 0.6, 0.020833333333333
77770, 1.6791666666667, 0.6, 0.041666666666667
77771, 1.7, 0.575, 0.041666666666667
77772, 1.7, 0.55, 0.020833333333333
77773, 1.6791666666667, 0.55, 0.041666666666667
77774, 1.7, 0.525, 0.041666666666667
77775, 1.7, 0.5, 0.020833333333333
77776, 1.6791666666667, 0.5, 0.041666666666667
77777, 1.7, 0.475, 0.041666666666667
77778, 1.7, 0.45, 0.020833333333333
77779, 1.6791666666667, 0.45, 0.041666666666667
77780, 1.7, 0.425, 0.041666666666667
77781, 1.7, 0.4, 0.020833333333333
77782, 1.6791666666667, 0.4, 0.041666666666667
77783, 1.7, 0.375, 0.041666666666667
77784, 1.7, 0.35, 0.020833333333333
77785, 1.6791666666667, 0.35, 0.041666666666667
77786, 1.7, 0.325, 0.041666666666667
77787, 1.7, 0.3, 0.020833333333333
77788, 1.6791666666667, 0.3, 0.041666666666667
77789, 1.7, 0.275, 0.041666666666667
77790, 1.7, 0.25, 0.020833333333333
77791, 1.6791666666667, 0.25, 0.041666666666667
77792, 1.7, 0.225, 0.041666666666667
77793, 1.7, 0.2, 0.020833333333333
77794, 1.6791666666667, 0.2, 0.041666666666667
77795, 1.7, 0.175, 0.041666666666667
77796, 1.7416666666667, 1.325, 0.041666666666667
77797, 1.7416666666667, 1.3, 0.020833333333333
77798, 1.7208333333333, 1.3, 0.041666666666667
77799, 1.7416666666667, 1.275, 0.041666666666667
77800, 1.7416666666667, 1.25, 0.020833333333333
77801, 1.7208333333333, 1.25, 0.041666666666667
77802, 1.7416666666667, 1.225, 0.041666666666667
77803, 1.7416666666667, 1.2, 0.020833333333333
77804, 1.7208333333333, 1.2, 0.041666666666667
77805, 1.7416666666667, 1.175, 0.041666666666667
77806, 1.7416666666667, 1.15, 0.020833333333333
77807, 1.7208333333333, 1.15, 0.041666666666667
77808, 1.7416666666667, 1.125, 0.041666666666667
77809, 1.7416666666667, 1.1, 0.020833333333333
77810, 1.7208333333333, 1.1, 0.041666666666667
77811, 1.7416666666667, 1.075, 0.041666666666667
77812, 1.7416666666667, 1.05, 0.020833333333333
77813, 1.7208333333333, 1.05, 0.041666666666667
77814, 1.7416666666667, 1.025, 0.041666666666667
77815, 1.7416666666667, 1, 0.020833333333333
77816, 1.7208333333333, 1, 0.041666666666667
77817, 1.7416666666667, 0.975, 0.041666666666667
77818, 1.7416666666667, 0.95, 0.020833333333333
77819, 1.7208333333333, 0.95, 0.041666666666667
77820, 1.7416666666667, 0.925, 0.041666666666667
77821, 1.7416666666667, 0.9, 0.020833333333333
77822, 1.7208333333333, 0.9, 0.041666666666667
77823, 1.7416666666667, 0.875, 0.041666666666667
77824, 1.7416666666667, 0.85, 0.020833333333333
77825, 1.7208333333333, 0.85, 0.041666666666667
77826, 1.7416666666667, 0.825, 0.041666666666667
77827, 1.7416666666667, 0.8, 0.020833333333333
77828, 1.7208333333333, 0.8, 0.041666666666667
77829, 1.7416666666667, 0.775, 0.041666666666667
77830, 1.7416666666667, 0.75, 0.020833333333333
77831, 1.7208333333333, 0.75, 0.041666666666667
77832, 1.7416666666667, 0.725, 0.041666666666667
77833, 1.7416666666667, 0.7, 0.020833333333333
77834, 1.7208333333333, 0.7, 0.041666666666667
77835, 1.7416666666667, 0.675, 0.041666666666667
77836, 1.7416666666667, 0.65, 0.020833333333333
77837, 1.7208333333333, 0.65, 0.041666666666667
77838, 1.7416666666667, 0.625, 0.041666666666667
77839, 1.7416666666667, 0.6, 0.020833333333333
77840, 1.7208333333333, 0.6, 0.041666666666667
77841, 1.7416666666667, 0.575, 0.041666666666667
77842, 1.7416666666667, 0.55, 0.020833333333333
77843, 1.7208333333333, 0.55, 0.041666666666667
77844, 1.7416666666667, 0.525, 0.041666666666667
77845, 1.7416666666667, 0.5, 0.020833333333333
77846, 1.7208333333333, 0.5, 0.041666666666667
77847, 1.7416666666667, 0.475, 0.041666666666667
77848, 1.7416666666667, 0.45, 0.020833333333333
77849, 1.7208333333333, 0.45, 0.041666666666667
77850, 1.7416666666667, 0.425, 0.041666666666667
77851, 1.7416666666667, 0.4, 0.020833333333333
77852, 1.7208333333333, 0.4, 0.041666666666667
77853, 1.7416666666667, 0.375, 0.041666666666667
77854, 1.7416666666667, 0.35, 0.020833333333333
77855, 1.7208333333333, 0.35, 0.041666666666667
77856, 1.7416666666667, 0.325, 0.041666666666667
77857, 1.7416666666667, 0.3, 0.020833333333333
77858, 1.7208333333333, 0.3, 0.041666666666667
77859, 1.7416666666667, 0.275, 0.041666666666667
77860, 1.7416666666667, 0.25, 0.020833333333333
77861, 1.7208333333333, 0.25, 0.041666666666667
77862, 1.7416666666667, 0.225, 0.041666666666667
77863, 1.7416666666667, 0.2, 0.020833333333333
77864, 1.7208333333333, 0.2, 0.041666666666667
77865, 1.7416666666667, 0.175, 0.041666666666667
77866, 1.7833333333333, 1.325, 0.041666666666667
77867, 1.7833333333333, 1.3, 0.020833333333333
77868, 1.7625, 1.3, 0.041666666666667
77869, 1.7833333333333, 1.275, 0.041666666666667
77870, 1.7833333333333, 1.25, 0.020833333333333
77871, 1.7625, 1.25, 0.041666666666667
77872, 1.7833333333333, 1.225, 0.041666666666667
77873, 1.7833333333333, 1.2, 0.020833333333333
77874, 1.7625, 1.2, 0.041666666666667
77875, 1.7833333333333, 1.175, 0.041666666666667
77876, 1.7833333333333, 1.15, 0.020833333333333
77877, 1.7625, 1.15, 0.041666666666667
77878, 1.7833333333333, 1.125, 0.041666666666667
77879, 1.7833333333333, 1.1, 0.020833333333333
77880, 1.7625, 1.1, 0.041666666666667
77881, 1.7833333333333, 1.075, 0.041666666666667
77882, 1.7833333333333, 1.05, 0.020833333333333
77883, 1.7625, 1.05, 0.041666666666667
77884, 1.7833333333333, 1.025, 0.041666666666667
77885, 1.7833333333333, 1, 0.020833333333333
77886, 1.7625, 1, 0.041666666666667
77887, 1.7833333333333, 0.975, 0.041666666666667
77888, 1.7833333333333, 0.95, 0.020833333333333
77889, 1.7625, 0.95, 0.041666666666667
77890, 1.7833333333333, 0.925, 0.041666666666667
77891, 1.7833333333333, 0.9, 0.020833333333333
77892, 1.7625, 0.9, 0.041666666666667
77893, 1.7833333333333, 0.875, 0.041666666666667
77894, 1.7833333333333, 0.85, 0.020833333333333
77895, 1.7625, 0.85, 0.041666666666667
77896, 1.7833333333333, 0.825, 0.041666666666667
77897, 1.7833333333333, 0.8, 0.020833333333333
77898, 1.7625, 0.8, 0.041666666666667
77899, 1.7833333333333, 0.775, 0.041666666666667
77900, 1.7833333333333, 0.75, 0.020833333333333
77901, 1.7625, 0.75, 0.041666666666667
77902, 1.7833333333333, 0.725, 0.041666666666667
77903, 1.7833333333333, 0.7, 0.020833333333333
77904, 1.7625, 0.7, 0.041666666666667
77905, 1.7833333333333, 0.675, 0.041666666666667
77906, 1.7833333333333, 0.65, 0.020833333333333
77907, 1.7625, 0.65, 0.041666666666667
77908, 1.7833333333333, 0.625, 0.041666666666667
77909, 1.7833333333333, 0.6, 0.020833333333333
77910, 1.7625, 0.6, 0.041666666666667
77911, 1.7833333333333, 0.575, 0.041666666666667
77912, 1.7833333333333, 0.55, 0.020833333333333
77913, 1.7625, 0.55, 0.041666666666667
77914, 1.7833333333333, 0.525, 0.041666666666667
77915, 1.7833333333333, 0.5, 0.020833333333333
77916, 1.7625, 0.5, 0.041666666666667
77917, 1.7833333333333, 0.475, 0.041666666666667
77918, 1.7833333333333, 0.45, 0.020833333333333
77919, 1.7625, 0.45, 0.041666666666667
77920, 1.7833333333333, 0.425, 0.041666666666667
77921, 1.7833333333333, 0.4, 0.020833333333333
77922, 1.7625, 0.4, 0.041666666666667
77923, 1.7833333333333, 0.375, 0.041666666666667
77924, 1.7833333333333, 0.35, 0.020833333333333
77925, 1.7625, 0.35, 0.041666666666667
77926, 1.7833333333333, 0.325, 0.041666666666667
77927, 1.7833333333333, 0.3, 0.020833333333333
77928, 1.7625, 0.3, 0.041666666666667
77929, 1.7833333333333, 0.275, 0.041666666666667
77930, 1.7833333333333, 0.25, 0.020833333333333
77931, 1.7625, 0.25, 0.041666666666667
77932, 1.7833333333333, 0.225, 0.041666666666667
77933, 1.7833333333333, 0.2, 0.020833333333333
77934, 1.7625, 0.2, 0.041666666666667
77935, 1.7833333333333, 0.175, 0.041666666666667
77936, 1.825, 1.325, 0.041666666666667
77937, 1.825, 1.3, 0.020833333333333
77938, 1.8041666666667, 1.3, 0.041666666666667
77939, 1.825, 1.275, 0.041666666666667
77940, 1.825, 1.25, 0.020833333333333
77941, 1.8041666666667, 1.25, 0.041666666666667
77942, 1.825, 1.225, 0.041666666666667
77943, 1.825, 1.2, 0.020833333333333
77944, 1.8041666666667, 1.2, 0.041666666666667
77945, 1.825, 1.175, 0.041666666666667
77946, 1.825, 1.15, 0.020833333333333
77947, 1.8041666666667, 1.15, 0.041666666666667
77948, 1.825, 1.125, 0.041666666666667
77949, 1.825, 1.1, 0.020833333333333
77950, 1.8041666666667, 1.1, 0.041666666666667
77951, 1.825, 1.075, 0.041666666666667
77952, 1.825, 1.05, 0.020833333333333
77953, 1.8041666666667, 1.05, 0.041666666666667
77954, 1.825, 1.025, 0.041666666666667
77955, 1.825, 1, 0.020833333333333
77956, 1.8041666666667, 1, 0.041666666666667
77957, 1.825, 0.975, 0.041666666666667
77958, 1.825, 0.95, 0.020833333333333
77959, 1.8041666666667, 0.95, 0.041666666666667
77960, 1.825, 0.925, 0.041666666666667
77961, 1.825, 0.9, 0.020833333333333
77962, 1.8041666666667, 0.9, 0.041666666666667
77963, 1.825, 0.875, 0.041666666666667
77964, 1.825, 0.85, 0.020833333333333
77965, 1.8041666666667, 0.85, 0.041666666666667
77966, 1.825, 0.825, 0.041666666666667
77967, 1.825, 0.8, 0.020833333333333
77968, 1.8041666666667, 0.8, 0.041666666666667
77969, 1.825, 0.775, 0.041666666666667
77970, 1.825, 0.75, 0.020833333333333
77971, 1.8041666666667, 0.75, 0.041666666666667
77972, 1.825, 0.725, 0.041666666666667
77973, 1.825, 0.7, 0.020833333333333
77974, 1.8041666666667, 0.7, 0.041666666666667
77975, 1.825, 0.675, 0.041666666666667
77976, 1.825, 0.65, 0.020833333333333
77977, 1.8041666666667, 0.65, 0.041666666666667
77978, 1.825, 0.625, 0.041666666666667
77979, 1.825, 0.6, 0.020833333333333
77980, 1.8041666666667, 0.6, 0.041666666666667
77981, 1.825, 0.575, 0.041666666666667
77982, 1.825, 0.55, 0.020833333333333
77983, 1.8041666666667, 0.55, 0.041666666666667
77984, 1.825, 0.525, 0.041666666666667
77985, 1.825, 0.5, 0.020833333333333
77986, 1.8041666666667, 0.5, 0.041666666666667
77987, 1.825, 0.475, 0.041666666666667
77988, 1.825, 0.45, 0.020833333333333
77989, 1.8041666666667, 0.45, 0.041666666666667
77990, 1.825, 0.425, 0.041666666666667
77991, 1.825, 0.4, 0.020833333333333
77992, 1.8041666666667, 0.4, 0.041666666666667
77993, 1.825, 0.375, 0.041666666666667
77994, 1.825, 0.35, 0.020833333333333
77995, 1.8041666666667, 0.35, 0.041666666666667
77996, 1.825, 0.325, 0.041666666666667
77997, 1.825, 0.3, 0.020833333333333
77998, 1.8041666666667, 0.3, 0.041666666666667
77999, 1.825, 0.275, 0.041666666666667
78000, 1.825, 0.25, 0.020833333333333
78001, 1.8041666666667, 0.25, 0.041666666666667
78002, 1.825, 0.225, 0.041666666666667
78003, 1.825, 0.2, 0.020833333333333
78004, 1.8041666666667, 0.2, 0.041666666666667
78005, 1.825, 0.175, 0.041666666666667
78006, 1.8666666666667, 1.325, 0.041666666666667
78007, 1.8666666666667, 1.3, 0.020833333333333
78008, 1.8458333333333, 1.3, 0.041666666666667
78009, 1.8666666666667, 1.275, 0.041666666666667
78010, 1.8666666666667, 1.25, 0.020833333333333
78011, 1.8458333333333, 1.25, 0.041666666666667
78012, 1.8666666666667, 1.225, 0.041666666666667
78013, 1.8666666666667, 1.2, 0.020833333333333
78014, 1.8458333333333, 1.2, 0.041666666666667
78015, 1.8666666666667, 1.175, 0.041666666666667
78016, 1.8666666666667, 1.15, 0.020833333333333
78017, 1.8458333333333, 1.15, 0.041666666666667
78018, 1.8666666666667, 1.125, 0.041666666666667
78019, 1.8666666666667, 1.1, 0.020833333333333
78020, 1.8458333333333, 1.1, 0.041666666666667
78021, 1.8666666666667, 1.075, 0.041666666666667
78022, 1.8666666666667, 1.05, 0.020833333333333
78023, 1.8458333333333, 1.05, 0.041666666666667
78024, 1.8666666666667, 1.025, 0.041666666666667
78025, 1.8666666666667, 1, 0.020833333333333
78026, 1.8458333333333, 1, 0.041666666666667
78027, 1.8666666666667, 0.975, 0.041666666666667
78028, 1.8666666666667, 0.95, 0.020833333333333
78029, 1.8458333333333, 0.95, 0.041666666666667
78030, 1.8666666666667, 0.925, 0.041666666666667
78031, 1.8666666666667, 0.9, 0.020833333333333
78032, 1.8458333333333, 0.9, 0.041666666666667
78033, 1.8666666666667, 0.875, 0.041666666666667
78034, 1.8666666666667, 0.85, 0.020833333333333
78035, 1.8458333333333, 0.85, 0.041666666666667
78036, 1.8666666666667, 0.825, 0.041666666666667
78037, 1.8666666666667, 0.8, 0.020833333333333
78038, 1.8458333333333, 0.8, 0.041666666666667
78039, 1.8666666666667, 0.775, 0.041666666666667
78040, 1.8666666666667, 0.75, 0.020833333333333
78041, 1.8458333333333, 0.75, 0.041666666666667
78042, 1.8666666666667, 0.725, 0.041666666666667
78043, 1.8666666666667, 0.7, 0.020833333333333
78044, 1.8458333333333, 0.7, 0.041666666666667
78045, 1.8666666666667, 0.675, 0.041666666666667
78046, 1.8666666666667, 0.65, 0.020833333333333
78047, 1.8458333333333, 0.65, 0.041666666666667
78048, 1.8666666666667, 0.625, 0.041666666666667
78049, 1.8666666666667, 0.6, 0.020833333333333
78050, 1.8458333333333, 0.6, 0.041666666666667
78051, 1.8666666666667, 0.575, 0.041666666666667
78052, 1.8666666666667, 0.55, 0.020833333333333
78053, 1.8458333333333, 0.55, 0.041666666666667
78054, 1.8666666666667, 0.525, 0.041666666666667
78055, 1.8666666666667, 0.5, 0.020833333333333
78056, 1.8458333333333, 0.5, 0.041666666666667
78057, 1.8666666666667, 0.475, 0.041666666666667
78058, 1.8666666666667, 0.45, 0.020833333333333
78059, 1.8458333333333, 0.45, 0.041666666666667
78060, 1.8666666666667, 0.425, 0.041666666666667
78061, 1.8666666666667, 0.4, 0.020833333333333
78062, 1.8458333333333, 0.4, 0.041666666666667
78063, 1.8666666666667, 0.375, 0.041666666666667
78064, 1.8666666666667, 0.35, 0.020833333333333
78065, 1.8458333333333, 0.35, 0.041666666666667
78066, 1.8666666666667, 0.325, 0.041666666666667
78067, 1.8666666666667, 0.3, 0.020833333333333
78068, 1.8458333333333, 0.3, 0.041666666666667
78069, 1.8666666666667, 0.275, 0.041666666666667
78070, 1.8666666666667, 0.25, 0.020833333333333
78071, 1.8458333333333, 0.25, 0.041666666666667
78072, 1.8666666666667, 0.225, 0.041666666666667
78073, 1.8666666666667, 0.2, 0.020833333333333
78074, 1.8458333333333, 0.2, 0.041666666666667
78075, 1.8666666666667, 0.175, 0.041666666666667
78076, 1.9083333333333, 1.325, 0.041666666666667
78077, 1.9083333333333, 1.3, 0.020833333333333
78078, 1.8875, 1.3, 0.041666666666667
78079, 1.9083333333333, 1.275, 0.041666666666667
78080, 1.9083333333333, 1.25, 0.020833333333333
78081, 1.8875, 1.25, 0.041666666666667
78082, 1.9083333333333, 1.225, 0.041666666666667
78083, 1.9083333333333, 1.2, 0.020833333333333
78084, 1.8875, 1.2, 0.041666666666667
78085, 1.9083333333333, 1.175, 0.041666666666667
78086, 1.9083333333333, 1.15, 0.020833333333333
78087, 1.8875, 1.15, 0.041666666666667
78088, 1.9083333333333, 1.125, 0.041666666666667
78089, 1.9083333333333, 1.1, 0.020833333333333
78090, 1.8875, 1.1, 0.041666666666667
78091, 1.9083333333333, 1.075, 0.041666666666667
78092, 1.9083333333333, 1.05, 0.020833333333333
78093, 1.8875, 1.05, 0.041666666666667
78094, 1.9083333333333, 1.025, 0.041666666666667
78095, 1.9083333333333, 1, 0.020833333333333
78096, 1.8875, 1, 0.041666666666667
78097, 1.9083333333333, 0.975, 0.041666666666667
78098, 1.9083333333333, 0.95, 0.020833333333333
78099, 1.8875, 0.95, 0.041666666666667
78100, 1.9083333333333, 0.925, 0.041666666666667
78101, 1.9083333333333, 0.9, 0.020833333333333
78102, 1.8875, 0.9, 0.041666666666667
78103, 1.9083333333333, 0.875, 0.041666666666667
78104, 1.9083333333333, 0.85, 0.020833333333333
78105, 1.8875, 0.85, 0.041666666666667
78106, 1.9083333333333, 0.825, 0.041666666666667
78107, 1.9083333333333, 0.8, 0.020833333333333
78108, 1.8875, 0.8, 0.041666666666667
78109, 1.9083333333333, 0.775, 0.041666666666667
78110, 1.9083333333333, 0.75, 0.020833333333333
78111, 1.8875, 0.75, 0.041666666666667
78112, 1.9083333333333, 0.725, 0.041666666666667
78113, 1.9083333333333, 0.7, 0.020833333333333
78114, 1.8875, 0.7, 0.041666666666667
78115, 1.9083333333333, 0.675, 0.041666666666667
78116, 1.9083333333333, 0.65, 0.020833333333333
78117, 1.8875, 0.65, 0.041666666666667
78118, 1.9083333333333, 0.625, 0.041666666666667
78119, 1.9083333333333, 0.6, 0.020833333333333
78120, 1.8875, 0.6, 0.041666666666667
78121, 1.9083333333333, 0.575, 0.041666666666667
78122, 1.9083333333333, 0.55, 0.020833333333333
78123, 1.8875, 0.55, 0.041666666666667
78124, 1.9083333333333, 0.525, 0.041666666666667
78125, 1.9083333333333, 0.5, 0.020833333333333
78126, 1.8875, 0.5, 0.041666666666667
78127, 1.9083333333333, 0.475, 0.041666666666667
78128, 1.9083333333333, 0.45, 0.020833333333333
78129, 1.8875, 0.45, 0.041666666666667
78130, 1.9083333333333, 0.425, 0.041666666666667
78131, 1.9083333333333, 0.4, 0.020833333333333
78132, 1.8875, 0.4, 0.041666666666667
78133, 1.9083333333333, 0.375, 0.041666666666667
78134, 1.9083333333333, 0.35, 0.020833333333333
78135, 1.8875, 0.35, 0.041666666666667
78136, 1.9083333333333, 0.325, 0.041666666666667
78137, 1.9083333333333, 0.3, 0.020833333333333
78138, 1.8875, 0.3, 0.041666666666667
78139, 1.9083333333333, 0.275, 0.041666666666667
78140, 1.9083333333333, 0.25, 0.020833333333333
78141, 1.8875, 0.25, 0.041666666666667
78142, 1.9083333333333, 0.225, 0.041666666666667
78143, 1.9083333333333, 0.2, 0.020833333333333
78144, 1.8875, 0.2, 0.041666666666667
78145, 1.9083333333333, 0.175, 0.041666666666667
78146, 1.95, 1.325, 0.041666666666667
78147, 1.95, 1.3, 0.020833333333333
78148, 1.9291666666667, 1.3, 0.041666666666667
78149, 1.95, 1.275, 0.041666666666667
78150, 1.95, 1.25, 0.020833333333333
78151, 1.9291666666667, 1.25, 0.041666666666667
78152, 1.95, 1.225, 0.041666666666667
78153, 1.95, 1.2, 0.020833333333333
78154, 1.9291666666667, 1.2, 0.041666666666667
78155, 1.95, 1.175, 0.041666666666667
78156, 1.95, 1.15, 0.020833333333333
78157, 1.9291666666667, 1.15, 0.041666666666667
78158, 1.95, 1.125, 0.041666666666667
78159, 1.95, 1.1, 0.020833333333333
78160, 1.9291666666667, 1.1, 0.041666666666667
78161, 1.95, 1.075, 0.041666666666667
78162, 1.95, 1.05, 0.020833333333333
78163, 1.9291666666667, 1.05, 0.041666666666667
78164, 1.95, 1.025, 0.041666666666667
78165, 1.95, 1, 0.020833333333333
78166, 1.9291666666667, 1, 0.041666666666667
78167, 1.95, 0.975, 0.041666666666667
78168, 1.95, 0.95, 0.020833333333333
78169, 1.9291666666667, 0.95, 0.041666666666667
78170, 1.95, 0.925, 0.041666666666667
78171, 1.95, 0.9, 0.020833333333333
78172, 1.9291666666667, 0.9, 0.041666666666667
78173, 1.95, 0.875, 0.041666666666667
78174, 1.95, 0.85, 0.020833333333333
78175, 1.9291666666667, 0.85, 0.041666666666667
78176, 1.95, 0.825, 0.041666666666667
78177, 1.95, 0.8, 0.020833333333333
78178, 1.9291666666667, 0.8, 0.041666666666667
78179, 1.95, 0.775, 0.041666666666667
78180, 1.95, 0.75, 0.020833333333333
78181, 1.9291666666667, 0.75, 0.041666666666667
78182, 1.95, 0.725, 0.041666666666667
78183, 1.95, 0.7, 0.020833333333333
78184, 1.9291666666667, 0.7, 0.041666666666667
78185, 1.95, 0.675, 0.041666666666667
78186, 1.95, 0.65, 0.020833333333333
78187, 1.9291666666667, 0.65, 0.041666666666667
78188, 1.95, 0.625, 0.041666666666667
78189, 1.95, 0.6, 0.020833333333333
78190, 1.9291666666667, 0.6, 0.041666666666667
78191, 1.95, 0.575, 0.041666666666667
78192, 1.95, 0.55, 0.020833333333333
78193, 1.9291666666667, 0.55, 0.041666666666667
78194, 1.95, 0.525, 0.041666666666667
78195, 1.95, 0.5, 0.020833333333333
78196, 1.9291666666667, 0.5, 0.041666666666667
78197, 1.95, 0.475, 0.041666666666667
78198, 1.95, 0.45, 0.020833333333333
78199, 1.9291666666667, 0.45, 0.041666666666667
78200, 1.95, 0.425, 0.041666666666667
78201, 1.95, 0.4, 0.020833333333333
78202, 1.9291666666667, 0.4, 0.041666666666667
78203, 1.95, 0.375, 0.041666666666667
78204, 1.95, 0.35, 0.020833333333333
78205, 1.9291666666667, 0.35, 0.041666666666667
78206, 1.95, 0.325, 0.041666666666667
78207, 1.95, 0.3, 0.020833333333333
78208, 1.9291666666667, 0.3, 0.041666666666667
78209, 1.95, 0.275, 0.041666666666667
78210, 1.95, 0.25, 0.020833333333333
78211, 1.9291666666667, 0.25, 0.041666666666667
78212, 1.95, 0.225, 0.041666666666667
78213, 1.95, 0.2, 0.020833333333333
78214, 1.9291666666667, 0.2, 0.041666666666667
78215, 1.95, 0.175, 0.041666666666667
78216, 1.9916666666667, 1.325, 0.041666666666667
78217, 1.9916666666667, 1.3, 0.020833333333333
78218, 1.9708333333333, 1.3, 0.041666666666667
78219, 1.9916666666667, 1.275, 0.041666666666667
78220, 1.9916666666667, 1.25, 0.020833333333333
78221, 1.9708333333333, 1.25, 0.041666666666667
78222, 1.9916666666667, 1.225, 0.041666666666667
78223, 1.9916666666667, 1.2, 0.020833333333333
78224, 1.9708333333333, 1.2, 0.041666666666667
78225, 1.9916666666667, 1.175, 0.041666666666667
78226, 1.9916666666667, 1.15, 0.020833333333333
78227, 1.9708333333333, 1.15, 0.041666666666667
78228, 1.9916666666667, 1.125, 0.041666666666667
78229, 1.9916666666667, 1.1, 0.020833333333333
78230, 1.9708333333333, 1.1, 0.041666666666667
78231, 1.9916666666667, 1.075, 0.041666666666667
78232, 1.9916666666667, 1.05, 0.020833333333333
78233, 1.9708333333333, 1.05, 0.041666666666667
78234, 1.9916666666667, 1.025, 0.041666666666667
78235, 1.9916666666667, 1, 0.020833333333333
78236, 1.9708333333333, 1, 0.041666666666667
78237, 1.9916666666667, 0.975, 0.041666666666667
78238, 1.9916666666667, 0.95, 0.020833333333333
78239, 1.9708333333333, 0.95, 0.041666666666667
78240, 1.9916666666667, 0.925, 0.041666666666667
78241, 1.9916666666667, 0.9, 0.020833333333333
78242, 1.9708333333333, 0.9, 0.041666666666667
78243, 1.9916666666667, 0.875, 0.041666666666667
78244, 1.9916666666667, 0.85, 0.020833333333333
78245, 1.9708333333333, 0.85, 0.041666666666667
78246, 1.9916666666667, 0.825, 0.041666666666667
78247, 1.9916666666667, 0.8, 0.020833333333333
78248, 1.9708333333333, 0.8, 0.041666666666667
78249, 1.9916666666667, 0.775, 0.041666666666667
78250, 1.9916666666667, 0.75, 0.020833333333333
78251, 1.9708333333333, 0.75, 0.041666666666667
78252, 1.9916666666667, 0.725, 0.041666666666667
78253, 1.9916666666667, 0.7, 0.020833333333333
78254, 1.9708333333333, 0.7, 0.041666666666667
78255, 1.9916666666667, 0.675, 0.041666666666667
78256, 1.9916666666667, 0.65, 0.020833333333333
78257, 1.9708333333333, 0.65, 0.041666666666667
78258, 1.9916666666667, 0.625, 0.041666666666667
78259, 1.9916666666667, 0.6, 0.020833333333333
78260, 1.9708333333333, 0.6, 0.041666666666667
78261, 1.9916666666667, 0.575, 0.041666666666667
78262, 1.9916666666667, 0.55, 0.020833333333333
78263, 1.9708333333333, 0.55, 0.041666666666667
78264, 1.9916666666667, 0.525, 0.041666666666667
78265, 1.9916666666667, 0.5, 0.020833333333333
78266, 1.9708333333333, 0.5, 0.041666666666667
78267, 1.9916666666667, 0.475, 0.041666666666667
78268, 1.9916666666667, 0.45, 0.020833333333333
78269, 1.9708333333333, 0.45, 0.041666666666667
78270, 1.9916666666667, 0.425, 0.041666666666667
78271, 1.9916666666667, 0.4, 0.020833333333333
78272, 1.9708333333333, 0.4, 0.041666666666667
78273, 1.9916666666667, 0.375, 0.041666666666667
78274, 1.9916666666667, 0.35, 0.020833333333333
78275, 1.9708333333333, 0.35, 0.041666666666667
78276, 1.9916666666667, 0.325, 0.041666666666667
78277, 1.9916666666667, 0.3, 0.020833333333333
78278, 1.9708333333333, 0.3, 0.041666666666667
78279, 1.9916666666667, 0.275, 0.041666666666667
78280, 1.9916666666667, 0.25, 0.020833333333333
78281, 1.9708333333333, 0.25, 0.041666666666667
78282, 1.9916666666667, 0.225, 0.041666666666667
78283, 1.9916666666667, 0.2, 0.020833333333333
78284, 1.9708333333333, 0.2, 0.041666666666667
78285, 1.9916666666667, 0.175, 0.041666666666667
78286, 2.0333333333333, 1.325, 0.041666666666667
78287, 2.0333333333333, 1.3, 0.020833333333333
78288, 2.0125, 1.3, 0.041666666666667
78289, 2.0333333333333, 1.275, 0.041666666666667
78290, 2.0333333333333, 1.25, 0.020833333333333
78291, 2.0125, 1.25, 0.041666666666667
78292, 2.0333333333333, 1.225, 0.041666666666667
78293, 2.0333333333333, 1.2, 0.020833333333333
78294, 2.0125, 1.2, 0.041666666666667
78295, 2.0333333333333, 1.175, 0.041666666666667
78296, 2.0333333333333, 1.15, 0.020833333333333
78297, 2.0125, 1.15, 0.041666666666667
78298, 2.0333333333333, 1.125, 0.041666666666667
78299, 2.0333333333333, 1.1, 0.020833333333333
78300, 2.0125, 1.1, 0.041666666666667
78301, 2.0333333333333, 1.075, 0.041666666666667
78302, 2.0333333333333, 1.05, 0.020833333333333
78303, 2.0125, 1.05, 0.041666666666667
78304, 2.0333333333333, 1.025, 0.041666666666667
78305, 2.0333333333333, 1, 0.020833333333333
78306, 2.0125, 1, 0.041666666666667
78307, 2.0333333333333, 0.975, 0.041666666666667
78308, 2.0333333333333, 0.95, 0.020833333333333
78309, 2.0125, 0.95, 0.041666666666667
78310, 2.0333333333333, 0.925, 0.041666666666667
78311, 2.0333333333333, 0.9, 0.020833333333333
78312, 2.0125, 0.9, 0.041666666666667
78313, 2.0333333333333, 0.875, 0.041666666666667
78314, 2.0333333333333, 0.85, 0.020833333333333
78315, 2.0125, 0.85, 0.041666666666667
78316, 2.0333333333333, 0.825, 0.041666666666667
78317, 2.0333333333333, 0.8, 0.020833333333333
78318, 2.0125, 0.8, 0.041666666666667
78319, 2.0333333333333, 0.775, 0.041666666666667
78320, 2.0333333333333, 0.75, 0.020833333333333
78321, 2.0125, 0.75, 0.041666666666667
78322, 2.0333333333333, 0.725, 0.041666666666667
78323, 2.0333333333333, 0.7, 0.020833333333333
78324, 2.0125, 0.7, 0.041666666666667
78325, 2.0333333333333, 0.675, 0.041666666666667
78326, 2.0333333333333, 0.65, 0.020833333333333
78327, 2.0125, 0.65, 0.041666666666667
78328, 2.0333333333333, 0.625, 0.041666666666667
78329, 2.0333333333333, 0.6, 0.020833333333333
78330, 2.0125, 0.6, 0.041666666666667
78331, 2.0333333333333, 0.575, 0.041666666666667
78332, 2.0333333333333, 0.55, 0.020833333333333
78333, 2.0125, 0.55, 0.041666666666667
78334, 2.0333333333333, 0.525, 0.041666666666667
78335, 2.0333333333333, 0.5, 0.020833333333333
78336, 2.0125, 0.5, 0.041666666666667
78337, 2.0333333333333, 0.475, 0.041666666666667
78338, 2.0333333333333, 0.45, 0.020833333333333
78339, 2.0125, 0.45, 0.041666666666667
78340, 2.0333333333333, 0.425, 0.041666666666667
78341, 2.0333333333333, 0.4, 0.020833333333333
78342, 2.0125, 0.4, 0.041666666666667
78343, 2.0333333333333, 0.375, 0.041666666666667
78344, 2.0333333333333, 0.35, 0.020833333333333
78345, 2.0125, 0.35, 0.041666666666667
78346, 2.0333333333333, 0.325, 0.041666666666667
78347, 2.0333333333333, 0.3, 0.020833333333333
78348, 2.0125, 0.3, 0.041666666666667
78349, 2.0333333333333, 0.275, 0.041666666666667
78350, 2.0333333333333, 0.25, 0.020833333333333
78351, 2.0125, 0.25, 0.041666666666667
78352, 2.0333333333333, 0.225, 0.041666666666667
78353, 2.0333333333333, 0.2, 0.020833333333333
78354, 2.0125, 0.2, 0.041666666666667
78355, 2.0333333333333, 0.175, 0.041666666666667
78356, 2.075, 1.325, 0.041666666666667
78357, 2.075, 1.3, 0.020833333333333
78358, 2.0541666666667, 1.3, 0.041666666666667
78359, 2.075, 1.275, 0.041666666666667
78360, 2.075, 1.25, 0.020833333333333
78361, 2.0541666666667, 1.25, 0.041666666666667
78362, 2.075, 1.225, 0.041666666666667
78363, 2.075, 1.2, 0.020833333333333
78364, 2.0541666666667, 1.2, 0.041666666666667
78365, 2.075, 1.175, 0.041666666666667
78366, 2.075, 1.15, 0.020833333333333
78367, 2.0541666666667, 1.15, 0.041666666666667
78368, 2.075, 1.125, 0.041666666666667
78369, 2.075, 1.1, 0.020833333333333
78370, 2.0541666666667, 1.1, 0.041666666666667
78371, 2.075, 1.075, 0.041666666666667
78372, 2.075, 1.05, 0.020833333333333
78373, 2.0541666666667, 1.05, 0.041666666666667
78374, 2.075, 1.025, 0.041666666666667
78375, 2.075, 1, 0.020833333333333
78376, 2.0541666666667, 1, 0.041666666666667
78377, 2.075, 0.975, 0.041666666666667
78378, 2.075, 0.95, 0.020833333333333
78379, 2.0541666666667, 0.95, 0.041666666666667
78380, 2.075, 0.925, 0.041666666666667
78381, 2.075, 0.9, 0.020833333333333
78382, 2.0541666666667, 0.9, 0.041666666666667
78383, 2.075, 0.875, 0.041666666666667
78384, 2.075, 0.85, 0.020833333333333
78385, 2.0541666666667, 0.85, 0.041666666666667
78386, 2.075, 0.825, 0.041666666666667
78387, 2.075, 0.8, 0.020833333333333
78388, 2.0541666666667, 0.8, 0.041666666666667
78389, 2.075, 0.775, 0.041666666666667
78390, 2.075, 0.75, 0.020833333333333
78391, 2.0541666666667, 0.75, 0.041666666666667
78392, 2.075, 0.725, 0.041666666666667
78393, 2.075, 0.7, 0.020833333333333
78394, 2.0541666666667, 0.7, 0.041666666666667
78395, 2.075, 0.675, 0.041666666666667
78396, 2.075, 0.65, 0.020833333333333
78397, 2.0541666666667, 0.65, 0.041666666666667
78398, 2.075, 0.625, 0.041666666666667
78399, 2.075, 0.6, 0.020833333333333
78400, 2.0541666666667, 0.6, 0.041666666666667
78401, 2.075, 0.575, 0.041666666666667
78402, 2.075, 0.55, 0.020833333333333
78403, 2.0541666666667, 0.55, 0.041666666666667
78404, 2.075, 0.525, 0.041666666666667
78405, 2.075, 0.5, 0.020833333333333
78406, 2.0541666666667, 0.5, 0.041666666666667
78407, 2.075, 0.475, 0.041666666666667
78408, 2.075, 0.45, 0.020833333333333
78409, 2.0541666666667, 0.45, 0.041666666666667
78410, 2.075, 0.425, 0.041666666666667
78411, 2.075, 0.4, 0.020833333333333
78412, 2.0541666666667, 0.4, 0.041666666666667
78413, 2.075, 0.375, 0.041666666666667
78414, 2.075, 0.35, 0.020833333333333
78415, 2.0541666666667, 0.35, 0.041666666666667
78416, 2.075, 0.325, 0.041666666666667
78417, 2.075, 0.3, 0.020833333333333
78418, 2.0541666666667, 0.3, 0.041666666666667
78419, 2.075, 0.275, 0.041666666666667
78420, 2.075, 0.25, 0.020833333333333
78421, 2.0541666666667, 0.25, 0.041666666666667
78422, 2.075, 0.225, 0.041666666666667
78423, 2.075, 0.2, 0.020833333333333
78424, 2.0541666666667, 0.2, 0.041666666666667
78425, 2.075, 0.175, 0.041666666666667
78426, 2.1166666666667, 1.325, 0.041666666666667
78427, 2.1166666666667, 1.3, 0.020833333333333
78428, 2.0958333333333, 1.3, 0.041666666666667
78429, 2.1166666666667, 1.275, 0.041666666666667
78430, 2.1166666666667, 1.25, 0.020833333333333
78431, 2.0958333333333, 1.25, 0.041666666666667
78432, 2.1166666666667, 1.225, 0.041666666666667
78433, 2.1166666666667, 1.2, 0.020833333333333
78434, 2.0958333333333, 1.2, 0.041666666666667
78435, 2.1166666666667, 1.175, 0.041666666666667
78436, 2.1166666666667, 1.15, 0.020833333333333
78437, 2.0958333333333, 1.15, 0.041666666666667
78438, 2.1166666666667, 1.125, 0.041666666666667
78439, 2.1166666666667, 1.1, 0.020833333333333
78440, 2.0958333333333, 1.1, 0.041666666666667
78441, 2.1166666666667, 1.075, 0.041666666666667
78442, 2.1166666666667, 1.05, 0.020833333333333
78443, 2.0958333333333, 1.05, 0.041666666666667
78444, 2.1166666666667, 1.025, 0.041666666666667
78445, 2.1166666666667, 1, 0.020833333333333
78446, 2.0958333333333, 1, 0.041666666666667
78447, 2.1166666666667, 0.975, 0.041666666666667
78448, 2.1166666666667, 0.95, 0.020833333333333
78449, 2.0958333333333, 0.95, 0.041666666666667
78450, 2.1166666666667, 0.925, 0.041666666666667
78451, 2.1166666666667, 0.9, 0.020833333333333
78452, 2.0958333333333, 0.9, 0.041666666666667
78453, 2.1166666666667, 0.875, 0.041666666666667
78454, 2.1166666666667, 0.85, 0.020833333333333
78455, 2.0958333333333, 0.85, 0.041666666666667
78456, 2.1166666666667, 0.825, 0.041666666666667
78457, 2.1166666666667, 0.8, 0.020833333333333
78458, 2.0958333333333, 0.8, 0.041666666666667
78459, 2.1166666666667, 0.775, 0.041666666666667
78460, 2.1166666666667, 0.75, 0.020833333333333
78461, 2.0958333333333, 0.75, 0.041666666666667
78462, 2.1166666666667, 0.725, 0.041666666666667
78463, 2.1166666666667, 0.7, 0.020833333333333
78464, 2.0958333333333, 0.7, 0.041666666666667
78465, 2.1166666666667, 0.675, 0.041666666666667
78466, 2.1166666666667, 0.65, 0.020833333333333
78467, 2.0958333333333, 0.65, 0.041666666666667
78468, 2.1166666666667, 0.625, 0.041666666666667
78469, 2.1166666666667, 0.6, 0.020833333333333
78470, 2.0958333333333, 0.6, 0.041666666666667
78471, 2.1166666666667, 0.575, 0.041666666666667
78472, 2.1166666666667, 0.55, 0.020833333333333
78473, 2.0958333333333, 0.55, 0.041666666666667
78474, 2.1166666666667, 0.525, 0.041666666666667
78475, 2.1166666666667, 0.5, 0.020833333333333
78476, 2.0958333333333, 0.5, 0.041666666666667
78477, 2.1166666666667, 0.475, 0.041666666666667
78478, 2.1166666666667, 0.45, 0.020833333333333
78479, 2.0958333333333, 0.45, 0.041666666666667
78480, 2.1166666666667, 0.425, 0.041666666666667
78481, 2.1166666666667, 0.4, 0.020833333333333
78482, 2.0958333333333, 0.4, 0.041666666666667
78483, 2.1166666666667, 0.375, 0.041666666666667
78484, 2.1166666666667, 0.35, 0.020833333333333
78485, 2.0958333333333, 0.35, 0.041666666666667
78486, 2.1166666666667, 0.325, 0.041666666666667
78487, 2.1166666666667, 0.3, 0.020833333333333
78488, 2.0958333333333, 0.3, 0.041666666666667
78489, 2.1166666666667, 0.275, 0.041666666666667
78490, 2.1166666666667, 0.25, 0.020833333333333
78491, 2.0958333333333, 0.25, 0.041666666666667
78492, 2.1166666666667, 0.225, 0.041666666666667
78493, 2.1166666666667, 0.2, 0.020833333333333
78494, 2.0958333333333, 0.2, 0.041666666666667
78495, 2.1166666666667, 0.175, 0.041666666666667
78496, 2.1583333333333, 1.325, 0.041666666666667
78497, 2.1583333333333, 1.3, 0.020833333333333
78498, 2.1375, 1.3, 0.041666666666667
78499, 2.1583333333333, 1.275, 0.041666666666667
78500, 2.1583333333333, 1.25, 0.020833333333333
78501, 2.1375, 1.25, 0.041666666666667
78502, 2.1583333333333, 1.225, 0.041666666666667
78503, 2.1583333333333, 1.2, 0.020833333333333
78504, 2.1375, 1.2, 0.041666666666667
78505, 2.1583333333333, 1.175, 0.041666666666667
78506, 2.1583333333333, 1.15, 0.020833333333333
78507, 2.1375, 1.15, 0.041666666666667
78508, 2.1583333333333, 1.125, 0.041666666666667
78509, 2.1583333333333, 1.1, 0.020833333333333
78510, 2.1375, 1.1, 0.041666666666667
78511, 2.1583333333333, 1.075, 0.041666666666667
78512, 2.1583333333333, 1.05, 0.020833333333333
78513, 2.1375, 1.05, 0.041666666666667
78514, 2.1583333333333, 1.025, 0.041666666666667
78515, 2.1583333333333, 1, 0.020833333333333
78516, 2.1375, 1, 0.041666666666667
78517, 2.1583333333333, 0.975, 0.041666666666667
78518, 2.1583333333333, 0.95, 0.020833333333333
78519, 2.1375, 0.95, 0.041666666666667
78520, 2.1583333333333, 0.925, 0.041666666666667
78521, 2.1583333333333, 0.9, 0.020833333333333
78522, 2.1375, 0.9, 0.041666666666667
78523, 2.1583333333333, 0.875, 0.041666666666667
78524, 2.1583333333333, 0.85, 0.020833333333333
78525, 2.1375, 0.85, 0.041666666666667
78526, 2.1583333333333, 0.825, 0.041666666666667
78527, 2.1583333333333, 0.8, 0.020833333333333
78528, 2.1375, 0.8, 0.041666666666667
78529, 2.1583333333333, 0.775, 0.041666666666667
78530, 2.1583333333333, 0.75, 0.020833333333333
78531, 2.1375, 0.75, 0.041666666666667
78532, 2.1583333333333, 0.725, 0.041666666666667
78533, 2.1583333333333, 0.7, 0.020833333333333
78534, 2.1375, 0.7, 0.041666666666667
78535, 2.1583333333333, 0.675, 0.041666666666667
78536, 2.1583333333333, 0.65, 0.020833333333333
78537, 2.1375, 0.65, 0.041666666666667
78538, 2.1583333333333, 0.625, 0.041666666666667
78539, 2.1583333333333, 0.6, 0.020833333333333
78540, 2.1375, 0.6, 0.041666666666667
78541, 2.1583333333333, 0.575, 0.041666666666667
78542, 2.1583333333333, 0.55, 0.020833333333333
78543, 2.1375, 0.55, 0.041666666666667
78544, 2.1583333333333, 0.525, 0.041666666666667
78545, 2.1583333333333, 0.5, 0.020833333333333
78546, 2.1375, 0.5, 0.041666666666667
78547, 2.1583333333333, 0.475, 0.041666666666667
78548, 2.1583333333333, 0.45, 0.020833333333333
78549, 2.1375, 0.45, 0.041666666666667
78550, 2.1583333333333, 0.425, 0.041666666666667
78551, 2.1583333333333, 0.4, 0.020833333333333
78552, 2.1375, 0.4, 0.041666666666667
78553, 2.1583333333333, 0.375, 0.041666666666667
78554, 2.1583333333333, 0.35, 0.020833333333333
78555, 2.1375, 0.35, 0.041666666666667
78556, 2.1583333333333, 0.325, 0.041666666666667
78557, 2.1583333333333, 0.3, 0.020833333333333
78558, 2.1375, 0.3, 0.041666666666667
78559, 2.1583333333333, 0.275, 0.041666666666667
78560, 2.1583333333333, 0.25, 0.020833333333333
78561, 2.1375, 0.25, 0.041666666666667
78562, 2.1583333333333, 0.225, 0.041666666666667
78563, 2.1583333333333, 0.2, 0.020833333333333
78564, 2.1375, 0.2, 0.041666666666667
78565, 2.1583333333333, 0.175, 0.041666666666667
78566, 2.1791666666667, 1.3, 0.041666666666667
78567, 2.1791666666667, 1.25, 0.041666666666667
78568, 2.1791666666667, 1.2, 0.041666666666667
78569, 2.1791666666667, 1.15, 0.041666666666667
78570, 2.1791666666667, 1.1, 0.041666666666667
78571, 2.1791666666667, 1.05, 0.041666666666667
78572, 2.1791666666667, 1, 0.041666666666667
78573, 2.1791666666667, 0.95, 0.041666666666667
78574, 2.1791666666667, 0.9, 0.041666666666667
78575, 2.1791666666667, 0.85, 0.041666666666667
78576, 2.1791666666667, 0.8, 0.041666666666667
78577, 2.1791666666667, 0.75, 0.041666666666667
78578, 2.1791666666667, 0.7, 0.041666666666667
78579, 2.1791666666667, 0.65, 0.041666666666667
78580, 2.1791666666667, 0.6, 0.041666666666667
78581, 2.1791666666667, 0.55, 0.041666666666667
78582, 2.1791666666667, 0.5, 0.041666666666667
78583, 2.1791666666667, 0.45, 0.041666666666667
78584, 2.1791666666667, 0.4, 0.041666666666667
78585, 2.1791666666667, 0.35, 0.041666666666667
78586, 2.1791666666667, 0.3, 0.041666666666667
78587, 2.1791666666667, 0.25, 0.041666666666667
78588, 2.1791666666667, 0.2, 0.041666666666667
78589, 1.2416666666667, 1.325, 0.083333333333333
78590, 1.2416666666667, 1.3, 0.0625
78591, 1.2208333333333, 1.3, 0.083333333333333
78592, 1.2416666666667, 1.275, 0.083333333333333
78593, 1.2416666666667, 1.25, 0.0625
78594, 1.2208333333333, 1.25, 0.083333333333333
78595, 1.2416666666667, 1.225, 0.083333333333333
78596, 1.2416666666667, 1.2, 0.0625
78597, 1.2208333333333, 1.2, 0.083333333333333
78598, 1.2416666666667, 1.175, 0.083333333333333
78599, 1.2416666666667, 1.15, 0.0625
78600, 1.2208333333333, 1.15, 0.083333333333333
78601, 1.2416666666667, 1.125, 0.083333333333333
78602, 1.2416666666667, 1.1, 0.0625
78603, 1.2208333333333, 1.1, 0.083333333333333
78604, 1.2416666666667, 1.075, 0.083333333333333
78605, 1.2416666666667, 1.05, 0.0625
78606, 1.2208333333333, 1.05, 0.083333333333333
78607, 1.2416666666667, 1.025, 0.083333333333333
78608, 1.2416666666667, 1, 0.0625
78609, 1.2208333333333, 1, 0.083333333333333
78610, 1.2416666666667, 0.975, 0.083333333333333
78611, 1.2416666666667, 0.95, 0.0625
78612, 1.2208333333333, 0.95, 0.083333333333333
78613, 1.2416666666667, 0.925, 0.083333333333333
78614, 1.2416666666667, 0.9, 0.0625
78615, 1.2208333333333, 0.9, 0.083333333333333
78616, 1.2416666666667, 0.875, 0.083333333333333
78617, 1.2416666666667, 0.85, 0.0625
78618, 1.2208333333333, 0.85, 0.083333333333333
78619, 1.2416666666667, 0.825, 0.083333333333333
78620, 1.2416666666667, 0.8, 0.0625
78621, 1.2208333333333, 0.8, 0.083333333333333
78622, 1.2416666666667, 0.775, 0.083333333333333
78623, 1.2416666666667, 0.75, 0.0625
78624, 1.2208333333333, 0.75, 0.083333333333333
78625, 1.2416666666667, 0.725, 0.083333333333333
78626, 1.2416666666667, 0.7, 0.0625
78627, 1.2208333333333, 0.7, 0.083333333333333
78628, 1.2416666666667, 0.675, 0.083333333333333
78629, 1.2416666666667, 0.65, 0.0625
78630, 1.2208333333333, 0.65, 0.083333333333333
78631, 1.2416666666667, 0.625, 0.083333333333333
78632, 1.2416666666667, 0.6, 0.0625
78633, 1.2208333333333, 0.6, 0.083333333333333
78634, 1.2416666666667, 0.575, 0.083333333333333
78635, 1.2416666666667, 0.55, 0.0625
78636, 1.2208333333333, 0.55, 0.083333333333333
78637, 1.2416666666667, 0.525, 0.083333333333333
78638, 1.2416666666667, 0.5, 0.0625
78639, 1.2208333333333, 0.5, 0.083333333333333
78640, 1.2416666666667, 0.475, 0.083333333333333
78641, 1.2416666666667, 0.45, 0.0625
78642, 1.2208333333333, 0.45, 0.083333333333333
78643, 1.2416666666667, 0.425, 0.083333333333333
78644, 1.2416666666667, 0.4, 0.0625
78645, 1.2208333333333, 0.4, 0.083333333333333
78646, 1.2416666666667, 0.375, 0.083333333333333
78647, 1.2416666666667, 0.35, 0.0625
78648, 1.2208333333333, 0.35, 0.083333333333333
78649, 1.2416666666667, 0.325, 0.083333333333333
78650, 1.2416666666667, 0.3, 0.0625
78651, 1.2208333333333, 0.3, 0.083333333333333
78652, 1.2416666666667, 0.275, 0.083333333333333
78653, 1.2416666666667, 0.25, 0.0625
78654, 1.2208333333333, 0.25, 0.083333333333333
78655, 1.2416666666667, 0.225, 0.083333333333333
78656, 1.2416666666667, 0.2, 0.0625
78657, 1.2208333333333, 0.2, 0.083333333333333
78658, 1.2416666666667, 0.175, 0.083333333333333
78659, 1.2833333333333, 1.325, 0.083333333333333
78660, 1.2833333333333, 1.3, 0.0625
78661, 1.2625, 1.3, 0.083333333333333
78662, 1.2833333333333, 1.275, 0.083333333333333
78663, 1.2833333333333, 1.25, 0.0625
78664, 1.2625, 1.25, 0.083333333333333
78665, 1.2833333333333, 1.225, 0.083333333333333
78666, 1.2833333333333, 1.2, 0.0625
78667, 1.2625, 1.2, 0.083333333333333
78668, 1.2833333333333, 1.175, 0.083333333333333
78669, 1.2833333333333, 1.15, 0.0625
78670, 1.2625, 1.15, 0.083333333333333
78671, 1.2833333333333, 1.125, 0.083333333333333
78672, 1.2833333333333, 1.1, 0.0625
78673, 1.2625, 1.1, 0.083333333333333
78674, 1.2833333333333, 1.075, 0.083333333333333
78675, 1.2833333333333, 1.05, 0.0625
78676, 1.2625, 1.05, 0.083333333333333
78677, 1.2833333333333, 1.025, 0.083333333333333
78678, 1.2833333333333, 1, 0.0625
78679, 1.2625, 1, 0.083333333333333
78680, 1.2833333333333, 0.975, 0.083333333333333
78681, 1.2833333333333, 0.95, 0.0625
78682, 1.2625, 0.95, 0.083333333333333
78683, 1.2833333333333, 0.925, 0.083333333333333
78684, 1.2833333333333, 0.9, 0.0625
78685, 1.2625, 0.9, 0.083333333333333
78686, 1.2833333333333, 0.875, 0.083333333333333
78687, 1.2833333333333, 0.85, 0.0625
78688, 1.2625, 0.85, 0.083333333333333
78689, 1.2833333333333, 0.825, 0.083333333333333
78690, 1.2833333333333, 0.8, 0.0625
78691, 1.2625, 0.8, 0.083333333333333
78692, 1.2833333333333, 0.775, 0.083333333333333
78693, 1.2833333333333, 0.75, 0.0625
78694, 1.2625, 0.75, 0.083333333333333
78695, 1.2833333333333, 0.725, 0.083333333333333
78696, 1.2833333333333, 0.7, 0.0625
78697, 1.2625, 0.7, 0.083333333333333
78698, 1.2833333333333, 0.675, 0.083333333333333
78699, 1.2833333333333, 0.65, 0.0625
78700, 1.2625, 0.65, 0.083333333333333
78701, 1.2833333333333, 0.625, 0.083333333333333
78702, 1.2833333333333, 0.6, 0.0625
78703, 1.2625, 0.6, 0.083333333333333
78704, 1.2833333333333, 0.575, 0.083333333333333
78705, 1.2833333333333, 0.55, 0.0625
78706, 1.2625, 0.55, 0.083333333333333
78707, 1.2833333333333, 0.525, 0.083333333333333
78708, 1.2833333333333, 0.5, 0.0625
78709, 1.2625, 0.5, 0.083333333333333
78710, 1.2833333333333, 0.475, 0.083333333333333
78711, 1.2833333333333, 0.45, 0.0625
78712, 1.2625, 0.45, 0.083333333333333
78713, 1.2833333333333, 0.425, 0.083333333333333
78714, 1.2833333333333, 0.4, 0.0625
78715, 1.2625, 0.4, 0.083333333333333
78716, 1.2833333333333, 0.375, 0.083333333333333
78717, 1.2833333333333, 0.35, 0.0625
78718, 1.2625, 0.35, 0.083333333333333
78719, 1.2833333333333, 0.325, 0.083333333333333
78720, 1.2833333333333, 0.3, 0.0625
78721, 1.2625, 0.3, 0.083333333333333
78722, 1.2833333333333, 0.275, 0.083333333333333
78723, 1.2833333333333, 0.25, 0.0625
78724, 1.2625, 0.25, 0.083333333333333
78725, 1.2833333333333, 0.225, 0.083333333333333
78726, 1.2833333333333, 0.2, 0.0625
78727, 1.2625, 0.2, 0.083333333333333
78728, 1.2833333333333, 0.175, 0.083333333333333
78729, 1.325, 1.325, 0.083333333333333
78730, 1.325, 1.3, 0.0625
78731, 1.3041666666667, 1.3, 0.083333333333333
78732, 1.325, 1.275, 0.083333333333333
78733, 1.325, 1.25, 0.0625
78734, 1.3041666666667, 1.25, 0.083333333333333
78735, 1.325, 1.225, 0.083333333333333
78736, 1.325, 1.2, 0.0625
78737, 1.3041666666667, 1.2, 0.083333333333333
78738, 1.325, 1.175, 0.083333333333333
78739, 1.325, 1.15, 0.0625
78740, 1.3041666666667, 1.15, 0.083333333333333
78741, 1.325, 1.125, 0.083333333333333
78742, 1.325, 1.1, 0.0625
78743, 1.3041666666667, 1.1, 0.083333333333333
78744, 1.325, 1.075, 0.083333333333333
78745, 1.325, 1.05, 0.0625
78746, 1.3041666666667, 1.05, 0.083333333333333
78747, 1.325, 1.025, 0.083333333333333
78748, 1.325, 1, 0.0625
78749, 1.3041666666667, 1, 0.083333333333333
78750, 1.325, 0.975, 0.083333333333333
78751, 1.325, 0.95, 0.0625
78752, 1.3041666666667, 0.95, 0.083333333333333
78753, 1.325, 0.925, 0.083333333333333
78754, 1.325, 0.9, 0.0625
78755, 1.3041666666667, 0.9, 0.083333333333333
78756, 1.325, 0.875, 0.083333333333333
78757, 1.325, 0.85, 0.0625
78758, 1.3041666666667, 0.85, 0.083333333333333
78759, 1.325, 0.825, 0.083333333333333
78760, 1.325, 0.8, 0.0625
78761, 1.3041666666667, 0.8, 0.083333333333333
78762, 1.325, 0.775, 0.083333333333333
78763, 1.325, 0.75, 0.0625
78764, 1.3041666666667, 0.75, 0.083333333333333
78765, 1.325, 0.725, 0.083333333333333
78766, 1.325, 0.7, 0.0625
78767, 1.3041666666667, 0.7, 0.083333333333333
78768, 1.325, 0.675, 0.083333333333333
78769, 1.325, 0.65, 0.0625
78770, 1.3041666666667, 0.65, 0.083333333333333
78771, 1.325, 0.625, 0.083333333333333
78772, 1.325, 0.6, 0.0625
78773, 1.3041666666667, 0.6, 0.083333333333333
78774, 1.325, 0.575, 0.083333333333333
78775, 1.325, 0.55, 0.0625
78776, 1.3041666666667, 0.55, 0.083333333333333
78777, 1.325, 0.525, 0.083333333333333
78778, 1.325, 0.5, 0.0625
78779, 1.3041666666667, 0.5, 0.083333333333333
78780, 1.325, 0.475, 0.083333333333333
78781, 1.325, 0.45, 0.0625
78782, 1.3041666666667, 0.45, 0.083333333333333
78783, 1.325, 0.425, 0.083333333333333
78784, 1.325, 0.4, 0.0625
78785, 1.3041666666667, 0.4, 0.083333333333333
78786, 1.325, 0.375, 0.083333333333333
78787, 1.325, 0.35, 0.0625
78788, 1.3041666666667, 0.35, 0.083333333333333
78789, 1.325, 0.325, 0.083333333333333
78790, 1.325, 0.3, 0.0625
78791, 1.3041666666667, 0.3, 0.083333333333333
78792, 1.325, 0.275, 0.083333333333333
78793, 1.325, 0.25, 0.0625
78794, 1.3041666666667, 0.25, 0.083333333333333
78795, 1.325, 0.225, 0.083333333333333
78796, 1.325, 0.2, 0.0625
78797, 1.3041666666667, 0.2, 0.083333333333333
78798, 1.325, 0.175, 0.083333333333333
78799, 1.3666666666667, 1.325, 0.083333333333333
78800, 1.3666666666667, 1.3, 0.0625
78801, 1.3458333333333, 1.3, 0.083333333333333
78802, 1.3666666666667, 1.275, 0.083333333333333
78803, 1.3666666666667, 1.25, 0.0625
78804, 1.3458333333333, 1.25, 0.083333333333333
78805, 1.3666666666667, 1.225, 0.083333333333333
78806, 1.3666666666667, 1.2, 0.0625
78807, 1.3458333333333, 1.2, 0.083333333333333
78808, 1.3666666666667, 1.175, 0.083333333333333
78809, 1.3666666666667, 1.15, 0.0625
78810, 1.3458333333333, 1.15, 0.083333333333333
78811, 1.3666666666667, 1.125, 0.083333333333333
78812, 1.3666666666667, 1.1, 0.0625
78813, 1.3458333333333, 1.1, 0.083333333333333
78814, 1.3666666666667, 1.075, 0.083333333333333
78815, 1.3666666666667, 1.05, 0.0625
78816, 1.3458333333333, 1.05, 0.083333333333333
78817, 1.3666666666667, 1.025, 0.083333333333333
78818, 1.3666666666667, 1, 0.0625
78819, 1.3458333333333, 1, 0.083333333333333
78820, 1.3666666666667, 0.975, 0.083333333333333
78821, 1.3666666666667, 0.95, 0.0625
78822, 1.3458333333333, 0.95, 0.083333333333333
78823, 1.3666666666667, 0.925, 0.083333333333333
78824, 1.3666666666667, 0.9, 0.0625
78825, 1.3458333333333, 0.9, 0.083333333333333
78826, 1.3666666666667, 0.875, 0.083333333333333
78827, 1.3666666666667, 0.85, 0.0625
78828, 1.3458333333333, 0.85, 0.083333333333333
78829, 1.3666666666667, 0.825, 0.083333333333333
78830, 1.3666666666667, 0.8, 0.0625
78831, 1.3458333333333, 0.8, 0.083333333333333
78832, 1.3666666666667, 0.775, 0.083333333333333
78833, 1.3666666666667, 0.75, 0.0625
78834, 1.3458333333333, 0.75, 0.083333333333333
78835, 1.3666666666667, 0.725, 0.083333333333333
78836, 1.3666666666667, 0.7, 0.0625
78837, 1.3458333333333, 0.7, 0.083333333333333
78838, 1.3666666666667, 0.675, 0.083333333333333
78839, 1.3666666666667, 0.65, 0.0625
78840, 1.3458333333333, 0.65, 0.083333333333333
78841, 1.3666666666667, 0.625, 0.083333333333333
78842, 1.3666666666667, 0.6, 0.0625
78843, 1.3458333333333, 0.6, 0.083333333333333
78844, 1.3666666666667, 0.575, 0.083333333333333
78845, 1.3666666666667, 0.55, 0.0625
78846, 1.3458333333333, 0.55, 0.083333333333333
78847, 1.3666666666667, 0.525, 0.083333333333333
78848, 1.3666666666667, 0.5, 0.0625
78849, 1.3458333333333, 0.5, 0.083333333333333
78850, 1.3666666666667, 0.475, 0.083333333333333
78851, 1.3666666666667, 0.45, 0.0625
78852, 1.3458333333333, 0.45, 0.083333333333333
78853, 1.3666666666667, 0.425, 0.083333333333333
78854, 1.3666666666667, 0.4, 0.0625
78855, 1.3458333333333, 0.4, 0.083333333333333
78856, 1.3666666666667, 0.375, 0.083333333333333
78857, 1.3666666666667, 0.35, 0.0625
78858, 1.3458333333333, 0.35, 0.083333333333333
78859, 1.3666666666667, 0.325, 0.083333333333333
78860, 1.3666666666667, 0.3, 0.0625
78861, 1.3458333333333, 0.3, 0.083333333333333
78862, 1.3666666666667, 0.275, 0.083333333333333
78863, 1.3666666666667, 0.25, 0.0625
78864, 1.3458333333333, 0.25, 0.083333333333333
78865, 1.3666666666667, 0.225, 0.083333333333333
78866, 1.3666666666667, 0.2, 0.0625
78867, 1.3458333333333, 0.2, 0.083333333333333
78868, 1.3666666666667, 0.175, 0.083333333333333
78869, 1.4083333333333, 1.325, 0.083333333333333
78870, 1.4083333333333, 1.3, 0.0625
78871, 1.3875, 1.3, 0.083333333333333
78872, 1.4083333333333, 1.275, 0.083333333333333
78873, 1.4083333333333, 1.25, 0.0625
78874, 1.3875, 1.25, 0.083333333333333
78875, 1.4083333333333, 1.225, 0.083333333333333
78876, 1.4083333333333, 1.2, 0.0625
78877, 1.3875, 1.2, 0.083333333333333
78878, 1.4083333333333, 1.175, 0.083333333333333
78879, 1.4083333333333, 1.15, 0.0625
78880, 1.3875, 1.15, 0.083333333333333
78881, 1.4083333333333, 1.125, 0.083333333333333
78882, 1.4083333333333, 1.1, 0.0625
78883, 1.3875, 1.1, 0.083333333333333
78884, 1.4083333333333, 1.075, 0.083333333333333
78885, 1.4083333333333, 1.05, 0.0625
78886, 1.3875, 1.05, 0.083333333333333
78887, 1.4083333333333, 1.025, 0.083333333333333
78888, 1.4083333333333, 1, 0.0625
78889, 1.3875, 1, 0.083333333333333
78890, 1.4083333333333, 0.975, 0.083333333333333
78891, 1.4083333333333, 0.95, 0.0625
78892, 1.3875, 0.95, 0.083333333333333
78893, 1.4083333333333, 0.925, 0.083333333333333
78894, 1.4083333333333, 0.9, 0.0625
78895, 1.3875, 0.9, 0.083333333333333
78896, 1.4083333333333, 0.875, 0.083333333333333
78897, 1.4083333333333, 0.85, 0.0625
78898, 1.3875, 0.85, 0.083333333333333
78899, 1.4083333333333, 0.825, 0.083333333333333
78900, 1.4083333333333, 0.8, 0.0625
78901, 1.3875, 0.8, 0.083333333333333
78902, 1.4083333333333, 0.775, 0.083333333333333
78903, 1.4083333333333, 0.75, 0.0625
78904, 1.3875, 0.75, 0.083333333333333
78905, 1.4083333333333, 0.725, 0.083333333333333
78906, 1.4083333333333, 0.7, 0.0625
78907, 1.3875, 0.7, 0.083333333333333
78908, 1.4083333333333, 0.675, 0.083333333333333
78909, 1.4083333333333, 0.65, 0.0625
78910, 1.3875, 0.65, 0.083333333333333
78911, 1.4083333333333, 0.625, 0.083333333333333
78912, 1.4083333333333, 0.6, 0.0625
78913, 1.3875, 0.6, 0.083333333333333
78914, 1.4083333333333, 0.575, 0.083333333333333
78915, 1.4083333333333, 0.55, 0.0625
78916, 1.3875, 0.55, 0.083333333333333
78917, 1.4083333333333, 0.525, 0.083333333333333
78918, 1.4083333333333, 0.5, 0.0625
78919, 1.3875, 0.5, 0.083333333333333
78920, 1.4083333333333, 0.475, 0.083333333333333
78921, 1.4083333333333, 0.45, 0.0625
78922, 1.3875, 0.45, 0.083333333333333
78923, 1.4083333333333, 0.425, 0.083333333333333
78924, 1.4083333333333, 0.4, 0.0625
78925, 1.3875, 0.4, 0.083333333333333
78926, 1.4083333333333, 0.375, 0.083333333333333
78927, 1.4083333333333, 0.35, 0.0625
78928, 1.3875, 0.35, 0.083333333333333
78929, 1.4083333333333, 0.325, 0.083333333333333
78930, 1.4083333333333, 0.3, 0.0625
78931, 1.3875, 0.3, 0.083333333333333
78932, 1.4083333333333, 0.275, 0.083333333333333
78933, 1.4083333333333, 0.25, 0.0625
78934, 1.3875, 0.25, 0.083333333333333
78935, 1.4083333333333, 0.225, 0.083333333333333
78936, 1.4083333333333, 0.2, 0.0625
78937, 1.3875, 0.2, 0.083333333333333
78938, 1.4083333333333, 0.175, 0.083333333333333
78939, 1.45, 1.325, 0.083333333333333
78940, 1.45, 1.3, 0.0625
78941, 1.4291666666667, 1.3, 0.083333333333333
78942, 1.45, 1.275, 0.083333333333333
78943, 1.45, 1.25, 0.0625
78944, 1.4291666666667, 1.25, 0.083333333333333
78945, 1.45, 1.225, 0.083333333333333
78946, 1.45, 1.2, 0.0625
78947, 1.4291666666667, 1.2, 0.083333333333333
78948, 1.45, 1.175, 0.083333333333333
78949, 1.45, 1.15, 0.0625
78950, 1.4291666666667, 1.15, 0.083333333333333
78951, 1.45, 1.125, 0.083333333333333
78952, 1.45, 1.1, 0.0625
78953, 1.4291666666667, 1.1, 0.083333333333333
78954, 1.45, 1.075, 0.083333333333333
78955, 1.45, 1.05, 0.0625
78956, 1.4291666666667, 1.05, 0.083333333333333
78957, 1.45, 1.025, 0.083333333333333
78958, 1.45, 1, 0.0625
78959, 1.4291666666667, 1, 0.083333333333333
78960, 1.45, 0.975, 0.083333333333333
78961, 1.45, 0.95, 0.0625
78962, 1.4291666666667, 0.95, 0.083333333333333
78963, 1.45, 0.925, 0.083333333333333
78964, 1.45, 0.9, 0.0625
78965, 1.4291666666667, 0.9, 0.083333333333333
78966, 1.45, 0.875, 0.083333333333333
78967, 1.45, 0.85, 0.0625
78968, 1.4291666666667, 0.85, 0.083333333333333
78969, 1.45, 0.825, 0.083333333333333
78970, 1.45, 0.8, 0.0625
78971, 1.4291666666667, 0.8, 0.083333333333333
78972, 1.45, 0.775, 0.083333333333333
78973, 1.45, 0.75, 0.0625
78974, 1.4291666666667, 0.75, 0.083333333333333
78975, 1.45, 0.725, 0.083333333333333
78976, 1.45, 0.7, 0.0625
78977, 1.4291666666667, 0.7, 0.083333333333333
78978, 1.45, 0.675, 0.083333333333333
78979, 1.45, 0.65, 0.0625
78980, 1.4291666666667, 0.65, 0.083333333333333
78981, 1.45, 0.625, 0.083333333333333
78982, 1.45, 0.6, 0.0625
78983, 1.4291666666667, 0.6, 0.083333333333333
78984, 1.45, 0.575, 0.083333333333333
78985, 1.45, 0.55, 0.0625
78986, 1.4291666666667, 0.55, 0.083333333333333
78987, 1.45, 0.525, 0.083333333333333
78988, 1.45, 0.5, 0.0625
78989, 1.4291666666667, 0.5, 0.083333333333333
78990, 1.45, 0.475, 0.083333333333333
78991, 1.45, 0.45, 0.0625
78992, 1.4291666666667, 0.45, 0.083333333333333
78993, 1.45, 0.425, 0.083333333333333
78994, 1.45, 0.4, 0.0625
78995, 1.4291666666667, 0.4, 0.083333333333333
78996, 1.45, 0.375, 0.083333333333333
78997, 1.45, 0.35, 0.0625
78998, 1.4291666666667, 0.35, 0.083333333333333
78999, 1.45, 0.325, 0.083333333333333
79000, 1.45, 0.3, 0.0625
79001, 1.4291666666667, 0.3, 0.083333333333333
79002, 1.45, 0.275, 0.083333333333333
79003, 1.45, 0.25, 0.0625
79004, 1.4291666666667, 0.25, 0.083333333333333
79005, 1.45, 0.225, 0.083333333333333
79006, 1.45, 0.2, 0.0625
79007, 1.4291666666667, 0.2, 0.083333333333333
79008, 1.45, 0.175, 0.083333333333333
79009, 1.4916666666667, 1.325, 0.083333333333333
79010, 1.4916666666667, 1.3, 0.0625
79011, 1.4708333333333, 1.3, 0.083333333333333
79012, 1.4916666666667, 1.275, 0.083333333333333
79013, 1.4916666666667, 1.25, 0.0625
79014, 1.4708333333333, 1.25, 0.083333333333333
79015, 1.4916666666667, 1.225, 0.083333333333333
79016, 1.4916666666667, 1.2, 0.0625
79017, 1.4708333333333, 1.2, 0.083333333333333
79018, 1.4916666666667, 1.175, 0.083333333333333
79019, 1.4916666666667, 1.15, 0.0625
79020, 1.4708333333333, 1.15, 0.083333333333333
79021, 1.4916666666667, 1.125, 0.083333333333333
79022, 1.4916666666667, 1.1, 0.0625
79023, 1.4708333333333, 1.1, 0.083333333333333
79024, 1.4916666666667, 1.075, 0.083333333333333
79025, 1.4916666666667, 1.05, 0.0625
79026, 1.4708333333333, 1.05, 0.083333333333333
79027, 1.4916666666667, 1.025, 0.083333333333333
79028, 1.4916666666667, 1, 0.0625
79029, 1.4708333333333, 1, 0.083333333333333
79030, 1.4916666666667, 0.975, 0.083333333333333
79031, 1.4916666666667, 0.95, 0.0625
79032, 1.4708333333333, 0.95, 0.083333333333333
79033, 1.4916666666667, 0.925, 0.083333333333333
79034, 1.4916666666667, 0.9, 0.0625
79035, 1.4708333333333, 0.9, 0.083333333333333
79036, 1.4916666666667, 0.875, 0.083333333333333
79037, 1.4916666666667, 0.85, 0.0625
79038, 1.4708333333333, 0.85, 0.083333333333333
79039, 1.4916666666667, 0.825, 0.083333333333333
79040, 1.4916666666667, 0.8, 0.0625
79041, 1.4708333333333, 0.8, 0.083333333333333
79042, 1.4916666666667, 0.775, 0.083333333333333
79043, 1.4916666666667, 0.75, 0.0625
79044, 1.4708333333333, 0.75, 0.083333333333333
79045, 1.4916666666667, 0.725, 0.083333333333333
79046, 1.4916666666667, 0.7, 0.0625
79047, 1.4708333333333, 0.7, 0.083333333333333
79048, 1.4916666666667, 0.675, 0.083333333333333
79049, 1.4916666666667, 0.65, 0.0625
79050, 1.4708333333333, 0.65, 0.083333333333333
79051, 1.4916666666667, 0.625, 0.083333333333333
79052, 1.4916666666667, 0.6, 0.0625
79053, 1.4708333333333, 0.6, 0.083333333333333
79054, 1.4916666666667, 0.575, 0.083333333333333
79055, 1.4916666666667, 0.55, 0.0625
79056, 1.4708333333333, 0.55, 0.083333333333333
79057, 1.4916666666667, 0.525, 0.083333333333333
79058, 1.4916666666667, 0.5, 0.0625
79059, 1.4708333333333, 0.5, 0.083333333333333
79060, 1.4916666666667, 0.475, 0.083333333333333
79061, 1.4916666666667, 0.45, 0.0625
79062, 1.4708333333333, 0.45, 0.083333333333333
79063, 1.4916666666667, 0.425, 0.083333333333333
79064, 1.4916666666667, 0.4, 0.0625
79065, 1.4708333333333, 0.4, 0.083333333333333
79066, 1.4916666666667, 0.375, 0.083333333333333
79067, 1.4916666666667, 0.35, 0.0625
79068, 1.4708333333333, 0.35, 0.083333333333333
79069, 1.4916666666667, 0.325, 0.083333333333333
79070, 1.4916666666667, 0.3, 0.0625
79071, 1.4708333333333, 0.3, 0.083333333333333
79072, 1.4916666666667, 0.275, 0.083333333333333
79073, 1.4916666666667, 0.25, 0.0625
79074, 1.4708333333333, 0.25, 0.083333333333333
79075, 1.4916666666667, 0.225, 0.083333333333333
79076, 1.4916666666667, 0.2, 0.0625
79077, 1.4708333333333, 0.2, 0.083333333333333
79078, 1.4916666666667, 0.175, 0.083333333333333
79079, 1.5333333333333, 1.325, 0.083333333333333
79080, 1.5333333333333, 1.3, 0.0625
79081, 1.5125, 1.3, 0.083333333333333
79082, 1.5333333333333, 1.275, 0.083333333333333
79083, 1.5333333333333, 1.25, 0.0625
79084, 1.5125, 1.25, 0.083333333333333
79085, 1.5333333333333, 1.225, 0.083333333333333
79086, 1.5333333333333, 1.2, 0.0625
79087, 1.5125, 1.2, 0.083333333333333
79088, 1.5333333333333, 1.175, 0.083333333333333
79089, 1.5333333333333, 1.15, 0.0625
79090, 1.5125, 1.15, 0.083333333333333
79091, 1.5333333333333, 1.125, 0.083333333333333
79092, 1.5333333333333, 1.1, 0.0625
79093, 1.5125, 1.1, 0.083333333333333
79094, 1.5333333333333, 1.075, 0.083333333333333
79095, 1.5333333333333, 1.05, 0.0625
79096, 1.5125, 1.05, 0.083333333333333
79097, 1.5333333333333, 1.025, 0.083333333333333
79098, 1.5333333333333, 1, 0.0625
79099, 1.5125, 1, 0.083333333333333
79100, 1.5333333333333, 0.975, 0.083333333333333
79101, 1.5333333333333, 0.95, 0.0625
79102, 1.5125, 0.95, 0.083333333333333
79103, 1.5333333333333, 0.925, 0.083333333333333
79104, 1.5333333333333, 0.9, 0.0625
79105, 1.5125, 0.9, 0.083333333333333
79106, 1.5333333333333, 0.875, 0.083333333333333
79107, 1.5333333333333, 0.85, 0.0625
79108, 1.5125, 0.85, 0.083333333333333
79109, 1.5333333333333, 0.825, 0.083333333333333
79110, 1.5333333333333, 0.8, 0.0625
79111, 1.5125, 0.8, 0.083333333333333
79112, 1.5333333333333, 0.775, 0.083333333333333
79113, 1.5333333333333, 0.75, 0.0625
79114, 1.5125, 0.75, 0.083333333333333
79115, 1.5333333333333, 0.725, 0.083333333333333
79116, 1.5333333333333, 0.7, 0.0625
79117, 1.5125, 0.7, 0.083333333333333
79118, 1.5333333333333, 0.675, 0.083333333333333
79119, 1.5333333333333, 0.65, 0.0625
79120, 1.5125, 0.65, 0.083333333333333
79121, 1.5333333333333, 0.625, 0.083333333333333
79122, 1.5333333333333, 0.6, 0.0625
79123, 1.5125, 0.6, 0.083333333333333
79124, 1.5333333333333, 0.575, 0.083333333333333
79125, 1.5333333333333, 0.55, 0.0625
79126, 1.5125, 0.55, 0.083333333333333
79127, 1.5333333333333, 0.525, 0.083333333333333
79128, 1.5333333333333, 0.5, 0.0625
79129, 1.5125, 0.5, 0.083333333333333
79130, 1.5333333333333, 0.475, 0.083333333333333
79131, 1.5333333333333, 0.45, 0.0625
79132, 1.5125, 0.45, 0.083333333333333
79133, 1.5333333333333, 0.425, 0.083333333333333
79134, 1.5333333333333, 0.4, 0.0625
79135, 1.5125, 0.4, 0.083333333333333
79136, 1.5333333333333, 0.375, 0.083333333333333
79137, 1.5333333333333, 0.35, 0.0625
79138, 1.5125, 0.35, 0.083333333333333
79139, 1.5333333333333, 0.325, 0.083333333333333
79140, 1.5333333333333, 0.3, 0.0625
79141, 1.5125, 0.3, 0.083333333333333
79142, 1.5333333333333, 0.275, 0.083333333333333
79143, 1.5333333333333, 0.25, 0.0625
79144, 1.5125, 0.25, 0.083333333333333
79145, 1.5333333333333, 0.225, 0.083333333333333
79146, 1.5333333333333, 0.2, 0.0625
79147, 1.5125, 0.2, 0.083333333333333
79148, 1.5333333333333, 0.175, 0.083333333333333
79149, 1.575, 1.325, 0.083333333333333
79150, 1.575, 1.3, 0.0625
79151, 1.5541666666667, 1.3, 0.083333333333333
79152, 1.575, 1.275, 0.083333333333333
79153, 1.575, 1.25, 0.0625
79154, 1.5541666666667, 1.25, 0.083333333333333
79155, 1.575, 1.225, 0.083333333333333
79156, 1.575, 1.2, 0.0625
79157, 1.5541666666667, 1.2, 0.083333333333333
79158, 1.575, 1.175, 0.083333333333333
79159, 1.575, 1.15, 0.0625
79160, 1.5541666666667, 1.15, 0.083333333333333
79161, 1.575, 1.125, 0.083333333333333
79162, 1.575, 1.1, 0.0625
79163, 1.5541666666667, 1.1, 0.083333333333333
79164, 1.575, 1.075, 0.083333333333333
79165, 1.575, 1.05, 0.0625
79166, 1.5541666666667, 1.05, 0.083333333333333
79167, 1.575, 1.025, 0.083333333333333
79168, 1.575, 1, 0.0625
79169, 1.5541666666667, 1, 0.083333333333333
79170, 1.575, 0.975, 0.083333333333333
79171, 1.575, 0.95, 0.0625
79172, 1.5541666666667, 0.95, 0.083333333333333
79173, 1.575, 0.925, 0.083333333333333
79174, 1.575, 0.9, 0.0625
79175, 1.5541666666667, 0.9, 0.083333333333333
79176, 1.575, 0.875, 0.083333333333333
79177, 1.575, 0.85, 0.0625
79178, 1.5541666666667, 0.85, 0.083333333333333
79179, 1.575, 0.825, 0.083333333333333
79180, 1.575, 0.8, 0.0625
79181, 1.5541666666667, 0.8, 0.083333333333333
79182, 1.575, 0.775, 0.083333333333333
79183, 1.575, 0.75, 0.0625
79184, 1.5541666666667, 0.75, 0.083333333333333
79185, 1.575, 0.725, 0.083333333333333
79186, 1.575, 0.7, 0.0625
79187, 1.5541666666667, 0.7, 0.083333333333333
79188, 1.575, 0.675, 0.083333333333333
79189, 1.575, 0.65, 0.0625
79190, 1.5541666666667, 0.65, 0.083333333333333
79191, 1.575, 0.625, 0.083333333333333
79192, 1.575, 0.6, 0.0625
79193, 1.5541666666667, 0.6, 0.083333333333333
79194, 1.575, 0.575, 0.083333333333333
79195, 1.575, 0.55, 0.0625
79196, 1.5541666666667, 0.55, 0.083333333333333
79197, 1.575, 0.525, 0.083333333333333
79198, 1.575, 0.5, 0.0625
79199, 1.5541666666667, 0.5, 0.083333333333333
79200, 1.575, 0.475, 0.083333333333333
79201, 1.575, 0.45, 0.0625
79202, 1.5541666666667, 0.45, 0.083333333333333
79203, 1.575, 0.425, 0.083333333333333
79204, 1.575, 0.4, 0.0625
79205, 1.5541666666667, 0.4, 0.083333333333333
79206, 1.575, 0.375, 0.083333333333333
79207, 1.575, 0.35, 0.0625
79208, 1.5541666666667, 0.35, 0.083333333333333
79209, 1.575, 0.325, 0.083333333333333
79210, 1.575, 0.3, 0.0625
79211, 1.5541666666667, 0.3, 0.083333333333333
79212, 1.575, 0.275, 0.083333333333333
79213, 1.575, 0.25, 0.0625
79214, 1.5541666666667, 0.25, 0.083333333333333
79215, 1.575, 0.225, 0.083333333333333
79216, 1.575, 0.2, 0.0625
79217, 1.5541666666667, 0.2, 0.083333333333333
79218, 1.575, 0.175, 0.083333333333333
79219, 1.6166666666667, 1.325, 0.083333333333333
79220, 1.6166666666667, 1.3, 0.0625
79221, 1.5958333333333, 1.3, 0.083333333333333
79222, 1.6166666666667, 1.275, 0.083333333333333
79223, 1.6166666666667, 1.25, 0.0625
79224, 1.5958333333333, 1.25, 0.083333333333333
79225, 1.6166666666667, 1.225, 0.083333333333333
79226, 1.6166666666667, 1.2, 0.0625
79227, 1.5958333333333, 1.2, 0.083333333333333
79228, 1.6166666666667, 1.175, 0.083333333333333
79229, 1.6166666666667, 1.15, 0.0625
79230, 1.5958333333333, 1.15, 0.083333333333333
79231, 1.6166666666667, 1.125, 0.083333333333333
79232, 1.6166666666667, 1.1, 0.0625
79233, 1.5958333333333, 1.1, 0.083333333333333
79234, 1.6166666666667, 1.075, 0.083333333333333
79235, 1.6166666666667, 1.05, 0.0625
79236, 1.5958333333333, 1.05, 0.083333333333333
79237, 1.6166666666667, 1.025, 0.083333333333333
79238, 1.6166666666667, 1, 0.0625
79239, 1.5958333333333, 1, 0.083333333333333
79240, 1.6166666666667, 0.975, 0.083333333333333
79241, 1.6166666666667, 0.95, 0.0625
79242, 1.5958333333333, 0.95, 0.083333333333333
79243, 1.6166666666667, 0.925, 0.083333333333333
79244, 1.6166666666667, 0.9, 0.0625
79245, 1.5958333333333, 0.9, 0.083333333333333
79246, 1.6166666666667, 0.875, 0.083333333333333
79247, 1.6166666666667, 0.85, 0.0625
79248, 1.5958333333333, 0.85, 0.083333333333333
79249, 1.6166666666667, 0.825, 0.083333333333333
79250, 1.6166666666667, 0.8, 0.0625
79251, 1.5958333333333, 0.8, 0.083333333333333
79252, 1.6166666666667, 0.775, 0.083333333333333
79253, 1.6166666666667, 0.75, 0.0625
79254, 1.5958333333333, 0.75, 0.083333333333333
79255, 1.6166666666667, 0.725, 0.083333333333333
79256, 1.6166666666667, 0.7, 0.0625
79257, 1.5958333333333, 0.7, 0.083333333333333
79258, 1.6166666666667, 0.675, 0.083333333333333
79259, 1.6166666666667, 0.65, 0.0625
79260, 1.5958333333333, 0.65, 0.083333333333333
79261, 1.6166666666667, 0.625, 0.083333333333333
79262, 1.6166666666667, 0.6, 0.0625
79263, 1.5958333333333, 0.6, 0.083333333333333
79264, 1.6166666666667, 0.575, 0.083333333333333
79265, 1.6166666666667, 0.55, 0.0625
79266, 1.5958333333333, 0.55, 0.083333333333333
79267, 1.6166666666667, 0.525, 0.083333333333333
79268, 1.6166666666667, 0.5, 0.0625
79269, 1.5958333333333, 0.5, 0.083333333333333
79270, 1.6166666666667, 0.475, 0.083333333333333
79271, 1.6166666666667, 0.45, 0.0625
79272, 1.5958333333333, 0.45, 0.083333333333333
79273, 1.6166666666667, 0.425, 0.083333333333333
79274, 1.6166666666667, 0.4, 0.0625
79275, 1.5958333333333, 0.4, 0.083333333333333
79276, 1.6166666666667, 0.375, 0.083333333333333
79277, 1.6166666666667, 0.35, 0.0625
79278, 1.5958333333333, 0.35, 0.083333333333333
79279, 1.6166666666667, 0.325, 0.083333333333333
79280, 1.6166666666667, 0.3, 0.0625
79281, 1.5958333333333, 0.3, 0.083333333333333
79282, 1.6166666666667, 0.275, 0.083333333333333
79283, 1.6166666666667, 0.25, 0.0625
79284, 1.5958333333333, 0.25, 0.083333333333333
79285, 1.6166666666667, 0.225, 0.083333333333333
79286, 1.6166666666667, 0.2, 0.0625
79287, 1.5958333333333, 0.2, 0.083333333333333
79288, 1.6166666666667, 0.175, 0.083333333333333
79289, 1.6583333333333, 1.325, 0.083333333333333
79290, 1.6583333333333, 1.3, 0.0625
79291, 1.6375, 1.3, 0.083333333333333
79292, 1.6583333333333, 1.275, 0.083333333333333
79293, 1.6583333333333, 1.25, 0.0625
79294, 1.6375, 1.25, 0.083333333333333
79295, 1.6583333333333, 1.225, 0.083333333333333
79296, 1.6583333333333, 1.2, 0.0625
79297, 1.6375, 1.2, 0.083333333333333
79298, 1.6583333333333, 1.175, 0.083333333333333
79299, 1.6583333333333, 1.15, 0.0625
79300, 1.6375, 1.15, 0.083333333333333
79301, 1.6583333333333, 1.125, 0.083333333333333
79302, 1.6583333333333, 1.1, 0.0625
79303, 1.6375, 1.1, 0.083333333333333
79304, 1.6583333333333, 1.075, 0.083333333333333
79305, 1.6583333333333, 1.05, 0.0625
79306, 1.6375, 1.05, 0.083333333333333
79307, 1.6583333333333, 1.025, 0.083333333333333
79308, 1.6583333333333, 1, 0.0625
79309, 1.6375, 1, 0.083333333333333
79310, 1.6583333333333, 0.975, 0.083333333333333
79311, 1.6583333333333, 0.95, 0.0625
79312, 1.6375, 0.95, 0.083333333333333
79313, 1.6583333333333, 0.925, 0.083333333333333
79314, 1.6583333333333, 0.9, 0.0625
79315, 1.6375, 0.9, 0.083333333333333
79316, 1.6583333333333, 0.875, 0.083333333333333
79317, 1.6583333333333, 0.85, 0.0625
79318, 1.6375, 0.85, 0.083333333333333
79319, 1.6583333333333, 0.825, 0.083333333333333
79320, 1.6583333333333, 0.8, 0.0625
79321, 1.6375, 0.8, 0.083333333333333
79322, 1.6583333333333, 0.775, 0.083333333333333
79323, 1.6583333333333, 0.75, 0.0625
79324, 1.6375, 0.75, 0.083333333333333
79325, 1.6583333333333, 0.725, 0.083333333333333
79326, 1.6583333333333, 0.7, 0.0625
79327, 1.6375, 0.7, 0.083333333333333
79328, 1.6583333333333, 0.675, 0.083333333333333
79329, 1.6583333333333, 0.65, 0.0625
79330, 1.6375, 0.65, 0.083333333333333
79331, 1.6583333333333, 0.625, 0.083333333333333
79332, 1.6583333333333, 0.6, 0.0625
79333, 1.6375, 0.6, 0.083333333333333
79334, 1.6583333333333, 0.575, 0.083333333333333
79335, 1.6583333333333, 0.55, 0.0625
79336, 1.6375, 0.55, 0.083333333333333
79337, 1.6583333333333, 0.525, 0.083333333333333
79338, 1.6583333333333, 0.5, 0.0625
79339, 1.6375, 0.5, 0.083333333333333
79340, 1.6583333333333, 0.475, 0.083333333333333
79341, 1.6583333333333, 0.45, 0.0625
79342, 1.6375, 0.45, 0.083333333333333
79343, 1.6583333333333, 0.425, 0.083333333333333
79344, 1.6583333333333, 0.4, 0.0625
79345, 1.6375, 0.4, 0.083333333333333
79346, 1.6583333333333, 0.375, 0.083333333333333
79347, 1.6583333333333, 0.35, 0.0625
79348, 1.6375, 0.35, 0.083333333333333
79349, 1.6583333333333, 0.325, 0.083333333333333
79350, 1.6583333333333, 0.3, 0.0625
79351, 1.6375, 0.3, 0.083333333333333
79352, 1.6583333333333, 0.275, 0.083333333333333
79353, 1.6583333333333, 0.25, 0.0625
79354, 1.6375, 0.25, 0.083333333333333
79355, 1.6583333333333, 0.225, 0.083333333333333
79356, 1.6583333333333, 0.2, 0.0625
79357, 1.6375, 0.2, 0.083333333333333
79358, 1.6583333333333, 0.175, 0.083333333333333
79359, 1.7, 1.325, 0.083333333333333
79360, 1.7, 1.3, 0.0625
79361, 1.6791666666667, 1.3, 0.083333333333333
79362, 1.7, 1.275, 0.083333333333333
79363, 1.7, 1.25, 0.0625
79364, 1.6791666666667, 1.25, 0.083333333333333
79365, 1.7, 1.225, 0.083333333333333
79366, 1.7, 1.2, 0.0625
79367, 1.6791666666667, 1.2, 0.083333333333333
79368, 1.7, 1.175, 0.083333333333333
79369, 1.7, 1.15, 0.0625
79370, 1.6791666666667, 1.15, 0.083333333333333
79371, 1.7, 1.125, 0.083333333333333
79372, 1.7, 1.1, 0.0625
79373, 1.6791666666667, 1.1, 0.083333333333333
79374, 1.7, 1.075, 0.083333333333333
79375, 1.7, 1.05, 0.0625
79376, 1.6791666666667, 1.05, 0.083333333333333
79377, 1.7, 1.025, 0.083333333333333
79378, 1.7, 1, 0.0625
79379, 1.6791666666667, 1, 0.083333333333333
79380, 1.7, 0.975, 0.083333333333333
79381, 1.7, 0.95, 0.0625
79382, 1.6791666666667, 0.95, 0.083333333333333
79383, 1.7, 0.925, 0.083333333333333
79384, 1.7, 0.9, 0.0625
79385, 1.6791666666667, 0.9, 0.083333333333333
79386, 1.7, 0.875, 0.083333333333333
79387, 1.7, 0.85, 0.0625
79388, 1.6791666666667, 0.85, 0.083333333333333
79389, 1.7, 0.825, 0.083333333333333
79390, 1.7, 0.8, 0.0625
79391, 1.6791666666667, 0.8, 0.083333333333333
79392, 1.7, 0.775, 0.083333333333333
79393, 1.7, 0.75, 0.0625
79394, 1.6791666666667, 0.75, 0.083333333333333
79395, 1.7, 0.725, 0.083333333333333
79396, 1.7, 0.7, 0.0625
79397, 1.6791666666667, 0.7, 0.083333333333333
79398, 1.7, 0.675, 0.083333333333333
79399, 1.7, 0.65, 0.0625
79400, 1.6791666666667, 0.65, 0.083333333333333
79401, 1.7, 0.625, 0.083333333333333
79402, 1.7, 0.6, 0.0625
79403, 1.6791666666667, 0.6, 0.083333333333333
79404, 1.7, 0.575, 0.083333333333333
79405, 1.7, 0.55, 0.0625
79406, 1.6791666666667, 0.55, 0.083333333333333
79407, 1.7, 0.525, 0.083333333333333
79408, 1.7, 0.5, 0.0625
79409, 1.6791666666667, 0.5, 0.083333333333333
79410, 1.7, 0.475, 0.083333333333333
79411, 1.7, 0.45, 0.0625
79412, 1.6791666666667, 0.45, 0.083333333333333
79413, 1.7, 0.425, 0.083333333333333
79414, 1.7, 0.4, 0.0625
79415, 1.6791666666667, 0.4, 0.083333333333333
79416, 1.7, 0.375, 0.083333333333333
79417, 1.7, 0.35, 0.0625
79418, 1.6791666666667, 0.35, 0.083333333333333
79419, 1.7, 0.325, 0.083333333333333
79420, 1.7, 0.3, 0.0625
79421, 1.6791666666667, 0.3, 0.083333333333333
79422, 1.7, 0.275, 0.083333333333333
79423, 1.7, 0.25, 0.0625
79424, 1.6791666666667, 0.25, 0.083333333333333
79425, 1.7, 0.225, 0.083333333333333
79426, 1.7, 0.2, 0.0625
79427, 1.6791666666667, 0.2, 0.083333333333333
79428, 1.7, 0.175, 0.083333333333333
79429, 1.7416666666667, 1.325, 0.083333333333333
79430, 1.7416666666667, 1.3, 0.0625
79431, 1.7208333333333, 1.3, 0.083333333333333
79432, 1.7416666666667, 1.275, 0.083333333333333
79433, 1.7416666666667, 1.25, 0.0625
79434, 1.7208333333333, 1.25, 0.083333333333333
79435, 1.7416666666667, 1.225, 0.083333333333333
79436, 1.7416666666667, 1.2, 0.0625
79437, 1.7208333333333, 1.2, 0.083333333333333
79438, 1.7416666666667, 1.175, 0.083333333333333
79439, 1.7416666666667, 1.15, 0.0625
79440, 1.7208333333333, 1.15, 0.083333333333333
79441, 1.7416666666667, 1.125, 0.083333333333333
79442, 1.7416666666667, 1.1, 0.0625
79443, 1.7208333333333, 1.1, 0.083333333333333
79444, 1.7416666666667, 1.075, 0.083333333333333
79445, 1.7416666666667, 1.05, 0.0625
79446, 1.7208333333333, 1.05, 0.083333333333333
79447, 1.7416666666667, 1.025, 0.083333333333333
79448, 1.7416666666667, 1, 0.0625
79449, 1.7208333333333, 1, 0.083333333333333
79450, 1.7416666666667, 0.975, 0.083333333333333
79451, 1.7416666666667, 0.95, 0.0625
79452, 1.7208333333333, 0.95, 0.083333333333333
79453, 1.7416666666667, 0.925, 0.083333333333333
79454, 1.7416666666667, 0.9, 0.0625
79455, 1.7208333333333, 0.9, 0.083333333333333
79456, 1.7416666666667, 0.875, 0.083333333333333
79457, 1.7416666666667, 0.85, 0.0625
79458, 1.7208333333333, 0.85, 0.083333333333333
79459, 1.7416666666667, 0.825, 0.083333333333333
79460, 1.7416666666667, 0.8, 0.0625
79461, 1.7208333333333, 0.8, 0.083333333333333
79462, 1.7416666666667, 0.775, 0.083333333333333
79463, 1.7416666666667, 0.75, 0.0625
79464, 1.7208333333333, 0.75, 0.083333333333333
79465, 1.7416666666667, 0.725, 0.083333333333333
79466, 1.7416666666667, 0.7, 0.0625
79467, 1.7208333333333, 0.7, 0.083333333333333
79468, 1.7416666666667, 0.675, 0.083333333333333
79469, 1.7416666666667, 0.65, 0.0625
79470, 1.7208333333333, 0.65, 0.083333333333333
79471, 1.7416666666667, 0.625, 0.083333333333333
79472, 1.7416666666667, 0.6, 0.0625
79473, 1.7208333333333, 0.6, 0.083333333333333
79474, 1.7416666666667, 0.575, 0.083333333333333
79475, 1.7416666666667, 0.55, 0.0625
79476, 1.7208333333333, 0.55, 0.083333333333333
79477, 1.7416666666667, 0.525, 0.083333333333333
79478, 1.7416666666667, 0.5, 0.0625
79479, 1.7208333333333, 0.5, 0.083333333333333
79480, 1.7416666666667, 0.475, 0.083333333333333
79481, 1.7416666666667, 0.45, 0.0625
79482, 1.7208333333333, 0.45, 0.083333333333333
79483, 1.7416666666667, 0.425, 0.083333333333333
79484, 1.7416666666667, 0.4, 0.0625
79485, 1.7208333333333, 0.4, 0.083333333333333
79486, 1.7416666666667, 0.375, 0.083333333333333
79487, 1.7416666666667, 0.35, 0.0625
79488, 1.7208333333333, 0.35, 0.083333333333333
79489, 1.7416666666667, 0.325, 0.083333333333333
79490, 1.7416666666667, 0.3, 0.0625
79491, 1.7208333333333, 0.3, 0.083333333333333
79492, 1.7416666666667, 0.275, 0.083333333333333
79493, 1.7416666666667, 0.25, 0.0625
79494, 1.7208333333333, 0.25, 0.083333333333333
79495, 1.7416666666667, 0.225, 0.083333333333333
79496, 1.7416666666667, 0.2, 0.0625
79497, 1.7208333333333, 0.2, 0.083333333333333
79498, 1.7416666666667, 0.175, 0.083333333333333
79499, 1.7833333333333, 1.325, 0.083333333333333
79500, 1.7833333333333, 1.3, 0.0625
79501, 1.7625, 1.3, 0.083333333333333
79502, 1.7833333333333, 1.275, 0.083333333333333
79503, 1.7833333333333, 1.25, 0.0625
79504, 1.7625, 1.25, 0.083333333333333
79505, 1.7833333333333, 1.225, 0.083333333333333
79506, 1.7833333333333, 1.2, 0.0625
79507, 1.7625, 1.2, 0.083333333333333
79508, 1.7833333333333, 1.175, 0.083333333333333
79509, 1.7833333333333, 1.15, 0.0625
79510, 1.7625, 1.15, 0.083333333333333
79511, 1.7833333333333, 1.125, 0.083333333333333
79512, 1.7833333333333, 1.1, 0.0625
79513, 1.7625, 1.1, 0.083333333333333
79514, 1.7833333333333, 1.075, 0.083333333333333
79515, 1.7833333333333, 1.05, 0.0625
79516, 1.7625, 1.05, 0.083333333333333
79517, 1.7833333333333, 1.025, 0.083333333333333
79518, 1.7833333333333, 1, 0.0625
79519, 1.7625, 1, 0.083333333333333
79520, 1.7833333333333, 0.975, 0.083333333333333
79521, 1.7833333333333, 0.95, 0.0625
79522, 1.7625, 0.95, 0.083333333333333
79523, 1.7833333333333, 0.925, 0.083333333333333
79524, 1.7833333333333, 0.9, 0.0625
79525, 1.7625, 0.9, 0.083333333333333
79526, 1.7833333333333, 0.875, 0.083333333333333
79527, 1.7833333333333, 0.85, 0.0625
79528, 1.7625, 0.85, 0.083333333333333
79529, 1.7833333333333, 0.825, 0.083333333333333
79530, 1.7833333333333, 0.8, 0.0625
79531, 1.7625, 0.8, 0.083333333333333
79532, 1.7833333333333, 0.775, 0.083333333333333
79533, 1.7833333333333, 0.75, 0.0625
79534, 1.7625, 0.75, 0.083333333333333
79535, 1.7833333333333, 0.725, 0.083333333333333
79536, 1.7833333333333, 0.7, 0.0625
79537, 1.7625, 0.7, 0.083333333333333
79538, 1.7833333333333, 0.675, 0.083333333333333
79539, 1.7833333333333, 0.65, 0.0625
79540, 1.7625, 0.65, 0.083333333333333
79541, 1.7833333333333, 0.625, 0.083333333333333
79542, 1.7833333333333, 0.6, 0.0625
79543, 1.7625, 0.6, 0.083333333333333
79544, 1.7833333333333, 0.575, 0.083333333333333
79545, 1.7833333333333, 0.55, 0.0625
79546, 1.7625, 0.55, 0.083333333333333
79547, 1.7833333333333, 0.525, 0.083333333333333
79548, 1.7833333333333, 0.5, 0.0625
79549, 1.7625, 0.5, 0.083333333333333
79550, 1.7833333333333, 0.475, 0.083333333333333
79551, 1.7833333333333, 0.45, 0.0625
79552, 1.7625, 0.45, 0.083333333333333
79553, 1.7833333333333, 0.425, 0.083333333333333
79554, 1.7833333333333, 0.4, 0.0625
79555, 1.7625, 0.4, 0.083333333333333
79556, 1.7833333333333, 0.375, 0.083333333333333
79557, 1.7833333333333, 0.35, 0.0625
79558, 1.7625, 0.35, 0.083333333333333
79559, 1.7833333333333, 0.325, 0.083333333333333
79560, 1.7833333333333, 0.3, 0.0625
79561, 1.7625, 0.3, 0.083333333333333
79562, 1.7833333333333, 0.275, 0.083333333333333
79563, 1.7833333333333, 0.25, 0.0625
79564, 1.7625, 0.25, 0.083333333333333
79565, 1.7833333333333, 0.225, 0.083333333333333
79566, 1.7833333333333, 0.2, 0.0625
79567, 1.7625, 0.2, 0.083333333333333
79568, 1.7833333333333, 0.175, 0.083333333333333
79569, 1.825, 1.325, 0.083333333333333
79570, 1.825, 1.3, 0.0625
79571, 1.8041666666667, 1.3, 0.083333333333333
79572, 1.825, 1.275, 0.083333333333333
79573, 1.825, 1.25, 0.0625
79574, 1.8041666666667, 1.25, 0.083333333333333
79575, 1.825, 1.225, 0.083333333333333
79576, 1.825, 1.2, 0.0625
79577, 1.8041666666667, 1.2, 0.083333333333333
79578, 1.825, 1.175, 0.083333333333333
79579, 1.825, 1.15, 0.0625
79580, 1.8041666666667, 1.15, 0.083333333333333
79581, 1.825, 1.125, 0.083333333333333
79582, 1.825, 1.1, 0.0625
79583, 1.8041666666667, 1.1, 0.083333333333333
79584, 1.825, 1.075, 0.083333333333333
79585, 1.825, 1.05, 0.0625
79586, 1.8041666666667, 1.05, 0.083333333333333
79587, 1.825, 1.025, 0.083333333333333
79588, 1.825, 1, 0.0625
79589, 1.8041666666667, 1, 0.083333333333333
79590, 1.825, 0.975, 0.083333333333333
79591, 1.825, 0.95, 0.0625
79592, 1.8041666666667, 0.95, 0.083333333333333
79593, 1.825, 0.925, 0.083333333333333
79594, 1.825, 0.9, 0.0625
79595, 1.8041666666667, 0.9, 0.083333333333333
79596, 1.825, 0.875, 0.083333333333333
79597, 1.825, 0.85, 0.0625
79598, 1.8041666666667, 0.85, 0.083333333333333
79599, 1.825, 0.825, 0.083333333333333
79600, 1.825, 0.8, 0.0625
79601, 1.8041666666667, 0.8, 0.083333333333333
79602, 1.825, 0.775, 0.083333333333333
79603, 1.825, 0.75, 0.0625
79604, 1.8041666666667, 0.75, 0.083333333333333
79605, 1.825, 0.725, 0.083333333333333
79606, 1.825, 0.7, 0.0625
79607, 1.8041666666667, 0.7, 0.083333333333333
79608, 1.825, 0.675, 0.083333333333333
79609, 1.825, 0.65, 0.0625
79610, 1.8041666666667, 0.65, 0.083333333333333
79611, 1.825, 0.625, 0.083333333333333
79612, 1.825, 0.6, 0.0625
79613, 1.8041666666667, 0.6, 0.083333333333333
79614, 1.825, 0.575, 0.083333333333333
79615, 1.825, 0.55, 0.0625
79616, 1.8041666666667, 0.55, 0.083333333333333
79617, 1.825, 0.525, 0.083333333333333
79618, 1.825, 0.5, 0.0625
79619, 1.8041666666667, 0.5, 0.083333333333333
79620, 1.825, 0.475, 0.083333333333333
79621, 1.825, 0.45, 0.0625
79622, 1.8041666666667, 0.45, 0.083333333333333
79623, 1.825, 0.425, 0.083333333333333
79624, 1.825, 0.4, 0.0625
79625, 1.8041666666667, 0.4, 0.083333333333333
79626, 1.825, 0.375, 0.083333333333333
79627, 1.825, 0.35, 0.0625
79628, 1.8041666666667, 0.35, 0.083333333333333
79629, 1.825, 0.325, 0.083333333333333
79630, 1.825, 0.3, 0.0625
79631, 1.8041666666667, 0.3, 0.083333333333333
79632, 1.825, 0.275, 0.083333333333333
79633, 1.825, 0.25, 0.0625
79634, 1.8041666666667, 0.25, 0.083333333333333
79635, 1.825, 0.225, 0.083333333333333
79636, 1.825, 0.2, 0.0625
79637, 1.8041666666667, 0.2, 0.083333333333333
79638, 1.825, 0.175, 0.083333333333333
79639, 1.8666666666667, 1.325, 0.083333333333333
79640, 1.8666666666667, 1.3, 0.0625
79641, 1.8458333333333, 1.3, 0.083333333333333
79642, 1.8666666666667, 1.275, 0.083333333333333
79643, 1.8666666666667, 1.25, 0.0625
79644, 1.8458333333333, 1.25, 0.083333333333333
79645, 1.8666666666667, 1.225, 0.083333333333333
79646, 1.8666666666667, 1.2, 0.0625
79647, 1.8458333333333, 1.2, 0.083333333333333
79648, 1.8666666666667, 1.175, 0.083333333333333
79649, 1.8666666666667, 1.15, 0.0625
79650, 1.8458333333333, 1.15, 0.083333333333333
79651, 1.8666666666667, 1.125, 0.083333333333333
79652, 1.8666666666667, 1.1, 0.0625
79653, 1.8458333333333, 1.1, 0.083333333333333
79654, 1.8666666666667, 1.075, 0.083333333333333
79655, 1.8666666666667, 1.05, 0.0625
79656, 1.8458333333333, 1.05, 0.083333333333333
79657, 1.8666666666667, 1.025, 0.083333333333333
79658, 1.8666666666667, 1, 0.0625
79659, 1.8458333333333, 1, 0.083333333333333
79660, 1.8666666666667, 0.975, 0.083333333333333
79661, 1.8666666666667, 0.95, 0.0625
79662, 1.8458333333333, 0.95, 0.083333333333333
79663, 1.8666666666667, 0.925, 0.083333333333333
79664, 1.8666666666667, 0.9, 0.0625
79665, 1.8458333333333, 0.9, 0.083333333333333
79666, 1.8666666666667, 0.875, 0.083333333333333
79667, 1.8666666666667, 0.85, 0.0625
79668, 1.8458333333333, 0.85, 0.083333333333333
79669, 1.8666666666667, 0.825, 0.083333333333333
79670, 1.8666666666667, 0.8, 0.0625
79671, 1.8458333333333, 0.8, 0.083333333333333
79672, 1.8666666666667, 0.775, 0.083333333333333
79673, 1.8666666666667, 0.75, 0.0625
79674, 1.8458333333333, 0.75, 0.083333333333333
79675, 1.8666666666667, 0.725, 0.083333333333333
79676, 1.8666666666667, 0.7, 0.0625
79677, 1.8458333333333, 0.7, 0.083333333333333
79678, 1.8666666666667, 0.675, 0.083333333333333
79679, 1.8666666666667, 0.65, 0.0625
79680, 1.8458333333333, 0.65, 0.083333333333333
79681, 1.8666666666667, 0.625, 0.083333333333333
79682, 1.8666666666667, 0.6, 0.0625
79683, 1.8458333333333, 0.6, 0.083333333333333
79684, 1.8666666666667, 0.575, 0.083333333333333
79685, 1.8666666666667, 0.55, 0.0625
79686, 1.8458333333333, 0.55, 0.083333333333333
79687, 1.8666666666667, 0.525, 0.083333333333333
79688, 1.8666666666667, 0.5, 0.0625
79689, 1.8458333333333, 0.5, 0.083333333333333
79690, 1.8666666666667, 0.475, 0.083333333333333
79691, 1.8666666666667, 0.45, 0.0625
79692, 1.8458333333333, 0.45, 0.083333333333333
79693, 1.8666666666667, 0.425, 0.083333333333333
79694, 1.8666666666667, 0.4, 0.0625
79695, 1.8458333333333, 0.4, 0.083333333333333
79696, 1.8666666666667, 0.375, 0.083333333333333
79697, 1.8666666666667, 0.35, 0.0625
79698, 1.8458333333333, 0.35, 0.083333333333333
79699, 1.8666666666667, 0.325, 0.083333333333333
79700, 1.8666666666667, 0.3, 0.0625
79701, 1.8458333333333, 0.3, 0.083333333333333
79702, 1.8666666666667, 0.275, 0.083333333333333
79703, 1.8666666666667, 0.25, 0.0625
79704, 1.8458333333333, 0.25, 0.083333333333333
79705, 1.8666666666667, 0.225, 0.083333333333333
79706, 1.8666666666667, 0.2, 0.0625
79707, 1.8458333333333, 0.2, 0.083333333333333
79708, 1.8666666666667, 0.175, 0.083333333333333
79709, 1.9083333333333, 1.325, 0.083333333333333
79710, 1.9083333333333, 1.3, 0.0625
79711, 1.8875, 1.3, 0.083333333333333
79712, 1.9083333333333, 1.275, 0.083333333333333
79713, 1.9083333333333, 1.25, 0.0625
79714, 1.8875, 1.25, 0.083333333333333
79715, 1.9083333333333, 1.225, 0.083333333333333
79716, 1.9083333333333, 1.2, 0.0625
79717, 1.8875, 1.2, 0.083333333333333
79718, 1.9083333333333, 1.175, 0.083333333333333
79719, 1.9083333333333, 1.15, 0.0625
79720, 1.8875, 1.15, 0.083333333333333
79721, 1.9083333333333, 1.125, 0.083333333333333
79722, 1.9083333333333, 1.1, 0.0625
79723, 1.8875, 1.1, 0.083333333333333
79724, 1.9083333333333, 1.075, 0.083333333333333
79725, 1.9083333333333, 1.05, 0.0625
79726, 1.8875, 1.05, 0.083333333333333
79727, 1.9083333333333, 1.025, 0.083333333333333
79728, 1.9083333333333, 1, 0.0625
79729, 1.8875, 1, 0.083333333333333
79730, 1.9083333333333, 0.975, 0.083333333333333
79731, 1.9083333333333, 0.95, 0.0625
79732, 1.8875, 0.95, 0.083333333333333
79733, 1.9083333333333, 0.925, 0.083333333333333
79734, 1.9083333333333, 0.9, 0.0625
79735, 1.8875, 0.9, 0.083333333333333
79736, 1.9083333333333, 0.875, 0.083333333333333
79737, 1.9083333333333, 0.85, 0.0625
79738, 1.8875, 0.85, 0.083333333333333
79739, 1.9083333333333, 0.825, 0.083333333333333
79740, 1.9083333333333, 0.8, 0.0625
79741, 1.8875, 0.8, 0.083333333333333
79742, 1.9083333333333, 0.775, 0.083333333333333
79743, 1.9083333333333, 0.75, 0.0625
79744, 1.8875, 0.75, 0.083333333333333
79745, 1.9083333333333, 0.725, 0.083333333333333
79746, 1.9083333333333, 0.7, 0.0625
79747, 1.8875, 0.7, 0.083333333333333
79748, 1.9083333333333, 0.675, 0.083333333333333
79749, 1.9083333333333, 0.65, 0.0625
79750, 1.8875, 0.65, 0.083333333333333
79751, 1.9083333333333, 0.625, 0.083333333333333
79752, 1.9083333333333, 0.6, 0.0625
79753, 1.8875, 0.6, 0.083333333333333
79754, 1.9083333333333, 0.575, 0.083333333333333
79755, 1.9083333333333, 0.55, 0.0625
79756, 1.8875, 0.55, 0.083333333333333
79757, 1.9083333333333, 0.525, 0.083333333333333
79758, 1.9083333333333, 0.5, 0.0625
79759, 1.8875, 0.5, 0.083333333333333
79760, 1.9083333333333, 0.475, 0.083333333333333
79761, 1.9083333333333, 0.45, 0.0625
79762, 1.8875, 0.45, 0.083333333333333
79763, 1.9083333333333, 0.425, 0.083333333333333
79764, 1.9083333333333, 0.4, 0.0625
79765, 1.8875, 0.4, 0.083333333333333
79766, 1.9083333333333, 0.375, 0.083333333333333
79767, 1.9083333333333, 0.35, 0.0625
79768, 1.8875, 0.35, 0.083333333333333
79769, 1.9083333333333, 0.325, 0.083333333333333
79770, 1.9083333333333, 0.3, 0.0625
79771, 1.8875, 0.3, 0.083333333333333
79772, 1.9083333333333, 0.275, 0.083333333333333
79773, 1.9083333333333, 0.25, 0.0625
79774, 1.8875, 0.25, 0.083333333333333
79775, 1.9083333333333, 0.225, 0.083333333333333
79776, 1.9083333333333, 0.2, 0.0625
79777, 1.8875, 0.2, 0.083333333333333
79778, 1.9083333333333, 0.175, 0.083333333333333
79779, 1.95, 1.325, 0.083333333333333
79780, 1.95, 1.3, 0.0625
79781, 1.9291666666667, 1.3, 0.083333333333333
79782, 1.95, 1.275, 0.083333333333333
79783, 1.95, 1.25, 0.0625
79784, 1.9291666666667, 1.25, 0.083333333333333
79785, 1.95, 1.225, 0.083333333333333
79786, 1.95, 1.2, 0.0625
79787, 1.9291666666667, 1.2, 0.083333333333333
79788, 1.95, 1.175, 0.083333333333333
79789, 1.95, 1.15, 0.0625
79790, 1.9291666666667, 1.15, 0.083333333333333
79791, 1.95, 1.125, 0.083333333333333
79792, 1.95, 1.1, 0.0625
79793, 1.9291666666667, 1.1, 0.083333333333333
79794, 1.95, 1.075, 0.083333333333333
79795, 1.95, 1.05, 0.0625
79796, 1.9291666666667, 1.05, 0.083333333333333
79797, 1.95, 1.025, 0.083333333333333
79798, 1.95, 1, 0.0625
79799, 1.9291666666667, 1, 0.083333333333333
79800, 1.95, 0.975, 0.083333333333333
79801, 1.95, 0.95, 0.0625
79802, 1.9291666666667, 0.95, 0.083333333333333
79803, 1.95, 0.925, 0.083333333333333
79804, 1.95, 0.9, 0.0625
79805, 1.9291666666667, 0.9, 0.083333333333333
79806, 1.95, 0.875, 0.083333333333333
79807, 1.95, 0.85, 0.0625
79808, 1.9291666666667, 0.85, 0.083333333333333
79809, 1.95, 0.825, 0.083333333333333
79810, 1.95, 0.8, 0.0625
79811, 1.9291666666667, 0.8, 0.083333333333333
79812, 1.95, 0.775, 0.083333333333333
79813, 1.95, 0.75, 0.0625
79814, 1.9291666666667, 0.75, 0.083333333333333
79815, 1.95, 0.725, 0.083333333333333
79816, 1.95, 0.7, 0.0625
79817, 1.9291666666667, 0.7, 0.083333333333333
79818, 1.95, 0.675, 0.083333333333333
79819, 1.95, 0.65, 0.0625
79820, 1.9291666666667, 0.65, 0.083333333333333
79821, 1.95, 0.625, 0.083333333333333
79822, 1.95, 0.6, 0.0625
79823, 1.9291666666667, 0.6, 0.083333333333333
79824, 1.95, 0.575, 0.083333333333333
79825, 1.95, 0.55, 0.0625
79826, 1.9291666666667, 0.55, 0.083333333333333
79827, 1.95, 0.525, 0.083333333333333
79828, 1.95, 0.5, 0.0625
79829, 1.9291666666667, 0.5, 0.083333333333333
79830, 1.95, 0.475, 0.083333333333333
79831, 1.95, 0.45, 0.0625
79832, 1.9291666666667, 0.45, 0.083333333333333
79833, 1.95, 0.425, 0.083333333333333
79834, 1.95, 0.4, 0.0625
79835, 1.9291666666667, 0.4, 0.083333333333333
79836, 1.95, 0.375, 0.083333333333333
79837, 1.95, 0.35, 0.0625
79838, 1.9291666666667, 0.35, 0.083333333333333
79839, 1.95, 0.325, 0.083333333333333
79840, 1.95, 0.3, 0.0625
79841, 1.9291666666667, 0.3, 0.083333333333333
79842, 1.95, 0.275, 0.083333333333333
79843, 1.95, 0.25, 0.0625
79844, 1.9291666666667, 0.25, 0.083333333333333
79845, 1.95, 0.225, 0.083333333333333
79846, 1.95, 0.2, 0.0625
79847, 1.9291666666667, 0.2, 0.083333333333333
79848, 1.95, 0.175, 0.083333333333333
79849, 1.9916666666667, 1.325, 0.083333333333333
79850, 1.9916666666667, 1.3, 0.0625
79851, 1.9708333333333, 1.3, 0.083333333333333
79852, 1.9916666666667, 1.275, 0.083333333333333
79853, 1.9916666666667, 1.25, 0.0625
79854, 1.9708333333333, 1.25, 0.083333333333333
79855, 1.9916666666667, 1.225, 0.083333333333333
79856, 1.9916666666667, 1.2, 0.0625
79857, 1.9708333333333, 1.2, 0.083333333333333
79858, 1.9916666666667, 1.175, 0.083333333333333
79859, 1.9916666666667, 1.15, 0.0625
79860, 1.9708333333333, 1.15, 0.083333333333333
79861, 1.9916666666667, 1.125, 0.083333333333333
79862, 1.9916666666667, 1.1, 0.0625
79863, 1.9708333333333, 1.1, 0.083333333333333
79864, 1.9916666666667, 1.075, 0.083333333333333
79865, 1.9916666666667, 1.05, 0.0625
79866, 1.9708333333333, 1.05, 0.083333333333333
79867, 1.9916666666667, 1.025, 0.083333333333333
79868, 1.9916666666667, 1, 0.0625
79869, 1.9708333333333, 1, 0.083333333333333
79870, 1.9916666666667, 0.975, 0.083333333333333
79871, 1.9916666666667, 0.95, 0.0625
79872, 1.9708333333333, 0.95, 0.083333333333333
79873, 1.9916666666667, 0.925, 0.083333333333333
79874, 1.9916666666667, 0.9, 0.0625
79875, 1.9708333333333, 0.9, 0.083333333333333
79876, 1.9916666666667, 0.875, 0.083333333333333
79877, 1.9916666666667, 0.85, 0.0625
79878, 1.9708333333333, 0.85, 0.083333333333333
79879, 1.9916666666667, 0.825, 0.083333333333333
79880, 1.9916666666667, 0.8, 0.0625
79881, 1.9708333333333, 0.8, 0.083333333333333
79882, 1.9916666666667, 0.775, 0.083333333333333
79883, 1.9916666666667, 0.75, 0.0625
79884, 1.9708333333333, 0.75, 0.083333333333333
79885, 1.9916666666667, 0.725, 0.083333333333333
79886, 1.9916666666667, 0.7, 0.0625
79887, 1.9708333333333, 0.7, 0.083333333333333
79888, 1.9916666666667, 0.675, 0.083333333333333
79889, 1.9916666666667, 0.65, 0.0625
79890, 1.9708333333333, 0.65, 0.083333333333333
79891, 1.9916666666667, 0.625, 0.083333333333333
79892, 1.9916666666667, 0.6, 0.0625
79893, 1.9708333333333, 0.6, 0.083333333333333
79894, 1.9916666666667, 0.575, 0.083333333333333
79895, 1.9916666666667, 0.55, 0.0625
79896, 1.9708333333333, 0.55, 0.083333333333333
79897, 1.9916666666667, 0.525, 0.083333333333333
79898, 1.9916666666667, 0.5, 0.0625
79899, 1.9708333333333, 0.5, 0.083333333333333
79900, 1.9916666666667, 0.475, 0.083333333333333
79901, 1.9916666666667, 0.45, 0.0625
79902, 1.9708333333333, 0.45, 0.083333333333333
79903, 1.9916666666667, 0.425, 0.083333333333333
79904, 1.9916666666667, 0.4, 0.0625
79905, 1.9708333333333, 0.4, 0.083333333333333
79906, 1.9916666666667, 0.375, 0.083333333333333
79907, 1.9916666666667, 0.35, 0.0625
79908, 1.9708333333333, 0.35, 0.083333333333333
79909, 1.9916666666667, 0.325, 0.083333333333333
79910, 1.9916666666667, 0.3, 0.0625
79911, 1.9708333333333, 0.3, 0.083333333333333
79912, 1.9916666666667, 0.275, 0.083333333333333
