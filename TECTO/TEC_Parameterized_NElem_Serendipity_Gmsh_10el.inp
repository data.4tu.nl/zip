92441, 1.7, 1.025, 0.41666666666667
92442, 1.7, 1, 0.39583333333333
92443, 1.6791666666667, 1, 0.41666666666667
92444, 1.7, 0.975, 0.41666666666667
92445, 1.7, 0.95, 0.39583333333333
92446, 1.6791666666667, 0.95, 0.41666666666667
92447, 1.7, 0.925, 0.41666666666667
92448, 1.7, 0.9, 0.39583333333333
92449, 1.6791666666667, 0.9, 0.41666666666667
92450, 1.7, 0.875, 0.41666666666667
92451, 1.7, 0.85, 0.39583333333333
92452, 1.6791666666667, 0.85, 0.41666666666667
92453, 1.7, 0.825, 0.41666666666667
92454, 1.7, 0.8, 0.39583333333333
92455, 1.6791666666667, 0.8, 0.41666666666667
92456, 1.7, 0.775, 0.41666666666667
92457, 1.7, 0.75, 0.39583333333333
92458, 1.6791666666667, 0.75, 0.41666666666667
92459, 1.7, 0.725, 0.41666666666667
92460, 1.7, 0.7, 0.39583333333333
92461, 1.6791666666667, 0.7, 0.41666666666667
92462, 1.7, 0.675, 0.41666666666667
92463, 1.7, 0.65, 0.39583333333333
92464, 1.6791666666667, 0.65, 0.41666666666667
92465, 1.7, 0.625, 0.41666666666667
92466, 1.7, 0.6, 0.39583333333333
92467, 1.6791666666667, 0.6, 0.41666666666667
92468, 1.7, 0.575, 0.41666666666667
92469, 1.7, 0.55, 0.39583333333333
92470, 1.6791666666667, 0.55, 0.41666666666667
92471, 1.7, 0.525, 0.41666666666667
92472, 1.7, 0.5, 0.39583333333333
92473, 1.6791666666667, 0.5, 0.41666666666667
92474, 1.7, 0.475, 0.41666666666667
92475, 1.7, 0.45, 0.39583333333333
92476, 1.6791666666667, 0.45, 0.41666666666667
92477, 1.7, 0.425, 0.41666666666667
92478, 1.7, 0.4, 0.39583333333333
92479, 1.6791666666667, 0.4, 0.41666666666667
92480, 1.7, 0.375, 0.41666666666667
92481, 1.7, 0.35, 0.39583333333333
92482, 1.6791666666667, 0.35, 0.41666666666667
92483, 1.7, 0.325, 0.41666666666667
92484, 1.7, 0.3, 0.39583333333333
92485, 1.6791666666667, 0.3, 0.41666666666667
92486, 1.7, 0.275, 0.41666666666667
92487, 1.7, 0.25, 0.39583333333333
92488, 1.6791666666667, 0.25, 0.41666666666667
92489, 1.7, 0.225, 0.41666666666667
92490, 1.7, 0.2, 0.39583333333333
92491, 1.6791666666667, 0.2, 0.41666666666667
92492, 1.7, 0.175, 0.41666666666667
92493, 1.7416666666667, 1.325, 0.41666666666667
92494, 1.7416666666667, 1.3, 0.39583333333333
92495, 1.7208333333333, 1.3, 0.41666666666667
92496, 1.7416666666667, 1.275, 0.41666666666667
92497, 1.7416666666667, 1.25, 0.39583333333333
92498, 1.7208333333333, 1.25, 0.41666666666667
92499, 1.7416666666667, 1.225, 0.41666666666667
92500, 1.7416666666667, 1.2, 0.39583333333333
92501, 1.7208333333333, 1.2, 0.41666666666667
92502, 1.7416666666667, 1.175, 0.41666666666667
92503, 1.7416666666667, 1.15, 0.39583333333333
92504, 1.7208333333333, 1.15, 0.41666666666667
92505, 1.7416666666667, 1.125, 0.41666666666667
92506, 1.7416666666667, 1.1, 0.39583333333333
92507, 1.7208333333333, 1.1, 0.41666666666667
92508, 1.7416666666667, 1.075, 0.41666666666667
92509, 1.7416666666667, 1.05, 0.39583333333333
92510, 1.7208333333333, 1.05, 0.41666666666667
92511, 1.7416666666667, 1.025, 0.41666666666667
92512, 1.7416666666667, 1, 0.39583333333333
92513, 1.7208333333333, 1, 0.41666666666667
92514, 1.7416666666667, 0.975, 0.41666666666667
92515, 1.7416666666667, 0.95, 0.39583333333333
92516, 1.7208333333333, 0.95, 0.41666666666667
92517, 1.7416666666667, 0.925, 0.41666666666667
92518, 1.7416666666667, 0.9, 0.39583333333333
92519, 1.7208333333333, 0.9, 0.41666666666667
92520, 1.7416666666667, 0.875, 0.41666666666667
92521, 1.7416666666667, 0.85, 0.39583333333333
92522, 1.7208333333333, 0.85, 0.41666666666667
92523, 1.7416666666667, 0.825, 0.41666666666667
92524, 1.7416666666667, 0.8, 0.39583333333333
92525, 1.7208333333333, 0.8, 0.41666666666667
92526, 1.7416666666667, 0.775, 0.41666666666667
92527, 1.7416666666667, 0.75, 0.39583333333333
92528, 1.7208333333333, 0.75, 0.41666666666667
92529, 1.7416666666667, 0.725, 0.41666666666667
92530, 1.7416666666667, 0.7, 0.39583333333333
92531, 1.7208333333333, 0.7, 0.41666666666667
92532, 1.7416666666667, 0.675, 0.41666666666667
92533, 1.7416666666667, 0.65, 0.39583333333333
92534, 1.7208333333333, 0.65, 0.41666666666667
92535, 1.7416666666667, 0.625, 0.41666666666667
92536, 1.7416666666667, 0.6, 0.39583333333333
92537, 1.7208333333333, 0.6, 0.41666666666667
92538, 1.7416666666667, 0.575, 0.41666666666667
92539, 1.7416666666667, 0.55, 0.39583333333333
92540, 1.7208333333333, 0.55, 0.41666666666667
92541, 1.7416666666667, 0.525, 0.41666666666667
92542, 1.7416666666667, 0.5, 0.39583333333333
92543, 1.7208333333333, 0.5, 0.41666666666667
92544, 1.7416666666667, 0.475, 0.41666666666667
92545, 1.7416666666667, 0.45, 0.39583333333333
92546, 1.7208333333333, 0.45, 0.41666666666667
92547, 1.7416666666667, 0.425, 0.41666666666667
92548, 1.7416666666667, 0.4, 0.39583333333333
92549, 1.7208333333333, 0.4, 0.41666666666667
92550, 1.7416666666667, 0.375, 0.41666666666667
92551, 1.7416666666667, 0.35, 0.39583333333333
92552, 1.7208333333333, 0.35, 0.41666666666667
92553, 1.7416666666667, 0.325, 0.41666666666667
92554, 1.7416666666667, 0.3, 0.39583333333333
92555, 1.7208333333333, 0.3, 0.41666666666667
92556, 1.7416666666667, 0.275, 0.41666666666667
92557, 1.7416666666667, 0.25, 0.39583333333333
92558, 1.7208333333333, 0.25, 0.41666666666667
92559, 1.7416666666667, 0.225, 0.41666666666667
92560, 1.7416666666667, 0.2, 0.39583333333333
92561, 1.7208333333333, 0.2, 0.41666666666667
92562, 1.7416666666667, 0.175, 0.41666666666667
92563, 1.7833333333333, 1.325, 0.41666666666667
92564, 1.7833333333333, 1.3, 0.39583333333333
92565, 1.7625, 1.3, 0.41666666666667
92566, 1.7833333333333, 1.275, 0.41666666666667
92567, 1.7833333333333, 1.25, 0.39583333333333
92568, 1.7625, 1.25, 0.41666666666667
92569, 1.7833333333333, 1.225, 0.41666666666667
92570, 1.7833333333333, 1.2, 0.39583333333333
92571, 1.7625, 1.2, 0.41666666666667
92572, 1.7833333333333, 1.175, 0.41666666666667
92573, 1.7833333333333, 1.15, 0.39583333333333
92574, 1.7625, 1.15, 0.41666666666667
92575, 1.7833333333333, 1.125, 0.41666666666667
92576, 1.7833333333333, 1.1, 0.39583333333333
92577, 1.7625, 1.1, 0.41666666666667
92578, 1.7833333333333, 1.075, 0.41666666666667
92579, 1.7833333333333, 1.05, 0.39583333333333
92580, 1.7625, 1.05, 0.41666666666667
92581, 1.7833333333333, 1.025, 0.41666666666667
92582, 1.7833333333333, 1, 0.39583333333333
92583, 1.7625, 1, 0.41666666666667
92584, 1.7833333333333, 0.975, 0.41666666666667
92585, 1.7833333333333, 0.95, 0.39583333333333
92586, 1.7625, 0.95, 0.41666666666667
92587, 1.7833333333333, 0.925, 0.41666666666667
92588, 1.7833333333333, 0.9, 0.39583333333333
92589, 1.7625, 0.9, 0.41666666666667
92590, 1.7833333333333, 0.875, 0.41666666666667
92591, 1.7833333333333, 0.85, 0.39583333333333
92592, 1.7625, 0.85, 0.41666666666667
92593, 1.7833333333333, 0.825, 0.41666666666667
92594, 1.7833333333333, 0.8, 0.39583333333333
92595, 1.7625, 0.8, 0.41666666666667
92596, 1.7833333333333, 0.775, 0.41666666666667
92597, 1.7833333333333, 0.75, 0.39583333333333
92598, 1.7625, 0.75, 0.41666666666667
92599, 1.7833333333333, 0.725, 0.41666666666667
92600, 1.7833333333333, 0.7, 0.39583333333333
92601, 1.7625, 0.7, 0.41666666666667
92602, 1.7833333333333, 0.675, 0.41666666666667
92603, 1.7833333333333, 0.65, 0.39583333333333
92604, 1.7625, 0.65, 0.41666666666667
92605, 1.7833333333333, 0.625, 0.41666666666667
92606, 1.7833333333333, 0.6, 0.39583333333333
92607, 1.7625, 0.6, 0.41666666666667
92608, 1.7833333333333, 0.575, 0.41666666666667
92609, 1.7833333333333, 0.55, 0.39583333333333
92610, 1.7625, 0.55, 0.41666666666667
92611, 1.7833333333333, 0.525, 0.41666666666667
92612, 1.7833333333333, 0.5, 0.39583333333333
92613, 1.7625, 0.5, 0.41666666666667
92614, 1.7833333333333, 0.475, 0.41666666666667
92615, 1.7833333333333, 0.45, 0.39583333333333
92616, 1.7625, 0.45, 0.41666666666667
92617, 1.7833333333333, 0.425, 0.41666666666667
92618, 1.7833333333333, 0.4, 0.39583333333333
92619, 1.7625, 0.4, 0.41666666666667
92620, 1.7833333333333, 0.375, 0.41666666666667
92621, 1.7833333333333, 0.35, 0.39583333333333
92622, 1.7625, 0.35, 0.41666666666667
92623, 1.7833333333333, 0.325, 0.41666666666667
92624, 1.7833333333333, 0.3, 0.39583333333333
92625, 1.7625, 0.3, 0.41666666666667
92626, 1.7833333333333, 0.275, 0.41666666666667
92627, 1.7833333333333, 0.25, 0.39583333333333
92628, 1.7625, 0.25, 0.41666666666667
92629, 1.7833333333333, 0.225, 0.41666666666667
92630, 1.7833333333333, 0.2, 0.39583333333333
92631, 1.7625, 0.2, 0.41666666666667
92632, 1.7833333333333, 0.175, 0.41666666666667
92633, 1.825, 1.325, 0.41666666666667
92634, 1.825, 1.3, 0.39583333333333
92635, 1.8041666666667, 1.3, 0.41666666666667
92636, 1.825, 1.275, 0.41666666666667
92637, 1.825, 1.25, 0.39583333333333
92638, 1.8041666666667, 1.25, 0.41666666666667
92639, 1.825, 1.225, 0.41666666666667
92640, 1.825, 1.2, 0.39583333333333
92641, 1.8041666666667, 1.2, 0.41666666666667
92642, 1.825, 1.175, 0.41666666666667
92643, 1.825, 1.15, 0.39583333333333
92644, 1.8041666666667, 1.15, 0.41666666666667
92645, 1.825, 1.125, 0.41666666666667
92646, 1.825, 1.1, 0.39583333333333
92647, 1.8041666666667, 1.1, 0.41666666666667
92648, 1.825, 1.075, 0.41666666666667
92649, 1.825, 1.05, 0.39583333333333
92650, 1.8041666666667, 1.05, 0.41666666666667
92651, 1.825, 1.025, 0.41666666666667
92652, 1.825, 1, 0.39583333333333
92653, 1.8041666666667, 1, 0.41666666666667
92654, 1.825, 0.975, 0.41666666666667
92655, 1.825, 0.95, 0.39583333333333
92656, 1.8041666666667, 0.95, 0.41666666666667
92657, 1.825, 0.925, 0.41666666666667
92658, 1.825, 0.9, 0.39583333333333
92659, 1.8041666666667, 0.9, 0.41666666666667
92660, 1.825, 0.875, 0.41666666666667
92661, 1.825, 0.85, 0.39583333333333
92662, 1.8041666666667, 0.85, 0.41666666666667
92663, 1.825, 0.825, 0.41666666666667
92664, 1.825, 0.8, 0.39583333333333
92665, 1.8041666666667, 0.8, 0.41666666666667
92666, 1.825, 0.775, 0.41666666666667
92667, 1.825, 0.75, 0.39583333333333
92668, 1.8041666666667, 0.75, 0.41666666666667
92669, 1.825, 0.725, 0.41666666666667
92670, 1.825, 0.7, 0.39583333333333
92671, 1.8041666666667, 0.7, 0.41666666666667
92672, 1.825, 0.675, 0.41666666666667
92673, 1.825, 0.65, 0.39583333333333
92674, 1.8041666666667, 0.65, 0.41666666666667
92675, 1.825, 0.625, 0.41666666666667
92676, 1.825, 0.6, 0.39583333333333
92677, 1.8041666666667, 0.6, 0.41666666666667
92678, 1.825, 0.575, 0.41666666666667
92679, 1.825, 0.55, 0.39583333333333
92680, 1.8041666666667, 0.55, 0.41666666666667
92681, 1.825, 0.525, 0.41666666666667
92682, 1.825, 0.5, 0.39583333333333
92683, 1.8041666666667, 0.5, 0.41666666666667
92684, 1.825, 0.475, 0.41666666666667
92685, 1.825, 0.45, 0.39583333333333
92686, 1.8041666666667, 0.45, 0.41666666666667
92687, 1.825, 0.425, 0.41666666666667
92688, 1.825, 0.4, 0.39583333333333
92689, 1.8041666666667, 0.4, 0.41666666666667
92690, 1.825, 0.375, 0.41666666666667
92691, 1.825, 0.35, 0.39583333333333
92692, 1.8041666666667, 0.35, 0.41666666666667
92693, 1.825, 0.325, 0.41666666666667
92694, 1.825, 0.3, 0.39583333333333
92695, 1.8041666666667, 0.3, 0.41666666666667
92696, 1.825, 0.275, 0.41666666666667
92697, 1.825, 0.25, 0.39583333333333
92698, 1.8041666666667, 0.25, 0.41666666666667
92699, 1.825, 0.225, 0.41666666666667
92700, 1.825, 0.2, 0.39583333333333
92701, 1.8041666666667, 0.2, 0.41666666666667
92702, 1.825, 0.175, 0.41666666666667
92703, 1.8666666666667, 1.325, 0.41666666666667
92704, 1.8666666666667, 1.3, 0.39583333333333
92705, 1.8458333333333, 1.3, 0.41666666666667
92706, 1.8666666666667, 1.275, 0.41666666666667
92707, 1.8666666666667, 1.25, 0.39583333333333
92708, 1.8458333333333, 1.25, 0.41666666666667
92709, 1.8666666666667, 1.225, 0.41666666666667
92710, 1.8666666666667, 1.2, 0.39583333333333
92711, 1.8458333333333, 1.2, 0.41666666666667
92712, 1.8666666666667, 1.175, 0.41666666666667
92713, 1.8666666666667, 1.15, 0.39583333333333
92714, 1.8458333333333, 1.15, 0.41666666666667
92715, 1.8666666666667, 1.125, 0.41666666666667
92716, 1.8666666666667, 1.1, 0.39583333333333
92717, 1.8458333333333, 1.1, 0.41666666666667
92718, 1.8666666666667, 1.075, 0.41666666666667
92719, 1.8666666666667, 1.05, 0.39583333333333
92720, 1.8458333333333, 1.05, 0.41666666666667
92721, 1.8666666666667, 1.025, 0.41666666666667
92722, 1.8666666666667, 1, 0.39583333333333
92723, 1.8458333333333, 1, 0.41666666666667
92724, 1.8666666666667, 0.975, 0.41666666666667
92725, 1.8666666666667, 0.95, 0.39583333333333
92726, 1.8458333333333, 0.95, 0.41666666666667
92727, 1.8666666666667, 0.925, 0.41666666666667
92728, 1.8666666666667, 0.9, 0.39583333333333
92729, 1.8458333333333, 0.9, 0.41666666666667
92730, 1.8666666666667, 0.875, 0.41666666666667
92731, 1.8666666666667, 0.85, 0.39583333333333
92732, 1.8458333333333, 0.85, 0.41666666666667
92733, 1.8666666666667, 0.825, 0.41666666666667
92734, 1.8666666666667, 0.8, 0.39583333333333
92735, 1.8458333333333, 0.8, 0.41666666666667
92736, 1.8666666666667, 0.775, 0.41666666666667
92737, 1.8666666666667, 0.75, 0.39583333333333
92738, 1.8458333333333, 0.75, 0.41666666666667
92739, 1.8666666666667, 0.725, 0.41666666666667
92740, 1.8666666666667, 0.7, 0.39583333333333
92741, 1.8458333333333, 0.7, 0.41666666666667
92742, 1.8666666666667, 0.675, 0.41666666666667
92743, 1.8666666666667, 0.65, 0.39583333333333
92744, 1.8458333333333, 0.65, 0.41666666666667
92745, 1.8666666666667, 0.625, 0.41666666666667
92746, 1.8666666666667, 0.6, 0.39583333333333
92747, 1.8458333333333, 0.6, 0.41666666666667
92748, 1.8666666666667, 0.575, 0.41666666666667
92749, 1.8666666666667, 0.55, 0.39583333333333
92750, 1.8458333333333, 0.55, 0.41666666666667
92751, 1.8666666666667, 0.525, 0.41666666666667
92752, 1.8666666666667, 0.5, 0.39583333333333
92753, 1.8458333333333, 0.5, 0.41666666666667
92754, 1.8666666666667, 0.475, 0.41666666666667
92755, 1.8666666666667, 0.45, 0.39583333333333
92756, 1.8458333333333, 0.45, 0.41666666666667
92757, 1.8666666666667, 0.425, 0.41666666666667
92758, 1.8666666666667, 0.4, 0.39583333333333
92759, 1.8458333333333, 0.4, 0.41666666666667
92760, 1.8666666666667, 0.375, 0.41666666666667
92761, 1.8666666666667, 0.35, 0.39583333333333
92762, 1.8458333333333, 0.35, 0.41666666666667
92763, 1.8666666666667, 0.325, 0.41666666666667
92764, 1.8666666666667, 0.3, 0.39583333333333
92765, 1.8458333333333, 0.3, 0.41666666666667
92766, 1.8666666666667, 0.275, 0.41666666666667
92767, 1.8666666666667, 0.25, 0.39583333333333
92768, 1.8458333333333, 0.25, 0.41666666666667
92769, 1.8666666666667, 0.225, 0.41666666666667
92770, 1.8666666666667, 0.2, 0.39583333333333
92771, 1.8458333333333, 0.2, 0.41666666666667
92772, 1.8666666666667, 0.175, 0.41666666666667
92773, 1.9083333333333, 1.325, 0.41666666666667
92774, 1.9083333333333, 1.3, 0.39583333333333
92775, 1.8875, 1.3, 0.41666666666667
92776, 1.9083333333333, 1.275, 0.41666666666667
92777, 1.9083333333333, 1.25, 0.39583333333333
92778, 1.8875, 1.25, 0.41666666666667
92779, 1.9083333333333, 1.225, 0.41666666666667
92780, 1.9083333333333, 1.2, 0.39583333333333
92781, 1.8875, 1.2, 0.41666666666667
92782, 1.9083333333333, 1.175, 0.41666666666667
92783, 1.9083333333333, 1.15, 0.39583333333333
92784, 1.8875, 1.15, 0.41666666666667
92785, 1.9083333333333, 1.125, 0.41666666666667
92786, 1.9083333333333, 1.1, 0.39583333333333
92787, 1.8875, 1.1, 0.41666666666667
92788, 1.9083333333333, 1.075, 0.41666666666667
92789, 1.9083333333333, 1.05, 0.39583333333333
92790, 1.8875, 1.05, 0.41666666666667
92791, 1.9083333333333, 1.025, 0.41666666666667
92792, 1.9083333333333, 1, 0.39583333333333
92793, 1.8875, 1, 0.41666666666667
92794, 1.9083333333333, 0.975, 0.41666666666667
92795, 1.9083333333333, 0.95, 0.39583333333333
92796, 1.8875, 0.95, 0.41666666666667
92797, 1.9083333333333, 0.925, 0.41666666666667
92798, 1.9083333333333, 0.9, 0.39583333333333
92799, 1.8875, 0.9, 0.41666666666667
92800, 1.9083333333333, 0.875, 0.41666666666667
92801, 1.9083333333333, 0.85, 0.39583333333333
92802, 1.8875, 0.85, 0.41666666666667
92803, 1.9083333333333, 0.825, 0.41666666666667
92804, 1.9083333333333, 0.8, 0.39583333333333
92805, 1.8875, 0.8, 0.41666666666667
92806, 1.9083333333333, 0.775, 0.41666666666667
92807, 1.9083333333333, 0.75, 0.39583333333333
92808, 1.8875, 0.75, 0.41666666666667
92809, 1.9083333333333, 0.725, 0.41666666666667
92810, 1.9083333333333, 0.7, 0.39583333333333
92811, 1.8875, 0.7, 0.41666666666667
92812, 1.9083333333333, 0.675, 0.41666666666667
92813, 1.9083333333333, 0.65, 0.39583333333333
92814, 1.8875, 0.65, 0.41666666666667
92815, 1.9083333333333, 0.625, 0.41666666666667
92816, 1.9083333333333, 0.6, 0.39583333333333
92817, 1.8875, 0.6, 0.41666666666667
92818, 1.9083333333333, 0.575, 0.41666666666667
92819, 1.9083333333333, 0.55, 0.39583333333333
92820, 1.8875, 0.55, 0.41666666666667
92821, 1.9083333333333, 0.525, 0.41666666666667
92822, 1.9083333333333, 0.5, 0.39583333333333
92823, 1.8875, 0.5, 0.41666666666667
92824, 1.9083333333333, 0.475, 0.41666666666667
92825, 1.9083333333333, 0.45, 0.39583333333333
92826, 1.8875, 0.45, 0.41666666666667
92827, 1.9083333333333, 0.425, 0.41666666666667
92828, 1.9083333333333, 0.4, 0.39583333333333
92829, 1.8875, 0.4, 0.41666666666667
92830, 1.9083333333333, 0.375, 0.41666666666667
92831, 1.9083333333333, 0.35, 0.39583333333333
92832, 1.8875, 0.35, 0.41666666666667
92833, 1.9083333333333, 0.325, 0.41666666666667
92834, 1.9083333333333, 0.3, 0.39583333333333
92835, 1.8875, 0.3, 0.41666666666667
92836, 1.9083333333333, 0.275, 0.41666666666667
92837, 1.9083333333333, 0.25, 0.39583333333333
92838, 1.8875, 0.25, 0.41666666666667
92839, 1.9083333333333, 0.225, 0.41666666666667
92840, 1.9083333333333, 0.2, 0.39583333333333
92841, 1.8875, 0.2, 0.41666666666667
92842, 1.9083333333333, 0.175, 0.41666666666667
92843, 1.95, 1.325, 0.41666666666667
92844, 1.95, 1.3, 0.39583333333333
92845, 1.9291666666667, 1.3, 0.41666666666667
92846, 1.95, 1.275, 0.41666666666667
92847, 1.95, 1.25, 0.39583333333333
92848, 1.9291666666667, 1.25, 0.41666666666667
92849, 1.95, 1.225, 0.41666666666667
92850, 1.95, 1.2, 0.39583333333333
92851, 1.9291666666667, 1.2, 0.41666666666667
92852, 1.95, 1.175, 0.41666666666667
92853, 1.95, 1.15, 0.39583333333333
92854, 1.9291666666667, 1.15, 0.41666666666667
92855, 1.95, 1.125, 0.41666666666667
92856, 1.95, 1.1, 0.39583333333333
92857, 1.9291666666667, 1.1, 0.41666666666667
92858, 1.95, 1.075, 0.41666666666667
92859, 1.95, 1.05, 0.39583333333333
92860, 1.9291666666667, 1.05, 0.41666666666667
92861, 1.95, 1.025, 0.41666666666667
92862, 1.95, 1, 0.39583333333333
92863, 1.9291666666667, 1, 0.41666666666667
92864, 1.95, 0.975, 0.41666666666667
92865, 1.95, 0.95, 0.39583333333333
92866, 1.9291666666667, 0.95, 0.41666666666667
92867, 1.95, 0.925, 0.41666666666667
92868, 1.95, 0.9, 0.39583333333333
92869, 1.9291666666667, 0.9, 0.41666666666667
92870, 1.95, 0.875, 0.41666666666667
92871, 1.95, 0.85, 0.39583333333333
92872, 1.9291666666667, 0.85, 0.41666666666667
92873, 1.95, 0.825, 0.41666666666667
92874, 1.95, 0.8, 0.39583333333333
92875, 1.9291666666667, 0.8, 0.41666666666667
92876, 1.95, 0.775, 0.41666666666667
92877, 1.95, 0.75, 0.39583333333333
92878, 1.9291666666667, 0.75, 0.41666666666667
92879, 1.95, 0.725, 0.41666666666667
92880, 1.95, 0.7, 0.39583333333333
92881, 1.9291666666667, 0.7, 0.41666666666667
92882, 1.95, 0.675, 0.41666666666667
92883, 1.95, 0.65, 0.39583333333333
92884, 1.9291666666667, 0.65, 0.41666666666667
92885, 1.95, 0.625, 0.41666666666667
92886, 1.95, 0.6, 0.39583333333333
92887, 1.9291666666667, 0.6, 0.41666666666667
92888, 1.95, 0.575, 0.41666666666667
92889, 1.95, 0.55, 0.39583333333333
92890, 1.9291666666667, 0.55, 0.41666666666667
92891, 1.95, 0.525, 0.41666666666667
92892, 1.95, 0.5, 0.39583333333333
92893, 1.9291666666667, 0.5, 0.41666666666667
92894, 1.95, 0.475, 0.41666666666667
92895, 1.95, 0.45, 0.39583333333333
92896, 1.9291666666667, 0.45, 0.41666666666667
92897, 1.95, 0.425, 0.41666666666667
92898, 1.95, 0.4, 0.39583333333333
92899, 1.9291666666667, 0.4, 0.41666666666667
92900, 1.95, 0.375, 0.41666666666667
92901, 1.95, 0.35, 0.39583333333333
92902, 1.9291666666667, 0.35, 0.41666666666667
92903, 1.95, 0.325, 0.41666666666667
92904, 1.95, 0.3, 0.39583333333333
92905, 1.9291666666667, 0.3, 0.41666666666667
92906, 1.95, 0.275, 0.41666666666667
92907, 1.95, 0.25, 0.39583333333333
92908, 1.9291666666667, 0.25, 0.41666666666667
92909, 1.95, 0.225, 0.41666666666667
92910, 1.95, 0.2, 0.39583333333333
92911, 1.9291666666667, 0.2, 0.41666666666667
92912, 1.95, 0.175, 0.41666666666667
92913, 1.9916666666667, 1.325, 0.41666666666667
92914, 1.9916666666667, 1.3, 0.39583333333333
92915, 1.9708333333333, 1.3, 0.41666666666667
92916, 1.9916666666667, 1.275, 0.41666666666667
92917, 1.9916666666667, 1.25, 0.39583333333333
92918, 1.9708333333333, 1.25, 0.41666666666667
92919, 1.9916666666667, 1.225, 0.41666666666667
92920, 1.9916666666667, 1.2, 0.39583333333333
92921, 1.9708333333333, 1.2, 0.41666666666667
92922, 1.9916666666667, 1.175, 0.41666666666667
92923, 1.9916666666667, 1.15, 0.39583333333333
92924, 1.9708333333333, 1.15, 0.41666666666667
92925, 1.9916666666667, 1.125, 0.41666666666667
92926, 1.9916666666667, 1.1, 0.39583333333333
92927, 1.9708333333333, 1.1, 0.41666666666667
92928, 1.9916666666667, 1.075, 0.41666666666667
92929, 1.9916666666667, 1.05, 0.39583333333333
92930, 1.9708333333333, 1.05, 0.41666666666667
92931, 1.9916666666667, 1.025, 0.41666666666667
92932, 1.9916666666667, 1, 0.39583333333333
92933, 1.9708333333333, 1, 0.41666666666667
92934, 1.9916666666667, 0.975, 0.41666666666667
92935, 1.9916666666667, 0.95, 0.39583333333333
92936, 1.9708333333333, 0.95, 0.41666666666667
92937, 1.9916666666667, 0.925, 0.41666666666667
92938, 1.9916666666667, 0.9, 0.39583333333333
92939, 1.9708333333333, 0.9, 0.41666666666667
92940, 1.9916666666667, 0.875, 0.41666666666667
92941, 1.9916666666667, 0.85, 0.39583333333333
92942, 1.9708333333333, 0.85, 0.41666666666667
92943, 1.9916666666667, 0.825, 0.41666666666667
92944, 1.9916666666667, 0.8, 0.39583333333333
92945, 1.9708333333333, 0.8, 0.41666666666667
92946, 1.9916666666667, 0.775, 0.41666666666667
92947, 1.9916666666667, 0.75, 0.39583333333333
92948, 1.9708333333333, 0.75, 0.41666666666667
92949, 1.9916666666667, 0.725, 0.41666666666667
92950, 1.9916666666667, 0.7, 0.39583333333333
92951, 1.9708333333333, 0.7, 0.41666666666667
92952, 1.9916666666667, 0.675, 0.41666666666667
92953, 1.9916666666667, 0.65, 0.39583333333333
92954, 1.9708333333333, 0.65, 0.41666666666667
92955, 1.9916666666667, 0.625, 0.41666666666667
92956, 1.9916666666667, 0.6, 0.39583333333333
92957, 1.9708333333333, 0.6, 0.41666666666667
92958, 1.9916666666667, 0.575, 0.41666666666667
92959, 1.9916666666667, 0.55, 0.39583333333333
92960, 1.9708333333333, 0.55, 0.41666666666667
92961, 1.9916666666667, 0.525, 0.41666666666667
92962, 1.9916666666667, 0.5, 0.39583333333333
92963, 1.9708333333333, 0.5, 0.41666666666667
92964, 1.9916666666667, 0.475, 0.41666666666667
92965, 1.9916666666667, 0.45, 0.39583333333333
92966, 1.9708333333333, 0.45, 0.41666666666667
92967, 1.9916666666667, 0.425, 0.41666666666667
92968, 1.9916666666667, 0.4, 0.39583333333333
92969, 1.9708333333333, 0.4, 0.41666666666667
92970, 1.9916666666667, 0.375, 0.41666666666667
92971, 1.9916666666667, 0.35, 0.39583333333333
92972, 1.9708333333333, 0.35, 0.41666666666667
92973, 1.9916666666667, 0.325, 0.41666666666667
92974, 1.9916666666667, 0.3, 0.39583333333333
92975, 1.9708333333333, 0.3, 0.41666666666667
92976, 1.9916666666667, 0.275, 0.41666666666667
92977, 1.9916666666667, 0.25, 0.39583333333333
92978, 1.9708333333333, 0.25, 0.41666666666667
92979, 1.9916666666667, 0.225, 0.41666666666667
92980, 1.9916666666667, 0.2, 0.39583333333333
92981, 1.9708333333333, 0.2, 0.41666666666667
92982, 1.9916666666667, 0.175, 0.41666666666667
92983, 2.0333333333333, 1.325, 0.41666666666667
92984, 2.0333333333333, 1.3, 0.39583333333333
92985, 2.0125, 1.3, 0.41666666666667
92986, 2.0333333333333, 1.275, 0.41666666666667
92987, 2.0333333333333, 1.25, 0.39583333333333
92988, 2.0125, 1.25, 0.41666666666667
92989, 2.0333333333333, 1.225, 0.41666666666667
92990, 2.0333333333333, 1.2, 0.39583333333333
92991, 2.0125, 1.2, 0.41666666666667
92992, 2.0333333333333, 1.175, 0.41666666666667
92993, 2.0333333333333, 1.15, 0.39583333333333
92994, 2.0125, 1.15, 0.41666666666667
92995, 2.0333333333333, 1.125, 0.41666666666667
92996, 2.0333333333333, 1.1, 0.39583333333333
92997, 2.0125, 1.1, 0.41666666666667
92998, 2.0333333333333, 1.075, 0.41666666666667
92999, 2.0333333333333, 1.05, 0.39583333333333
93000, 2.0125, 1.05, 0.41666666666667
93001, 2.0333333333333, 1.025, 0.41666666666667
93002, 2.0333333333333, 1, 0.39583333333333
93003, 2.0125, 1, 0.41666666666667
93004, 2.0333333333333, 0.975, 0.41666666666667
93005, 2.0333333333333, 0.95, 0.39583333333333
93006, 2.0125, 0.95, 0.41666666666667
93007, 2.0333333333333, 0.925, 0.41666666666667
93008, 2.0333333333333, 0.9, 0.39583333333333
93009, 2.0125, 0.9, 0.41666666666667
93010, 2.0333333333333, 0.875, 0.41666666666667
93011, 2.0333333333333, 0.85, 0.39583333333333
93012, 2.0125, 0.85, 0.41666666666667
93013, 2.0333333333333, 0.825, 0.41666666666667
93014, 2.0333333333333, 0.8, 0.39583333333333
93015, 2.0125, 0.8, 0.41666666666667
93016, 2.0333333333333, 0.775, 0.41666666666667
93017, 2.0333333333333, 0.75, 0.39583333333333
93018, 2.0125, 0.75, 0.41666666666667
93019, 2.0333333333333, 0.725, 0.41666666666667
93020, 2.0333333333333, 0.7, 0.39583333333333
93021, 2.0125, 0.7, 0.41666666666667
93022, 2.0333333333333, 0.675, 0.41666666666667
93023, 2.0333333333333, 0.65, 0.39583333333333
93024, 2.0125, 0.65, 0.41666666666667
93025, 2.0333333333333, 0.625, 0.41666666666667
93026, 2.0333333333333, 0.6, 0.39583333333333
93027, 2.0125, 0.6, 0.41666666666667
93028, 2.0333333333333, 0.575, 0.41666666666667
93029, 2.0333333333333, 0.55, 0.39583333333333
93030, 2.0125, 0.55, 0.41666666666667
93031, 2.0333333333333, 0.525, 0.41666666666667
93032, 2.0333333333333, 0.5, 0.39583333333333
93033, 2.0125, 0.5, 0.41666666666667
93034, 2.0333333333333, 0.475, 0.41666666666667
93035, 2.0333333333333, 0.45, 0.39583333333333
93036, 2.0125, 0.45, 0.41666666666667
93037, 2.0333333333333, 0.425, 0.41666666666667
93038, 2.0333333333333, 0.4, 0.39583333333333
93039, 2.0125, 0.4, 0.41666666666667
93040, 2.0333333333333, 0.375, 0.41666666666667
93041, 2.0333333333333, 0.35, 0.39583333333333
93042, 2.0125, 0.35, 0.41666666666667
93043, 2.0333333333333, 0.325, 0.41666666666667
93044, 2.0333333333333, 0.3, 0.39583333333333
93045, 2.0125, 0.3, 0.41666666666667
93046, 2.0333333333333, 0.275, 0.41666666666667
93047, 2.0333333333333, 0.25, 0.39583333333333
93048, 2.0125, 0.25, 0.41666666666667
93049, 2.0333333333333, 0.225, 0.41666666666667
93050, 2.0333333333333, 0.2, 0.39583333333333
93051, 2.0125, 0.2, 0.41666666666667
93052, 2.0333333333333, 0.175, 0.41666666666667
93053, 2.075, 1.325, 0.41666666666667
93054, 2.075, 1.3, 0.39583333333333
93055, 2.0541666666667, 1.3, 0.41666666666667
93056, 2.075, 1.275, 0.41666666666667
93057, 2.075, 1.25, 0.39583333333333
93058, 2.0541666666667, 1.25, 0.41666666666667
93059, 2.075, 1.225, 0.41666666666667
93060, 2.075, 1.2, 0.39583333333333
93061, 2.0541666666667, 1.2, 0.41666666666667
93062, 2.075, 1.175, 0.41666666666667
93063, 2.075, 1.15, 0.39583333333333
93064, 2.0541666666667, 1.15, 0.41666666666667
93065, 2.075, 1.125, 0.41666666666667
93066, 2.075, 1.1, 0.39583333333333
93067, 2.0541666666667, 1.1, 0.41666666666667
93068, 2.075, 1.075, 0.41666666666667
93069, 2.075, 1.05, 0.39583333333333
93070, 2.0541666666667, 1.05, 0.41666666666667
93071, 2.075, 1.025, 0.41666666666667
93072, 2.075, 1, 0.39583333333333
93073, 2.0541666666667, 1, 0.41666666666667
93074, 2.075, 0.975, 0.41666666666667
93075, 2.075, 0.95, 0.39583333333333
93076, 2.0541666666667, 0.95, 0.41666666666667
93077, 2.075, 0.925, 0.41666666666667
93078, 2.075, 0.9, 0.39583333333333
93079, 2.0541666666667, 0.9, 0.41666666666667
93080, 2.075, 0.875, 0.41666666666667
93081, 2.075, 0.85, 0.39583333333333
93082, 2.0541666666667, 0.85, 0.41666666666667
93083, 2.075, 0.825, 0.41666666666667
93084, 2.075, 0.8, 0.39583333333333
93085, 2.0541666666667, 0.8, 0.41666666666667
93086, 2.075, 0.775, 0.41666666666667
93087, 2.075, 0.75, 0.39583333333333
93088, 2.0541666666667, 0.75, 0.41666666666667
93089, 2.075, 0.725, 0.41666666666667
93090, 2.075, 0.7, 0.39583333333333
93091, 2.0541666666667, 0.7, 0.41666666666667
93092, 2.075, 0.675, 0.41666666666667
93093, 2.075, 0.65, 0.39583333333333
93094, 2.0541666666667, 0.65, 0.41666666666667
93095, 2.075, 0.625, 0.41666666666667
93096, 2.075, 0.6, 0.39583333333333
93097, 2.0541666666667, 0.6, 0.41666666666667
93098, 2.075, 0.575, 0.41666666666667
93099, 2.075, 0.55, 0.39583333333333
93100, 2.0541666666667, 0.55, 0.41666666666667
93101, 2.075, 0.525, 0.41666666666667
93102, 2.075, 0.5, 0.39583333333333
93103, 2.0541666666667, 0.5, 0.41666666666667
93104, 2.075, 0.475, 0.41666666666667
93105, 2.075, 0.45, 0.39583333333333
93106, 2.0541666666667, 0.45, 0.41666666666667
93107, 2.075, 0.425, 0.41666666666667
93108, 2.075, 0.4, 0.39583333333333
93109, 2.0541666666667, 0.4, 0.41666666666667
93110, 2.075, 0.375, 0.41666666666667
93111, 2.075, 0.35, 0.39583333333333
93112, 2.0541666666667, 0.35, 0.41666666666667
93113, 2.075, 0.325, 0.41666666666667
93114, 2.075, 0.3, 0.39583333333333
93115, 2.0541666666667, 0.3, 0.41666666666667
93116, 2.075, 0.275, 0.41666666666667
93117, 2.075, 0.25, 0.39583333333333
93118, 2.0541666666667, 0.25, 0.41666666666667
93119, 2.075, 0.225, 0.41666666666667
93120, 2.075, 0.2, 0.39583333333333
93121, 2.0541666666667, 0.2, 0.41666666666667
93122, 2.075, 0.175, 0.41666666666667
93123, 2.1166666666667, 1.325, 0.41666666666667
93124, 2.1166666666667, 1.3, 0.39583333333333
93125, 2.0958333333333, 1.3, 0.41666666666667
93126, 2.1166666666667, 1.275, 0.41666666666667
93127, 2.1166666666667, 1.25, 0.39583333333333
93128, 2.0958333333333, 1.25, 0.41666666666667
93129, 2.1166666666667, 1.225, 0.41666666666667
93130, 2.1166666666667, 1.2, 0.39583333333333
93131, 2.0958333333333, 1.2, 0.41666666666667
93132, 2.1166666666667, 1.175, 0.41666666666667
93133, 2.1166666666667, 1.15, 0.39583333333333
93134, 2.0958333333333, 1.15, 0.41666666666667
93135, 2.1166666666667, 1.125, 0.41666666666667
93136, 2.1166666666667, 1.1, 0.39583333333333
93137, 2.0958333333333, 1.1, 0.41666666666667
93138, 2.1166666666667, 1.075, 0.41666666666667
93139, 2.1166666666667, 1.05, 0.39583333333333
93140, 2.0958333333333, 1.05, 0.41666666666667
93141, 2.1166666666667, 1.025, 0.41666666666667
93142, 2.1166666666667, 1, 0.39583333333333
93143, 2.0958333333333, 1, 0.41666666666667
93144, 2.1166666666667, 0.975, 0.41666666666667
93145, 2.1166666666667, 0.95, 0.39583333333333
93146, 2.0958333333333, 0.95, 0.41666666666667
93147, 2.1166666666667, 0.925, 0.41666666666667
93148, 2.1166666666667, 0.9, 0.39583333333333
93149, 2.0958333333333, 0.9, 0.41666666666667
93150, 2.1166666666667, 0.875, 0.41666666666667
93151, 2.1166666666667, 0.85, 0.39583333333333
93152, 2.0958333333333, 0.85, 0.41666666666667
93153, 2.1166666666667, 0.825, 0.41666666666667
93154, 2.1166666666667, 0.8, 0.39583333333333
93155, 2.0958333333333, 0.8, 0.41666666666667
93156, 2.1166666666667, 0.775, 0.41666666666667
93157, 2.1166666666667, 0.75, 0.39583333333333
93158, 2.0958333333333, 0.75, 0.41666666666667
93159, 2.1166666666667, 0.725, 0.41666666666667
93160, 2.1166666666667, 0.7, 0.39583333333333
93161, 2.0958333333333, 0.7, 0.41666666666667
93162, 2.1166666666667, 0.675, 0.41666666666667
93163, 2.1166666666667, 0.65, 0.39583333333333
93164, 2.0958333333333, 0.65, 0.41666666666667
93165, 2.1166666666667, 0.625, 0.41666666666667
93166, 2.1166666666667, 0.6, 0.39583333333333
93167, 2.0958333333333, 0.6, 0.41666666666667
93168, 2.1166666666667, 0.575, 0.41666666666667
93169, 2.1166666666667, 0.55, 0.39583333333333
93170, 2.0958333333333, 0.55, 0.41666666666667
93171, 2.1166666666667, 0.525, 0.41666666666667
93172, 2.1166666666667, 0.5, 0.39583333333333
93173, 2.0958333333333, 0.5, 0.41666666666667
93174, 2.1166666666667, 0.475, 0.41666666666667
93175, 2.1166666666667, 0.45, 0.39583333333333
93176, 2.0958333333333, 0.45, 0.41666666666667
93177, 2.1166666666667, 0.425, 0.41666666666667
93178, 2.1166666666667, 0.4, 0.39583333333333
93179, 2.0958333333333, 0.4, 0.41666666666667
93180, 2.1166666666667, 0.375, 0.41666666666667
93181, 2.1166666666667, 0.35, 0.39583333333333
93182, 2.0958333333333, 0.35, 0.41666666666667
93183, 2.1166666666667, 0.325, 0.41666666666667
93184, 2.1166666666667, 0.3, 0.39583333333333
93185, 2.0958333333333, 0.3, 0.41666666666667
93186, 2.1166666666667, 0.275, 0.41666666666667
93187, 2.1166666666667, 0.25, 0.39583333333333
93188, 2.0958333333333, 0.25, 0.41666666666667
93189, 2.1166666666667, 0.225, 0.41666666666667
93190, 2.1166666666667, 0.2, 0.39583333333333
93191, 2.0958333333333, 0.2, 0.41666666666667
93192, 2.1166666666667, 0.175, 0.41666666666667
93193, 2.1583333333333, 1.325, 0.41666666666667
93194, 2.1583333333333, 1.3, 0.39583333333333
93195, 2.1375, 1.3, 0.41666666666667
93196, 2.1583333333333, 1.275, 0.41666666666667
93197, 2.1583333333333, 1.25, 0.39583333333333
93198, 2.1375, 1.25, 0.41666666666667
93199, 2.1583333333333, 1.225, 0.41666666666667
93200, 2.1583333333333, 1.2, 0.39583333333333
93201, 2.1375, 1.2, 0.41666666666667
93202, 2.1583333333333, 1.175, 0.41666666666667
93203, 2.1583333333333, 1.15, 0.39583333333333
93204, 2.1375, 1.15, 0.41666666666667
93205, 2.1583333333333, 1.125, 0.41666666666667
93206, 2.1583333333333, 1.1, 0.39583333333333
93207, 2.1375, 1.1, 0.41666666666667
93208, 2.1583333333333, 1.075, 0.41666666666667
93209, 2.1583333333333, 1.05, 0.39583333333333
93210, 2.1375, 1.05, 0.41666666666667
93211, 2.1583333333333, 1.025, 0.41666666666667
93212, 2.1583333333333, 1, 0.39583333333333
93213, 2.1375, 1, 0.41666666666667
93214, 2.1583333333333, 0.975, 0.41666666666667
93215, 2.1583333333333, 0.95, 0.39583333333333
93216, 2.1375, 0.95, 0.41666666666667
93217, 2.1583333333333, 0.925, 0.41666666666667
93218, 2.1583333333333, 0.9, 0.39583333333333
93219, 2.1375, 0.9, 0.41666666666667
93220, 2.1583333333333, 0.875, 0.41666666666667
93221, 2.1583333333333, 0.85, 0.39583333333333
93222, 2.1375, 0.85, 0.41666666666667
93223, 2.1583333333333, 0.825, 0.41666666666667
93224, 2.1583333333333, 0.8, 0.39583333333333
93225, 2.1375, 0.8, 0.41666666666667
93226, 2.1583333333333, 0.775, 0.41666666666667
93227, 2.1583333333333, 0.75, 0.39583333333333
93228, 2.1375, 0.75, 0.41666666666667
93229, 2.1583333333333, 0.725, 0.41666666666667
93230, 2.1583333333333, 0.7, 0.39583333333333
93231, 2.1375, 0.7, 0.41666666666667
93232, 2.1583333333333, 0.675, 0.41666666666667
93233, 2.1583333333333, 0.65, 0.39583333333333
93234, 2.1375, 0.65, 0.41666666666667
93235, 2.1583333333333, 0.625, 0.41666666666667
93236, 2.1583333333333, 0.6, 0.39583333333333
93237, 2.1375, 0.6, 0.41666666666667
93238, 2.1583333333333, 0.575, 0.41666666666667
93239, 2.1583333333333, 0.55, 0.39583333333333
93240, 2.1375, 0.55, 0.41666666666667
93241, 2.1583333333333, 0.525, 0.41666666666667
93242, 2.1583333333333, 0.5, 0.39583333333333
93243, 2.1375, 0.5, 0.41666666666667
93244, 2.1583333333333, 0.475, 0.41666666666667
93245, 2.1583333333333, 0.45, 0.39583333333333
93246, 2.1375, 0.45, 0.41666666666667
93247, 2.1583333333333, 0.425, 0.41666666666667
93248, 2.1583333333333, 0.4, 0.39583333333333
93249, 2.1375, 0.4, 0.41666666666667
93250, 2.1583333333333, 0.375, 0.41666666666667
93251, 2.1583333333333, 0.35, 0.39583333333333
93252, 2.1375, 0.35, 0.41666666666667
93253, 2.1583333333333, 0.325, 0.41666666666667
93254, 2.1583333333333, 0.3, 0.39583333333333
93255, 2.1375, 0.3, 0.41666666666667
93256, 2.1583333333333, 0.275, 0.41666666666667
93257, 2.1583333333333, 0.25, 0.39583333333333
93258, 2.1375, 0.25, 0.41666666666667
93259, 2.1583333333333, 0.225, 0.41666666666667
93260, 2.1583333333333, 0.2, 0.39583333333333
93261, 2.1375, 0.2, 0.41666666666667
93262, 2.1583333333333, 0.175, 0.41666666666667
93263, 2.1791666666667, 1.3, 0.41666666666667
93264, 2.1791666666667, 1.25, 0.41666666666667
93265, 2.1791666666667, 1.2, 0.41666666666667
93266, 2.1791666666667, 1.15, 0.41666666666667
93267, 2.1791666666667, 1.1, 0.41666666666667
93268, 2.1791666666667, 1.05, 0.41666666666667
93269, 2.1791666666667, 1, 0.41666666666667
93270, 2.1791666666667, 0.95, 0.41666666666667
93271, 2.1791666666667, 0.9, 0.41666666666667
93272, 2.1791666666667, 0.85, 0.41666666666667
93273, 2.1791666666667, 0.8, 0.41666666666667
93274, 2.1791666666667, 0.75, 0.41666666666667
93275, 2.1791666666667, 0.7, 0.41666666666667
93276, 2.1791666666667, 0.65, 0.41666666666667
93277, 2.1791666666667, 0.6, 0.41666666666667
93278, 2.1791666666667, 0.55, 0.41666666666667
93279, 2.1791666666667, 0.5, 0.41666666666667
93280, 2.1791666666667, 0.45, 0.41666666666667
93281, 2.1791666666667, 0.4, 0.41666666666667
93282, 2.1791666666667, 0.35, 0.41666666666667
93283, 2.1791666666667, 0.3, 0.41666666666667
93284, 2.1791666666667, 0.25, 0.41666666666667
93285, 2.1791666666667, 0.2, 0.41666666666667
93286, 1.2416666666667, 1.325, 0.45833333333333
93287, 1.2416666666667, 1.3, 0.4375
93288, 1.2208333333333, 1.3, 0.45833333333333
93289, 1.2416666666667, 1.275, 0.45833333333333
93290, 1.2416666666667, 1.25, 0.4375
93291, 1.2208333333333, 1.25, 0.45833333333333
93292, 1.2416666666667, 1.225, 0.45833333333333
93293, 1.2416666666667, 1.2, 0.4375
93294, 1.2208333333333, 1.2, 0.45833333333333
93295, 1.2416666666667, 1.175, 0.45833333333333
93296, 1.2416666666667, 1.15, 0.4375
93297, 1.2208333333333, 1.15, 0.45833333333333
93298, 1.2416666666667, 1.125, 0.45833333333333
93299, 1.2416666666667, 1.1, 0.4375
93300, 1.2208333333333, 1.1, 0.45833333333333
93301, 1.2416666666667, 1.075, 0.45833333333333
93302, 1.2416666666667, 1.05, 0.4375
93303, 1.2208333333333, 1.05, 0.45833333333333
93304, 1.2416666666667, 1.025, 0.45833333333333
93305, 1.2416666666667, 1, 0.4375
93306, 1.2208333333333, 1, 0.45833333333333
93307, 1.2416666666667, 0.975, 0.45833333333333
93308, 1.2416666666667, 0.95, 0.4375
93309, 1.2208333333333, 0.95, 0.45833333333333
93310, 1.2416666666667, 0.925, 0.45833333333333
93311, 1.2416666666667, 0.9, 0.4375
93312, 1.2208333333333, 0.9, 0.45833333333333
93313, 1.2416666666667, 0.875, 0.45833333333333
93314, 1.2416666666667, 0.85, 0.4375
93315, 1.2208333333333, 0.85, 0.45833333333333
93316, 1.2416666666667, 0.825, 0.45833333333333
93317, 1.2416666666667, 0.8, 0.4375
93318, 1.2208333333333, 0.8, 0.45833333333333
93319, 1.2416666666667, 0.775, 0.45833333333333
93320, 1.2416666666667, 0.75, 0.4375
93321, 1.2208333333333, 0.75, 0.45833333333333
93322, 1.2416666666667, 0.725, 0.45833333333333
93323, 1.2416666666667, 0.7, 0.4375
93324, 1.2208333333333, 0.7, 0.45833333333333
93325, 1.2416666666667, 0.675, 0.45833333333333
93326, 1.2416666666667, 0.65, 0.4375
93327, 1.2208333333333, 0.65, 0.45833333333333
93328, 1.2416666666667, 0.625, 0.45833333333333
93329, 1.2416666666667, 0.6, 0.4375
93330, 1.2208333333333, 0.6, 0.45833333333333
93331, 1.2416666666667, 0.575, 0.45833333333333
93332, 1.2416666666667, 0.55, 0.4375
93333, 1.2208333333333, 0.55, 0.45833333333333
93334, 1.2416666666667, 0.525, 0.45833333333333
93335, 1.2416666666667, 0.5, 0.4375
93336, 1.2208333333333, 0.5, 0.45833333333333
93337, 1.2416666666667, 0.475, 0.45833333333333
93338, 1.2416666666667, 0.45, 0.4375
93339, 1.2208333333333, 0.45, 0.45833333333333
93340, 1.2416666666667, 0.425, 0.45833333333333
93341, 1.2416666666667, 0.4, 0.4375
93342, 1.2208333333333, 0.4, 0.45833333333333
93343, 1.2416666666667, 0.375, 0.45833333333333
93344, 1.2416666666667, 0.35, 0.4375
93345, 1.2208333333333, 0.35, 0.45833333333333
93346, 1.2416666666667, 0.325, 0.45833333333333
93347, 1.2416666666667, 0.3, 0.4375
93348, 1.2208333333333, 0.3, 0.45833333333333
93349, 1.2416666666667, 0.275, 0.45833333333333
93350, 1.2416666666667, 0.25, 0.4375
93351, 1.2208333333333, 0.25, 0.45833333333333
93352, 1.2416666666667, 0.225, 0.45833333333333
93353, 1.2416666666667, 0.2, 0.4375
93354, 1.2208333333333, 0.2, 0.45833333333333
93355, 1.2416666666667, 0.175, 0.45833333333333
93356, 1.2833333333333, 1.325, 0.45833333333333
93357, 1.2833333333333, 1.3, 0.4375
93358, 1.2625, 1.3, 0.45833333333333
93359, 1.2833333333333, 1.275, 0.45833333333333
93360, 1.2833333333333, 1.25, 0.4375
93361, 1.2625, 1.25, 0.45833333333333
93362, 1.2833333333333, 1.225, 0.45833333333333
93363, 1.2833333333333, 1.2, 0.4375
93364, 1.2625, 1.2, 0.45833333333333
93365, 1.2833333333333, 1.175, 0.45833333333333
93366, 1.2833333333333, 1.15, 0.4375
93367, 1.2625, 1.15, 0.45833333333333
93368, 1.2833333333333, 1.125, 0.45833333333333
93369, 1.2833333333333, 1.1, 0.4375
93370, 1.2625, 1.1, 0.45833333333333
93371, 1.2833333333333, 1.075, 0.45833333333333
93372, 1.2833333333333, 1.05, 0.4375
93373, 1.2625, 1.05, 0.45833333333333
93374, 1.2833333333333, 1.025, 0.45833333333333
93375, 1.2833333333333, 1, 0.4375
93376, 1.2625, 1, 0.45833333333333
93377, 1.2833333333333, 0.975, 0.45833333333333
93378, 1.2833333333333, 0.95, 0.4375
93379, 1.2625, 0.95, 0.45833333333333
93380, 1.2833333333333, 0.925, 0.45833333333333
93381, 1.2833333333333, 0.9, 0.4375
93382, 1.2625, 0.9, 0.45833333333333
93383, 1.2833333333333, 0.875, 0.45833333333333
93384, 1.2833333333333, 0.85, 0.4375
93385, 1.2625, 0.85, 0.45833333333333
93386, 1.2833333333333, 0.825, 0.45833333333333
93387, 1.2833333333333, 0.8, 0.4375
93388, 1.2625, 0.8, 0.45833333333333
93389, 1.2833333333333, 0.775, 0.45833333333333
93390, 1.2833333333333, 0.75, 0.4375
93391, 1.2625, 0.75, 0.45833333333333
93392, 1.2833333333333, 0.725, 0.45833333333333
93393, 1.2833333333333, 0.7, 0.4375
93394, 1.2625, 0.7, 0.45833333333333
93395, 1.2833333333333, 0.675, 0.45833333333333
93396, 1.2833333333333, 0.65, 0.4375
93397, 1.2625, 0.65, 0.45833333333333
93398, 1.2833333333333, 0.625, 0.45833333333333
93399, 1.2833333333333, 0.6, 0.4375
93400, 1.2625, 0.6, 0.45833333333333
93401, 1.2833333333333, 0.575, 0.45833333333333
93402, 1.2833333333333, 0.55, 0.4375
93403, 1.2625, 0.55, 0.45833333333333
93404, 1.2833333333333, 0.525, 0.45833333333333
93405, 1.2833333333333, 0.5, 0.4375
93406, 1.2625, 0.5, 0.45833333333333
93407, 1.2833333333333, 0.475, 0.45833333333333
93408, 1.2833333333333, 0.45, 0.4375
93409, 1.2625, 0.45, 0.45833333333333
93410, 1.2833333333333, 0.425, 0.45833333333333
93411, 1.2833333333333, 0.4, 0.4375
93412, 1.2625, 0.4, 0.45833333333333
93413, 1.2833333333333, 0.375, 0.45833333333333
93414, 1.2833333333333, 0.35, 0.4375
93415, 1.2625, 0.35, 0.45833333333333
93416, 1.2833333333333, 0.325, 0.45833333333333
93417, 1.2833333333333, 0.3, 0.4375
93418, 1.2625, 0.3, 0.45833333333333
93419, 1.2833333333333, 0.275, 0.45833333333333
93420, 1.2833333333333, 0.25, 0.4375
93421, 1.2625, 0.25, 0.45833333333333
93422, 1.2833333333333, 0.225, 0.45833333333333
93423, 1.2833333333333, 0.2, 0.4375
93424, 1.2625, 0.2, 0.45833333333333
93425, 1.2833333333333, 0.175, 0.45833333333333
93426, 1.325, 1.325, 0.45833333333333
93427, 1.325, 1.3, 0.4375
93428, 1.3041666666667, 1.3, 0.45833333333333
93429, 1.325, 1.275, 0.45833333333333
93430, 1.325, 1.25, 0.4375
93431, 1.3041666666667, 1.25, 0.45833333333333
93432, 1.325, 1.225, 0.45833333333333
93433, 1.325, 1.2, 0.4375
93434, 1.3041666666667, 1.2, 0.45833333333333
93435, 1.325, 1.175, 0.45833333333333
93436, 1.325, 1.15, 0.4375
93437, 1.3041666666667, 1.15, 0.45833333333333
93438, 1.325, 1.125, 0.45833333333333
93439, 1.325, 1.1, 0.4375
93440, 1.3041666666667, 1.1, 0.45833333333333
93441, 1.325, 1.075, 0.45833333333333
93442, 1.325, 1.05, 0.4375
93443, 1.3041666666667, 1.05, 0.45833333333333
93444, 1.325, 1.025, 0.45833333333333
93445, 1.325, 1, 0.4375
93446, 1.3041666666667, 1, 0.45833333333333
93447, 1.325, 0.975, 0.45833333333333
93448, 1.325, 0.95, 0.4375
93449, 1.3041666666667, 0.95, 0.45833333333333
93450, 1.325, 0.925, 0.45833333333333
93451, 1.325, 0.9, 0.4375
93452, 1.3041666666667, 0.9, 0.45833333333333
93453, 1.325, 0.875, 0.45833333333333
93454, 1.325, 0.85, 0.4375
93455, 1.3041666666667, 0.85, 0.45833333333333
93456, 1.325, 0.825, 0.45833333333333
93457, 1.325, 0.8, 0.4375
93458, 1.3041666666667, 0.8, 0.45833333333333
93459, 1.325, 0.775, 0.45833333333333
93460, 1.325, 0.75, 0.4375
93461, 1.3041666666667, 0.75, 0.45833333333333
93462, 1.325, 0.725, 0.45833333333333
93463, 1.325, 0.7, 0.4375
93464, 1.3041666666667, 0.7, 0.45833333333333
93465, 1.325, 0.675, 0.45833333333333
93466, 1.325, 0.65, 0.4375
93467, 1.3041666666667, 0.65, 0.45833333333333
93468, 1.325, 0.625, 0.45833333333333
93469, 1.325, 0.6, 0.4375
93470, 1.3041666666667, 0.6, 0.45833333333333
93471, 1.325, 0.575, 0.45833333333333
93472, 1.325, 0.55, 0.4375
93473, 1.3041666666667, 0.55, 0.45833333333333
93474, 1.325, 0.525, 0.45833333333333
93475, 1.325, 0.5, 0.4375
93476, 1.3041666666667, 0.5, 0.45833333333333
93477, 1.325, 0.475, 0.45833333333333
93478, 1.325, 0.45, 0.4375
93479, 1.3041666666667, 0.45, 0.45833333333333
93480, 1.325, 0.425, 0.45833333333333
93481, 1.325, 0.4, 0.4375
93482, 1.3041666666667, 0.4, 0.45833333333333
93483, 1.325, 0.375, 0.45833333333333
93484, 1.325, 0.35, 0.4375
93485, 1.3041666666667, 0.35, 0.45833333333333
93486, 1.325, 0.325, 0.45833333333333
93487, 1.325, 0.3, 0.4375
93488, 1.3041666666667, 0.3, 0.45833333333333
93489, 1.325, 0.275, 0.45833333333333
93490, 1.325, 0.25, 0.4375
93491, 1.3041666666667, 0.25, 0.45833333333333
93492, 1.325, 0.225, 0.45833333333333
93493, 1.325, 0.2, 0.4375
93494, 1.3041666666667, 0.2, 0.45833333333333
93495, 1.325, 0.175, 0.45833333333333
93496, 1.3666666666667, 1.325, 0.45833333333333
93497, 1.3666666666667, 1.3, 0.4375
93498, 1.3458333333333, 1.3, 0.45833333333333
93499, 1.3666666666667, 1.275, 0.45833333333333
93500, 1.3666666666667, 1.25, 0.4375
93501, 1.3458333333333, 1.25, 0.45833333333333
93502, 1.3666666666667, 1.225, 0.45833333333333
93503, 1.3666666666667, 1.2, 0.4375
93504, 1.3458333333333, 1.2, 0.45833333333333
93505, 1.3666666666667, 1.175, 0.45833333333333
93506, 1.3666666666667, 1.15, 0.4375
93507, 1.3458333333333, 1.15, 0.45833333333333
93508, 1.3666666666667, 1.125, 0.45833333333333
93509, 1.3666666666667, 1.1, 0.4375
93510, 1.3458333333333, 1.1, 0.45833333333333
93511, 1.3666666666667, 1.075, 0.45833333333333
93512, 1.3666666666667, 1.05, 0.4375
93513, 1.3458333333333, 1.05, 0.45833333333333
93514, 1.3666666666667, 1.025, 0.45833333333333
93515, 1.3666666666667, 1, 0.4375
93516, 1.3458333333333, 1, 0.45833333333333
93517, 1.3666666666667, 0.975, 0.45833333333333
93518, 1.3666666666667, 0.95, 0.4375
93519, 1.3458333333333, 0.95, 0.45833333333333
93520, 1.3666666666667, 0.925, 0.45833333333333
93521, 1.3666666666667, 0.9, 0.4375
93522, 1.3458333333333, 0.9, 0.45833333333333
93523, 1.3666666666667, 0.875, 0.45833333333333
93524, 1.3666666666667, 0.85, 0.4375
93525, 1.3458333333333, 0.85, 0.45833333333333
93526, 1.3666666666667, 0.825, 0.45833333333333
93527, 1.3666666666667, 0.8, 0.4375
93528, 1.3458333333333, 0.8, 0.45833333333333
93529, 1.3666666666667, 0.775, 0.45833333333333
93530, 1.3666666666667, 0.75, 0.4375
93531, 1.3458333333333, 0.75, 0.45833333333333
93532, 1.3666666666667, 0.725, 0.45833333333333
93533, 1.3666666666667, 0.7, 0.4375
93534, 1.3458333333333, 0.7, 0.45833333333333
93535, 1.3666666666667, 0.675, 0.45833333333333
93536, 1.3666666666667, 0.65, 0.4375
93537, 1.3458333333333, 0.65, 0.45833333333333
93538, 1.3666666666667, 0.625, 0.45833333333333
93539, 1.3666666666667, 0.6, 0.4375
93540, 1.3458333333333, 0.6, 0.45833333333333
93541, 1.3666666666667, 0.575, 0.45833333333333
93542, 1.3666666666667, 0.55, 0.4375
93543, 1.3458333333333, 0.55, 0.45833333333333
93544, 1.3666666666667, 0.525, 0.45833333333333
93545, 1.3666666666667, 0.5, 0.4375
93546, 1.3458333333333, 0.5, 0.45833333333333
93547, 1.3666666666667, 0.475, 0.45833333333333
93548, 1.3666666666667, 0.45, 0.4375
93549, 1.3458333333333, 0.45, 0.45833333333333
93550, 1.3666666666667, 0.425, 0.45833333333333
93551, 1.3666666666667, 0.4, 0.4375
93552, 1.3458333333333, 0.4, 0.45833333333333
93553, 1.3666666666667, 0.375, 0.45833333333333
93554, 1.3666666666667, 0.35, 0.4375
93555, 1.3458333333333, 0.35, 0.45833333333333
93556, 1.3666666666667, 0.325, 0.45833333333333
93557, 1.3666666666667, 0.3, 0.4375
93558, 1.3458333333333, 0.3, 0.45833333333333
93559, 1.3666666666667, 0.275, 0.45833333333333
93560, 1.3666666666667, 0.25, 0.4375
93561, 1.3458333333333, 0.25, 0.45833333333333
93562, 1.3666666666667, 0.225, 0.45833333333333
93563, 1.3666666666667, 0.2, 0.4375
93564, 1.3458333333333, 0.2, 0.45833333333333
93565, 1.3666666666667, 0.175, 0.45833333333333
93566, 1.4083333333333, 1.325, 0.45833333333333
93567, 1.4083333333333, 1.3, 0.4375
93568, 1.3875, 1.3, 0.45833333333333
93569, 1.4083333333333, 1.275, 0.45833333333333
93570, 1.4083333333333, 1.25, 0.4375
93571, 1.3875, 1.25, 0.45833333333333
93572, 1.4083333333333, 1.225, 0.45833333333333
93573, 1.4083333333333, 1.2, 0.4375
93574, 1.3875, 1.2, 0.45833333333333
93575, 1.4083333333333, 1.175, 0.45833333333333
93576, 1.4083333333333, 1.15, 0.4375
93577, 1.3875, 1.15, 0.45833333333333
93578, 1.4083333333333, 1.125, 0.45833333333333
93579, 1.4083333333333, 1.1, 0.4375
93580, 1.3875, 1.1, 0.45833333333333
93581, 1.4083333333333, 1.075, 0.45833333333333
93582, 1.4083333333333, 1.05, 0.4375
93583, 1.3875, 1.05, 0.45833333333333
93584, 1.4083333333333, 1.025, 0.45833333333333
93585, 1.4083333333333, 1, 0.4375
93586, 1.3875, 1, 0.45833333333333
93587, 1.4083333333333, 0.975, 0.45833333333333
93588, 1.4083333333333, 0.95, 0.4375
93589, 1.3875, 0.95, 0.45833333333333
93590, 1.4083333333333, 0.925, 0.45833333333333
93591, 1.4083333333333, 0.9, 0.4375
93592, 1.3875, 0.9, 0.45833333333333
93593, 1.4083333333333, 0.875, 0.45833333333333
93594, 1.4083333333333, 0.85, 0.4375
93595, 1.3875, 0.85, 0.45833333333333
93596, 1.4083333333333, 0.825, 0.45833333333333
93597, 1.4083333333333, 0.8, 0.4375
93598, 1.3875, 0.8, 0.45833333333333
93599, 1.4083333333333, 0.775, 0.45833333333333
93600, 1.4083333333333, 0.75, 0.4375
93601, 1.3875, 0.75, 0.45833333333333
93602, 1.4083333333333, 0.725, 0.45833333333333
93603, 1.4083333333333, 0.7, 0.4375
93604, 1.3875, 0.7, 0.45833333333333
93605, 1.4083333333333, 0.675, 0.45833333333333
93606, 1.4083333333333, 0.65, 0.4375
93607, 1.3875, 0.65, 0.45833333333333
93608, 1.4083333333333, 0.625, 0.45833333333333
93609, 1.4083333333333, 0.6, 0.4375
93610, 1.3875, 0.6, 0.45833333333333
93611, 1.4083333333333, 0.575, 0.45833333333333
93612, 1.4083333333333, 0.55, 0.4375
93613, 1.3875, 0.55, 0.45833333333333
93614, 1.4083333333333, 0.525, 0.45833333333333
93615, 1.4083333333333, 0.5, 0.4375
93616, 1.3875, 0.5, 0.45833333333333
93617, 1.4083333333333, 0.475, 0.45833333333333
93618, 1.4083333333333, 0.45, 0.4375
93619, 1.3875, 0.45, 0.45833333333333
93620, 1.4083333333333, 0.425, 0.45833333333333
93621, 1.4083333333333, 0.4, 0.4375
93622, 1.3875, 0.4, 0.45833333333333
93623, 1.4083333333333, 0.375, 0.45833333333333
93624, 1.4083333333333, 0.35, 0.4375
93625, 1.3875, 0.35, 0.45833333333333
93626, 1.4083333333333, 0.325, 0.45833333333333
93627, 1.4083333333333, 0.3, 0.4375
93628, 1.3875, 0.3, 0.45833333333333
93629, 1.4083333333333, 0.275, 0.45833333333333
93630, 1.4083333333333, 0.25, 0.4375
93631, 1.3875, 0.25, 0.45833333333333
93632, 1.4083333333333, 0.225, 0.45833333333333
93633, 1.4083333333333, 0.2, 0.4375
93634, 1.3875, 0.2, 0.45833333333333
93635, 1.4083333333333, 0.175, 0.45833333333333
93636, 1.45, 1.325, 0.45833333333333
93637, 1.45, 1.3, 0.4375
93638, 1.4291666666667, 1.3, 0.45833333333333
93639, 1.45, 1.275, 0.45833333333333
93640, 1.45, 1.25, 0.4375
93641, 1.4291666666667, 1.25, 0.45833333333333
93642, 1.45, 1.225, 0.45833333333333
93643, 1.45, 1.2, 0.4375
93644, 1.4291666666667, 1.2, 0.45833333333333
93645, 1.45, 1.175, 0.45833333333333
93646, 1.45, 1.15, 0.4375
93647, 1.4291666666667, 1.15, 0.45833333333333
93648, 1.45, 1.125, 0.45833333333333
93649, 1.45, 1.1, 0.4375
93650, 1.4291666666667, 1.1, 0.45833333333333
93651, 1.45, 1.075, 0.45833333333333
93652, 1.45, 1.05, 0.4375
93653, 1.4291666666667, 1.05, 0.45833333333333
93654, 1.45, 1.025, 0.45833333333333
93655, 1.45, 1, 0.4375
93656, 1.4291666666667, 1, 0.45833333333333
93657, 1.45, 0.975, 0.45833333333333
93658, 1.45, 0.95, 0.4375
93659, 1.4291666666667, 0.95, 0.45833333333333
93660, 1.45, 0.925, 0.45833333333333
93661, 1.45, 0.9, 0.4375
93662, 1.4291666666667, 0.9, 0.45833333333333
93663, 1.45, 0.875, 0.45833333333333
93664, 1.45, 0.85, 0.4375
93665, 1.4291666666667, 0.85, 0.45833333333333
93666, 1.45, 0.825, 0.45833333333333
93667, 1.45, 0.8, 0.4375
93668, 1.4291666666667, 0.8, 0.45833333333333
93669, 1.45, 0.775, 0.45833333333333
93670, 1.45, 0.75, 0.4375
93671, 1.4291666666667, 0.75, 0.45833333333333
93672, 1.45, 0.725, 0.45833333333333
93673, 1.45, 0.7, 0.4375
93674, 1.4291666666667, 0.7, 0.45833333333333
93675, 1.45, 0.675, 0.45833333333333
93676, 1.45, 0.65, 0.4375
93677, 1.4291666666667, 0.65, 0.45833333333333
93678, 1.45, 0.625, 0.45833333333333
93679, 1.45, 0.6, 0.4375
93680, 1.4291666666667, 0.6, 0.45833333333333
93681, 1.45, 0.575, 0.45833333333333
93682, 1.45, 0.55, 0.4375
93683, 1.4291666666667, 0.55, 0.45833333333333
93684, 1.45, 0.525, 0.45833333333333
93685, 1.45, 0.5, 0.4375
93686, 1.4291666666667, 0.5, 0.45833333333333
93687, 1.45, 0.475, 0.45833333333333
93688, 1.45, 0.45, 0.4375
93689, 1.4291666666667, 0.45, 0.45833333333333
93690, 1.45, 0.425, 0.45833333333333
93691, 1.45, 0.4, 0.4375
93692, 1.4291666666667, 0.4, 0.45833333333333
93693, 1.45, 0.375, 0.45833333333333
93694, 1.45, 0.35, 0.4375
93695, 1.4291666666667, 0.35, 0.45833333333333
93696, 1.45, 0.325, 0.45833333333333
93697, 1.45, 0.3, 0.4375
93698, 1.4291666666667, 0.3, 0.45833333333333
93699, 1.45, 0.275, 0.45833333333333
93700, 1.45, 0.25, 0.4375
93701, 1.4291666666667, 0.25, 0.45833333333333
93702, 1.45, 0.225, 0.45833333333333
93703, 1.45, 0.2, 0.4375
93704, 1.4291666666667, 0.2, 0.45833333333333
93705, 1.45, 0.175, 0.45833333333333
93706, 1.4916666666667, 1.325, 0.45833333333333
93707, 1.4916666666667, 1.3, 0.4375
93708, 1.4708333333333, 1.3, 0.45833333333333
93709, 1.4916666666667, 1.275, 0.45833333333333
93710, 1.4916666666667, 1.25, 0.4375
93711, 1.4708333333333, 1.25, 0.45833333333333
93712, 1.4916666666667, 1.225, 0.45833333333333
93713, 1.4916666666667, 1.2, 0.4375
93714, 1.4708333333333, 1.2, 0.45833333333333
93715, 1.4916666666667, 1.175, 0.45833333333333
93716, 1.4916666666667, 1.15, 0.4375
93717, 1.4708333333333, 1.15, 0.45833333333333
93718, 1.4916666666667, 1.125, 0.45833333333333
93719, 1.4916666666667, 1.1, 0.4375
93720, 1.4708333333333, 1.1, 0.45833333333333
93721, 1.4916666666667, 1.075, 0.45833333333333
93722, 1.4916666666667, 1.05, 0.4375
93723, 1.4708333333333, 1.05, 0.45833333333333
93724, 1.4916666666667, 1.025, 0.45833333333333
93725, 1.4916666666667, 1, 0.4375
93726, 1.4708333333333, 1, 0.45833333333333
93727, 1.4916666666667, 0.975, 0.45833333333333
93728, 1.4916666666667, 0.95, 0.4375
93729, 1.4708333333333, 0.95, 0.45833333333333
93730, 1.4916666666667, 0.925, 0.45833333333333
93731, 1.4916666666667, 0.9, 0.4375
93732, 1.4708333333333, 0.9, 0.45833333333333
93733, 1.4916666666667, 0.875, 0.45833333333333
93734, 1.4916666666667, 0.85, 0.4375
93735, 1.4708333333333, 0.85, 0.45833333333333
93736, 1.4916666666667, 0.825, 0.45833333333333
93737, 1.4916666666667, 0.8, 0.4375
93738, 1.4708333333333, 0.8, 0.45833333333333
93739, 1.4916666666667, 0.775, 0.45833333333333
93740, 1.4916666666667, 0.75, 0.4375
93741, 1.4708333333333, 0.75, 0.45833333333333
93742, 1.4916666666667, 0.725, 0.45833333333333
93743, 1.4916666666667, 0.7, 0.4375
93744, 1.4708333333333, 0.7, 0.45833333333333
93745, 1.4916666666667, 0.675, 0.45833333333333
93746, 1.4916666666667, 0.65, 0.4375
93747, 1.4708333333333, 0.65, 0.45833333333333
93748, 1.4916666666667, 0.625, 0.45833333333333
93749, 1.4916666666667, 0.6, 0.4375
93750, 1.4708333333333, 0.6, 0.45833333333333
93751, 1.4916666666667, 0.575, 0.45833333333333
93752, 1.4916666666667, 0.55, 0.4375
93753, 1.4708333333333, 0.55, 0.45833333333333
93754, 1.4916666666667, 0.525, 0.45833333333333
93755, 1.4916666666667, 0.5, 0.4375
93756, 1.4708333333333, 0.5, 0.45833333333333
93757, 1.4916666666667, 0.475, 0.45833333333333
93758, 1.4916666666667, 0.45, 0.4375
93759, 1.4708333333333, 0.45, 0.45833333333333
93760, 1.4916666666667, 0.425, 0.45833333333333
93761, 1.4916666666667, 0.4, 0.4375
93762, 1.4708333333333, 0.4, 0.45833333333333
93763, 1.4916666666667, 0.375, 0.45833333333333
93764, 1.4916666666667, 0.35, 0.4375
93765, 1.4708333333333, 0.35, 0.45833333333333
93766, 1.4916666666667, 0.325, 0.45833333333333
93767, 1.4916666666667, 0.3, 0.4375
93768, 1.4708333333333, 0.3, 0.45833333333333
93769, 1.4916666666667, 0.275, 0.45833333333333
93770, 1.4916666666667, 0.25, 0.4375
93771, 1.4708333333333, 0.25, 0.45833333333333
93772, 1.4916666666667, 0.225, 0.45833333333333
93773, 1.4916666666667, 0.2, 0.4375
93774, 1.4708333333333, 0.2, 0.45833333333333
93775, 1.4916666666667, 0.175, 0.45833333333333
93776, 1.5333333333333, 1.325, 0.45833333333333
93777, 1.5333333333333, 1.3, 0.4375
93778, 1.5125, 1.3, 0.45833333333333
93779, 1.5333333333333, 1.275, 0.45833333333333
93780, 1.5333333333333, 1.25, 0.4375
93781, 1.5125, 1.25, 0.45833333333333
93782, 1.5333333333333, 1.225, 0.45833333333333
93783, 1.5333333333333, 1.2, 0.4375
93784, 1.5125, 1.2, 0.45833333333333
93785, 1.5333333333333, 1.175, 0.45833333333333
93786, 1.5333333333333, 1.15, 0.4375
93787, 1.5125, 1.15, 0.45833333333333
93788, 1.5333333333333, 1.125, 0.45833333333333
93789, 1.5333333333333, 1.1, 0.4375
93790, 1.5125, 1.1, 0.45833333333333
93791, 1.5333333333333, 1.075, 0.45833333333333
93792, 1.5333333333333, 1.05, 0.4375
93793, 1.5125, 1.05, 0.45833333333333
93794, 1.5333333333333, 1.025, 0.45833333333333
93795, 1.5333333333333, 1, 0.4375
93796, 1.5125, 1, 0.45833333333333
93797, 1.5333333333333, 0.975, 0.45833333333333
93798, 1.5333333333333, 0.95, 0.4375
93799, 1.5125, 0.95, 0.45833333333333
93800, 1.5333333333333, 0.925, 0.45833333333333
93801, 1.5333333333333, 0.9, 0.4375
93802, 1.5125, 0.9, 0.45833333333333
93803, 1.5333333333333, 0.875, 0.45833333333333
93804, 1.5333333333333, 0.85, 0.4375
93805, 1.5125, 0.85, 0.45833333333333
93806, 1.5333333333333, 0.825, 0.45833333333333
93807, 1.5333333333333, 0.8, 0.4375
93808, 1.5125, 0.8, 0.45833333333333
93809, 1.5333333333333, 0.775, 0.45833333333333
93810, 1.5333333333333, 0.75, 0.4375
93811, 1.5125, 0.75, 0.45833333333333
93812, 1.5333333333333, 0.725, 0.45833333333333
93813, 1.5333333333333, 0.7, 0.4375
93814, 1.5125, 0.7, 0.45833333333333
93815, 1.5333333333333, 0.675, 0.45833333333333
93816, 1.5333333333333, 0.65, 0.4375
93817, 1.5125, 0.65, 0.45833333333333
93818, 1.5333333333333, 0.625, 0.45833333333333
93819, 1.5333333333333, 0.6, 0.4375
93820, 1.5125, 0.6, 0.45833333333333
93821, 1.5333333333333, 0.575, 0.45833333333333
93822, 1.5333333333333, 0.55, 0.4375
93823, 1.5125, 0.55, 0.45833333333333
93824, 1.5333333333333, 0.525, 0.45833333333333
93825, 1.5333333333333, 0.5, 0.4375
93826, 1.5125, 0.5, 0.45833333333333
93827, 1.5333333333333, 0.475, 0.45833333333333
93828, 1.5333333333333, 0.45, 0.4375
93829, 1.5125, 0.45, 0.45833333333333
93830, 1.5333333333333, 0.425, 0.45833333333333
93831, 1.5333333333333, 0.4, 0.4375
93832, 1.5125, 0.4, 0.45833333333333
93833, 1.5333333333333, 0.375, 0.45833333333333
93834, 1.5333333333333, 0.35, 0.4375
93835, 1.5125, 0.35, 0.45833333333333
93836, 1.5333333333333, 0.325, 0.45833333333333
93837, 1.5333333333333, 0.3, 0.4375
93838, 1.5125, 0.3, 0.45833333333333
93839, 1.5333333333333, 0.275, 0.45833333333333
93840, 1.5333333333333, 0.25, 0.4375
93841, 1.5125, 0.25, 0.45833333333333
93842, 1.5333333333333, 0.225, 0.45833333333333
93843, 1.5333333333333, 0.2, 0.4375
93844, 1.5125, 0.2, 0.45833333333333
93845, 1.5333333333333, 0.175, 0.45833333333333
93846, 1.575, 1.325, 0.45833333333333
93847, 1.575, 1.3, 0.4375
93848, 1.5541666666667, 1.3, 0.45833333333333
93849, 1.575, 1.275, 0.45833333333333
93850, 1.575, 1.25, 0.4375
93851, 1.5541666666667, 1.25, 0.45833333333333
93852, 1.575, 1.225, 0.45833333333333
93853, 1.575, 1.2, 0.4375
93854, 1.5541666666667, 1.2, 0.45833333333333
93855, 1.575, 1.175, 0.45833333333333
93856, 1.575, 1.15, 0.4375
93857, 1.5541666666667, 1.15, 0.45833333333333
93858, 1.575, 1.125, 0.45833333333333
93859, 1.575, 1.1, 0.4375
93860, 1.5541666666667, 1.1, 0.45833333333333
93861, 1.575, 1.075, 0.45833333333333
93862, 1.575, 1.05, 0.4375
93863, 1.5541666666667, 1.05, 0.45833333333333
93864, 1.575, 1.025, 0.45833333333333
93865, 1.575, 1, 0.4375
93866, 1.5541666666667, 1, 0.45833333333333
93867, 1.575, 0.975, 0.45833333333333
93868, 1.575, 0.95, 0.4375
93869, 1.5541666666667, 0.95, 0.45833333333333
93870, 1.575, 0.925, 0.45833333333333
93871, 1.575, 0.9, 0.4375
93872, 1.5541666666667, 0.9, 0.45833333333333
93873, 1.575, 0.875, 0.45833333333333
93874, 1.575, 0.85, 0.4375
93875, 1.5541666666667, 0.85, 0.45833333333333
93876, 1.575, 0.825, 0.45833333333333
93877, 1.575, 0.8, 0.4375
93878, 1.5541666666667, 0.8, 0.45833333333333
93879, 1.575, 0.775, 0.45833333333333
93880, 1.575, 0.75, 0.4375
93881, 1.5541666666667, 0.75, 0.45833333333333
93882, 1.575, 0.725, 0.45833333333333
93883, 1.575, 0.7, 0.4375
93884, 1.5541666666667, 0.7, 0.45833333333333
93885, 1.575, 0.675, 0.45833333333333
93886, 1.575, 0.65, 0.4375
93887, 1.5541666666667, 0.65, 0.45833333333333
93888, 1.575, 0.625, 0.45833333333333
93889, 1.575, 0.6, 0.4375
93890, 1.5541666666667, 0.6, 0.45833333333333
93891, 1.575, 0.575, 0.45833333333333
93892, 1.575, 0.55, 0.4375
93893, 1.5541666666667, 0.55, 0.45833333333333
93894, 1.575, 0.525, 0.45833333333333
93895, 1.575, 0.5, 0.4375
93896, 1.5541666666667, 0.5, 0.45833333333333
93897, 1.575, 0.475, 0.45833333333333
93898, 1.575, 0.45, 0.4375
93899, 1.5541666666667, 0.45, 0.45833333333333
93900, 1.575, 0.425, 0.45833333333333
93901, 1.575, 0.4, 0.4375
93902, 1.5541666666667, 0.4, 0.45833333333333
93903, 1.575, 0.375, 0.45833333333333
93904, 1.575, 0.35, 0.4375
93905, 1.5541666666667, 0.35, 0.45833333333333
93906, 1.575, 0.325, 0.45833333333333
93907, 1.575, 0.3, 0.4375
93908, 1.5541666666667, 0.3, 0.45833333333333
93909, 1.575, 0.275, 0.45833333333333
93910, 1.575, 0.25, 0.4375
93911, 1.5541666666667, 0.25, 0.45833333333333
93912, 1.575, 0.225, 0.45833333333333
93913, 1.575, 0.2, 0.4375
93914, 1.5541666666667, 0.2, 0.45833333333333
93915, 1.575, 0.175, 0.45833333333333
93916, 1.6166666666667, 1.325, 0.45833333333333
93917, 1.6166666666667, 1.3, 0.4375
93918, 1.5958333333333, 1.3, 0.45833333333333
93919, 1.6166666666667, 1.275, 0.45833333333333
93920, 1.6166666666667, 1.25, 0.4375
93921, 1.5958333333333, 1.25, 0.45833333333333
93922, 1.6166666666667, 1.225, 0.45833333333333
93923, 1.6166666666667, 1.2, 0.4375
93924, 1.5958333333333, 1.2, 0.45833333333333
93925, 1.6166666666667, 1.175, 0.45833333333333
93926, 1.6166666666667, 1.15, 0.4375
93927, 1.5958333333333, 1.15, 0.45833333333333
93928, 1.6166666666667, 1.125, 0.45833333333333
93929, 1.6166666666667, 1.1, 0.4375
93930, 1.5958333333333, 1.1, 0.45833333333333
93931, 1.6166666666667, 1.075, 0.45833333333333
93932, 1.6166666666667, 1.05, 0.4375
93933, 1.5958333333333, 1.05, 0.45833333333333
93934, 1.6166666666667, 1.025, 0.45833333333333
93935, 1.6166666666667, 1, 0.4375
93936, 1.5958333333333, 1, 0.45833333333333
93937, 1.6166666666667, 0.975, 0.45833333333333
93938, 1.6166666666667, 0.95, 0.4375
93939, 1.5958333333333, 0.95, 0.45833333333333
93940, 1.6166666666667, 0.925, 0.45833333333333
93941, 1.6166666666667, 0.9, 0.4375
93942, 1.5958333333333, 0.9, 0.45833333333333
93943, 1.6166666666667, 0.875, 0.45833333333333
93944, 1.6166666666667, 0.85, 0.4375
93945, 1.5958333333333, 0.85, 0.45833333333333
93946, 1.6166666666667, 0.825, 0.45833333333333
93947, 1.6166666666667, 0.8, 0.4375
93948, 1.5958333333333, 0.8, 0.45833333333333
93949, 1.6166666666667, 0.775, 0.45833333333333
93950, 1.6166666666667, 0.75, 0.4375
93951, 1.5958333333333, 0.75, 0.45833333333333
93952, 1.6166666666667, 0.725, 0.45833333333333
93953, 1.6166666666667, 0.7, 0.4375
93954, 1.5958333333333, 0.7, 0.45833333333333
93955, 1.6166666666667, 0.675, 0.45833333333333
93956, 1.6166666666667, 0.65, 0.4375
93957, 1.5958333333333, 0.65, 0.45833333333333
93958, 1.6166666666667, 0.625, 0.45833333333333
93959, 1.6166666666667, 0.6, 0.4375
93960, 1.5958333333333, 0.6, 0.45833333333333
93961, 1.6166666666667, 0.575, 0.45833333333333
93962, 1.6166666666667, 0.55, 0.4375
93963, 1.5958333333333, 0.55, 0.45833333333333
93964, 1.6166666666667, 0.525, 0.45833333333333
93965, 1.6166666666667, 0.5, 0.4375
93966, 1.5958333333333, 0.5, 0.45833333333333
93967, 1.6166666666667, 0.475, 0.45833333333333
93968, 1.6166666666667, 0.45, 0.4375
93969, 1.5958333333333, 0.45, 0.45833333333333
93970, 1.6166666666667, 0.425, 0.45833333333333
93971, 1.6166666666667, 0.4, 0.4375
93972, 1.5958333333333, 0.4, 0.45833333333333
93973, 1.6166666666667, 0.375, 0.45833333333333
93974, 1.6166666666667, 0.35, 0.4375
93975, 1.5958333333333, 0.35, 0.45833333333333
93976, 1.6166666666667, 0.325, 0.45833333333333
93977, 1.6166666666667, 0.3, 0.4375
93978, 1.5958333333333, 0.3, 0.45833333333333
93979, 1.6166666666667, 0.275, 0.45833333333333
93980, 1.6166666666667, 0.25, 0.4375
93981, 1.5958333333333, 0.25, 0.45833333333333
93982, 1.6166666666667, 0.225, 0.45833333333333
93983, 1.6166666666667, 0.2, 0.4375
93984, 1.5958333333333, 0.2, 0.45833333333333
93985, 1.6166666666667, 0.175, 0.45833333333333
93986, 1.6583333333333, 1.325, 0.45833333333333
93987, 1.6583333333333, 1.3, 0.4375
93988, 1.6375, 1.3, 0.45833333333333
93989, 1.6583333333333, 1.275, 0.45833333333333
93990, 1.6583333333333, 1.25, 0.4375
93991, 1.6375, 1.25, 0.45833333333333
93992, 1.6583333333333, 1.225, 0.45833333333333
93993, 1.6583333333333, 1.2, 0.4375
93994, 1.6375, 1.2, 0.45833333333333
93995, 1.6583333333333, 1.175, 0.45833333333333
93996, 1.6583333333333, 1.15, 0.4375
93997, 1.6375, 1.15, 0.45833333333333
93998, 1.6583333333333, 1.125, 0.45833333333333
93999, 1.6583333333333, 1.1, 0.4375
94000, 1.6375, 1.1, 0.45833333333333
94001, 1.6583333333333, 1.075, 0.45833333333333
94002, 1.6583333333333, 1.05, 0.4375
94003, 1.6375, 1.05, 0.45833333333333
94004, 1.6583333333333, 1.025, 0.45833333333333
94005, 1.6583333333333, 1, 0.4375
94006, 1.6375, 1, 0.45833333333333
94007, 1.6583333333333, 0.975, 0.45833333333333
94008, 1.6583333333333, 0.95, 0.4375
94009, 1.6375, 0.95, 0.45833333333333
94010, 1.6583333333333, 0.925, 0.45833333333333
94011, 1.6583333333333, 0.9, 0.4375
94012, 1.6375, 0.9, 0.45833333333333
94013, 1.6583333333333, 0.875, 0.45833333333333
94014, 1.6583333333333, 0.85, 0.4375
94015, 1.6375, 0.85, 0.45833333333333
94016, 1.6583333333333, 0.825, 0.45833333333333
94017, 1.6583333333333, 0.8, 0.4375
94018, 1.6375, 0.8, 0.45833333333333
94019, 1.6583333333333, 0.775, 0.45833333333333
94020, 1.6583333333333, 0.75, 0.4375
94021, 1.6375, 0.75, 0.45833333333333
94022, 1.6583333333333, 0.725, 0.45833333333333
94023, 1.6583333333333, 0.7, 0.4375
94024, 1.6375, 0.7, 0.45833333333333
94025, 1.6583333333333, 0.675, 0.45833333333333
94026, 1.6583333333333, 0.65, 0.4375
94027, 1.6375, 0.65, 0.45833333333333
94028, 1.6583333333333, 0.625, 0.45833333333333
94029, 1.6583333333333, 0.6, 0.4375
94030, 1.6375, 0.6, 0.45833333333333
94031, 1.6583333333333, 0.575, 0.45833333333333
94032, 1.6583333333333, 0.55, 0.4375
94033, 1.6375, 0.55, 0.45833333333333
94034, 1.6583333333333, 0.525, 0.45833333333333
94035, 1.6583333333333, 0.5, 0.4375
94036, 1.6375, 0.5, 0.45833333333333
94037, 1.6583333333333, 0.475, 0.45833333333333
94038, 1.6583333333333, 0.45, 0.4375
94039, 1.6375, 0.45, 0.45833333333333
94040, 1.6583333333333, 0.425, 0.45833333333333
94041, 1.6583333333333, 0.4, 0.4375
94042, 1.6375, 0.4, 0.45833333333333
94043, 1.6583333333333, 0.375, 0.45833333333333
94044, 1.6583333333333, 0.35, 0.4375
94045, 1.6375, 0.35, 0.45833333333333
94046, 1.6583333333333, 0.325, 0.45833333333333
94047, 1.6583333333333, 0.3, 0.4375
94048, 1.6375, 0.3, 0.45833333333333
94049, 1.6583333333333, 0.275, 0.45833333333333
94050, 1.6583333333333, 0.25, 0.4375
94051, 1.6375, 0.25, 0.45833333333333
94052, 1.6583333333333, 0.225, 0.45833333333333
94053, 1.6583333333333, 0.2, 0.4375
94054, 1.6375, 0.2, 0.45833333333333
94055, 1.6583333333333, 0.175, 0.45833333333333
94056, 1.7, 1.325, 0.45833333333333
94057, 1.7, 1.3, 0.4375
94058, 1.6791666666667, 1.3, 0.45833333333333
94059, 1.7, 1.275, 0.45833333333333
94060, 1.7, 1.25, 0.4375
94061, 1.6791666666667, 1.25, 0.45833333333333
94062, 1.7, 1.225, 0.45833333333333
94063, 1.7, 1.2, 0.4375
94064, 1.6791666666667, 1.2, 0.45833333333333
94065, 1.7, 1.175, 0.45833333333333
94066, 1.7, 1.15, 0.4375
94067, 1.6791666666667, 1.15, 0.45833333333333
94068, 1.7, 1.125, 0.45833333333333
94069, 1.7, 1.1, 0.4375
94070, 1.6791666666667, 1.1, 0.45833333333333
94071, 1.7, 1.075, 0.45833333333333
94072, 1.7, 1.05, 0.4375
94073, 1.6791666666667, 1.05, 0.45833333333333
94074, 1.7, 1.025, 0.45833333333333
94075, 1.7, 1, 0.4375
94076, 1.6791666666667, 1, 0.45833333333333
94077, 1.7, 0.975, 0.45833333333333
94078, 1.7, 0.95, 0.4375
94079, 1.6791666666667, 0.95, 0.45833333333333
94080, 1.7, 0.925, 0.45833333333333
94081, 1.7, 0.9, 0.4375
94082, 1.6791666666667, 0.9, 0.45833333333333
94083, 1.7, 0.875, 0.45833333333333
94084, 1.7, 0.85, 0.4375
94085, 1.6791666666667, 0.85, 0.45833333333333
94086, 1.7, 0.825, 0.45833333333333
94087, 1.7, 0.8, 0.4375
94088, 1.6791666666667, 0.8, 0.45833333333333
94089, 1.7, 0.775, 0.45833333333333
94090, 1.7, 0.75, 0.4375
94091, 1.6791666666667, 0.75, 0.45833333333333
94092, 1.7, 0.725, 0.45833333333333
94093, 1.7, 0.7, 0.4375
94094, 1.6791666666667, 0.7, 0.45833333333333
94095, 1.7, 0.675, 0.45833333333333
94096, 1.7, 0.65, 0.4375
94097, 1.6791666666667, 0.65, 0.45833333333333
94098, 1.7, 0.625, 0.45833333333333
94099, 1.7, 0.6, 0.4375
94100, 1.6791666666667, 0.6, 0.45833333333333
94101, 1.7, 0.575, 0.45833333333333
94102, 1.7, 0.55, 0.4375
94103, 1.6791666666667, 0.55, 0.45833333333333
94104, 1.7, 0.525, 0.45833333333333
94105, 1.7, 0.5, 0.4375
94106, 1.6791666666667, 0.5, 0.45833333333333
94107, 1.7, 0.475, 0.45833333333333
94108, 1.7, 0.45, 0.4375
94109, 1.6791666666667, 0.45, 0.45833333333333
94110, 1.7, 0.425, 0.45833333333333
94111, 1.7, 0.4, 0.4375
94112, 1.6791666666667, 0.4, 0.45833333333333
94113, 1.7, 0.375, 0.45833333333333
94114, 1.7, 0.35, 0.4375
94115, 1.6791666666667, 0.35, 0.45833333333333
94116, 1.7, 0.325, 0.45833333333333
94117, 1.7, 0.3, 0.4375
94118, 1.6791666666667, 0.3, 0.45833333333333
94119, 1.7, 0.275, 0.45833333333333
94120, 1.7, 0.25, 0.4375
94121, 1.6791666666667, 0.25, 0.45833333333333
94122, 1.7, 0.225, 0.45833333333333
94123, 1.7, 0.2, 0.4375
94124, 1.6791666666667, 0.2, 0.45833333333333
94125, 1.7, 0.175, 0.45833333333333
94126, 1.7416666666667, 1.325, 0.45833333333333
94127, 1.7416666666667, 1.3, 0.4375
94128, 1.7208333333333, 1.3, 0.45833333333333
94129, 1.7416666666667, 1.275, 0.45833333333333
94130, 1.7416666666667, 1.25, 0.4375
94131, 1.7208333333333, 1.25, 0.45833333333333
94132, 1.7416666666667, 1.225, 0.45833333333333
94133, 1.7416666666667, 1.2, 0.4375
94134, 1.7208333333333, 1.2, 0.45833333333333
94135, 1.7416666666667, 1.175, 0.45833333333333
94136, 1.7416666666667, 1.15, 0.4375
94137, 1.7208333333333, 1.15, 0.45833333333333
94138, 1.7416666666667, 1.125, 0.45833333333333
94139, 1.7416666666667, 1.1, 0.4375
94140, 1.7208333333333, 1.1, 0.45833333333333
94141, 1.7416666666667, 1.075, 0.45833333333333
94142, 1.7416666666667, 1.05, 0.4375
94143, 1.7208333333333, 1.05, 0.45833333333333
94144, 1.7416666666667, 1.025, 0.45833333333333
94145, 1.7416666666667, 1, 0.4375
94146, 1.7208333333333, 1, 0.45833333333333
94147, 1.7416666666667, 0.975, 0.45833333333333
94148, 1.7416666666667, 0.95, 0.4375
94149, 1.7208333333333, 0.95, 0.45833333333333
94150, 1.7416666666667, 0.925, 0.45833333333333
94151, 1.7416666666667, 0.9, 0.4375
94152, 1.7208333333333, 0.9, 0.45833333333333
94153, 1.7416666666667, 0.875, 0.45833333333333
94154, 1.7416666666667, 0.85, 0.4375
94155, 1.7208333333333, 0.85, 0.45833333333333
94156, 1.7416666666667, 0.825, 0.45833333333333
94157, 1.7416666666667, 0.8, 0.4375
94158, 1.7208333333333, 0.8, 0.45833333333333
94159, 1.7416666666667, 0.775, 0.45833333333333
94160, 1.7416666666667, 0.75, 0.4375
94161, 1.7208333333333, 0.75, 0.45833333333333
94162, 1.7416666666667, 0.725, 0.45833333333333
94163, 1.7416666666667, 0.7, 0.4375
94164, 1.7208333333333, 0.7, 0.45833333333333
94165, 1.7416666666667, 0.675, 0.45833333333333
94166, 1.7416666666667, 0.65, 0.4375
94167, 1.7208333333333, 0.65, 0.45833333333333
94168, 1.7416666666667, 0.625, 0.45833333333333
94169, 1.7416666666667, 0.6, 0.4375
94170, 1.7208333333333, 0.6, 0.45833333333333
94171, 1.7416666666667, 0.575, 0.45833333333333
94172, 1.7416666666667, 0.55, 0.4375
94173, 1.7208333333333, 0.55, 0.45833333333333
94174, 1.7416666666667, 0.525, 0.45833333333333
94175, 1.7416666666667, 0.5, 0.4375
94176, 1.7208333333333, 0.5, 0.45833333333333
94177, 1.7416666666667, 0.475, 0.45833333333333
94178, 1.7416666666667, 0.45, 0.4375
94179, 1.7208333333333, 0.45, 0.45833333333333
94180, 1.7416666666667, 0.425, 0.45833333333333
94181, 1.7416666666667, 0.4, 0.4375
94182, 1.7208333333333, 0.4, 0.45833333333333
94183, 1.7416666666667, 0.375, 0.45833333333333
94184, 1.7416666666667, 0.35, 0.4375
94185, 1.7208333333333, 0.35, 0.45833333333333
94186, 1.7416666666667, 0.325, 0.45833333333333
94187, 1.7416666666667, 0.3, 0.4375
94188, 1.7208333333333, 0.3, 0.45833333333333
94189, 1.7416666666667, 0.275, 0.45833333333333
94190, 1.7416666666667, 0.25, 0.4375
94191, 1.7208333333333, 0.25, 0.45833333333333
94192, 1.7416666666667, 0.225, 0.45833333333333
94193, 1.7416666666667, 0.2, 0.4375
94194, 1.7208333333333, 0.2, 0.45833333333333
94195, 1.7416666666667, 0.175, 0.45833333333333
94196, 1.7833333333333, 1.325, 0.45833333333333
94197, 1.7833333333333, 1.3, 0.4375
94198, 1.7625, 1.3, 0.45833333333333
94199, 1.7833333333333, 1.275, 0.45833333333333
94200, 1.7833333333333, 1.25, 0.4375
94201, 1.7625, 1.25, 0.45833333333333
94202, 1.7833333333333, 1.225, 0.45833333333333
94203, 1.7833333333333, 1.2, 0.4375
94204, 1.7625, 1.2, 0.45833333333333
94205, 1.7833333333333, 1.175, 0.45833333333333
94206, 1.7833333333333, 1.15, 0.4375
94207, 1.7625, 1.15, 0.45833333333333
94208, 1.7833333333333, 1.125, 0.45833333333333
94209, 1.7833333333333, 1.1, 0.4375
94210, 1.7625, 1.1, 0.45833333333333
94211, 1.7833333333333, 1.075, 0.45833333333333
94212, 1.7833333333333, 1.05, 0.4375
94213, 1.7625, 1.05, 0.45833333333333
94214, 1.7833333333333, 1.025, 0.45833333333333
94215, 1.7833333333333, 1, 0.4375
94216, 1.7625, 1, 0.45833333333333
94217, 1.7833333333333, 0.975, 0.45833333333333
94218, 1.7833333333333, 0.95, 0.4375
94219, 1.7625, 0.95, 0.45833333333333
94220, 1.7833333333333, 0.925, 0.45833333333333
94221, 1.7833333333333, 0.9, 0.4375
94222, 1.7625, 0.9, 0.45833333333333
94223, 1.7833333333333, 0.875, 0.45833333333333
94224, 1.7833333333333, 0.85, 0.4375
94225, 1.7625, 0.85, 0.45833333333333
94226, 1.7833333333333, 0.825, 0.45833333333333
94227, 1.7833333333333, 0.8, 0.4375
94228, 1.7625, 0.8, 0.45833333333333
94229, 1.7833333333333, 0.775, 0.45833333333333
94230, 1.7833333333333, 0.75, 0.4375
94231, 1.7625, 0.75, 0.45833333333333
94232, 1.7833333333333, 0.725, 0.45833333333333
94233, 1.7833333333333, 0.7, 0.4375
94234, 1.7625, 0.7, 0.45833333333333
94235, 1.7833333333333, 0.675, 0.45833333333333
94236, 1.7833333333333, 0.65, 0.4375
94237, 1.7625, 0.65, 0.45833333333333
94238, 1.7833333333333, 0.625, 0.45833333333333
94239, 1.7833333333333, 0.6, 0.4375
94240, 1.7625, 0.6, 0.45833333333333
94241, 1.7833333333333, 0.575, 0.45833333333333
94242, 1.7833333333333, 0.55, 0.4375
94243, 1.7625, 0.55, 0.45833333333333
94244, 1.7833333333333, 0.525, 0.45833333333333
94245, 1.7833333333333, 0.5, 0.4375
94246, 1.7625, 0.5, 0.45833333333333
94247, 1.7833333333333, 0.475, 0.45833333333333
94248, 1.7833333333333, 0.45, 0.4375
94249, 1.7625, 0.45, 0.45833333333333
94250, 1.7833333333333, 0.425, 0.45833333333333
94251, 1.7833333333333, 0.4, 0.4375
94252, 1.7625, 0.4, 0.45833333333333
94253, 1.7833333333333, 0.375, 0.45833333333333
94254, 1.7833333333333, 0.35, 0.4375
94255, 1.7625, 0.35, 0.45833333333333
94256, 1.7833333333333, 0.325, 0.45833333333333
94257, 1.7833333333333, 0.3, 0.4375
94258, 1.7625, 0.3, 0.45833333333333
94259, 1.7833333333333, 0.275, 0.45833333333333
94260, 1.7833333333333, 0.25, 0.4375
94261, 1.7625, 0.25, 0.45833333333333
94262, 1.7833333333333, 0.225, 0.45833333333333
94263, 1.7833333333333, 0.2, 0.4375
94264, 1.7625, 0.2, 0.45833333333333
94265, 1.7833333333333, 0.175, 0.45833333333333
94266, 1.825, 1.325, 0.45833333333333
94267, 1.825, 1.3, 0.4375
94268, 1.8041666666667, 1.3, 0.45833333333333
94269, 1.825, 1.275, 0.45833333333333
94270, 1.825, 1.25, 0.4375
94271, 1.8041666666667, 1.25, 0.45833333333333
94272, 1.825, 1.225, 0.45833333333333
94273, 1.825, 1.2, 0.4375
94274, 1.8041666666667, 1.2, 0.45833333333333
94275, 1.825, 1.175, 0.45833333333333
94276, 1.825, 1.15, 0.4375
94277, 1.8041666666667, 1.15, 0.45833333333333
94278, 1.825, 1.125, 0.45833333333333
94279, 1.825, 1.1, 0.4375
94280, 1.8041666666667, 1.1, 0.45833333333333
94281, 1.825, 1.075, 0.45833333333333
94282, 1.825, 1.05, 0.4375
94283, 1.8041666666667, 1.05, 0.45833333333333
94284, 1.825, 1.025, 0.45833333333333
94285, 1.825, 1, 0.4375
94286, 1.8041666666667, 1, 0.45833333333333
94287, 1.825, 0.975, 0.45833333333333
94288, 1.825, 0.95, 0.4375
94289, 1.8041666666667, 0.95, 0.45833333333333
94290, 1.825, 0.925, 0.45833333333333
94291, 1.825, 0.9, 0.4375
94292, 1.8041666666667, 0.9, 0.45833333333333
94293, 1.825, 0.875, 0.45833333333333
94294, 1.825, 0.85, 0.4375
94295, 1.8041666666667, 0.85, 0.45833333333333
94296, 1.825, 0.825, 0.45833333333333
94297, 1.825, 0.8, 0.4375
94298, 1.8041666666667, 0.8, 0.45833333333333
94299, 1.825, 0.775, 0.45833333333333
94300, 1.825, 0.75, 0.4375
94301, 1.8041666666667, 0.75, 0.45833333333333
94302, 1.825, 0.725, 0.45833333333333
94303, 1.825, 0.7, 0.4375
94304, 1.8041666666667, 0.7, 0.45833333333333
94305, 1.825, 0.675, 0.45833333333333
94306, 1.825, 0.65, 0.4375
94307, 1.8041666666667, 0.65, 0.45833333333333
94308, 1.825, 0.625, 0.45833333333333
94309, 1.825, 0.6, 0.4375
94310, 1.8041666666667, 0.6, 0.45833333333333
94311, 1.825, 0.575, 0.45833333333333
94312, 1.825, 0.55, 0.4375
94313, 1.8041666666667, 0.55, 0.45833333333333
94314, 1.825, 0.525, 0.45833333333333
94315, 1.825, 0.5, 0.4375
94316, 1.8041666666667, 0.5, 0.45833333333333
94317, 1.825, 0.475, 0.45833333333333
94318, 1.825, 0.45, 0.4375
94319, 1.8041666666667, 0.45, 0.45833333333333
94320, 1.825, 0.425, 0.45833333333333
94321, 1.825, 0.4, 0.4375
94322, 1.8041666666667, 0.4, 0.45833333333333
94323, 1.825, 0.375, 0.45833333333333
94324, 1.825, 0.35, 0.4375
94325, 1.8041666666667, 0.35, 0.45833333333333
94326, 1.825, 0.325, 0.45833333333333
94327, 1.825, 0.3, 0.4375
94328, 1.8041666666667, 0.3, 0.45833333333333
94329, 1.825, 0.275, 0.45833333333333
94330, 1.825, 0.25, 0.4375
94331, 1.8041666666667, 0.25, 0.45833333333333
94332, 1.825, 0.225, 0.45833333333333
94333, 1.825, 0.2, 0.4375
94334, 1.8041666666667, 0.2, 0.45833333333333
94335, 1.825, 0.175, 0.45833333333333
94336, 1.8666666666667, 1.325, 0.45833333333333
94337, 1.8666666666667, 1.3, 0.4375
94338, 1.8458333333333, 1.3, 0.45833333333333
94339, 1.8666666666667, 1.275, 0.45833333333333
94340, 1.8666666666667, 1.25, 0.4375
94341, 1.8458333333333, 1.25, 0.45833333333333
94342, 1.8666666666667, 1.225, 0.45833333333333
94343, 1.8666666666667, 1.2, 0.4375
94344, 1.8458333333333, 1.2, 0.45833333333333
94345, 1.8666666666667, 1.175, 0.45833333333333
94346, 1.8666666666667, 1.15, 0.4375
94347, 1.8458333333333, 1.15, 0.45833333333333
94348, 1.8666666666667, 1.125, 0.45833333333333
94349, 1.8666666666667, 1.1, 0.4375
94350, 1.8458333333333, 1.1, 0.45833333333333
94351, 1.8666666666667, 1.075, 0.45833333333333
94352, 1.8666666666667, 1.05, 0.4375
94353, 1.8458333333333, 1.05, 0.45833333333333
94354, 1.8666666666667, 1.025, 0.45833333333333
94355, 1.8666666666667, 1, 0.4375
94356, 1.8458333333333, 1, 0.45833333333333
94357, 1.8666666666667, 0.975, 0.45833333333333
94358, 1.8666666666667, 0.95, 0.4375
94359, 1.8458333333333, 0.95, 0.45833333333333
94360, 1.8666666666667, 0.925, 0.45833333333333
94361, 1.8666666666667, 0.9, 0.4375
94362, 1.8458333333333, 0.9, 0.45833333333333
94363, 1.8666666666667, 0.875, 0.45833333333333
94364, 1.8666666666667, 0.85, 0.4375
94365, 1.8458333333333, 0.85, 0.45833333333333
94366, 1.8666666666667, 0.825, 0.45833333333333
94367, 1.8666666666667, 0.8, 0.4375
94368, 1.8458333333333, 0.8, 0.45833333333333
94369, 1.8666666666667, 0.775, 0.45833333333333
94370, 1.8666666666667, 0.75, 0.4375
94371, 1.8458333333333, 0.75, 0.45833333333333
94372, 1.8666666666667, 0.725, 0.45833333333333
94373, 1.8666666666667, 0.7, 0.4375
94374, 1.8458333333333, 0.7, 0.45833333333333
94375, 1.8666666666667, 0.675, 0.45833333333333
94376, 1.8666666666667, 0.65, 0.4375
94377, 1.8458333333333, 0.65, 0.45833333333333
94378, 1.8666666666667, 0.625, 0.45833333333333
94379, 1.8666666666667, 0.6, 0.4375
94380, 1.8458333333333, 0.6, 0.45833333333333
94381, 1.8666666666667, 0.575, 0.45833333333333
94382, 1.8666666666667, 0.55, 0.4375
94383, 1.8458333333333, 0.55, 0.45833333333333
94384, 1.8666666666667, 0.525, 0.45833333333333
94385, 1.8666666666667, 0.5, 0.4375
94386, 1.8458333333333, 0.5, 0.45833333333333
94387, 1.8666666666667, 0.475, 0.45833333333333
94388, 1.8666666666667, 0.45, 0.4375
94389, 1.8458333333333, 0.45, 0.45833333333333
94390, 1.8666666666667, 0.425, 0.45833333333333
94391, 1.8666666666667, 0.4, 0.4375
94392, 1.8458333333333, 0.4, 0.45833333333333
94393, 1.8666666666667, 0.375, 0.45833333333333
94394, 1.8666666666667, 0.35, 0.4375
94395, 1.8458333333333, 0.35, 0.45833333333333
94396, 1.8666666666667, 0.325, 0.45833333333333
94397, 1.8666666666667, 0.3, 0.4375
94398, 1.8458333333333, 0.3, 0.45833333333333
94399, 1.8666666666667, 0.275, 0.45833333333333
94400, 1.8666666666667, 0.25, 0.4375
94401, 1.8458333333333, 0.25, 0.45833333333333
94402, 1.8666666666667, 0.225, 0.45833333333333
94403, 1.8666666666667, 0.2, 0.4375
94404, 1.8458333333333, 0.2, 0.45833333333333
94405, 1.8666666666667, 0.175, 0.45833333333333
94406, 1.9083333333333, 1.325, 0.45833333333333
94407, 1.9083333333333, 1.3, 0.4375
94408, 1.8875, 1.3, 0.45833333333333
94409, 1.9083333333333, 1.275, 0.45833333333333
94410, 1.9083333333333, 1.25, 0.4375
94411, 1.8875, 1.25, 0.45833333333333
94412, 1.9083333333333, 1.225, 0.45833333333333
94413, 1.9083333333333, 1.2, 0.4375
94414, 1.8875, 1.2, 0.45833333333333
94415, 1.9083333333333, 1.175, 0.45833333333333
94416, 1.9083333333333, 1.15, 0.4375
94417, 1.8875, 1.15, 0.45833333333333
94418, 1.9083333333333, 1.125, 0.45833333333333
94419, 1.9083333333333, 1.1, 0.4375
94420, 1.8875, 1.1, 0.45833333333333
94421, 1.9083333333333, 1.075, 0.45833333333333
94422, 1.9083333333333, 1.05, 0.4375
94423, 1.8875, 1.05, 0.45833333333333
94424, 1.9083333333333, 1.025, 0.45833333333333
94425, 1.9083333333333, 1, 0.4375
94426, 1.8875, 1, 0.45833333333333
94427, 1.9083333333333, 0.975, 0.45833333333333
94428, 1.9083333333333, 0.95, 0.4375
94429, 1.8875, 0.95, 0.45833333333333
94430, 1.9083333333333, 0.925, 0.45833333333333
94431, 1.9083333333333, 0.9, 0.4375
94432, 1.8875, 0.9, 0.45833333333333
94433, 1.9083333333333, 0.875, 0.45833333333333
94434, 1.9083333333333, 0.85, 0.4375
94435, 1.8875, 0.85, 0.45833333333333
94436, 1.9083333333333, 0.825, 0.45833333333333
94437, 1.9083333333333, 0.8, 0.4375
94438, 1.8875, 0.8, 0.45833333333333
94439, 1.9083333333333, 0.775, 0.45833333333333
94440, 1.9083333333333, 0.75, 0.4375
94441, 1.8875, 0.75, 0.45833333333333
94442, 1.9083333333333, 0.725, 0.45833333333333
94443, 1.9083333333333, 0.7, 0.4375
94444, 1.8875, 0.7, 0.45833333333333
94445, 1.9083333333333, 0.675, 0.45833333333333
94446, 1.9083333333333, 0.65, 0.4375
94447, 1.8875, 0.65, 0.45833333333333
94448, 1.9083333333333, 0.625, 0.45833333333333
94449, 1.9083333333333, 0.6, 0.4375
94450, 1.8875, 0.6, 0.45833333333333
94451, 1.9083333333333, 0.575, 0.45833333333333
94452, 1.9083333333333, 0.55, 0.4375
94453, 1.8875, 0.55, 0.45833333333333
94454, 1.9083333333333, 0.525, 0.45833333333333
94455, 1.9083333333333, 0.5, 0.4375
94456, 1.8875, 0.5, 0.45833333333333
94457, 1.9083333333333, 0.475, 0.45833333333333
94458, 1.9083333333333, 0.45, 0.4375
94459, 1.8875, 0.45, 0.45833333333333
94460, 1.9083333333333, 0.425, 0.45833333333333
94461, 1.9083333333333, 0.4, 0.4375
94462, 1.8875, 0.4, 0.45833333333333
94463, 1.9083333333333, 0.375, 0.45833333333333
94464, 1.9083333333333, 0.35, 0.4375
94465, 1.8875, 0.35, 0.45833333333333
94466, 1.9083333333333, 0.325, 0.45833333333333
94467, 1.9083333333333, 0.3, 0.4375
94468, 1.8875, 0.3, 0.45833333333333
94469, 1.9083333333333, 0.275, 0.45833333333333
94470, 1.9083333333333, 0.25, 0.4375
94471, 1.8875, 0.25, 0.45833333333333
94472, 1.9083333333333, 0.225, 0.45833333333333
94473, 1.9083333333333, 0.2, 0.4375
94474, 1.8875, 0.2, 0.45833333333333
94475, 1.9083333333333, 0.175, 0.45833333333333
94476, 1.95, 1.325, 0.45833333333333
94477, 1.95, 1.3, 0.4375
94478, 1.9291666666667, 1.3, 0.45833333333333
94479, 1.95, 1.275, 0.45833333333333
94480, 1.95, 1.25, 0.4375
94481, 1.9291666666667, 1.25, 0.45833333333333
94482, 1.95, 1.225, 0.45833333333333
94483, 1.95, 1.2, 0.4375
94484, 1.9291666666667, 1.2, 0.45833333333333
94485, 1.95, 1.175, 0.45833333333333
94486, 1.95, 1.15, 0.4375
94487, 1.9291666666667, 1.15, 0.45833333333333
94488, 1.95, 1.125, 0.45833333333333
94489, 1.95, 1.1, 0.4375
94490, 1.9291666666667, 1.1, 0.45833333333333
94491, 1.95, 1.075, 0.45833333333333
94492, 1.95, 1.05, 0.4375
94493, 1.9291666666667, 1.05, 0.45833333333333
94494, 1.95, 1.025, 0.45833333333333
94495, 1.95, 1, 0.4375
94496, 1.9291666666667, 1, 0.45833333333333
94497, 1.95, 0.975, 0.45833333333333
94498, 1.95, 0.95, 0.4375
94499, 1.9291666666667, 0.95, 0.45833333333333
94500, 1.95, 0.925, 0.45833333333333
94501, 1.95, 0.9, 0.4375
94502, 1.9291666666667, 0.9, 0.45833333333333
94503, 1.95, 0.875, 0.45833333333333
94504, 1.95, 0.85, 0.4375
94505, 1.9291666666667, 0.85, 0.45833333333333
94506, 1.95, 0.825, 0.45833333333333
94507, 1.95, 0.8, 0.4375
94508, 1.9291666666667, 0.8, 0.45833333333333
94509, 1.95, 0.775, 0.45833333333333
94510, 1.95, 0.75, 0.4375
94511, 1.9291666666667, 0.75, 0.45833333333333
94512, 1.95, 0.725, 0.45833333333333
94513, 1.95, 0.7, 0.4375
94514, 1.9291666666667, 0.7, 0.45833333333333
94515, 1.95, 0.675, 0.45833333333333
94516, 1.95, 0.65, 0.4375
94517, 1.9291666666667, 0.65, 0.45833333333333
94518, 1.95, 0.625, 0.45833333333333
94519, 1.95, 0.6, 0.4375
94520, 1.9291666666667, 0.6, 0.45833333333333
94521, 1.95, 0.575, 0.45833333333333
94522, 1.95, 0.55, 0.4375
94523, 1.9291666666667, 0.55, 0.45833333333333
94524, 1.95, 0.525, 0.45833333333333
94525, 1.95, 0.5, 0.4375
94526, 1.9291666666667, 0.5, 0.45833333333333
94527, 1.95, 0.475, 0.45833333333333
94528, 1.95, 0.45, 0.4375
94529, 1.9291666666667, 0.45, 0.45833333333333
94530, 1.95, 0.425, 0.45833333333333
94531, 1.95, 0.4, 0.4375
94532, 1.9291666666667, 0.4, 0.45833333333333
94533, 1.95, 0.375, 0.45833333333333
94534, 1.95, 0.35, 0.4375
94535, 1.9291666666667, 0.35, 0.45833333333333
94536, 1.95, 0.325, 0.45833333333333
94537, 1.95, 0.3, 0.4375
94538, 1.9291666666667, 0.3, 0.45833333333333
94539, 1.95, 0.275, 0.45833333333333
94540, 1.95, 0.25, 0.4375
94541, 1.9291666666667, 0.25, 0.45833333333333
94542, 1.95, 0.225, 0.45833333333333
94543, 1.95, 0.2, 0.4375
94544, 1.9291666666667, 0.2, 0.45833333333333
94545, 1.95, 0.175, 0.45833333333333
94546, 1.9916666666667, 1.325, 0.45833333333333
94547, 1.9916666666667, 1.3, 0.4375
94548, 1.9708333333333, 1.3, 0.45833333333333
94549, 1.9916666666667, 1.275, 0.45833333333333
94550, 1.9916666666667, 1.25, 0.4375
94551, 1.9708333333333, 1.25, 0.45833333333333
94552, 1.9916666666667, 1.225, 0.45833333333333
94553, 1.9916666666667, 1.2, 0.4375
94554, 1.9708333333333, 1.2, 0.45833333333333
94555, 1.9916666666667, 1.175, 0.45833333333333
94556, 1.9916666666667, 1.15, 0.4375
94557, 1.9708333333333, 1.15, 0.45833333333333
94558, 1.9916666666667, 1.125, 0.45833333333333
94559, 1.9916666666667, 1.1, 0.4375
94560, 1.9708333333333, 1.1, 0.45833333333333
94561, 1.9916666666667, 1.075, 0.45833333333333
94562, 1.9916666666667, 1.05, 0.4375
94563, 1.9708333333333, 1.05, 0.45833333333333
94564, 1.9916666666667, 1.025, 0.45833333333333
94565, 1.9916666666667, 1, 0.4375
94566, 1.9708333333333, 1, 0.45833333333333
94567, 1.9916666666667, 0.975, 0.45833333333333
94568, 1.9916666666667, 0.95, 0.4375
94569, 1.9708333333333, 0.95, 0.45833333333333
94570, 1.9916666666667, 0.925, 0.45833333333333
94571, 1.9916666666667, 0.9, 0.4375
94572, 1.9708333333333, 0.9, 0.45833333333333
94573, 1.9916666666667, 0.875, 0.45833333333333
94574, 1.9916666666667, 0.85, 0.4375
94575, 1.9708333333333, 0.85, 0.45833333333333
94576, 1.9916666666667, 0.825, 0.45833333333333
94577, 1.9916666666667, 0.8, 0.4375
94578, 1.9708333333333, 0.8, 0.45833333333333
94579, 1.9916666666667, 0.775, 0.45833333333333
94580, 1.9916666666667, 0.75, 0.4375
94581, 1.9708333333333, 0.75, 0.45833333333333
94582, 1.9916666666667, 0.725, 0.45833333333333
94583, 1.9916666666667, 0.7, 0.4375
94584, 1.9708333333333, 0.7, 0.45833333333333
94585, 1.9916666666667, 0.675, 0.45833333333333
94586, 1.9916666666667, 0.65, 0.4375
94587, 1.9708333333333, 0.65, 0.45833333333333
94588, 1.9916666666667, 0.625, 0.45833333333333
94589, 1.9916666666667, 0.6, 0.4375
94590, 1.9708333333333, 0.6, 0.45833333333333
94591, 1.9916666666667, 0.575, 0.45833333333333
94592, 1.9916666666667, 0.55, 0.4375
94593, 1.9708333333333, 0.55, 0.45833333333333
94594, 1.9916666666667, 0.525, 0.45833333333333
94595, 1.9916666666667, 0.5, 0.4375
94596, 1.9708333333333, 0.5, 0.45833333333333
94597, 1.9916666666667, 0.475, 0.45833333333333
94598, 1.9916666666667, 0.45, 0.4375
94599, 1.9708333333333, 0.45, 0.45833333333333
94600, 1.9916666666667, 0.425, 0.45833333333333
94601, 1.9916666666667, 0.4, 0.4375
94602, 1.9708333333333, 0.4, 0.45833333333333
94603, 1.9916666666667, 0.375, 0.45833333333333
94604, 1.9916666666667, 0.35, 0.4375
94605, 1.9708333333333, 0.35, 0.45833333333333
94606, 1.9916666666667, 0.325, 0.45833333333333
94607, 1.9916666666667, 0.3, 0.4375
94608, 1.9708333333333, 0.3, 0.45833333333333
94609, 1.9916666666667, 0.275, 0.45833333333333
94610, 1.9916666666667, 0.25, 0.4375
94611, 1.9708333333333, 0.25, 0.45833333333333
94612, 1.9916666666667, 0.225, 0.45833333333333
94613, 1.9916666666667, 0.2, 0.4375
94614, 1.9708333333333, 0.2, 0.45833333333333
94615, 1.9916666666667, 0.175, 0.45833333333333
94616, 2.0333333333333, 1.325, 0.45833333333333
94617, 2.0333333333333, 1.3, 0.4375
94618, 2.0125, 1.3, 0.45833333333333
94619, 2.0333333333333, 1.275, 0.45833333333333
94620, 2.0333333333333, 1.25, 0.4375
94621, 2.0125, 1.25, 0.45833333333333
94622, 2.0333333333333, 1.225, 0.45833333333333
94623, 2.0333333333333, 1.2, 0.4375
94624, 2.0125, 1.2, 0.45833333333333
94625, 2.0333333333333, 1.175, 0.45833333333333
94626, 2.0333333333333, 1.15, 0.4375
94627, 2.0125, 1.15, 0.45833333333333
94628, 2.0333333333333, 1.125, 0.45833333333333
94629, 2.0333333333333, 1.1, 0.4375
94630, 2.0125, 1.1, 0.45833333333333
94631, 2.0333333333333, 1.075, 0.45833333333333
94632, 2.0333333333333, 1.05, 0.4375
94633, 2.0125, 1.05, 0.45833333333333
94634, 2.0333333333333, 1.025, 0.45833333333333
94635, 2.0333333333333, 1, 0.4375
94636, 2.0125, 1, 0.45833333333333
94637, 2.0333333333333, 0.975, 0.45833333333333
94638, 2.0333333333333, 0.95, 0.4375
94639, 2.0125, 0.95, 0.45833333333333
94640, 2.0333333333333, 0.925, 0.45833333333333
94641, 2.0333333333333, 0.9, 0.4375
94642, 2.0125, 0.9, 0.45833333333333
94643, 2.0333333333333, 0.875, 0.45833333333333
94644, 2.0333333333333, 0.85, 0.4375
94645, 2.0125, 0.85, 0.45833333333333
94646, 2.0333333333333, 0.825, 0.45833333333333
94647, 2.0333333333333, 0.8, 0.4375
94648, 2.0125, 0.8, 0.45833333333333
94649, 2.0333333333333, 0.775, 0.45833333333333
94650, 2.0333333333333, 0.75, 0.4375
94651, 2.0125, 0.75, 0.45833333333333
94652, 2.0333333333333, 0.725, 0.45833333333333
94653, 2.0333333333333, 0.7, 0.4375
94654, 2.0125, 0.7, 0.45833333333333
94655, 2.0333333333333, 0.675, 0.45833333333333
94656, 2.0333333333333, 0.65, 0.4375
94657, 2.0125, 0.65, 0.45833333333333
94658, 2.0333333333333, 0.625, 0.45833333333333
94659, 2.0333333333333, 0.6, 0.4375
94660, 2.0125, 0.6, 0.45833333333333
94661, 2.0333333333333, 0.575, 0.45833333333333
94662, 2.0333333333333, 0.55, 0.4375
94663, 2.0125, 0.55, 0.45833333333333
94664, 2.0333333333333, 0.525, 0.45833333333333
94665, 2.0333333333333, 0.5, 0.4375
94666, 2.0125, 0.5, 0.45833333333333
94667, 2.0333333333333, 0.475, 0.45833333333333
94668, 2.0333333333333, 0.45, 0.4375
94669, 2.0125, 0.45, 0.45833333333333
94670, 2.0333333333333, 0.425, 0.45833333333333
94671, 2.0333333333333, 0.4, 0.4375
94672, 2.0125, 0.4, 0.45833333333333
94673, 2.0333333333333, 0.375, 0.45833333333333
94674, 2.0333333333333, 0.35, 0.4375
94675, 2.0125, 0.35, 0.45833333333333
94676, 2.0333333333333, 0.325, 0.45833333333333
94677, 2.0333333333333, 0.3, 0.4375
94678, 2.0125, 0.3, 0.45833333333333
94679, 2.0333333333333, 0.275, 0.45833333333333
94680, 2.0333333333333, 0.25, 0.4375
94681, 2.0125, 0.25, 0.45833333333333
94682, 2.0333333333333, 0.225, 0.45833333333333
94683, 2.0333333333333, 0.2, 0.4375
94684, 2.0125, 0.2, 0.45833333333333
94685, 2.0333333333333, 0.175, 0.45833333333333
94686, 2.075, 1.325, 0.45833333333333
94687, 2.075, 1.3, 0.4375
94688, 2.0541666666667, 1.3, 0.45833333333333
94689, 2.075, 1.275, 0.45833333333333
94690, 2.075, 1.25, 0.4375
94691, 2.0541666666667, 1.25, 0.45833333333333
94692, 2.075, 1.225, 0.45833333333333
94693, 2.075, 1.2, 0.4375
94694, 2.0541666666667, 1.2, 0.45833333333333
94695, 2.075, 1.175, 0.45833333333333
94696, 2.075, 1.15, 0.4375
94697, 2.0541666666667, 1.15, 0.45833333333333
94698, 2.075, 1.125, 0.45833333333333
94699, 2.075, 1.1, 0.4375
94700, 2.0541666666667, 1.1, 0.45833333333333
94701, 2.075, 1.075, 0.45833333333333
94702, 2.075, 1.05, 0.4375
94703, 2.0541666666667, 1.05, 0.45833333333333
94704, 2.075, 1.025, 0.45833333333333
94705, 2.075, 1, 0.4375
94706, 2.0541666666667, 1, 0.45833333333333
94707, 2.075, 0.975, 0.45833333333333
94708, 2.075, 0.95, 0.4375
94709, 2.0541666666667, 0.95, 0.45833333333333
94710, 2.075, 0.925, 0.45833333333333
94711, 2.075, 0.9, 0.4375
94712, 2.0541666666667, 0.9, 0.45833333333333
94713, 2.075, 0.875, 0.45833333333333
94714, 2.075, 0.85, 0.4375
94715, 2.0541666666667, 0.85, 0.45833333333333
94716, 2.075, 0.825, 0.45833333333333
94717, 2.075, 0.8, 0.4375
94718, 2.0541666666667, 0.8, 0.45833333333333
94719, 2.075, 0.775, 0.45833333333333
94720, 2.075, 0.75, 0.4375
94721, 2.0541666666667, 0.75, 0.45833333333333
94722, 2.075, 0.725, 0.45833333333333
94723, 2.075, 0.7, 0.4375
94724, 2.0541666666667, 0.7, 0.45833333333333
94725, 2.075, 0.675, 0.45833333333333
94726, 2.075, 0.65, 0.4375
94727, 2.0541666666667, 0.65, 0.45833333333333
94728, 2.075, 0.625, 0.45833333333333
94729, 2.075, 0.6, 0.4375
94730, 2.0541666666667, 0.6, 0.45833333333333
94731, 2.075, 0.575, 0.45833333333333
94732, 2.075, 0.55, 0.4375
94733, 2.0541666666667, 0.55, 0.45833333333333
94734, 2.075, 0.525, 0.45833333333333
94735, 2.075, 0.5, 0.4375
94736, 2.0541666666667, 0.5, 0.45833333333333
94737, 2.075, 0.475, 0.45833333333333
94738, 2.075, 0.45, 0.4375
94739, 2.0541666666667, 0.45, 0.45833333333333
94740, 2.075, 0.425, 0.45833333333333
94741, 2.075, 0.4, 0.4375
94742, 2.0541666666667, 0.4, 0.45833333333333
94743, 2.075, 0.375, 0.45833333333333
94744, 2.075, 0.35, 0.4375
94745, 2.0541666666667, 0.35, 0.45833333333333
94746, 2.075, 0.325, 0.45833333333333
94747, 2.075, 0.3, 0.4375
94748, 2.0541666666667, 0.3, 0.45833333333333
94749, 2.075, 0.275, 0.45833333333333
94750, 2.075, 0.25, 0.4375
94751, 2.0541666666667, 0.25, 0.45833333333333
94752, 2.075, 0.225, 0.45833333333333
94753, 2.075, 0.2, 0.4375
94754, 2.0541666666667, 0.2, 0.45833333333333
94755, 2.075, 0.175, 0.45833333333333
94756, 2.1166666666667, 1.325, 0.45833333333333
94757, 2.1166666666667, 1.3, 0.4375
94758, 2.0958333333333, 1.3, 0.45833333333333
94759, 2.1166666666667, 1.275, 0.45833333333333
94760, 2.1166666666667, 1.25, 0.4375
94761, 2.0958333333333, 1.25, 0.45833333333333
94762, 2.1166666666667, 1.225, 0.45833333333333
94763, 2.1166666666667, 1.2, 0.4375
94764, 2.0958333333333, 1.2, 0.45833333333333
94765, 2.1166666666667, 1.175, 0.45833333333333
94766, 2.1166666666667, 1.15, 0.4375
94767, 2.0958333333333, 1.15, 0.45833333333333
94768, 2.1166666666667, 1.125, 0.45833333333333
94769, 2.1166666666667, 1.1, 0.4375
94770, 2.0958333333333, 1.1, 0.45833333333333
94771, 2.1166666666667, 1.075, 0.45833333333333
94772, 2.1166666666667, 1.05, 0.4375
94773, 2.0958333333333, 1.05, 0.45833333333333
94774, 2.1166666666667, 1.025, 0.45833333333333
94775, 2.1166666666667, 1, 0.4375
94776, 2.0958333333333, 1, 0.45833333333333
94777, 2.1166666666667, 0.975, 0.45833333333333
94778, 2.1166666666667, 0.95, 0.4375
94779, 2.0958333333333, 0.95, 0.45833333333333
94780, 2.1166666666667, 0.925, 0.45833333333333
94781, 2.1166666666667, 0.9, 0.4375
94782, 2.0958333333333, 0.9, 0.45833333333333
94783, 2.1166666666667, 0.875, 0.45833333333333
94784, 2.1166666666667, 0.85, 0.4375
94785, 2.0958333333333, 0.85, 0.45833333333333
94786, 2.1166666666667, 0.825, 0.45833333333333
94787, 2.1166666666667, 0.8, 0.4375
94788, 2.0958333333333, 0.8, 0.45833333333333
94789, 2.1166666666667, 0.775, 0.45833333333333
94790, 2.1166666666667, 0.75, 0.4375
94791, 2.0958333333333, 0.75, 0.45833333333333
94792, 2.1166666666667, 0.725, 0.45833333333333
94793, 2.1166666666667, 0.7, 0.4375
94794, 2.0958333333333, 0.7, 0.45833333333333
94795, 2.1166666666667, 0.675, 0.45833333333333
94796, 2.1166666666667, 0.65, 0.4375
94797, 2.0958333333333, 0.65, 0.45833333333333
94798, 2.1166666666667, 0.625, 0.45833333333333
94799, 2.1166666666667, 0.6, 0.4375
94800, 2.0958333333333, 0.6, 0.45833333333333
94801, 2.1166666666667, 0.575, 0.45833333333333
94802, 2.1166666666667, 0.55, 0.4375
94803, 2.0958333333333, 0.55, 0.45833333333333
94804, 2.1166666666667, 0.525, 0.45833333333333
94805, 2.1166666666667, 0.5, 0.4375
94806, 2.0958333333333, 0.5, 0.45833333333333
94807, 2.1166666666667, 0.475, 0.45833333333333
94808, 2.1166666666667, 0.45, 0.4375
94809, 2.0958333333333, 0.45, 0.45833333333333
94810, 2.1166666666667, 0.425, 0.45833333333333
94811, 2.1166666666667, 0.4, 0.4375
94812, 2.0958333333333, 0.4, 0.45833333333333
94813, 2.1166666666667, 0.375, 0.45833333333333
94814, 2.1166666666667, 0.35, 0.4375
94815, 2.0958333333333, 0.35, 0.45833333333333
94816, 2.1166666666667, 0.325, 0.45833333333333
94817, 2.1166666666667, 0.3, 0.4375
94818, 2.0958333333333, 0.3, 0.45833333333333
94819, 2.1166666666667, 0.275, 0.45833333333333
94820, 2.1166666666667, 0.25, 0.4375
94821, 2.0958333333333, 0.25, 0.45833333333333
94822, 2.1166666666667, 0.225, 0.45833333333333
94823, 2.1166666666667, 0.2, 0.4375
94824, 2.0958333333333, 0.2, 0.45833333333333
94825, 2.1166666666667, 0.175, 0.45833333333333
94826, 2.1583333333333, 1.325, 0.45833333333333
94827, 2.1583333333333, 1.3, 0.4375
94828, 2.1375, 1.3, 0.45833333333333
94829, 2.1583333333333, 1.275, 0.45833333333333
94830, 2.1583333333333, 1.25, 0.4375
94831, 2.1375, 1.25, 0.45833333333333
94832, 2.1583333333333, 1.225, 0.45833333333333
94833, 2.1583333333333, 1.2, 0.4375
94834, 2.1375, 1.2, 0.45833333333333
94835, 2.1583333333333, 1.175, 0.45833333333333
94836, 2.1583333333333, 1.15, 0.4375
94837, 2.1375, 1.15, 0.45833333333333
94838, 2.1583333333333, 1.125, 0.45833333333333
94839, 2.1583333333333, 1.1, 0.4375
94840, 2.1375, 1.1, 0.45833333333333
94841, 2.1583333333333, 1.075, 0.45833333333333
94842, 2.1583333333333, 1.05, 0.4375
94843, 2.1375, 1.05, 0.45833333333333
