6392, 0.020833333333333, 0.15, 0.33333333333333
6393, 0.041666666666667, 0.15, 0.3125
6394, 0.020833333333333, 0.15, 0.375
6395, 0.041666666666667, 0.15, 0.35416666666667
6396, 0.020833333333333, 0.15, 0.41666666666667
6397, 0.041666666666667, 0.15, 0.39583333333333
6398, 0.020833333333333, 0.15, 0.45833333333333
6399, 0.041666666666667, 0.15, 0.4375
6400, 0.041666666666667, 0.15, 0.47916666666667
6401, 0.0625, 0.15, 0.041666666666667
6402, 0.083333333333333, 0.15, 0.020833333333333
6403, 0.0625, 0.15, 0.083333333333333
6404, 0.083333333333333, 0.15, 0.0625
6405, 0.0625, 0.15, 0.125
6406, 0.083333333333333, 0.15, 0.10416666666667
6407, 0.0625, 0.15, 0.16666666666667
6408, 0.083333333333333, 0.15, 0.14583333333333
6409, 0.0625, 0.15, 0.20833333333333
6410, 0.083333333333333, 0.15, 0.1875
6411, 0.0625, 0.15, 0.25
6412, 0.083333333333333, 0.15, 0.22916666666667
6413, 0.0625, 0.15, 0.29166666666667
6414, 0.083333333333333, 0.15, 0.27083333333333
6415, 0.0625, 0.15, 0.33333333333333
6416, 0.083333333333333, 0.15, 0.3125
6417, 0.0625, 0.15, 0.375
6418, 0.083333333333333, 0.15, 0.35416666666667
6419, 0.0625, 0.15, 0.41666666666667
6420, 0.083333333333333, 0.15, 0.39583333333333
6421, 0.0625, 0.15, 0.45833333333333
6422, 0.083333333333333, 0.15, 0.4375
6423, 0.083333333333333, 0.15, 0.47916666666667
6424, 0.10416666666667, 0.15, 0.041666666666667
6425, 0.125, 0.15, 0.020833333333333
6426, 0.10416666666667, 0.15, 0.083333333333333
6427, 0.125, 0.15, 0.0625
6428, 0.10416666666667, 0.15, 0.125
6429, 0.125, 0.15, 0.10416666666667
6430, 0.10416666666667, 0.15, 0.16666666666667
6431, 0.125, 0.15, 0.14583333333333
6432, 0.10416666666667, 0.15, 0.20833333333333
6433, 0.125, 0.15, 0.1875
6434, 0.10416666666667, 0.15, 0.25
6435, 0.125, 0.15, 0.22916666666667
6436, 0.10416666666667, 0.15, 0.29166666666667
6437, 0.125, 0.15, 0.27083333333333
6438, 0.10416666666667, 0.15, 0.33333333333333
6439, 0.125, 0.15, 0.3125
6440, 0.10416666666667, 0.15, 0.375
6441, 0.125, 0.15, 0.35416666666667
6442, 0.10416666666667, 0.15, 0.41666666666667
6443, 0.125, 0.15, 0.39583333333333
6444, 0.10416666666667, 0.15, 0.45833333333333
6445, 0.125, 0.15, 0.4375
6446, 0.125, 0.15, 0.47916666666667
6447, 0.14583333333333, 0.15, 0.041666666666667
6448, 0.16666666666667, 0.15, 0.020833333333333
6449, 0.14583333333333, 0.15, 0.083333333333333
6450, 0.16666666666667, 0.15, 0.0625
6451, 0.14583333333333, 0.15, 0.125
6452, 0.16666666666667, 0.15, 0.10416666666667
6453, 0.14583333333333, 0.15, 0.16666666666667
6454, 0.16666666666667, 0.15, 0.14583333333333
6455, 0.14583333333333, 0.15, 0.20833333333333
6456, 0.16666666666667, 0.15, 0.1875
6457, 0.14583333333333, 0.15, 0.25
6458, 0.16666666666667, 0.15, 0.22916666666667
6459, 0.14583333333333, 0.15, 0.29166666666667
6460, 0.16666666666667, 0.15, 0.27083333333333
6461, 0.14583333333333, 0.15, 0.33333333333333
6462, 0.16666666666667, 0.15, 0.3125
6463, 0.14583333333333, 0.15, 0.375
6464, 0.16666666666667, 0.15, 0.35416666666667
6465, 0.14583333333333, 0.15, 0.41666666666667
6466, 0.16666666666667, 0.15, 0.39583333333333
6467, 0.14583333333333, 0.15, 0.45833333333333
6468, 0.16666666666667, 0.15, 0.4375
6469, 0.16666666666667, 0.15, 0.47916666666667
6470, 0.1875, 0.15, 0.041666666666667
6471, 0.20833333333333, 0.15, 0.020833333333333
6472, 0.1875, 0.15, 0.083333333333333
6473, 0.20833333333333, 0.15, 0.0625
6474, 0.1875, 0.15, 0.125
6475, 0.20833333333333, 0.15, 0.10416666666667
6476, 0.1875, 0.15, 0.16666666666667
6477, 0.20833333333333, 0.15, 0.14583333333333
6478, 0.1875, 0.15, 0.20833333333333
6479, 0.20833333333333, 0.15, 0.1875
6480, 0.1875, 0.15, 0.25
6481, 0.20833333333333, 0.15, 0.22916666666667
6482, 0.1875, 0.15, 0.29166666666667
6483, 0.20833333333333, 0.15, 0.27083333333333
6484, 0.1875, 0.15, 0.33333333333333
6485, 0.20833333333333, 0.15, 0.3125
6486, 0.1875, 0.15, 0.375
6487, 0.20833333333333, 0.15, 0.35416666666667
6488, 0.1875, 0.15, 0.41666666666667
6489, 0.20833333333333, 0.15, 0.39583333333333
6490, 0.1875, 0.15, 0.45833333333333
6491, 0.20833333333333, 0.15, 0.4375
6492, 0.20833333333333, 0.15, 0.47916666666667
6493, 0.22916666666667, 0.15, 0.041666666666667
6494, 0.25, 0.15, 0.020833333333333
6495, 0.22916666666667, 0.15, 0.083333333333333
6496, 0.25, 0.15, 0.0625
6497, 0.22916666666667, 0.15, 0.125
6498, 0.25, 0.15, 0.10416666666667
6499, 0.22916666666667, 0.15, 0.16666666666667
6500, 0.25, 0.15, 0.14583333333333
6501, 0.22916666666667, 0.15, 0.20833333333333
6502, 0.25, 0.15, 0.1875
6503, 0.22916666666667, 0.15, 0.25
6504, 0.25, 0.15, 0.22916666666667
6505, 0.22916666666667, 0.15, 0.29166666666667
6506, 0.25, 0.15, 0.27083333333333
6507, 0.22916666666667, 0.15, 0.33333333333333
6508, 0.25, 0.15, 0.3125
6509, 0.22916666666667, 0.15, 0.375
6510, 0.25, 0.15, 0.35416666666667
6511, 0.22916666666667, 0.15, 0.41666666666667
6512, 0.25, 0.15, 0.39583333333333
6513, 0.22916666666667, 0.15, 0.45833333333333
6514, 0.25, 0.15, 0.4375
6515, 0.25, 0.15, 0.47916666666667
6516, 0.27083333333333, 0.15, 0.041666666666667
6517, 0.29166666666667, 0.15, 0.020833333333333
6518, 0.27083333333333, 0.15, 0.083333333333333
6519, 0.29166666666667, 0.15, 0.0625
6520, 0.27083333333333, 0.15, 0.125
6521, 0.29166666666667, 0.15, 0.10416666666667
6522, 0.27083333333333, 0.15, 0.16666666666667
6523, 0.29166666666667, 0.15, 0.14583333333333
6524, 0.27083333333333, 0.15, 0.20833333333333
6525, 0.29166666666667, 0.15, 0.1875
6526, 0.27083333333333, 0.15, 0.25
6527, 0.29166666666667, 0.15, 0.22916666666667
6528, 0.27083333333333, 0.15, 0.29166666666667
6529, 0.29166666666667, 0.15, 0.27083333333333
6530, 0.27083333333333, 0.15, 0.33333333333333
6531, 0.29166666666667, 0.15, 0.3125
6532, 0.27083333333333, 0.15, 0.375
6533, 0.29166666666667, 0.15, 0.35416666666667
6534, 0.27083333333333, 0.15, 0.41666666666667
6535, 0.29166666666667, 0.15, 0.39583333333333
6536, 0.27083333333333, 0.15, 0.45833333333333
6537, 0.29166666666667, 0.15, 0.4375
6538, 0.29166666666667, 0.15, 0.47916666666667
6539, 0.3125, 0.15, 0.041666666666667
6540, 0.33333333333333, 0.15, 0.020833333333333
6541, 0.3125, 0.15, 0.083333333333333
6542, 0.33333333333333, 0.15, 0.0625
6543, 0.3125, 0.15, 0.125
6544, 0.33333333333333, 0.15, 0.10416666666667
6545, 0.3125, 0.15, 0.16666666666667
6546, 0.33333333333333, 0.15, 0.14583333333333
6547, 0.3125, 0.15, 0.20833333333333
6548, 0.33333333333333, 0.15, 0.1875
6549, 0.3125, 0.15, 0.25
6550, 0.33333333333333, 0.15, 0.22916666666667
6551, 0.3125, 0.15, 0.29166666666667
6552, 0.33333333333333, 0.15, 0.27083333333333
6553, 0.3125, 0.15, 0.33333333333333
6554, 0.33333333333333, 0.15, 0.3125
6555, 0.3125, 0.15, 0.375
6556, 0.33333333333333, 0.15, 0.35416666666667
6557, 0.3125, 0.15, 0.41666666666667
6558, 0.33333333333333, 0.15, 0.39583333333333
6559, 0.3125, 0.15, 0.45833333333333
6560, 0.33333333333333, 0.15, 0.4375
6561, 0.33333333333333, 0.15, 0.47916666666667
6562, 0.35416666666667, 0.15, 0.041666666666667
6563, 0.375, 0.15, 0.020833333333333
6564, 0.35416666666667, 0.15, 0.083333333333333
6565, 0.375, 0.15, 0.0625
6566, 0.35416666666667, 0.15, 0.125
6567, 0.375, 0.15, 0.10416666666667
6568, 0.35416666666667, 0.15, 0.16666666666667
6569, 0.375, 0.15, 0.14583333333333
6570, 0.35416666666667, 0.15, 0.20833333333333
6571, 0.375, 0.15, 0.1875
6572, 0.35416666666667, 0.15, 0.25
6573, 0.375, 0.15, 0.22916666666667
6574, 0.35416666666667, 0.15, 0.29166666666667
6575, 0.375, 0.15, 0.27083333333333
6576, 0.35416666666667, 0.15, 0.33333333333333
6577, 0.375, 0.15, 0.3125
6578, 0.35416666666667, 0.15, 0.375
6579, 0.375, 0.15, 0.35416666666667
6580, 0.35416666666667, 0.15, 0.41666666666667
6581, 0.375, 0.15, 0.39583333333333
6582, 0.35416666666667, 0.15, 0.45833333333333
6583, 0.375, 0.15, 0.4375
6584, 0.375, 0.15, 0.47916666666667
6585, 0.39583333333333, 0.15, 0.041666666666667
6586, 0.41666666666667, 0.15, 0.020833333333333
6587, 0.39583333333333, 0.15, 0.083333333333333
6588, 0.41666666666667, 0.15, 0.0625
6589, 0.39583333333333, 0.15, 0.125
6590, 0.41666666666667, 0.15, 0.10416666666667
6591, 0.39583333333333, 0.15, 0.16666666666667
6592, 0.41666666666667, 0.15, 0.14583333333333
6593, 0.39583333333333, 0.15, 0.20833333333333
6594, 0.41666666666667, 0.15, 0.1875
6595, 0.39583333333333, 0.15, 0.25
6596, 0.41666666666667, 0.15, 0.22916666666667
6597, 0.39583333333333, 0.15, 0.29166666666667
6598, 0.41666666666667, 0.15, 0.27083333333333
6599, 0.39583333333333, 0.15, 0.33333333333333
6600, 0.41666666666667, 0.15, 0.3125
6601, 0.39583333333333, 0.15, 0.375
6602, 0.41666666666667, 0.15, 0.35416666666667
6603, 0.39583333333333, 0.15, 0.41666666666667
6604, 0.41666666666667, 0.15, 0.39583333333333
6605, 0.39583333333333, 0.15, 0.45833333333333
6606, 0.41666666666667, 0.15, 0.4375
6607, 0.41666666666667, 0.15, 0.47916666666667
6608, 0.4375, 0.15, 0.041666666666667
6609, 0.45833333333333, 0.15, 0.020833333333333
6610, 0.4375, 0.15, 0.083333333333333
6611, 0.45833333333333, 0.15, 0.0625
6612, 0.4375, 0.15, 0.125
6613, 0.45833333333333, 0.15, 0.10416666666667
6614, 0.4375, 0.15, 0.16666666666667
6615, 0.45833333333333, 0.15, 0.14583333333333
6616, 0.4375, 0.15, 0.20833333333333
6617, 0.45833333333333, 0.15, 0.1875
6618, 0.4375, 0.15, 0.25
6619, 0.45833333333333, 0.15, 0.22916666666667
6620, 0.4375, 0.15, 0.29166666666667
6621, 0.45833333333333, 0.15, 0.27083333333333
6622, 0.4375, 0.15, 0.33333333333333
6623, 0.45833333333333, 0.15, 0.3125
6624, 0.4375, 0.15, 0.375
6625, 0.45833333333333, 0.15, 0.35416666666667
6626, 0.4375, 0.15, 0.41666666666667
6627, 0.45833333333333, 0.15, 0.39583333333333
6628, 0.4375, 0.15, 0.45833333333333
6629, 0.45833333333333, 0.15, 0.4375
6630, 0.45833333333333, 0.15, 0.47916666666667
6631, 0.47916666666667, 0.15, 0.041666666666667
6632, 0.5, 0.15, 0.020833333333333
6633, 0.47916666666667, 0.15, 0.083333333333333
6634, 0.5, 0.15, 0.0625
6635, 0.47916666666667, 0.15, 0.125
6636, 0.5, 0.15, 0.10416666666667
6637, 0.47916666666667, 0.15, 0.16666666666667
6638, 0.5, 0.15, 0.14583333333333
6639, 0.47916666666667, 0.15, 0.20833333333333
6640, 0.5, 0.15, 0.1875
6641, 0.47916666666667, 0.15, 0.25
6642, 0.5, 0.15, 0.22916666666667
6643, 0.47916666666667, 0.15, 0.29166666666667
6644, 0.5, 0.15, 0.27083333333333
6645, 0.47916666666667, 0.15, 0.33333333333333
6646, 0.5, 0.15, 0.3125
6647, 0.47916666666667, 0.15, 0.375
6648, 0.5, 0.15, 0.35416666666667
6649, 0.47916666666667, 0.15, 0.41666666666667
6650, 0.5, 0.15, 0.39583333333333
6651, 0.47916666666667, 0.15, 0.45833333333333
6652, 0.5, 0.15, 0.4375
6653, 0.5, 0.15, 0.47916666666667
6654, 0.52083333333333, 0.15, 0.041666666666667
6655, 0.54166666666667, 0.15, 0.020833333333333
6656, 0.52083333333333, 0.15, 0.083333333333333
6657, 0.54166666666667, 0.15, 0.0625
6658, 0.52083333333333, 0.15, 0.125
6659, 0.54166666666667, 0.15, 0.10416666666667
6660, 0.52083333333333, 0.15, 0.16666666666667
6661, 0.54166666666667, 0.15, 0.14583333333333
6662, 0.52083333333333, 0.15, 0.20833333333333
6663, 0.54166666666667, 0.15, 0.1875
6664, 0.52083333333333, 0.15, 0.25
6665, 0.54166666666667, 0.15, 0.22916666666667
6666, 0.52083333333333, 0.15, 0.29166666666667
6667, 0.54166666666667, 0.15, 0.27083333333333
6668, 0.52083333333333, 0.15, 0.33333333333333
6669, 0.54166666666667, 0.15, 0.3125
6670, 0.52083333333333, 0.15, 0.375
6671, 0.54166666666667, 0.15, 0.35416666666667
6672, 0.52083333333333, 0.15, 0.41666666666667
6673, 0.54166666666667, 0.15, 0.39583333333333
6674, 0.52083333333333, 0.15, 0.45833333333333
6675, 0.54166666666667, 0.15, 0.4375
6676, 0.54166666666667, 0.15, 0.47916666666667
6677, 0.5625, 0.15, 0.041666666666667
6678, 0.58333333333333, 0.15, 0.020833333333333
6679, 0.5625, 0.15, 0.083333333333333
6680, 0.58333333333333, 0.15, 0.0625
6681, 0.5625, 0.15, 0.125
6682, 0.58333333333333, 0.15, 0.10416666666667
6683, 0.5625, 0.15, 0.16666666666667
6684, 0.58333333333333, 0.15, 0.14583333333333
6685, 0.5625, 0.15, 0.20833333333333
6686, 0.58333333333333, 0.15, 0.1875
6687, 0.5625, 0.15, 0.25
6688, 0.58333333333333, 0.15, 0.22916666666667
6689, 0.5625, 0.15, 0.29166666666667
6690, 0.58333333333333, 0.15, 0.27083333333333
6691, 0.5625, 0.15, 0.33333333333333
6692, 0.58333333333333, 0.15, 0.3125
6693, 0.5625, 0.15, 0.375
6694, 0.58333333333333, 0.15, 0.35416666666667
6695, 0.5625, 0.15, 0.41666666666667
6696, 0.58333333333333, 0.15, 0.39583333333333
6697, 0.5625, 0.15, 0.45833333333333
6698, 0.58333333333333, 0.15, 0.4375
6699, 0.58333333333333, 0.15, 0.47916666666667
6700, 0.60416666666667, 0.15, 0.041666666666667
6701, 0.625, 0.15, 0.020833333333333
6702, 0.60416666666667, 0.15, 0.083333333333333
6703, 0.625, 0.15, 0.0625
6704, 0.60416666666667, 0.15, 0.125
6705, 0.625, 0.15, 0.10416666666667
6706, 0.60416666666667, 0.15, 0.16666666666667
6707, 0.625, 0.15, 0.14583333333333
6708, 0.60416666666667, 0.15, 0.20833333333333
6709, 0.625, 0.15, 0.1875
6710, 0.60416666666667, 0.15, 0.25
6711, 0.625, 0.15, 0.22916666666667
6712, 0.60416666666667, 0.15, 0.29166666666667
6713, 0.625, 0.15, 0.27083333333333
6714, 0.60416666666667, 0.15, 0.33333333333333
6715, 0.625, 0.15, 0.3125
6716, 0.60416666666667, 0.15, 0.375
6717, 0.625, 0.15, 0.35416666666667
6718, 0.60416666666667, 0.15, 0.41666666666667
6719, 0.625, 0.15, 0.39583333333333
6720, 0.60416666666667, 0.15, 0.45833333333333
6721, 0.625, 0.15, 0.4375
6722, 0.625, 0.15, 0.47916666666667
6723, 0.64583333333333, 0.15, 0.041666666666667
6724, 0.66666666666667, 0.15, 0.020833333333333
6725, 0.64583333333333, 0.15, 0.083333333333333
6726, 0.66666666666667, 0.15, 0.0625
6727, 0.64583333333333, 0.15, 0.125
6728, 0.66666666666667, 0.15, 0.10416666666667
6729, 0.64583333333333, 0.15, 0.16666666666667
6730, 0.66666666666667, 0.15, 0.14583333333333
6731, 0.64583333333333, 0.15, 0.20833333333333
6732, 0.66666666666667, 0.15, 0.1875
6733, 0.64583333333333, 0.15, 0.25
6734, 0.66666666666667, 0.15, 0.22916666666667
6735, 0.64583333333333, 0.15, 0.29166666666667
6736, 0.66666666666667, 0.15, 0.27083333333333
6737, 0.64583333333333, 0.15, 0.33333333333333
6738, 0.66666666666667, 0.15, 0.3125
6739, 0.64583333333333, 0.15, 0.375
6740, 0.66666666666667, 0.15, 0.35416666666667
6741, 0.64583333333333, 0.15, 0.41666666666667
6742, 0.66666666666667, 0.15, 0.39583333333333
6743, 0.64583333333333, 0.15, 0.45833333333333
6744, 0.66666666666667, 0.15, 0.4375
6745, 0.66666666666667, 0.15, 0.47916666666667
6746, 0.6875, 0.15, 0.041666666666667
6747, 0.70833333333333, 0.15, 0.020833333333333
6748, 0.6875, 0.15, 0.083333333333333
6749, 0.70833333333333, 0.15, 0.0625
6750, 0.6875, 0.15, 0.125
6751, 0.70833333333333, 0.15, 0.10416666666667
6752, 0.6875, 0.15, 0.16666666666667
6753, 0.70833333333333, 0.15, 0.14583333333333
6754, 0.6875, 0.15, 0.20833333333333
6755, 0.70833333333333, 0.15, 0.1875
6756, 0.6875, 0.15, 0.25
6757, 0.70833333333333, 0.15, 0.22916666666667
6758, 0.6875, 0.15, 0.29166666666667
6759, 0.70833333333333, 0.15, 0.27083333333333
6760, 0.6875, 0.15, 0.33333333333333
6761, 0.70833333333333, 0.15, 0.3125
6762, 0.6875, 0.15, 0.375
6763, 0.70833333333333, 0.15, 0.35416666666667
6764, 0.6875, 0.15, 0.41666666666667
6765, 0.70833333333333, 0.15, 0.39583333333333
6766, 0.6875, 0.15, 0.45833333333333
6767, 0.70833333333333, 0.15, 0.4375
6768, 0.70833333333333, 0.15, 0.47916666666667
6769, 0.72916666666667, 0.15, 0.041666666666667
6770, 0.75, 0.15, 0.020833333333333
6771, 0.72916666666667, 0.15, 0.083333333333333
6772, 0.75, 0.15, 0.0625
6773, 0.72916666666667, 0.15, 0.125
6774, 0.75, 0.15, 0.10416666666667
6775, 0.72916666666667, 0.15, 0.16666666666667
6776, 0.75, 0.15, 0.14583333333333
6777, 0.72916666666667, 0.15, 0.20833333333333
6778, 0.75, 0.15, 0.1875
6779, 0.72916666666667, 0.15, 0.25
6780, 0.75, 0.15, 0.22916666666667
6781, 0.72916666666667, 0.15, 0.29166666666667
6782, 0.75, 0.15, 0.27083333333333
6783, 0.72916666666667, 0.15, 0.33333333333333
6784, 0.75, 0.15, 0.3125
6785, 0.72916666666667, 0.15, 0.375
6786, 0.75, 0.15, 0.35416666666667
6787, 0.72916666666667, 0.15, 0.41666666666667
6788, 0.75, 0.15, 0.39583333333333
6789, 0.72916666666667, 0.15, 0.45833333333333
6790, 0.75, 0.15, 0.4375
6791, 0.75, 0.15, 0.47916666666667
6792, 0.77083333333333, 0.15, 0.041666666666667
6793, 0.79166666666667, 0.15, 0.020833333333333
6794, 0.77083333333333, 0.15, 0.083333333333333
6795, 0.79166666666667, 0.15, 0.0625
6796, 0.77083333333333, 0.15, 0.125
6797, 0.79166666666667, 0.15, 0.10416666666667
6798, 0.77083333333333, 0.15, 0.16666666666667
6799, 0.79166666666667, 0.15, 0.14583333333333
6800, 0.77083333333333, 0.15, 0.20833333333333
6801, 0.79166666666667, 0.15, 0.1875
6802, 0.77083333333333, 0.15, 0.25
6803, 0.79166666666667, 0.15, 0.22916666666667
6804, 0.77083333333333, 0.15, 0.29166666666667
6805, 0.79166666666667, 0.15, 0.27083333333333
6806, 0.77083333333333, 0.15, 0.33333333333333
6807, 0.79166666666667, 0.15, 0.3125
6808, 0.77083333333333, 0.15, 0.375
6809, 0.79166666666667, 0.15, 0.35416666666667
6810, 0.77083333333333, 0.15, 0.41666666666667
6811, 0.79166666666667, 0.15, 0.39583333333333
6812, 0.77083333333333, 0.15, 0.45833333333333
6813, 0.79166666666667, 0.15, 0.4375
6814, 0.79166666666667, 0.15, 0.47916666666667
6815, 0.8125, 0.15, 0.041666666666667
6816, 0.83333333333333, 0.15, 0.020833333333333
6817, 0.8125, 0.15, 0.083333333333333
6818, 0.83333333333333, 0.15, 0.0625
6819, 0.8125, 0.15, 0.125
6820, 0.83333333333333, 0.15, 0.10416666666667
6821, 0.8125, 0.15, 0.16666666666667
6822, 0.83333333333333, 0.15, 0.14583333333333
6823, 0.8125, 0.15, 0.20833333333333
6824, 0.83333333333333, 0.15, 0.1875
6825, 0.8125, 0.15, 0.25
6826, 0.83333333333333, 0.15, 0.22916666666667
6827, 0.8125, 0.15, 0.29166666666667
6828, 0.83333333333333, 0.15, 0.27083333333333
6829, 0.8125, 0.15, 0.33333333333333
6830, 0.83333333333333, 0.15, 0.3125
6831, 0.8125, 0.15, 0.375
6832, 0.83333333333333, 0.15, 0.35416666666667
6833, 0.8125, 0.15, 0.41666666666667
6834, 0.83333333333333, 0.15, 0.39583333333333
6835, 0.8125, 0.15, 0.45833333333333
6836, 0.83333333333333, 0.15, 0.4375
6837, 0.83333333333333, 0.15, 0.47916666666667
6838, 0.85416666666667, 0.15, 0.041666666666667
6839, 0.875, 0.15, 0.020833333333333
6840, 0.85416666666667, 0.15, 0.083333333333333
6841, 0.875, 0.15, 0.0625
6842, 0.85416666666667, 0.15, 0.125
6843, 0.875, 0.15, 0.10416666666667
6844, 0.85416666666667, 0.15, 0.16666666666667
6845, 0.875, 0.15, 0.14583333333333
6846, 0.85416666666667, 0.15, 0.20833333333333
6847, 0.875, 0.15, 0.1875
6848, 0.85416666666667, 0.15, 0.25
6849, 0.875, 0.15, 0.22916666666667
6850, 0.85416666666667, 0.15, 0.29166666666667
6851, 0.875, 0.15, 0.27083333333333
6852, 0.85416666666667, 0.15, 0.33333333333333
6853, 0.875, 0.15, 0.3125
6854, 0.85416666666667, 0.15, 0.375
6855, 0.875, 0.15, 0.35416666666667
6856, 0.85416666666667, 0.15, 0.41666666666667
6857, 0.875, 0.15, 0.39583333333333
6858, 0.85416666666667, 0.15, 0.45833333333333
6859, 0.875, 0.15, 0.4375
6860, 0.875, 0.15, 0.47916666666667
6861, 0.89583333333333, 0.15, 0.041666666666667
6862, 0.91666666666667, 0.15, 0.020833333333333
6863, 0.89583333333333, 0.15, 0.083333333333333
6864, 0.91666666666667, 0.15, 0.0625
6865, 0.89583333333333, 0.15, 0.125
6866, 0.91666666666667, 0.15, 0.10416666666667
6867, 0.89583333333333, 0.15, 0.16666666666667
6868, 0.91666666666667, 0.15, 0.14583333333333
6869, 0.89583333333333, 0.15, 0.20833333333333
6870, 0.91666666666667, 0.15, 0.1875
6871, 0.89583333333333, 0.15, 0.25
6872, 0.91666666666667, 0.15, 0.22916666666667
6873, 0.89583333333333, 0.15, 0.29166666666667
6874, 0.91666666666667, 0.15, 0.27083333333333
6875, 0.89583333333333, 0.15, 0.33333333333333
6876, 0.91666666666667, 0.15, 0.3125
6877, 0.89583333333333, 0.15, 0.375
6878, 0.91666666666667, 0.15, 0.35416666666667
6879, 0.89583333333333, 0.15, 0.41666666666667
6880, 0.91666666666667, 0.15, 0.39583333333333
6881, 0.89583333333333, 0.15, 0.45833333333333
6882, 0.91666666666667, 0.15, 0.4375
6883, 0.91666666666667, 0.15, 0.47916666666667
6884, 0.9375, 0.15, 0.041666666666667
6885, 0.95833333333333, 0.15, 0.020833333333333
6886, 0.9375, 0.15, 0.083333333333333
6887, 0.95833333333333, 0.15, 0.0625
6888, 0.9375, 0.15, 0.125
6889, 0.95833333333333, 0.15, 0.10416666666667
6890, 0.9375, 0.15, 0.16666666666667
6891, 0.95833333333333, 0.15, 0.14583333333333
6892, 0.9375, 0.15, 0.20833333333333
6893, 0.95833333333333, 0.15, 0.1875
6894, 0.9375, 0.15, 0.25
6895, 0.95833333333333, 0.15, 0.22916666666667
6896, 0.9375, 0.15, 0.29166666666667
6897, 0.95833333333333, 0.15, 0.27083333333333
6898, 0.9375, 0.15, 0.33333333333333
6899, 0.95833333333333, 0.15, 0.3125
6900, 0.9375, 0.15, 0.375
6901, 0.95833333333333, 0.15, 0.35416666666667
6902, 0.9375, 0.15, 0.41666666666667
6903, 0.95833333333333, 0.15, 0.39583333333333
6904, 0.9375, 0.15, 0.45833333333333
6905, 0.95833333333333, 0.15, 0.4375
6906, 0.95833333333333, 0.15, 0.47916666666667
6907, 0.97916666666667, 0.15, 0.041666666666667
6908, 0.97916666666667, 0.15, 0.083333333333333
6909, 0.97916666666667, 0.15, 0.125
6910, 0.97916666666667, 0.15, 0.16666666666667
6911, 0.97916666666667, 0.15, 0.20833333333333
6912, 0.97916666666667, 0.15, 0.25
6913, 0.97916666666667, 0.15, 0.29166666666667
6914, 0.97916666666667, 0.15, 0.33333333333333
6915, 0.97916666666667, 0.15, 0.375
6916, 0.97916666666667, 0.15, 0.41666666666667
6917, 0.97916666666667, 0.15, 0.45833333333333
6918, 0.041666666666667, 0.2, 0
6919, 0.041666666666667, 0.25, 0
6920, 0.041666666666667, 0.3, 0
6921, 0.041666666666667, 0.35, 0
6922, 0.041666666666667, 0.4, 0
6923, 0.041666666666667, 0.45, 0
6924, 0.041666666666667, 0.5, 0
6925, 0.041666666666667, 0.55, 0
6926, 0.041666666666667, 0.6, 0
6927, 0.041666666666667, 0.65, 0
6928, 0.041666666666667, 0.7, 0
6929, 0.041666666666667, 0.75, 0
6930, 0.041666666666667, 0.8, 0
6931, 0.041666666666667, 0.85, 0
6932, 0.041666666666667, 0.9, 0
6933, 0.041666666666667, 0.95, 0
6934, 0.041666666666667, 1, 0
6935, 0.041666666666667, 1.05, 0
6936, 0.041666666666667, 1.1, 0
6937, 0.041666666666667, 1.15, 0
6938, 0.041666666666667, 1.2, 0
6939, 0.041666666666667, 1.25, 0
6940, 0.041666666666667, 1.3, 0
6941, 0.083333333333333, 0.2, 0
6942, 0.083333333333333, 0.25, 0
6943, 0.083333333333333, 0.3, 0
6944, 0.083333333333333, 0.35, 0
6945, 0.083333333333333, 0.4, 0
6946, 0.083333333333333, 0.45, 0
6947, 0.083333333333333, 0.5, 0
6948, 0.083333333333333, 0.55, 0
6949, 0.083333333333333, 0.6, 0
6950, 0.083333333333333, 0.65, 0
6951, 0.083333333333333, 0.7, 0
6952, 0.083333333333333, 0.75, 0
6953, 0.083333333333333, 0.8, 0
6954, 0.083333333333333, 0.85, 0
6955, 0.083333333333333, 0.9, 0
6956, 0.083333333333333, 0.95, 0
6957, 0.083333333333333, 1, 0
6958, 0.083333333333333, 1.05, 0
6959, 0.083333333333333, 1.1, 0
6960, 0.083333333333333, 1.15, 0
6961, 0.083333333333333, 1.2, 0
6962, 0.083333333333333, 1.25, 0
6963, 0.083333333333333, 1.3, 0
6964, 0.125, 0.2, 0
6965, 0.125, 0.25, 0
6966, 0.125, 0.3, 0
6967, 0.125, 0.35, 0
6968, 0.125, 0.4, 0
6969, 0.125, 0.45, 0
6970, 0.125, 0.5, 0
6971, 0.125, 0.55, 0
6972, 0.125, 0.6, 0
6973, 0.125, 0.65, 0
6974, 0.125, 0.7, 0
6975, 0.125, 0.75, 0
6976, 0.125, 0.8, 0
6977, 0.125, 0.85, 0
6978, 0.125, 0.9, 0
6979, 0.125, 0.95, 0
6980, 0.125, 1, 0
6981, 0.125, 1.05, 0
6982, 0.125, 1.1, 0
6983, 0.125, 1.15, 0
6984, 0.125, 1.2, 0
6985, 0.125, 1.25, 0
6986, 0.125, 1.3, 0
6987, 0.16666666666667, 0.2, 0
6988, 0.16666666666667, 0.25, 0
6989, 0.16666666666667, 0.3, 0
6990, 0.16666666666667, 0.35, 0
6991, 0.16666666666667, 0.4, 0
6992, 0.16666666666667, 0.45, 0
6993, 0.16666666666667, 0.5, 0
6994, 0.16666666666667, 0.55, 0
6995, 0.16666666666667, 0.6, 0
6996, 0.16666666666667, 0.65, 0
6997, 0.16666666666667, 0.7, 0
6998, 0.16666666666667, 0.75, 0
6999, 0.16666666666667, 0.8, 0
7000, 0.16666666666667, 0.85, 0
7001, 0.16666666666667, 0.9, 0
7002, 0.16666666666667, 0.95, 0
7003, 0.16666666666667, 1, 0
7004, 0.16666666666667, 1.05, 0
7005, 0.16666666666667, 1.1, 0
7006, 0.16666666666667, 1.15, 0
7007, 0.16666666666667, 1.2, 0
7008, 0.16666666666667, 1.25, 0
7009, 0.16666666666667, 1.3, 0
7010, 0.20833333333333, 0.2, 0
7011, 0.20833333333333, 0.25, 0
7012, 0.20833333333333, 0.3, 0
7013, 0.20833333333333, 0.35, 0
7014, 0.20833333333333, 0.4, 0
7015, 0.20833333333333, 0.45, 0
7016, 0.20833333333333, 0.5, 0
7017, 0.20833333333333, 0.55, 0
7018, 0.20833333333333, 0.6, 0
7019, 0.20833333333333, 0.65, 0
7020, 0.20833333333333, 0.7, 0
7021, 0.20833333333333, 0.75, 0
7022, 0.20833333333333, 0.8, 0
7023, 0.20833333333333, 0.85, 0
7024, 0.20833333333333, 0.9, 0
7025, 0.20833333333333, 0.95, 0
7026, 0.20833333333333, 1, 0
7027, 0.20833333333333, 1.05, 0
7028, 0.20833333333333, 1.1, 0
7029, 0.20833333333333, 1.15, 0
7030, 0.20833333333333, 1.2, 0
7031, 0.20833333333333, 1.25, 0
7032, 0.20833333333333, 1.3, 0
7033, 0.25, 0.2, 0
7034, 0.25, 0.25, 0
7035, 0.25, 0.3, 0
7036, 0.25, 0.35, 0
7037, 0.25, 0.4, 0
7038, 0.25, 0.45, 0
7039, 0.25, 0.5, 0
7040, 0.25, 0.55, 0
7041, 0.25, 0.6, 0
7042, 0.25, 0.65, 0
7043, 0.25, 0.7, 0
7044, 0.25, 0.75, 0
7045, 0.25, 0.8, 0
7046, 0.25, 0.85, 0
7047, 0.25, 0.9, 0
7048, 0.25, 0.95, 0
7049, 0.25, 1, 0
7050, 0.25, 1.05, 0
7051, 0.25, 1.1, 0
7052, 0.25, 1.15, 0
7053, 0.25, 1.2, 0
7054, 0.25, 1.25, 0
7055, 0.25, 1.3, 0
7056, 0.29166666666667, 0.2, 0
7057, 0.29166666666667, 0.25, 0
7058, 0.29166666666667, 0.3, 0
7059, 0.29166666666667, 0.35, 0
7060, 0.29166666666667, 0.4, 0
7061, 0.29166666666667, 0.45, 0
7062, 0.29166666666667, 0.5, 0
7063, 0.29166666666667, 0.55, 0
7064, 0.29166666666667, 0.6, 0
7065, 0.29166666666667, 0.65, 0
7066, 0.29166666666667, 0.7, 0
7067, 0.29166666666667, 0.75, 0
7068, 0.29166666666667, 0.8, 0
7069, 0.29166666666667, 0.85, 0
7070, 0.29166666666667, 0.9, 0
7071, 0.29166666666667, 0.95, 0
7072, 0.29166666666667, 1, 0
7073, 0.29166666666667, 1.05, 0
7074, 0.29166666666667, 1.1, 0
7075, 0.29166666666667, 1.15, 0
7076, 0.29166666666667, 1.2, 0
7077, 0.29166666666667, 1.25, 0
7078, 0.29166666666667, 1.3, 0
7079, 0.33333333333333, 0.2, 0
7080, 0.33333333333333, 0.25, 0
7081, 0.33333333333333, 0.3, 0
7082, 0.33333333333333, 0.35, 0
7083, 0.33333333333333, 0.4, 0
7084, 0.33333333333333, 0.45, 0
7085, 0.33333333333333, 0.5, 0
7086, 0.33333333333333, 0.55, 0
7087, 0.33333333333333, 0.6, 0
7088, 0.33333333333333, 0.65, 0
7089, 0.33333333333333, 0.7, 0
7090, 0.33333333333333, 0.75, 0
7091, 0.33333333333333, 0.8, 0
7092, 0.33333333333333, 0.85, 0
7093, 0.33333333333333, 0.9, 0
7094, 0.33333333333333, 0.95, 0
7095, 0.33333333333333, 1, 0
7096, 0.33333333333333, 1.05, 0
7097, 0.33333333333333, 1.1, 0
7098, 0.33333333333333, 1.15, 0
7099, 0.33333333333333, 1.2, 0
7100, 0.33333333333333, 1.25, 0
7101, 0.33333333333333, 1.3, 0
7102, 0.375, 0.2, 0
7103, 0.375, 0.25, 0
7104, 0.375, 0.3, 0
7105, 0.375, 0.35, 0
7106, 0.375, 0.4, 0
7107, 0.375, 0.45, 0
7108, 0.375, 0.5, 0
7109, 0.375, 0.55, 0
7110, 0.375, 0.6, 0
7111, 0.375, 0.65, 0
7112, 0.375, 0.7, 0
7113, 0.375, 0.75, 0
7114, 0.375, 0.8, 0
7115, 0.375, 0.85, 0
7116, 0.375, 0.9, 0
7117, 0.375, 0.95, 0
7118, 0.375, 1, 0
7119, 0.375, 1.05, 0
7120, 0.375, 1.1, 0
7121, 0.375, 1.15, 0
7122, 0.375, 1.2, 0
7123, 0.375, 1.25, 0
7124, 0.375, 1.3, 0
7125, 0.41666666666667, 0.2, 0
7126, 0.41666666666667, 0.25, 0
7127, 0.41666666666667, 0.3, 0
7128, 0.41666666666667, 0.35, 0
7129, 0.41666666666667, 0.4, 0
7130, 0.41666666666667, 0.45, 0
7131, 0.41666666666667, 0.5, 0
7132, 0.41666666666667, 0.55, 0
7133, 0.41666666666667, 0.6, 0
7134, 0.41666666666667, 0.65, 0
7135, 0.41666666666667, 0.7, 0
7136, 0.41666666666667, 0.75, 0
7137, 0.41666666666667, 0.8, 0
7138, 0.41666666666667, 0.85, 0
7139, 0.41666666666667, 0.9, 0
7140, 0.41666666666667, 0.95, 0
7141, 0.41666666666667, 1, 0
7142, 0.41666666666667, 1.05, 0
7143, 0.41666666666667, 1.1, 0
7144, 0.41666666666667, 1.15, 0
7145, 0.41666666666667, 1.2, 0
7146, 0.41666666666667, 1.25, 0
7147, 0.41666666666667, 1.3, 0
7148, 0.45833333333333, 0.2, 0
7149, 0.45833333333333, 0.25, 0
7150, 0.45833333333333, 0.3, 0
7151, 0.45833333333333, 0.35, 0
7152, 0.45833333333333, 0.4, 0
7153, 0.45833333333333, 0.45, 0
7154, 0.45833333333333, 0.5, 0
7155, 0.45833333333333, 0.55, 0
7156, 0.45833333333333, 0.6, 0
7157, 0.45833333333333, 0.65, 0
7158, 0.45833333333333, 0.7, 0
7159, 0.45833333333333, 0.75, 0
7160, 0.45833333333333, 0.8, 0
7161, 0.45833333333333, 0.85, 0
7162, 0.45833333333333, 0.9, 0
7163, 0.45833333333333, 0.95, 0
7164, 0.45833333333333, 1, 0
7165, 0.45833333333333, 1.05, 0
7166, 0.45833333333333, 1.1, 0
7167, 0.45833333333333, 1.15, 0
7168, 0.45833333333333, 1.2, 0
7169, 0.45833333333333, 1.25, 0
7170, 0.45833333333333, 1.3, 0
7171, 0.5, 0.2, 0
7172, 0.5, 0.25, 0
7173, 0.5, 0.3, 0
7174, 0.5, 0.35, 0
7175, 0.5, 0.4, 0
7176, 0.5, 0.45, 0
7177, 0.5, 0.5, 0
7178, 0.5, 0.55, 0
7179, 0.5, 0.6, 0
7180, 0.5, 0.65, 0
7181, 0.5, 0.7, 0
7182, 0.5, 0.75, 0
7183, 0.5, 0.8, 0
7184, 0.5, 0.85, 0
7185, 0.5, 0.9, 0
7186, 0.5, 0.95, 0
7187, 0.5, 1, 0
7188, 0.5, 1.05, 0
7189, 0.5, 1.1, 0
7190, 0.5, 1.15, 0
7191, 0.5, 1.2, 0
7192, 0.5, 1.25, 0
7193, 0.5, 1.3, 0
7194, 0.54166666666667, 0.2, 0
7195, 0.54166666666667, 0.25, 0
7196, 0.54166666666667, 0.3, 0
7197, 0.54166666666667, 0.35, 0
7198, 0.54166666666667, 0.4, 0
7199, 0.54166666666667, 0.45, 0
7200, 0.54166666666667, 0.5, 0
7201, 0.54166666666667, 0.55, 0
7202, 0.54166666666667, 0.6, 0
7203, 0.54166666666667, 0.65, 0
7204, 0.54166666666667, 0.7, 0
7205, 0.54166666666667, 0.75, 0
7206, 0.54166666666667, 0.8, 0
7207, 0.54166666666667, 0.85, 0
7208, 0.54166666666667, 0.9, 0
7209, 0.54166666666667, 0.95, 0
7210, 0.54166666666667, 1, 0
7211, 0.54166666666667, 1.05, 0
7212, 0.54166666666667, 1.1, 0
7213, 0.54166666666667, 1.15, 0
7214, 0.54166666666667, 1.2, 0
7215, 0.54166666666667, 1.25, 0
7216, 0.54166666666667, 1.3, 0
7217, 0.58333333333333, 0.2, 0
7218, 0.58333333333333, 0.25, 0
7219, 0.58333333333333, 0.3, 0
7220, 0.58333333333333, 0.35, 0
7221, 0.58333333333333, 0.4, 0
7222, 0.58333333333333, 0.45, 0
7223, 0.58333333333333, 0.5, 0
7224, 0.58333333333333, 0.55, 0
7225, 0.58333333333333, 0.6, 0
7226, 0.58333333333333, 0.65, 0
7227, 0.58333333333333, 0.7, 0
7228, 0.58333333333333, 0.75, 0
7229, 0.58333333333333, 0.8, 0
7230, 0.58333333333333, 0.85, 0
7231, 0.58333333333333, 0.9, 0
7232, 0.58333333333333, 0.95, 0
7233, 0.58333333333333, 1, 0
7234, 0.58333333333333, 1.05, 0
7235, 0.58333333333333, 1.1, 0
7236, 0.58333333333333, 1.15, 0
7237, 0.58333333333333, 1.2, 0
7238, 0.58333333333333, 1.25, 0
7239, 0.58333333333333, 1.3, 0
7240, 0.625, 0.2, 0
7241, 0.625, 0.25, 0
7242, 0.625, 0.3, 0
7243, 0.625, 0.35, 0
7244, 0.625, 0.4, 0
7245, 0.625, 0.45, 0
7246, 0.625, 0.5, 0
7247, 0.625, 0.55, 0
7248, 0.625, 0.6, 0
7249, 0.625, 0.65, 0
7250, 0.625, 0.7, 0
7251, 0.625, 0.75, 0
7252, 0.625, 0.8, 0
7253, 0.625, 0.85, 0
7254, 0.625, 0.9, 0
7255, 0.625, 0.95, 0
7256, 0.625, 1, 0
7257, 0.625, 1.05, 0
7258, 0.625, 1.1, 0
7259, 0.625, 1.15, 0
7260, 0.625, 1.2, 0
7261, 0.625, 1.25, 0
7262, 0.625, 1.3, 0
7263, 0.66666666666667, 0.2, 0
7264, 0.66666666666667, 0.25, 0
7265, 0.66666666666667, 0.3, 0
7266, 0.66666666666667, 0.35, 0
7267, 0.66666666666667, 0.4, 0
7268, 0.66666666666667, 0.45, 0
7269, 0.66666666666667, 0.5, 0
7270, 0.66666666666667, 0.55, 0
7271, 0.66666666666667, 0.6, 0
7272, 0.66666666666667, 0.65, 0
7273, 0.66666666666667, 0.7, 0
7274, 0.66666666666667, 0.75, 0
7275, 0.66666666666667, 0.8, 0
7276, 0.66666666666667, 0.85, 0
7277, 0.66666666666667, 0.9, 0
7278, 0.66666666666667, 0.95, 0
7279, 0.66666666666667, 1, 0
7280, 0.66666666666667, 1.05, 0
7281, 0.66666666666667, 1.1, 0
7282, 0.66666666666667, 1.15, 0
7283, 0.66666666666667, 1.2, 0
7284, 0.66666666666667, 1.25, 0
7285, 0.66666666666667, 1.3, 0
7286, 0.70833333333333, 0.2, 0
7287, 0.70833333333333, 0.25, 0
7288, 0.70833333333333, 0.3, 0
7289, 0.70833333333333, 0.35, 0
7290, 0.70833333333333, 0.4, 0
7291, 0.70833333333333, 0.45, 0
7292, 0.70833333333333, 0.5, 0
7293, 0.70833333333333, 0.55, 0
7294, 0.70833333333333, 0.6, 0
7295, 0.70833333333333, 0.65, 0
7296, 0.70833333333333, 0.7, 0
7297, 0.70833333333333, 0.75, 0
7298, 0.70833333333333, 0.8, 0
7299, 0.70833333333333, 0.85, 0
7300, 0.70833333333333, 0.9, 0
7301, 0.70833333333333, 0.95, 0
7302, 0.70833333333333, 1, 0
7303, 0.70833333333333, 1.05, 0
7304, 0.70833333333333, 1.1, 0
7305, 0.70833333333333, 1.15, 0
7306, 0.70833333333333, 1.2, 0
7307, 0.70833333333333, 1.25, 0
7308, 0.70833333333333, 1.3, 0
7309, 0.75, 0.2, 0
7310, 0.75, 0.25, 0
7311, 0.75, 0.3, 0
7312, 0.75, 0.35, 0
7313, 0.75, 0.4, 0
7314, 0.75, 0.45, 0
7315, 0.75, 0.5, 0
7316, 0.75, 0.55, 0
7317, 0.75, 0.6, 0
7318, 0.75, 0.65, 0
7319, 0.75, 0.7, 0
7320, 0.75, 0.75, 0
7321, 0.75, 0.8, 0
7322, 0.75, 0.85, 0
7323, 0.75, 0.9, 0
7324, 0.75, 0.95, 0
7325, 0.75, 1, 0
7326, 0.75, 1.05, 0
7327, 0.75, 1.1, 0
7328, 0.75, 1.15, 0
7329, 0.75, 1.2, 0
7330, 0.75, 1.25, 0
7331, 0.75, 1.3, 0
7332, 0.79166666666667, 0.2, 0
7333, 0.79166666666667, 0.25, 0
7334, 0.79166666666667, 0.3, 0
7335, 0.79166666666667, 0.35, 0
7336, 0.79166666666667, 0.4, 0
7337, 0.79166666666667, 0.45, 0
7338, 0.79166666666667, 0.5, 0
7339, 0.79166666666667, 0.55, 0
7340, 0.79166666666667, 0.6, 0
7341, 0.79166666666667, 0.65, 0
7342, 0.79166666666667, 0.7, 0
7343, 0.79166666666667, 0.75, 0
7344, 0.79166666666667, 0.8, 0
7345, 0.79166666666667, 0.85, 0
7346, 0.79166666666667, 0.9, 0
7347, 0.79166666666667, 0.95, 0
7348, 0.79166666666667, 1, 0
7349, 0.79166666666667, 1.05, 0
7350, 0.79166666666667, 1.1, 0
7351, 0.79166666666667, 1.15, 0
7352, 0.79166666666667, 1.2, 0
7353, 0.79166666666667, 1.25, 0
7354, 0.79166666666667, 1.3, 0
7355, 0.83333333333333, 0.2, 0
7356, 0.83333333333333, 0.25, 0
7357, 0.83333333333333, 0.3, 0
7358, 0.83333333333333, 0.35, 0
7359, 0.83333333333333, 0.4, 0
7360, 0.83333333333333, 0.45, 0
7361, 0.83333333333333, 0.5, 0
7362, 0.83333333333333, 0.55, 0
7363, 0.83333333333333, 0.6, 0
7364, 0.83333333333333, 0.65, 0
7365, 0.83333333333333, 0.7, 0
7366, 0.83333333333333, 0.75, 0
7367, 0.83333333333333, 0.8, 0
7368, 0.83333333333333, 0.85, 0
7369, 0.83333333333333, 0.9, 0
7370, 0.83333333333333, 0.95, 0
7371, 0.83333333333333, 1, 0
7372, 0.83333333333333, 1.05, 0
7373, 0.83333333333333, 1.1, 0
7374, 0.83333333333333, 1.15, 0
7375, 0.83333333333333, 1.2, 0
7376, 0.83333333333333, 1.25, 0
7377, 0.83333333333333, 1.3, 0
7378, 0.875, 0.2, 0
7379, 0.875, 0.25, 0
7380, 0.875, 0.3, 0
7381, 0.875, 0.35, 0
7382, 0.875, 0.4, 0
7383, 0.875, 0.45, 0
7384, 0.875, 0.5, 0
7385, 0.875, 0.55, 0
7386, 0.875, 0.6, 0
7387, 0.875, 0.65, 0
7388, 0.875, 0.7, 0
7389, 0.875, 0.75, 0
7390, 0.875, 0.8, 0
7391, 0.875, 0.85, 0
7392, 0.875, 0.9, 0
7393, 0.875, 0.95, 0
7394, 0.875, 1, 0
7395, 0.875, 1.05, 0
7396, 0.875, 1.1, 0
7397, 0.875, 1.15, 0
7398, 0.875, 1.2, 0
7399, 0.875, 1.25, 0
7400, 0.875, 1.3, 0
7401, 0.91666666666667, 0.2, 0
7402, 0.91666666666667, 0.25, 0
7403, 0.91666666666667, 0.3, 0
7404, 0.91666666666667, 0.35, 0
7405, 0.91666666666667, 0.4, 0
7406, 0.91666666666667, 0.45, 0
7407, 0.91666666666667, 0.5, 0
7408, 0.91666666666667, 0.55, 0
7409, 0.91666666666667, 0.6, 0
7410, 0.91666666666667, 0.65, 0
7411, 0.91666666666667, 0.7, 0
7412, 0.91666666666667, 0.75, 0
7413, 0.91666666666667, 0.8, 0
7414, 0.91666666666667, 0.85, 0
7415, 0.91666666666667, 0.9, 0
7416, 0.91666666666667, 0.95, 0
7417, 0.91666666666667, 1, 0
7418, 0.91666666666667, 1.05, 0
7419, 0.91666666666667, 1.1, 0
7420, 0.91666666666667, 1.15, 0
7421, 0.91666666666667, 1.2, 0
7422, 0.91666666666667, 1.25, 0
7423, 0.91666666666667, 1.3, 0
7424, 0.95833333333333, 0.2, 0
7425, 0.95833333333333, 0.25, 0
7426, 0.95833333333333, 0.3, 0
7427, 0.95833333333333, 0.35, 0
7428, 0.95833333333333, 0.4, 0
7429, 0.95833333333333, 0.45, 0
7430, 0.95833333333333, 0.5, 0
7431, 0.95833333333333, 0.55, 0
7432, 0.95833333333333, 0.6, 0
7433, 0.95833333333333, 0.65, 0
7434, 0.95833333333333, 0.7, 0
7435, 0.95833333333333, 0.75, 0
7436, 0.95833333333333, 0.8, 0
7437, 0.95833333333333, 0.85, 0
7438, 0.95833333333333, 0.9, 0
7439, 0.95833333333333, 0.95, 0
7440, 0.95833333333333, 1, 0
7441, 0.95833333333333, 1.05, 0
7442, 0.95833333333333, 1.1, 0
7443, 0.95833333333333, 1.15, 0
7444, 0.95833333333333, 1.2, 0
7445, 0.95833333333333, 1.25, 0
7446, 0.95833333333333, 1.3, 0
7447, 0.020833333333333, 0.2, 0
7448, 0.041666666666667, 0.175, 0
7449, 0.020833333333333, 0.25, 0
7450, 0.041666666666667, 0.225, 0
7451, 0.020833333333333, 0.3, 0
7452, 0.041666666666667, 0.275, 0
7453, 0.020833333333333, 0.35, 0
7454, 0.041666666666667, 0.325, 0
7455, 0.020833333333333, 0.4, 0
7456, 0.041666666666667, 0.375, 0
7457, 0.020833333333333, 0.45, 0
7458, 0.041666666666667, 0.425, 0
7459, 0.020833333333333, 0.5, 0
7460, 0.041666666666667, 0.475, 0
7461, 0.020833333333333, 0.55, 0
7462, 0.041666666666667, 0.525, 0
7463, 0.020833333333333, 0.6, 0
7464, 0.041666666666667, 0.575, 0
7465, 0.020833333333333, 0.65, 0
7466, 0.041666666666667, 0.625, 0
7467, 0.020833333333333, 0.7, 0
7468, 0.041666666666667, 0.675, 0
7469, 0.020833333333333, 0.75, 0
7470, 0.041666666666667, 0.725, 0
7471, 0.020833333333333, 0.8, 0
7472, 0.041666666666667, 0.775, 0
7473, 0.020833333333333, 0.85, 0
7474, 0.041666666666667, 0.825, 0
7475, 0.020833333333333, 0.9, 0
7476, 0.041666666666667, 0.875, 0
7477, 0.020833333333333, 0.95, 0
7478, 0.041666666666667, 0.925, 0
7479, 0.020833333333333, 1, 0
7480, 0.041666666666667, 0.975, 0
7481, 0.020833333333333, 1.05, 0
7482, 0.041666666666667, 1.025, 0
7483, 0.020833333333333, 1.1, 0
7484, 0.041666666666667, 1.075, 0
7485, 0.020833333333333, 1.15, 0
7486, 0.041666666666667, 1.125, 0
7487, 0.020833333333333, 1.2, 0
7488, 0.041666666666667, 1.175, 0
7489, 0.020833333333333, 1.25, 0
7490, 0.041666666666667, 1.225, 0
7491, 0.020833333333333, 1.3, 0
7492, 0.041666666666667, 1.275, 0
7493, 0.041666666666667, 1.325, 0
7494, 0.0625, 0.2, 0
7495, 0.083333333333333, 0.175, 0
7496, 0.0625, 0.25, 0
7497, 0.083333333333333, 0.225, 0
7498, 0.0625, 0.3, 0
7499, 0.083333333333333, 0.275, 0
7500, 0.0625, 0.35, 0
7501, 0.083333333333333, 0.325, 0
7502, 0.0625, 0.4, 0
7503, 0.083333333333333, 0.375, 0
7504, 0.0625, 0.45, 0
7505, 0.083333333333333, 0.425, 0
7506, 0.0625, 0.5, 0
7507, 0.083333333333333, 0.475, 0
7508, 0.0625, 0.55, 0
7509, 0.083333333333333, 0.525, 0
7510, 0.0625, 0.6, 0
7511, 0.083333333333333, 0.575, 0
7512, 0.0625, 0.65, 0
7513, 0.083333333333333, 0.625, 0
7514, 0.0625, 0.7, 0
7515, 0.083333333333333, 0.675, 0
7516, 0.0625, 0.75, 0
7517, 0.083333333333333, 0.725, 0
7518, 0.0625, 0.8, 0
7519, 0.083333333333333, 0.775, 0
7520, 0.0625, 0.85, 0
7521, 0.083333333333333, 0.825, 0
7522, 0.0625, 0.9, 0
7523, 0.083333333333333, 0.875, 0
7524, 0.0625, 0.95, 0
7525, 0.083333333333333, 0.925, 0
7526, 0.0625, 1, 0
7527, 0.083333333333333, 0.975, 0
7528, 0.0625, 1.05, 0
7529, 0.083333333333333, 1.025, 0
7530, 0.0625, 1.1, 0
7531, 0.083333333333333, 1.075, 0
7532, 0.0625, 1.15, 0
7533, 0.083333333333333, 1.125, 0
7534, 0.0625, 1.2, 0
7535, 0.083333333333333, 1.175, 0
7536, 0.0625, 1.25, 0
7537, 0.083333333333333, 1.225, 0
7538, 0.0625, 1.3, 0
7539, 0.083333333333333, 1.275, 0
7540, 0.083333333333333, 1.325, 0
7541, 0.10416666666667, 0.2, 0
7542, 0.125, 0.175, 0
7543, 0.10416666666667, 0.25, 0
7544, 0.125, 0.225, 0
7545, 0.10416666666667, 0.3, 0
7546, 0.125, 0.275, 0
7547, 0.10416666666667, 0.35, 0
7548, 0.125, 0.325, 0
7549, 0.10416666666667, 0.4, 0
7550, 0.125, 0.375, 0
7551, 0.10416666666667, 0.45, 0
7552, 0.125, 0.425, 0
7553, 0.10416666666667, 0.5, 0
7554, 0.125, 0.475, 0
7555, 0.10416666666667, 0.55, 0
7556, 0.125, 0.525, 0
7557, 0.10416666666667, 0.6, 0
7558, 0.125, 0.575, 0
7559, 0.10416666666667, 0.65, 0
7560, 0.125, 0.625, 0
7561, 0.10416666666667, 0.7, 0
7562, 0.125, 0.675, 0
7563, 0.10416666666667, 0.75, 0
7564, 0.125, 0.725, 0
7565, 0.10416666666667, 0.8, 0
7566, 0.125, 0.775, 0
7567, 0.10416666666667, 0.85, 0
7568, 0.125, 0.825, 0
7569, 0.10416666666667, 0.9, 0
7570, 0.125, 0.875, 0
7571, 0.10416666666667, 0.95, 0
7572, 0.125, 0.925, 0
7573, 0.10416666666667, 1, 0
7574, 0.125, 0.975, 0
7575, 0.10416666666667, 1.05, 0
7576, 0.125, 1.025, 0
7577, 0.10416666666667, 1.1, 0
7578, 0.125, 1.075, 0
7579, 0.10416666666667, 1.15, 0
7580, 0.125, 1.125, 0
7581, 0.10416666666667, 1.2, 0
7582, 0.125, 1.175, 0
7583, 0.10416666666667, 1.25, 0
7584, 0.125, 1.225, 0
7585, 0.10416666666667, 1.3, 0
7586, 0.125, 1.275, 0
7587, 0.125, 1.325, 0
7588, 0.14583333333333, 0.2, 0
7589, 0.16666666666667, 0.175, 0
7590, 0.14583333333333, 0.25, 0
7591, 0.16666666666667, 0.225, 0
7592, 0.14583333333333, 0.3, 0
7593, 0.16666666666667, 0.275, 0
7594, 0.14583333333333, 0.35, 0
7595, 0.16666666666667, 0.325, 0
7596, 0.14583333333333, 0.4, 0
7597, 0.16666666666667, 0.375, 0
7598, 0.14583333333333, 0.45, 0
7599, 0.16666666666667, 0.425, 0
7600, 0.14583333333333, 0.5, 0
7601, 0.16666666666667, 0.475, 0
7602, 0.14583333333333, 0.55, 0
7603, 0.16666666666667, 0.525, 0
7604, 0.14583333333333, 0.6, 0
7605, 0.16666666666667, 0.575, 0
7606, 0.14583333333333, 0.65, 0
7607, 0.16666666666667, 0.625, 0
7608, 0.14583333333333, 0.7, 0
7609, 0.16666666666667, 0.675, 0
7610, 0.14583333333333, 0.75, 0
7611, 0.16666666666667, 0.725, 0
7612, 0.14583333333333, 0.8, 0
7613, 0.16666666666667, 0.775, 0
7614, 0.14583333333333, 0.85, 0
7615, 0.16666666666667, 0.825, 0
7616, 0.14583333333333, 0.9, 0
7617, 0.16666666666667, 0.875, 0
7618, 0.14583333333333, 0.95, 0
7619, 0.16666666666667, 0.925, 0
7620, 0.14583333333333, 1, 0
7621, 0.16666666666667, 0.975, 0
7622, 0.14583333333333, 1.05, 0
7623, 0.16666666666667, 1.025, 0
7624, 0.14583333333333, 1.1, 0
7625, 0.16666666666667, 1.075, 0
7626, 0.14583333333333, 1.15, 0
7627, 0.16666666666667, 1.125, 0
7628, 0.14583333333333, 1.2, 0
7629, 0.16666666666667, 1.175, 0
7630, 0.14583333333333, 1.25, 0
7631, 0.16666666666667, 1.225, 0
7632, 0.14583333333333, 1.3, 0
7633, 0.16666666666667, 1.275, 0
7634, 0.16666666666667, 1.325, 0
7635, 0.1875, 0.2, 0
7636, 0.20833333333333, 0.175, 0
7637, 0.1875, 0.25, 0
7638, 0.20833333333333, 0.225, 0
7639, 0.1875, 0.3, 0
7640, 0.20833333333333, 0.275, 0
7641, 0.1875, 0.35, 0
7642, 0.20833333333333, 0.325, 0
7643, 0.1875, 0.4, 0
7644, 0.20833333333333, 0.375, 0
7645, 0.1875, 0.45, 0
7646, 0.20833333333333, 0.425, 0
7647, 0.1875, 0.5, 0
7648, 0.20833333333333, 0.475, 0
7649, 0.1875, 0.55, 0
7650, 0.20833333333333, 0.525, 0
7651, 0.1875, 0.6, 0
7652, 0.20833333333333, 0.575, 0
7653, 0.1875, 0.65, 0
7654, 0.20833333333333, 0.625, 0
7655, 0.1875, 0.7, 0
7656, 0.20833333333333, 0.675, 0
7657, 0.1875, 0.75, 0
7658, 0.20833333333333, 0.725, 0
7659, 0.1875, 0.8, 0
7660, 0.20833333333333, 0.775, 0
7661, 0.1875, 0.85, 0
7662, 0.20833333333333, 0.825, 0
7663, 0.1875, 0.9, 0
7664, 0.20833333333333, 0.875, 0
7665, 0.1875, 0.95, 0
7666, 0.20833333333333, 0.925, 0
7667, 0.1875, 1, 0
7668, 0.20833333333333, 0.975, 0
7669, 0.1875, 1.05, 0
7670, 0.20833333333333, 1.025, 0
7671, 0.1875, 1.1, 0
7672, 0.20833333333333, 1.075, 0
7673, 0.1875, 1.15, 0
7674, 0.20833333333333, 1.125, 0
7675, 0.1875, 1.2, 0
7676, 0.20833333333333, 1.175, 0
7677, 0.1875, 1.25, 0
7678, 0.20833333333333, 1.225, 0
7679, 0.1875, 1.3, 0
7680, 0.20833333333333, 1.275, 0
7681, 0.20833333333333, 1.325, 0
7682, 0.22916666666667, 0.2, 0
7683, 0.25, 0.175, 0
7684, 0.22916666666667, 0.25, 0
7685, 0.25, 0.225, 0
7686, 0.22916666666667, 0.3, 0
7687, 0.25, 0.275, 0
7688, 0.22916666666667, 0.35, 0
7689, 0.25, 0.325, 0
7690, 0.22916666666667, 0.4, 0
7691, 0.25, 0.375, 0
7692, 0.22916666666667, 0.45, 0
7693, 0.25, 0.425, 0
7694, 0.22916666666667, 0.5, 0
7695, 0.25, 0.475, 0
7696, 0.22916666666667, 0.55, 0
7697, 0.25, 0.525, 0
7698, 0.22916666666667, 0.6, 0
7699, 0.25, 0.575, 0
7700, 0.22916666666667, 0.65, 0
7701, 0.25, 0.625, 0
7702, 0.22916666666667, 0.7, 0
7703, 0.25, 0.675, 0
7704, 0.22916666666667, 0.75, 0
7705, 0.25, 0.725, 0
7706, 0.22916666666667, 0.8, 0
7707, 0.25, 0.775, 0
7708, 0.22916666666667, 0.85, 0
7709, 0.25, 0.825, 0
7710, 0.22916666666667, 0.9, 0
7711, 0.25, 0.875, 0
7712, 0.22916666666667, 0.95, 0
7713, 0.25, 0.925, 0
7714, 0.22916666666667, 1, 0
7715, 0.25, 0.975, 0
7716, 0.22916666666667, 1.05, 0
7717, 0.25, 1.025, 0
7718, 0.22916666666667, 1.1, 0
7719, 0.25, 1.075, 0
7720, 0.22916666666667, 1.15, 0
7721, 0.25, 1.125, 0
7722, 0.22916666666667, 1.2, 0
7723, 0.25, 1.175, 0
7724, 0.22916666666667, 1.25, 0
7725, 0.25, 1.225, 0
7726, 0.22916666666667, 1.3, 0
7727, 0.25, 1.275, 0
7728, 0.25, 1.325, 0
7729, 0.27083333333333, 0.2, 0
7730, 0.29166666666667, 0.175, 0
7731, 0.27083333333333, 0.25, 0
7732, 0.29166666666667, 0.225, 0
7733, 0.27083333333333, 0.3, 0
7734, 0.29166666666667, 0.275, 0
7735, 0.27083333333333, 0.35, 0
7736, 0.29166666666667, 0.325, 0
7737, 0.27083333333333, 0.4, 0
7738, 0.29166666666667, 0.375, 0
7739, 0.27083333333333, 0.45, 0
7740, 0.29166666666667, 0.425, 0
7741, 0.27083333333333, 0.5, 0
7742, 0.29166666666667, 0.475, 0
7743, 0.27083333333333, 0.55, 0
7744, 0.29166666666667, 0.525, 0
7745, 0.27083333333333, 0.6, 0
7746, 0.29166666666667, 0.575, 0
7747, 0.27083333333333, 0.65, 0
7748, 0.29166666666667, 0.625, 0
7749, 0.27083333333333, 0.7, 0
7750, 0.29166666666667, 0.675, 0
7751, 0.27083333333333, 0.75, 0
7752, 0.29166666666667, 0.725, 0
7753, 0.27083333333333, 0.8, 0
7754, 0.29166666666667, 0.775, 0
7755, 0.27083333333333, 0.85, 0
7756, 0.29166666666667, 0.825, 0
7757, 0.27083333333333, 0.9, 0
7758, 0.29166666666667, 0.875, 0
7759, 0.27083333333333, 0.95, 0
7760, 0.29166666666667, 0.925, 0
7761, 0.27083333333333, 1, 0
7762, 0.29166666666667, 0.975, 0
7763, 0.27083333333333, 1.05, 0
7764, 0.29166666666667, 1.025, 0
7765, 0.27083333333333, 1.1, 0
7766, 0.29166666666667, 1.075, 0
7767, 0.27083333333333, 1.15, 0
7768, 0.29166666666667, 1.125, 0
7769, 0.27083333333333, 1.2, 0
7770, 0.29166666666667, 1.175, 0
7771, 0.27083333333333, 1.25, 0
7772, 0.29166666666667, 1.225, 0
7773, 0.27083333333333, 1.3, 0
7774, 0.29166666666667, 1.275, 0
7775, 0.29166666666667, 1.325, 0
7776, 0.3125, 0.2, 0
7777, 0.33333333333333, 0.175, 0
7778, 0.3125, 0.25, 0
7779, 0.33333333333333, 0.225, 0
7780, 0.3125, 0.3, 0
7781, 0.33333333333333, 0.275, 0
7782, 0.3125, 0.35, 0
7783, 0.33333333333333, 0.325, 0
7784, 0.3125, 0.4, 0
7785, 0.33333333333333, 0.375, 0
7786, 0.3125, 0.45, 0
7787, 0.33333333333333, 0.425, 0
7788, 0.3125, 0.5, 0
7789, 0.33333333333333, 0.475, 0
7790, 0.3125, 0.55, 0
7791, 0.33333333333333, 0.525, 0
7792, 0.3125, 0.6, 0
7793, 0.33333333333333, 0.575, 0
7794, 0.3125, 0.65, 0
7795, 0.33333333333333, 0.625, 0
7796, 0.3125, 0.7, 0
7797, 0.33333333333333, 0.675, 0
7798, 0.3125, 0.75, 0
7799, 0.33333333333333, 0.725, 0
7800, 0.3125, 0.8, 0
7801, 0.33333333333333, 0.775, 0
7802, 0.3125, 0.85, 0
7803, 0.33333333333333, 0.825, 0
7804, 0.3125, 0.9, 0
7805, 0.33333333333333, 0.875, 0
7806, 0.3125, 0.95, 0
7807, 0.33333333333333, 0.925, 0
7808, 0.3125, 1, 0
7809, 0.33333333333333, 0.975, 0
7810, 0.3125, 1.05, 0
7811, 0.33333333333333, 1.025, 0
7812, 0.3125, 1.1, 0
7813, 0.33333333333333, 1.075, 0
7814, 0.3125, 1.15, 0
7815, 0.33333333333333, 1.125, 0
7816, 0.3125, 1.2, 0
7817, 0.33333333333333, 1.175, 0
7818, 0.3125, 1.25, 0
7819, 0.33333333333333, 1.225, 0
7820, 0.3125, 1.3, 0
7821, 0.33333333333333, 1.275, 0
7822, 0.33333333333333, 1.325, 0
7823, 0.35416666666667, 0.2, 0
7824, 0.375, 0.175, 0
7825, 0.35416666666667, 0.25, 0
7826, 0.375, 0.225, 0
7827, 0.35416666666667, 0.3, 0
7828, 0.375, 0.275, 0
7829, 0.35416666666667, 0.35, 0
7830, 0.375, 0.325, 0
7831, 0.35416666666667, 0.4, 0
7832, 0.375, 0.375, 0
7833, 0.35416666666667, 0.45, 0
7834, 0.375, 0.425, 0
7835, 0.35416666666667, 0.5, 0
7836, 0.375, 0.475, 0
7837, 0.35416666666667, 0.55, 0
7838, 0.375, 0.525, 0
7839, 0.35416666666667, 0.6, 0
7840, 0.375, 0.575, 0
7841, 0.35416666666667, 0.65, 0
7842, 0.375, 0.625, 0
7843, 0.35416666666667, 0.7, 0
7844, 0.375, 0.675, 0
7845, 0.35416666666667, 0.75, 0
7846, 0.375, 0.725, 0
7847, 0.35416666666667, 0.8, 0
7848, 0.375, 0.775, 0
7849, 0.35416666666667, 0.85, 0
7850, 0.375, 0.825, 0
7851, 0.35416666666667, 0.9, 0
7852, 0.375, 0.875, 0
7853, 0.35416666666667, 0.95, 0
7854, 0.375, 0.925, 0
7855, 0.35416666666667, 1, 0
7856, 0.375, 0.975, 0
7857, 0.35416666666667, 1.05, 0
7858, 0.375, 1.025, 0
7859, 0.35416666666667, 1.1, 0
7860, 0.375, 1.075, 0
7861, 0.35416666666667, 1.15, 0
7862, 0.375, 1.125, 0
7863, 0.35416666666667, 1.2, 0
7864, 0.375, 1.175, 0
7865, 0.35416666666667, 1.25, 0
7866, 0.375, 1.225, 0
7867, 0.35416666666667, 1.3, 0
7868, 0.375, 1.275, 0
7869, 0.375, 1.325, 0
7870, 0.39583333333333, 0.2, 0
7871, 0.41666666666667, 0.175, 0
7872, 0.39583333333333, 0.25, 0
7873, 0.41666666666667, 0.225, 0
7874, 0.39583333333333, 0.3, 0
7875, 0.41666666666667, 0.275, 0
7876, 0.39583333333333, 0.35, 0
7877, 0.41666666666667, 0.325, 0
7878, 0.39583333333333, 0.4, 0
7879, 0.41666666666667, 0.375, 0
7880, 0.39583333333333, 0.45, 0
7881, 0.41666666666667, 0.425, 0
7882, 0.39583333333333, 0.5, 0
7883, 0.41666666666667, 0.475, 0
7884, 0.39583333333333, 0.55, 0
7885, 0.41666666666667, 0.525, 0
7886, 0.39583333333333, 0.6, 0
7887, 0.41666666666667, 0.575, 0
7888, 0.39583333333333, 0.65, 0
7889, 0.41666666666667, 0.625, 0
7890, 0.39583333333333, 0.7, 0
7891, 0.41666666666667, 0.675, 0
7892, 0.39583333333333, 0.75, 0
7893, 0.41666666666667, 0.725, 0
7894, 0.39583333333333, 0.8, 0
7895, 0.41666666666667, 0.775, 0
7896, 0.39583333333333, 0.85, 0
7897, 0.41666666666667, 0.825, 0
7898, 0.39583333333333, 0.9, 0
7899, 0.41666666666667, 0.875, 0
7900, 0.39583333333333, 0.95, 0
7901, 0.41666666666667, 0.925, 0
7902, 0.39583333333333, 1, 0
7903, 0.41666666666667, 0.975, 0
7904, 0.39583333333333, 1.05, 0
7905, 0.41666666666667, 1.025, 0
7906, 0.39583333333333, 1.1, 0
7907, 0.41666666666667, 1.075, 0
7908, 0.39583333333333, 1.15, 0
7909, 0.41666666666667, 1.125, 0
7910, 0.39583333333333, 1.2, 0
7911, 0.41666666666667, 1.175, 0
7912, 0.39583333333333, 1.25, 0
7913, 0.41666666666667, 1.225, 0
7914, 0.39583333333333, 1.3, 0
7915, 0.41666666666667, 1.275, 0
7916, 0.41666666666667, 1.325, 0
7917, 0.4375, 0.2, 0
7918, 0.45833333333333, 0.175, 0
7919, 0.4375, 0.25, 0
7920, 0.45833333333333, 0.225, 0
7921, 0.4375, 0.3, 0
7922, 0.45833333333333, 0.275, 0
7923, 0.4375, 0.35, 0
7924, 0.45833333333333, 0.325, 0
7925, 0.4375, 0.4, 0
7926, 0.45833333333333, 0.375, 0
7927, 0.4375, 0.45, 0
7928, 0.45833333333333, 0.425, 0
7929, 0.4375, 0.5, 0
7930, 0.45833333333333, 0.475, 0
7931, 0.4375, 0.55, 0
7932, 0.45833333333333, 0.525, 0
7933, 0.4375, 0.6, 0
7934, 0.45833333333333, 0.575, 0
7935, 0.4375, 0.65, 0
7936, 0.45833333333333, 0.625, 0
7937, 0.4375, 0.7, 0
7938, 0.45833333333333, 0.675, 0
7939, 0.4375, 0.75, 0
7940, 0.45833333333333, 0.725, 0
7941, 0.4375, 0.8, 0
7942, 0.45833333333333, 0.775, 0
7943, 0.4375, 0.85, 0
7944, 0.45833333333333, 0.825, 0
7945, 0.4375, 0.9, 0
7946, 0.45833333333333, 0.875, 0
7947, 0.4375, 0.95, 0
7948, 0.45833333333333, 0.925, 0
7949, 0.4375, 1, 0
7950, 0.45833333333333, 0.975, 0
7951, 0.4375, 1.05, 0
7952, 0.45833333333333, 1.025, 0
7953, 0.4375, 1.1, 0
7954, 0.45833333333333, 1.075, 0
7955, 0.4375, 1.15, 0
7956, 0.45833333333333, 1.125, 0
7957, 0.4375, 1.2, 0
7958, 0.45833333333333, 1.175, 0
7959, 0.4375, 1.25, 0
7960, 0.45833333333333, 1.225, 0
7961, 0.4375, 1.3, 0
7962, 0.45833333333333, 1.275, 0
7963, 0.45833333333333, 1.325, 0
7964, 0.47916666666667, 0.2, 0
7965, 0.5, 0.175, 0
7966, 0.47916666666667, 0.25, 0
7967, 0.5, 0.225, 0
7968, 0.47916666666667, 0.3, 0
7969, 0.5, 0.275, 0
7970, 0.47916666666667, 0.35, 0
7971, 0.5, 0.325, 0
7972, 0.47916666666667, 0.4, 0
7973, 0.5, 0.375, 0
7974, 0.47916666666667, 0.45, 0
7975, 0.5, 0.425, 0
7976, 0.47916666666667, 0.5, 0
7977, 0.5, 0.475, 0
7978, 0.47916666666667, 0.55, 0
7979, 0.5, 0.525, 0
7980, 0.47916666666667, 0.6, 0
7981, 0.5, 0.575, 0
7982, 0.47916666666667, 0.65, 0
7983, 0.5, 0.625, 0
7984, 0.47916666666667, 0.7, 0
7985, 0.5, 0.675, 0
7986, 0.47916666666667, 0.75, 0
7987, 0.5, 0.725, 0
7988, 0.47916666666667, 0.8, 0
7989, 0.5, 0.775, 0
7990, 0.47916666666667, 0.85, 0
7991, 0.5, 0.825, 0
7992, 0.47916666666667, 0.9, 0
7993, 0.5, 0.875, 0
7994, 0.47916666666667, 0.95, 0
7995, 0.5, 0.925, 0
7996, 0.47916666666667, 1, 0
7997, 0.5, 0.975, 0
7998, 0.47916666666667, 1.05, 0
7999, 0.5, 1.025, 0
8000, 0.47916666666667, 1.1, 0
8001, 0.5, 1.075, 0
8002, 0.47916666666667, 1.15, 0
8003, 0.5, 1.125, 0
8004, 0.47916666666667, 1.2, 0
8005, 0.5, 1.175, 0
8006, 0.47916666666667, 1.25, 0
8007, 0.5, 1.225, 0
8008, 0.47916666666667, 1.3, 0
8009, 0.5, 1.275, 0
8010, 0.5, 1.325, 0
8011, 0.52083333333333, 0.2, 0
8012, 0.54166666666667, 0.175, 0
8013, 0.52083333333333, 0.25, 0
8014, 0.54166666666667, 0.225, 0
8015, 0.52083333333333, 0.3, 0
8016, 0.54166666666667, 0.275, 0
8017, 0.52083333333333, 0.35, 0
8018, 0.54166666666667, 0.325, 0
8019, 0.52083333333333, 0.4, 0
8020, 0.54166666666667, 0.375, 0
8021, 0.52083333333333, 0.45, 0
8022, 0.54166666666667, 0.425, 0
8023, 0.52083333333333, 0.5, 0
8024, 0.54166666666667, 0.475, 0
8025, 0.52083333333333, 0.55, 0
8026, 0.54166666666667, 0.525, 0
8027, 0.52083333333333, 0.6, 0
8028, 0.54166666666667, 0.575, 0
8029, 0.52083333333333, 0.65, 0
8030, 0.54166666666667, 0.625, 0
8031, 0.52083333333333, 0.7, 0
8032, 0.54166666666667, 0.675, 0
8033, 0.52083333333333, 0.75, 0
8034, 0.54166666666667, 0.725, 0
8035, 0.52083333333333, 0.8, 0
8036, 0.54166666666667, 0.775, 0
8037, 0.52083333333333, 0.85, 0
8038, 0.54166666666667, 0.825, 0
8039, 0.52083333333333, 0.9, 0
8040, 0.54166666666667, 0.875, 0
8041, 0.52083333333333, 0.95, 0
8042, 0.54166666666667, 0.925, 0
8043, 0.52083333333333, 1, 0
8044, 0.54166666666667, 0.975, 0
8045, 0.52083333333333, 1.05, 0
8046, 0.54166666666667, 1.025, 0
8047, 0.52083333333333, 1.1, 0
8048, 0.54166666666667, 1.075, 0
8049, 0.52083333333333, 1.15, 0
8050, 0.54166666666667, 1.125, 0
8051, 0.52083333333333, 1.2, 0
8052, 0.54166666666667, 1.175, 0
8053, 0.52083333333333, 1.25, 0
8054, 0.54166666666667, 1.225, 0
8055, 0.52083333333333, 1.3, 0
8056, 0.54166666666667, 1.275, 0
8057, 0.54166666666667, 1.325, 0
8058, 0.5625, 0.2, 0
8059, 0.58333333333333, 0.175, 0
8060, 0.5625, 0.25, 0
8061, 0.58333333333333, 0.225, 0
8062, 0.5625, 0.3, 0
8063, 0.58333333333333, 0.275, 0
8064, 0.5625, 0.35, 0
8065, 0.58333333333333, 0.325, 0
8066, 0.5625, 0.4, 0
8067, 0.58333333333333, 0.375, 0
8068, 0.5625, 0.45, 0
8069, 0.58333333333333, 0.425, 0
8070, 0.5625, 0.5, 0
8071, 0.58333333333333, 0.475, 0
8072, 0.5625, 0.55, 0
8073, 0.58333333333333, 0.525, 0
8074, 0.5625, 0.6, 0
8075, 0.58333333333333, 0.575, 0
8076, 0.5625, 0.65, 0
8077, 0.58333333333333, 0.625, 0
8078, 0.5625, 0.7, 0
8079, 0.58333333333333, 0.675, 0
8080, 0.5625, 0.75, 0
8081, 0.58333333333333, 0.725, 0
8082, 0.5625, 0.8, 0
8083, 0.58333333333333, 0.775, 0
8084, 0.5625, 0.85, 0
8085, 0.58333333333333, 0.825, 0
8086, 0.5625, 0.9, 0
8087, 0.58333333333333, 0.875, 0
8088, 0.5625, 0.95, 0
8089, 0.58333333333333, 0.925, 0
8090, 0.5625, 1, 0
8091, 0.58333333333333, 0.975, 0
8092, 0.5625, 1.05, 0
8093, 0.58333333333333, 1.025, 0
8094, 0.5625, 1.1, 0
8095, 0.58333333333333, 1.075, 0
8096, 0.5625, 1.15, 0
8097, 0.58333333333333, 1.125, 0
8098, 0.5625, 1.2, 0
8099, 0.58333333333333, 1.175, 0
8100, 0.5625, 1.25, 0
8101, 0.58333333333333, 1.225, 0
8102, 0.5625, 1.3, 0
8103, 0.58333333333333, 1.275, 0
8104, 0.58333333333333, 1.325, 0
8105, 0.60416666666667, 0.2, 0
8106, 0.625, 0.175, 0
8107, 0.60416666666667, 0.25, 0
8108, 0.625, 0.225, 0
8109, 0.60416666666667, 0.3, 0
8110, 0.625, 0.275, 0
8111, 0.60416666666667, 0.35, 0
8112, 0.625, 0.325, 0
8113, 0.60416666666667, 0.4, 0
8114, 0.625, 0.375, 0
8115, 0.60416666666667, 0.45, 0
8116, 0.625, 0.425, 0
8117, 0.60416666666667, 0.5, 0
8118, 0.625, 0.475, 0
8119, 0.60416666666667, 0.55, 0
8120, 0.625, 0.525, 0
8121, 0.60416666666667, 0.6, 0
8122, 0.625, 0.575, 0
8123, 0.60416666666667, 0.65, 0
8124, 0.625, 0.625, 0
8125, 0.60416666666667, 0.7, 0
8126, 0.625, 0.675, 0
8127, 0.60416666666667, 0.75, 0
8128, 0.625, 0.725, 0
8129, 0.60416666666667, 0.8, 0
8130, 0.625, 0.775, 0
8131, 0.60416666666667, 0.85, 0
8132, 0.625, 0.825, 0
8133, 0.60416666666667, 0.9, 0
8134, 0.625, 0.875, 0
8135, 0.60416666666667, 0.95, 0
8136, 0.625, 0.925, 0
8137, 0.60416666666667, 1, 0
8138, 0.625, 0.975, 0
8139, 0.60416666666667, 1.05, 0
8140, 0.625, 1.025, 0
8141, 0.60416666666667, 1.1, 0
8142, 0.625, 1.075, 0
8143, 0.60416666666667, 1.15, 0
8144, 0.625, 1.125, 0
8145, 0.60416666666667, 1.2, 0
8146, 0.625, 1.175, 0
8147, 0.60416666666667, 1.25, 0
8148, 0.625, 1.225, 0
8149, 0.60416666666667, 1.3, 0
8150, 0.625, 1.275, 0
8151, 0.625, 1.325, 0
8152, 0.64583333333333, 0.2, 0
8153, 0.66666666666667, 0.175, 0
8154, 0.64583333333333, 0.25, 0
8155, 0.66666666666667, 0.225, 0
8156, 0.64583333333333, 0.3, 0
8157, 0.66666666666667, 0.275, 0
8158, 0.64583333333333, 0.35, 0
8159, 0.66666666666667, 0.325, 0
8160, 0.64583333333333, 0.4, 0
8161, 0.66666666666667, 0.375, 0
8162, 0.64583333333333, 0.45, 0
8163, 0.66666666666667, 0.425, 0
8164, 0.64583333333333, 0.5, 0
8165, 0.66666666666667, 0.475, 0
8166, 0.64583333333333, 0.55, 0
8167, 0.66666666666667, 0.525, 0
8168, 0.64583333333333, 0.6, 0
8169, 0.66666666666667, 0.575, 0
8170, 0.64583333333333, 0.65, 0
8171, 0.66666666666667, 0.625, 0
8172, 0.64583333333333, 0.7, 0
8173, 0.66666666666667, 0.675, 0
8174, 0.64583333333333, 0.75, 0
8175, 0.66666666666667, 0.725, 0
8176, 0.64583333333333, 0.8, 0
8177, 0.66666666666667, 0.775, 0
8178, 0.64583333333333, 0.85, 0
8179, 0.66666666666667, 0.825, 0
8180, 0.64583333333333, 0.9, 0
8181, 0.66666666666667, 0.875, 0
8182, 0.64583333333333, 0.95, 0
8183, 0.66666666666667, 0.925, 0
8184, 0.64583333333333, 1, 0
8185, 0.66666666666667, 0.975, 0
8186, 0.64583333333333, 1.05, 0
8187, 0.66666666666667, 1.025, 0
8188, 0.64583333333333, 1.1, 0
8189, 0.66666666666667, 1.075, 0
8190, 0.64583333333333, 1.15, 0
8191, 0.66666666666667, 1.125, 0
8192, 0.64583333333333, 1.2, 0
8193, 0.66666666666667, 1.175, 0
8194, 0.64583333333333, 1.25, 0
8195, 0.66666666666667, 1.225, 0
8196, 0.64583333333333, 1.3, 0
8197, 0.66666666666667, 1.275, 0
8198, 0.66666666666667, 1.325, 0
8199, 0.6875, 0.2, 0
8200, 0.70833333333333, 0.175, 0
8201, 0.6875, 0.25, 0
8202, 0.70833333333333, 0.225, 0
8203, 0.6875, 0.3, 0
8204, 0.70833333333333, 0.275, 0
8205, 0.6875, 0.35, 0
8206, 0.70833333333333, 0.325, 0
8207, 0.6875, 0.4, 0
8208, 0.70833333333333, 0.375, 0
8209, 0.6875, 0.45, 0
8210, 0.70833333333333, 0.425, 0
8211, 0.6875, 0.5, 0
8212, 0.70833333333333, 0.475, 0
8213, 0.6875, 0.55, 0
8214, 0.70833333333333, 0.525, 0
8215, 0.6875, 0.6, 0
8216, 0.70833333333333, 0.575, 0
8217, 0.6875, 0.65, 0
8218, 0.70833333333333, 0.625, 0
8219, 0.6875, 0.7, 0
8220, 0.70833333333333, 0.675, 0
8221, 0.6875, 0.75, 0
8222, 0.70833333333333, 0.725, 0
8223, 0.6875, 0.8, 0
8224, 0.70833333333333, 0.775, 0
8225, 0.6875, 0.85, 0
8226, 0.70833333333333, 0.825, 0
8227, 0.6875, 0.9, 0
8228, 0.70833333333333, 0.875, 0
8229, 0.6875, 0.95, 0
8230, 0.70833333333333, 0.925, 0
8231, 0.6875, 1, 0
8232, 0.70833333333333, 0.975, 0
8233, 0.6875, 1.05, 0
8234, 0.70833333333333, 1.025, 0
8235, 0.6875, 1.1, 0
8236, 0.70833333333333, 1.075, 0
8237, 0.6875, 1.15, 0
8238, 0.70833333333333, 1.125, 0
8239, 0.6875, 1.2, 0
8240, 0.70833333333333, 1.175, 0
8241, 0.6875, 1.25, 0
8242, 0.70833333333333, 1.225, 0
8243, 0.6875, 1.3, 0
8244, 0.70833333333333, 1.275, 0
8245, 0.70833333333333, 1.325, 0
8246, 0.72916666666667, 0.2, 0
8247, 0.75, 0.175, 0
8248, 0.72916666666667, 0.25, 0
8249, 0.75, 0.225, 0
8250, 0.72916666666667, 0.3, 0
8251, 0.75, 0.275, 0
8252, 0.72916666666667, 0.35, 0
8253, 0.75, 0.325, 0
8254, 0.72916666666667, 0.4, 0
8255, 0.75, 0.375, 0
8256, 0.72916666666667, 0.45, 0
8257, 0.75, 0.425, 0
8258, 0.72916666666667, 0.5, 0
8259, 0.75, 0.475, 0
8260, 0.72916666666667, 0.55, 0
8261, 0.75, 0.525, 0
8262, 0.72916666666667, 0.6, 0
8263, 0.75, 0.575, 0
8264, 0.72916666666667, 0.65, 0
8265, 0.75, 0.625, 0
8266, 0.72916666666667, 0.7, 0
8267, 0.75, 0.675, 0
8268, 0.72916666666667, 0.75, 0
8269, 0.75, 0.725, 0
8270, 0.72916666666667, 0.8, 0
8271, 0.75, 0.775, 0
8272, 0.72916666666667, 0.85, 0
8273, 0.75, 0.825, 0
8274, 0.72916666666667, 0.9, 0
8275, 0.75, 0.875, 0
8276, 0.72916666666667, 0.95, 0
8277, 0.75, 0.925, 0
8278, 0.72916666666667, 1, 0
8279, 0.75, 0.975, 0
8280, 0.72916666666667, 1.05, 0
8281, 0.75, 1.025, 0
8282, 0.72916666666667, 1.1, 0
8283, 0.75, 1.075, 0
8284, 0.72916666666667, 1.15, 0
8285, 0.75, 1.125, 0
8286, 0.72916666666667, 1.2, 0
8287, 0.75, 1.175, 0
8288, 0.72916666666667, 1.25, 0
8289, 0.75, 1.225, 0
8290, 0.72916666666667, 1.3, 0
8291, 0.75, 1.275, 0
8292, 0.75, 1.325, 0
8293, 0.77083333333333, 0.2, 0
8294, 0.79166666666667, 0.175, 0
8295, 0.77083333333333, 0.25, 0
8296, 0.79166666666667, 0.225, 0
8297, 0.77083333333333, 0.3, 0
8298, 0.79166666666667, 0.275, 0
8299, 0.77083333333333, 0.35, 0
8300, 0.79166666666667, 0.325, 0
8301, 0.77083333333333, 0.4, 0
8302, 0.79166666666667, 0.375, 0
8303, 0.77083333333333, 0.45, 0
8304, 0.79166666666667, 0.425, 0
8305, 0.77083333333333, 0.5, 0
8306, 0.79166666666667, 0.475, 0
8307, 0.77083333333333, 0.55, 0
8308, 0.79166666666667, 0.525, 0
8309, 0.77083333333333, 0.6, 0
8310, 0.79166666666667, 0.575, 0
8311, 0.77083333333333, 0.65, 0
8312, 0.79166666666667, 0.625, 0
8313, 0.77083333333333, 0.7, 0
8314, 0.79166666666667, 0.675, 0
8315, 0.77083333333333, 0.75, 0
8316, 0.79166666666667, 0.725, 0
8317, 0.77083333333333, 0.8, 0
8318, 0.79166666666667, 0.775, 0
8319, 0.77083333333333, 0.85, 0
8320, 0.79166666666667, 0.825, 0
8321, 0.77083333333333, 0.9, 0
8322, 0.79166666666667, 0.875, 0
8323, 0.77083333333333, 0.95, 0
8324, 0.79166666666667, 0.925, 0
8325, 0.77083333333333, 1, 0
8326, 0.79166666666667, 0.975, 0
8327, 0.77083333333333, 1.05, 0
8328, 0.79166666666667, 1.025, 0
8329, 0.77083333333333, 1.1, 0
8330, 0.79166666666667, 1.075, 0
8331, 0.77083333333333, 1.15, 0
8332, 0.79166666666667, 1.125, 0
8333, 0.77083333333333, 1.2, 0
8334, 0.79166666666667, 1.175, 0
8335, 0.77083333333333, 1.25, 0
8336, 0.79166666666667, 1.225, 0
8337, 0.77083333333333, 1.3, 0
8338, 0.79166666666667, 1.275, 0
8339, 0.79166666666667, 1.325, 0
8340, 0.8125, 0.2, 0
8341, 0.83333333333333, 0.175, 0
8342, 0.8125, 0.25, 0
8343, 0.83333333333333, 0.225, 0
8344, 0.8125, 0.3, 0
8345, 0.83333333333333, 0.275, 0
8346, 0.8125, 0.35, 0
8347, 0.83333333333333, 0.325, 0
8348, 0.8125, 0.4, 0
8349, 0.83333333333333, 0.375, 0
8350, 0.8125, 0.45, 0
8351, 0.83333333333333, 0.425, 0
8352, 0.8125, 0.5, 0
8353, 0.83333333333333, 0.475, 0
8354, 0.8125, 0.55, 0
8355, 0.83333333333333, 0.525, 0
8356, 0.8125, 0.6, 0
8357, 0.83333333333333, 0.575, 0
8358, 0.8125, 0.65, 0
8359, 0.83333333333333, 0.625, 0
8360, 0.8125, 0.7, 0
8361, 0.83333333333333, 0.675, 0
8362, 0.8125, 0.75, 0
8363, 0.83333333333333, 0.725, 0
8364, 0.8125, 0.8, 0
8365, 0.83333333333333, 0.775, 0
8366, 0.8125, 0.85, 0
8367, 0.83333333333333, 0.825, 0
8368, 0.8125, 0.9, 0
8369, 0.83333333333333, 0.875, 0
8370, 0.8125, 0.95, 0
8371, 0.83333333333333, 0.925, 0
8372, 0.8125, 1, 0
8373, 0.83333333333333, 0.975, 0
8374, 0.8125, 1.05, 0
8375, 0.83333333333333, 1.025, 0
8376, 0.8125, 1.1, 0
8377, 0.83333333333333, 1.075, 0
8378, 0.8125, 1.15, 0
8379, 0.83333333333333, 1.125, 0
8380, 0.8125, 1.2, 0
8381, 0.83333333333333, 1.175, 0
8382, 0.8125, 1.25, 0
8383, 0.83333333333333, 1.225, 0
8384, 0.8125, 1.3, 0
8385, 0.83333333333333, 1.275, 0
8386, 0.83333333333333, 1.325, 0
8387, 0.85416666666667, 0.2, 0
8388, 0.875, 0.175, 0
8389, 0.85416666666667, 0.25, 0
8390, 0.875, 0.225, 0
8391, 0.85416666666667, 0.3, 0
8392, 0.875, 0.275, 0
8393, 0.85416666666667, 0.35, 0
8394, 0.875, 0.325, 0
8395, 0.85416666666667, 0.4, 0
8396, 0.875, 0.375, 0
8397, 0.85416666666667, 0.45, 0
8398, 0.875, 0.425, 0
8399, 0.85416666666667, 0.5, 0
8400, 0.875, 0.475, 0
8401, 0.85416666666667, 0.55, 0
8402, 0.875, 0.525, 0
8403, 0.85416666666667, 0.6, 0
8404, 0.875, 0.575, 0
8405, 0.85416666666667, 0.65, 0
8406, 0.875, 0.625, 0
8407, 0.85416666666667, 0.7, 0
8408, 0.875, 0.675, 0
8409, 0.85416666666667, 0.75, 0
8410, 0.875, 0.725, 0
8411, 0.85416666666667, 0.8, 0
8412, 0.875, 0.775, 0
8413, 0.85416666666667, 0.85, 0
8414, 0.875, 0.825, 0
8415, 0.85416666666667, 0.9, 0
8416, 0.875, 0.875, 0
8417, 0.85416666666667, 0.95, 0
8418, 0.875, 0.925, 0
8419, 0.85416666666667, 1, 0
8420, 0.875, 0.975, 0
8421, 0.85416666666667, 1.05, 0
8422, 0.875, 1.025, 0
8423, 0.85416666666667, 1.1, 0
8424, 0.875, 1.075, 0
8425, 0.85416666666667, 1.15, 0
8426, 0.875, 1.125, 0
8427, 0.85416666666667, 1.2, 0
8428, 0.875, 1.175, 0
8429, 0.85416666666667, 1.25, 0
8430, 0.875, 1.225, 0
8431, 0.85416666666667, 1.3, 0
8432, 0.875, 1.275, 0
8433, 0.875, 1.325, 0
8434, 0.89583333333333, 0.2, 0
8435, 0.91666666666667, 0.175, 0
8436, 0.89583333333333, 0.25, 0
8437, 0.91666666666667, 0.225, 0
8438, 0.89583333333333, 0.3, 0
8439, 0.91666666666667, 0.275, 0
8440, 0.89583333333333, 0.35, 0
8441, 0.91666666666667, 0.325, 0
8442, 0.89583333333333, 0.4, 0
8443, 0.91666666666667, 0.375, 0
8444, 0.89583333333333, 0.45, 0
8445, 0.91666666666667, 0.425, 0
8446, 0.89583333333333, 0.5, 0
8447, 0.91666666666667, 0.475, 0
8448, 0.89583333333333, 0.55, 0
8449, 0.91666666666667, 0.525, 0
8450, 0.89583333333333, 0.6, 0
8451, 0.91666666666667, 0.575, 0
8452, 0.89583333333333, 0.65, 0
8453, 0.91666666666667, 0.625, 0
8454, 0.89583333333333, 0.7, 0
8455, 0.91666666666667, 0.675, 0
8456, 0.89583333333333, 0.75, 0
8457, 0.91666666666667, 0.725, 0
8458, 0.89583333333333, 0.8, 0
8459, 0.91666666666667, 0.775, 0
8460, 0.89583333333333, 0.85, 0
8461, 0.91666666666667, 0.825, 0
8462, 0.89583333333333, 0.9, 0
8463, 0.91666666666667, 0.875, 0
8464, 0.89583333333333, 0.95, 0
8465, 0.91666666666667, 0.925, 0
8466, 0.89583333333333, 1, 0
8467, 0.91666666666667, 0.975, 0
8468, 0.89583333333333, 1.05, 0
8469, 0.91666666666667, 1.025, 0
8470, 0.89583333333333, 1.1, 0
8471, 0.91666666666667, 1.075, 0
8472, 0.89583333333333, 1.15, 0
8473, 0.91666666666667, 1.125, 0
8474, 0.89583333333333, 1.2, 0
8475, 0.91666666666667, 1.175, 0
8476, 0.89583333333333, 1.25, 0
8477, 0.91666666666667, 1.225, 0
8478, 0.89583333333333, 1.3, 0
8479, 0.91666666666667, 1.275, 0
8480, 0.91666666666667, 1.325, 0
8481, 0.9375, 0.2, 0
8482, 0.95833333333333, 0.175, 0
8483, 0.9375, 0.25, 0
8484, 0.95833333333333, 0.225, 0
8485, 0.9375, 0.3, 0
8486, 0.95833333333333, 0.275, 0
8487, 0.9375, 0.35, 0
8488, 0.95833333333333, 0.325, 0
8489, 0.9375, 0.4, 0
8490, 0.95833333333333, 0.375, 0
8491, 0.9375, 0.45, 0
8492, 0.95833333333333, 0.425, 0
8493, 0.9375, 0.5, 0
8494, 0.95833333333333, 0.475, 0
8495, 0.9375, 0.55, 0
8496, 0.95833333333333, 0.525, 0
8497, 0.9375, 0.6, 0
8498, 0.95833333333333, 0.575, 0
8499, 0.9375, 0.65, 0
8500, 0.95833333333333, 0.625, 0
8501, 0.9375, 0.7, 0
8502, 0.95833333333333, 0.675, 0
8503, 0.9375, 0.75, 0
8504, 0.95833333333333, 0.725, 0
8505, 0.9375, 0.8, 0
8506, 0.95833333333333, 0.775, 0
8507, 0.9375, 0.85, 0
8508, 0.95833333333333, 0.825, 0
8509, 0.9375, 0.9, 0
8510, 0.95833333333333, 0.875, 0
8511, 0.9375, 0.95, 0
8512, 0.95833333333333, 0.925, 0
8513, 0.9375, 1, 0
8514, 0.95833333333333, 0.975, 0
8515, 0.9375, 1.05, 0
8516, 0.95833333333333, 1.025, 0
8517, 0.9375, 1.1, 0
8518, 0.95833333333333, 1.075, 0
8519, 0.9375, 1.15, 0
8520, 0.95833333333333, 1.125, 0
8521, 0.9375, 1.2, 0
8522, 0.95833333333333, 1.175, 0
8523, 0.9375, 1.25, 0
8524, 0.95833333333333, 1.225, 0
8525, 0.9375, 1.3, 0
8526, 0.95833333333333, 1.275, 0
8527, 0.95833333333333, 1.325, 0
8528, 0.97916666666667, 0.2, 0
8529, 0.97916666666667, 0.25, 0
8530, 0.97916666666667, 0.3, 0
8531, 0.97916666666667, 0.35, 0
8532, 0.97916666666667, 0.4, 0
8533, 0.97916666666667, 0.45, 0
8534, 0.97916666666667, 0.5, 0
8535, 0.97916666666667, 0.55, 0
8536, 0.97916666666667, 0.6, 0
8537, 0.97916666666667, 0.65, 0
8538, 0.97916666666667, 0.7, 0
8539, 0.97916666666667, 0.75, 0
8540, 0.97916666666667, 0.8, 0
8541, 0.97916666666667, 0.85, 0
8542, 0.97916666666667, 0.9, 0
8543, 0.97916666666667, 0.95, 0
8544, 0.97916666666667, 1, 0
8545, 0.97916666666667, 1.05, 0
8546, 0.97916666666667, 1.1, 0
8547, 0.97916666666667, 1.15, 0
8548, 0.97916666666667, 1.2, 0
8549, 0.97916666666667, 1.25, 0
8550, 0.97916666666667, 1.3, 0
8551, 1, 0.2, 0.041666666666667
8552, 1, 0.25, 0.041666666666667
8553, 1, 0.3, 0.041666666666667
8554, 1, 0.35, 0.041666666666667
8555, 1, 0.4, 0.041666666666667
8556, 1, 0.45, 0.041666666666667
8557, 1, 0.5, 0.041666666666667
8558, 1, 0.55, 0.041666666666667
8559, 1, 0.6, 0.041666666666667
8560, 1, 0.65, 0.041666666666667
8561, 1, 0.7, 0.041666666666667
8562, 1, 0.75, 0.041666666666667
8563, 1, 0.8, 0.041666666666667
8564, 1, 0.85, 0.041666666666667
8565, 1, 0.9, 0.041666666666667
8566, 1, 0.95, 0.041666666666667
8567, 1, 1, 0.041666666666667
8568, 1, 1.05, 0.041666666666667
8569, 1, 1.1, 0.041666666666667
8570, 1, 1.15, 0.041666666666667
8571, 1, 1.2, 0.041666666666667
8572, 1, 1.25, 0.041666666666667
8573, 1, 1.3, 0.041666666666667
8574, 1, 0.2, 0.083333333333333
8575, 1, 0.25, 0.083333333333333
8576, 1, 0.3, 0.083333333333333
8577, 1, 0.35, 0.083333333333333
8578, 1, 0.4, 0.083333333333333
8579, 1, 0.45, 0.083333333333333
8580, 1, 0.5, 0.083333333333333
8581, 1, 0.55, 0.083333333333333
8582, 1, 0.6, 0.083333333333333
8583, 1, 0.65, 0.083333333333333
8584, 1, 0.7, 0.083333333333333
8585, 1, 0.75, 0.083333333333333
8586, 1, 0.8, 0.083333333333333
8587, 1, 0.85, 0.083333333333333
8588, 1, 0.9, 0.083333333333333
8589, 1, 0.95, 0.083333333333333
8590, 1, 1, 0.083333333333333
8591, 1, 1.05, 0.083333333333333
8592, 1, 1.1, 0.083333333333333
8593, 1, 1.15, 0.083333333333333
8594, 1, 1.2, 0.083333333333333
8595, 1, 1.25, 0.083333333333333
8596, 1, 1.3, 0.083333333333333
8597, 1, 0.2, 0.125
8598, 1, 0.25, 0.125
8599, 1, 0.3, 0.125
8600, 1, 0.35, 0.125
8601, 1, 0.4, 0.125
8602, 1, 0.45, 0.125
8603, 1, 0.5, 0.125
8604, 1, 0.55, 0.125
8605, 1, 0.6, 0.125
8606, 1, 0.65, 0.125
8607, 1, 0.7, 0.125
8608, 1, 0.75, 0.125
8609, 1, 0.8, 0.125
8610, 1, 0.85, 0.125
8611, 1, 0.9, 0.125
8612, 1, 0.95, 0.125
8613, 1, 1, 0.125
8614, 1, 1.05, 0.125
8615, 1, 1.1, 0.125
8616, 1, 1.15, 0.125
8617, 1, 1.2, 0.125
8618, 1, 1.25, 0.125
8619, 1, 1.3, 0.125
8620, 1, 0.2, 0.16666666666667
8621, 1, 0.25, 0.16666666666667
8622, 1, 0.3, 0.16666666666667
8623, 1, 0.35, 0.16666666666667
8624, 1, 0.4, 0.16666666666667
8625, 1, 0.45, 0.16666666666667
8626, 1, 0.5, 0.16666666666667
8627, 1, 0.55, 0.16666666666667
8628, 1, 0.6, 0.16666666666667
8629, 1, 0.65, 0.16666666666667
8630, 1, 0.7, 0.16666666666667
8631, 1, 0.75, 0.16666666666667
8632, 1, 0.8, 0.16666666666667
8633, 1, 0.85, 0.16666666666667
8634, 1, 0.9, 0.16666666666667
8635, 1, 0.95, 0.16666666666667
8636, 1, 1, 0.16666666666667
8637, 1, 1.05, 0.16666666666667
8638, 1, 1.1, 0.16666666666667
8639, 1, 1.15, 0.16666666666667
8640, 1, 1.2, 0.16666666666667
8641, 1, 1.25, 0.16666666666667
8642, 1, 1.3, 0.16666666666667
8643, 1, 0.2, 0.20833333333333
8644, 1, 0.25, 0.20833333333333
8645, 1, 0.3, 0.20833333333333
8646, 1, 0.35, 0.20833333333333
8647, 1, 0.4, 0.20833333333333
8648, 1, 0.45, 0.20833333333333
8649, 1, 0.5, 0.20833333333333
8650, 1, 0.55, 0.20833333333333
8651, 1, 0.6, 0.20833333333333
8652, 1, 0.65, 0.20833333333333
8653, 1, 0.7, 0.20833333333333
8654, 1, 0.75, 0.20833333333333
8655, 1, 0.8, 0.20833333333333
8656, 1, 0.85, 0.20833333333333
8657, 1, 0.9, 0.20833333333333
8658, 1, 0.95, 0.20833333333333
8659, 1, 1, 0.20833333333333
8660, 1, 1.05, 0.20833333333333
8661, 1, 1.1, 0.20833333333333
8662, 1, 1.15, 0.20833333333333
8663, 1, 1.2, 0.20833333333333
8664, 1, 1.25, 0.20833333333333
8665, 1, 1.3, 0.20833333333333
8666, 1, 0.2, 0.25
8667, 1, 0.25, 0.25
8668, 1, 0.3, 0.25
8669, 1, 0.35, 0.25
8670, 1, 0.4, 0.25
8671, 1, 0.45, 0.25
8672, 1, 0.5, 0.25
8673, 1, 0.55, 0.25
8674, 1, 0.6, 0.25
8675, 1, 0.65, 0.25
8676, 1, 0.7, 0.25
8677, 1, 0.75, 0.25
8678, 1, 0.8, 0.25
8679, 1, 0.85, 0.25
8680, 1, 0.9, 0.25
8681, 1, 0.95, 0.25
8682, 1, 1, 0.25
8683, 1, 1.05, 0.25
8684, 1, 1.1, 0.25
8685, 1, 1.15, 0.25
8686, 1, 1.2, 0.25
8687, 1, 1.25, 0.25
8688, 1, 1.3, 0.25
8689, 1, 0.2, 0.29166666666667
8690, 1, 0.25, 0.29166666666667
8691, 1, 0.3, 0.29166666666667
8692, 1, 0.35, 0.29166666666667
8693, 1, 0.4, 0.29166666666667
8694, 1, 0.45, 0.29166666666667
8695, 1, 0.5, 0.29166666666667
8696, 1, 0.55, 0.29166666666667
8697, 1, 0.6, 0.29166666666667
8698, 1, 0.65, 0.29166666666667
8699, 1, 0.7, 0.29166666666667
8700, 1, 0.75, 0.29166666666667
8701, 1, 0.8, 0.29166666666667
8702, 1, 0.85, 0.29166666666667
8703, 1, 0.9, 0.29166666666667
8704, 1, 0.95, 0.29166666666667
8705, 1, 1, 0.29166666666667
8706, 1, 1.05, 0.29166666666667
8707, 1, 1.1, 0.29166666666667
8708, 1, 1.15, 0.29166666666667
8709, 1, 1.2, 0.29166666666667
8710, 1, 1.25, 0.29166666666667
8711, 1, 1.3, 0.29166666666667
8712, 1, 0.2, 0.33333333333333
8713, 1, 0.25, 0.33333333333333
8714, 1, 0.3, 0.33333333333333
8715, 1, 0.35, 0.33333333333333
8716, 1, 0.4, 0.33333333333333
8717, 1, 0.45, 0.33333333333333
8718, 1, 0.5, 0.33333333333333
8719, 1, 0.55, 0.33333333333333
8720, 1, 0.6, 0.33333333333333
8721, 1, 0.65, 0.33333333333333
8722, 1, 0.7, 0.33333333333333
8723, 1, 0.75, 0.33333333333333
8724, 1, 0.8, 0.33333333333333
8725, 1, 0.85, 0.33333333333333
8726, 1, 0.9, 0.33333333333333
8727, 1, 0.95, 0.33333333333333
8728, 1, 1, 0.33333333333333
8729, 1, 1.05, 0.33333333333333
8730, 1, 1.1, 0.33333333333333
8731, 1, 1.15, 0.33333333333333
8732, 1, 1.2, 0.33333333333333
8733, 1, 1.25, 0.33333333333333
8734, 1, 1.3, 0.33333333333333
8735, 1, 0.2, 0.375
8736, 1, 0.25, 0.375
8737, 1, 0.3, 0.375
8738, 1, 0.35, 0.375
8739, 1, 0.4, 0.375
8740, 1, 0.45, 0.375
8741, 1, 0.5, 0.375
8742, 1, 0.55, 0.375
8743, 1, 0.6, 0.375
8744, 1, 0.65, 0.375
8745, 1, 0.7, 0.375
8746, 1, 0.75, 0.375
8747, 1, 0.8, 0.375
8748, 1, 0.85, 0.375
8749, 1, 0.9, 0.375
8750, 1, 0.95, 0.375
8751, 1, 1, 0.375
8752, 1, 1.05, 0.375
8753, 1, 1.1, 0.375
8754, 1, 1.15, 0.375
8755, 1, 1.2, 0.375
8756, 1, 1.25, 0.375
8757, 1, 1.3, 0.375
8758, 1, 0.2, 0.41666666666667
8759, 1, 0.25, 0.41666666666667
8760, 1, 0.3, 0.41666666666667
8761, 1, 0.35, 0.41666666666667
8762, 1, 0.4, 0.41666666666667
8763, 1, 0.45, 0.41666666666667
8764, 1, 0.5, 0.41666666666667
8765, 1, 0.55, 0.41666666666667
8766, 1, 0.6, 0.41666666666667
8767, 1, 0.65, 0.41666666666667
8768, 1, 0.7, 0.41666666666667
8769, 1, 0.75, 0.41666666666667
8770, 1, 0.8, 0.41666666666667
8771, 1, 0.85, 0.41666666666667
8772, 1, 0.9, 0.41666666666667
8773, 1, 0.95, 0.41666666666667
8774, 1, 1, 0.41666666666667
8775, 1, 1.05, 0.41666666666667
8776, 1, 1.1, 0.41666666666667
8777, 1, 1.15, 0.41666666666667
8778, 1, 1.2, 0.41666666666667
8779, 1, 1.25, 0.41666666666667
8780, 1, 1.3, 0.41666666666667
8781, 1, 0.2, 0.45833333333333
8782, 1, 0.25, 0.45833333333333
8783, 1, 0.3, 0.45833333333333
8784, 1, 0.35, 0.45833333333333
8785, 1, 0.4, 0.45833333333333
8786, 1, 0.45, 0.45833333333333
8787, 1, 0.5, 0.45833333333333
8788, 1, 0.55, 0.45833333333333
8789, 1, 0.6, 0.45833333333333
8790, 1, 0.65, 0.45833333333333
8791, 1, 0.7, 0.45833333333333
8792, 1, 0.75, 0.45833333333333
8793, 1, 0.8, 0.45833333333333
8794, 1, 0.85, 0.45833333333333
8795, 1, 0.9, 0.45833333333333
8796, 1, 0.95, 0.45833333333333
8797, 1, 1, 0.45833333333333
8798, 1, 1.05, 0.45833333333333
8799, 1, 1.1, 0.45833333333333
8800, 1, 1.15, 0.45833333333333
8801, 1, 1.2, 0.45833333333333
8802, 1, 1.25, 0.45833333333333
8803, 1, 1.3, 0.45833333333333
8804, 1, 0.2, 0.020833333333333
8805, 1, 0.175, 0.041666666666667
8806, 1, 0.25, 0.020833333333333
8807, 1, 0.225, 0.041666666666667
8808, 1, 0.3, 0.020833333333333
8809, 1, 0.275, 0.041666666666667
8810, 1, 0.35, 0.020833333333333
8811, 1, 0.325, 0.041666666666667
8812, 1, 0.4, 0.020833333333333
8813, 1, 0.375, 0.041666666666667
8814, 1, 0.45, 0.020833333333333
8815, 1, 0.425, 0.041666666666667
8816, 1, 0.5, 0.020833333333333
8817, 1, 0.475, 0.041666666666667
8818, 1, 0.55, 0.020833333333333
8819, 1, 0.525, 0.041666666666667
8820, 1, 0.6, 0.020833333333333
8821, 1, 0.575, 0.041666666666667
8822, 1, 0.65, 0.020833333333333
8823, 1, 0.625, 0.041666666666667
8824, 1, 0.7, 0.020833333333333
8825, 1, 0.675, 0.041666666666667
8826, 1, 0.75, 0.020833333333333
8827, 1, 0.725, 0.041666666666667
8828, 1, 0.8, 0.020833333333333
8829, 1, 0.775, 0.041666666666667
8830, 1, 0.85, 0.020833333333333
8831, 1, 0.825, 0.041666666666667
8832, 1, 0.9, 0.020833333333333
8833, 1, 0.875, 0.041666666666667
8834, 1, 0.95, 0.020833333333333
8835, 1, 0.925, 0.041666666666667
8836, 1, 1, 0.020833333333333
8837, 1, 0.975, 0.041666666666667
8838, 1, 1.05, 0.020833333333333
8839, 1, 1.025, 0.041666666666667
8840, 1, 1.1, 0.020833333333333
8841, 1, 1.075, 0.041666666666667
8842, 1, 1.15, 0.020833333333333
8843, 1, 1.125, 0.041666666666667
8844, 1, 1.2, 0.020833333333333
8845, 1, 1.175, 0.041666666666667
8846, 1, 1.25, 0.020833333333333
8847, 1, 1.225, 0.041666666666667
8848, 1, 1.3, 0.020833333333333
8849, 1, 1.275, 0.041666666666667
8850, 1, 1.325, 0.041666666666667
8851, 1, 0.2, 0.0625
8852, 1, 0.175, 0.083333333333333
8853, 1, 0.25, 0.0625
8854, 1, 0.225, 0.083333333333333
8855, 1, 0.3, 0.0625
8856, 1, 0.275, 0.083333333333333
8857, 1, 0.35, 0.0625
8858, 1, 0.325, 0.083333333333333
8859, 1, 0.4, 0.0625
8860, 1, 0.375, 0.083333333333333
8861, 1, 0.45, 0.0625
8862, 1, 0.425, 0.083333333333333
8863, 1, 0.5, 0.0625
8864, 1, 0.475, 0.083333333333333
8865, 1, 0.55, 0.0625
8866, 1, 0.525, 0.083333333333333
8867, 1, 0.6, 0.0625
8868, 1, 0.575, 0.083333333333333
8869, 1, 0.65, 0.0625
8870, 1, 0.625, 0.083333333333333
8871, 1, 0.7, 0.0625
8872, 1, 0.675, 0.083333333333333
8873, 1, 0.75, 0.0625
8874, 1, 0.725, 0.083333333333333
8875, 1, 0.8, 0.0625
8876, 1, 0.775, 0.083333333333333
8877, 1, 0.85, 0.0625
8878, 1, 0.825, 0.083333333333333
8879, 1, 0.9, 0.0625
8880, 1, 0.875, 0.083333333333333
8881, 1, 0.95, 0.0625
8882, 1, 0.925, 0.083333333333333
8883, 1, 1, 0.0625
8884, 1, 0.975, 0.083333333333333
8885, 1, 1.05, 0.0625
8886, 1, 1.025, 0.083333333333333
8887, 1, 1.1, 0.0625
8888, 1, 1.075, 0.083333333333333
8889, 1, 1.15, 0.0625
8890, 1, 1.125, 0.083333333333333
8891, 1, 1.2, 0.0625
8892, 1, 1.175, 0.083333333333333
8893, 1, 1.25, 0.0625
8894, 1, 1.225, 0.083333333333333
8895, 1, 1.3, 0.0625
8896, 1, 1.275, 0.083333333333333
8897, 1, 1.325, 0.083333333333333
8898, 1, 0.2, 0.10416666666667
8899, 1, 0.175, 0.125
8900, 1, 0.25, 0.10416666666667
8901, 1, 0.225, 0.125
8902, 1, 0.3, 0.10416666666667
8903, 1, 0.275, 0.125
8904, 1, 0.35, 0.10416666666667
8905, 1, 0.325, 0.125
8906, 1, 0.4, 0.10416666666667
8907, 1, 0.375, 0.125
8908, 1, 0.45, 0.10416666666667
8909, 1, 0.425, 0.125
8910, 1, 0.5, 0.10416666666667
8911, 1, 0.475, 0.125
8912, 1, 0.55, 0.10416666666667
8913, 1, 0.525, 0.125
8914, 1, 0.6, 0.10416666666667
8915, 1, 0.575, 0.125
8916, 1, 0.65, 0.10416666666667
8917, 1, 0.625, 0.125
8918, 1, 0.7, 0.10416666666667
8919, 1, 0.675, 0.125
8920, 1, 0.75, 0.10416666666667
8921, 1, 0.725, 0.125
8922, 1, 0.8, 0.10416666666667
8923, 1, 0.775, 0.125
8924, 1, 0.85, 0.10416666666667
8925, 1, 0.825, 0.125
8926, 1, 0.9, 0.10416666666667
8927, 1, 0.875, 0.125
8928, 1, 0.95, 0.10416666666667
8929, 1, 0.925, 0.125
8930, 1, 1, 0.10416666666667
8931, 1, 0.975, 0.125
8932, 1, 1.05, 0.10416666666667
8933, 1, 1.025, 0.125
8934, 1, 1.1, 0.10416666666667
8935, 1, 1.075, 0.125
8936, 1, 1.15, 0.10416666666667
8937, 1, 1.125, 0.125
8938, 1, 1.2, 0.10416666666667
8939, 1, 1.175, 0.125
8940, 1, 1.25, 0.10416666666667
8941, 1, 1.225, 0.125
8942, 1, 1.3, 0.10416666666667
8943, 1, 1.275, 0.125
8944, 1, 1.325, 0.125
8945, 1, 0.2, 0.14583333333333
8946, 1, 0.175, 0.16666666666667
8947, 1, 0.25, 0.14583333333333
8948, 1, 0.225, 0.16666666666667
8949, 1, 0.3, 0.14583333333333
8950, 1, 0.275, 0.16666666666667
8951, 1, 0.35, 0.14583333333333
8952, 1, 0.325, 0.16666666666667
8953, 1, 0.4, 0.14583333333333
8954, 1, 0.375, 0.16666666666667
8955, 1, 0.45, 0.14583333333333
8956, 1, 0.425, 0.16666666666667
8957, 1, 0.5, 0.14583333333333
8958, 1, 0.475, 0.16666666666667
8959, 1, 0.55, 0.14583333333333
8960, 1, 0.525, 0.16666666666667
8961, 1, 0.6, 0.14583333333333
8962, 1, 0.575, 0.16666666666667
8963, 1, 0.65, 0.14583333333333
8964, 1, 0.625, 0.16666666666667
8965, 1, 0.7, 0.14583333333333
8966, 1, 0.675, 0.16666666666667
8967, 1, 0.75, 0.14583333333333
8968, 1, 0.725, 0.16666666666667
8969, 1, 0.8, 0.14583333333333
8970, 1, 0.775, 0.16666666666667
8971, 1, 0.85, 0.14583333333333
8972, 1, 0.825, 0.16666666666667
8973, 1, 0.9, 0.14583333333333
8974, 1, 0.875, 0.16666666666667
8975, 1, 0.95, 0.14583333333333
8976, 1, 0.925, 0.16666666666667
8977, 1, 1, 0.14583333333333
8978, 1, 0.975, 0.16666666666667
8979, 1, 1.05, 0.14583333333333
8980, 1, 1.025, 0.16666666666667
8981, 1, 1.1, 0.14583333333333
8982, 1, 1.075, 0.16666666666667
8983, 1, 1.15, 0.14583333333333
8984, 1, 1.125, 0.16666666666667
8985, 1, 1.2, 0.14583333333333
8986, 1, 1.175, 0.16666666666667
8987, 1, 1.25, 0.14583333333333
8988, 1, 1.225, 0.16666666666667
8989, 1, 1.3, 0.14583333333333
8990, 1, 1.275, 0.16666666666667
8991, 1, 1.325, 0.16666666666667
8992, 1, 0.2, 0.1875
8993, 1, 0.175, 0.20833333333333
8994, 1, 0.25, 0.1875
8995, 1, 0.225, 0.20833333333333
8996, 1, 0.3, 0.1875
8997, 1, 0.275, 0.20833333333333
8998, 1, 0.35, 0.1875
8999, 1, 0.325, 0.20833333333333
9000, 1, 0.4, 0.1875
9001, 1, 0.375, 0.20833333333333
9002, 1, 0.45, 0.1875
9003, 1, 0.425, 0.20833333333333
9004, 1, 0.5, 0.1875
9005, 1, 0.475, 0.20833333333333
9006, 1, 0.55, 0.1875
9007, 1, 0.525, 0.20833333333333
9008, 1, 0.6, 0.1875
9009, 1, 0.575, 0.20833333333333
9010, 1, 0.65, 0.1875
9011, 1, 0.625, 0.20833333333333
9012, 1, 0.7, 0.1875
9013, 1, 0.675, 0.20833333333333
9014, 1, 0.75, 0.1875
9015, 1, 0.725, 0.20833333333333
9016, 1, 0.8, 0.1875
9017, 1, 0.775, 0.20833333333333
9018, 1, 0.85, 0.1875
9019, 1, 0.825, 0.20833333333333
9020, 1, 0.9, 0.1875
9021, 1, 0.875, 0.20833333333333
9022, 1, 0.95, 0.1875
9023, 1, 0.925, 0.20833333333333
9024, 1, 1, 0.1875
9025, 1, 0.975, 0.20833333333333
9026, 1, 1.05, 0.1875
9027, 1, 1.025, 0.20833333333333
9028, 1, 1.1, 0.1875
9029, 1, 1.075, 0.20833333333333
9030, 1, 1.15, 0.1875
9031, 1, 1.125, 0.20833333333333
9032, 1, 1.2, 0.1875
9033, 1, 1.175, 0.20833333333333
9034, 1, 1.25, 0.1875
9035, 1, 1.225, 0.20833333333333
9036, 1, 1.3, 0.1875
9037, 1, 1.275, 0.20833333333333
9038, 1, 1.325, 0.20833333333333
9039, 1, 0.2, 0.22916666666667
9040, 1, 0.175, 0.25
9041, 1, 0.25, 0.22916666666667
9042, 1, 0.225, 0.25
9043, 1, 0.3, 0.22916666666667
9044, 1, 0.275, 0.25
9045, 1, 0.35, 0.22916666666667
9046, 1, 0.325, 0.25
9047, 1, 0.4, 0.22916666666667
9048, 1, 0.375, 0.25
9049, 1, 0.45, 0.22916666666667
9050, 1, 0.425, 0.25
9051, 1, 0.5, 0.22916666666667
9052, 1, 0.475, 0.25
9053, 1, 0.55, 0.22916666666667
9054, 1, 0.525, 0.25
9055, 1, 0.6, 0.22916666666667
9056, 1, 0.575, 0.25
9057, 1, 0.65, 0.22916666666667
9058, 1, 0.625, 0.25
9059, 1, 0.7, 0.22916666666667
9060, 1, 0.675, 0.25
9061, 1, 0.75, 0.22916666666667
9062, 1, 0.725, 0.25
9063, 1, 0.8, 0.22916666666667
9064, 1, 0.775, 0.25
9065, 1, 0.85, 0.22916666666667
9066, 1, 0.825, 0.25
9067, 1, 0.9, 0.22916666666667
9068, 1, 0.875, 0.25
9069, 1, 0.95, 0.22916666666667
9070, 1, 0.925, 0.25
9071, 1, 1, 0.22916666666667
9072, 1, 0.975, 0.25
9073, 1, 1.05, 0.22916666666667
9074, 1, 1.025, 0.25
9075, 1, 1.1, 0.22916666666667
9076, 1, 1.075, 0.25
9077, 1, 1.15, 0.22916666666667
9078, 1, 1.125, 0.25
9079, 1, 1.2, 0.22916666666667
9080, 1, 1.175, 0.25
9081, 1, 1.25, 0.22916666666667
9082, 1, 1.225, 0.25
9083, 1, 1.3, 0.22916666666667
9084, 1, 1.275, 0.25
9085, 1, 1.325, 0.25
9086, 1, 0.2, 0.27083333333333
9087, 1, 0.175, 0.29166666666667
9088, 1, 0.25, 0.27083333333333
9089, 1, 0.225, 0.29166666666667
9090, 1, 0.3, 0.27083333333333
9091, 1, 0.275, 0.29166666666667
9092, 1, 0.35, 0.27083333333333
9093, 1, 0.325, 0.29166666666667
9094, 1, 0.4, 0.27083333333333
9095, 1, 0.375, 0.29166666666667
9096, 1, 0.45, 0.27083333333333
9097, 1, 0.425, 0.29166666666667
9098, 1, 0.5, 0.27083333333333
9099, 1, 0.475, 0.29166666666667
9100, 1, 0.55, 0.27083333333333
9101, 1, 0.525, 0.29166666666667
9102, 1, 0.6, 0.27083333333333
9103, 1, 0.575, 0.29166666666667
9104, 1, 0.65, 0.27083333333333
9105, 1, 0.625, 0.29166666666667
9106, 1, 0.7, 0.27083333333333
9107, 1, 0.675, 0.29166666666667
9108, 1, 0.75, 0.27083333333333
9109, 1, 0.725, 0.29166666666667
9110, 1, 0.8, 0.27083333333333
9111, 1, 0.775, 0.29166666666667
9112, 1, 0.85, 0.27083333333333
9113, 1, 0.825, 0.29166666666667
9114, 1, 0.9, 0.27083333333333
9115, 1, 0.875, 0.29166666666667
9116, 1, 0.95, 0.27083333333333
9117, 1, 0.925, 0.29166666666667
9118, 1, 1, 0.27083333333333
9119, 1, 0.975, 0.29166666666667
9120, 1, 1.05, 0.27083333333333
9121, 1, 1.025, 0.29166666666667
9122, 1, 1.1, 0.27083333333333
9123, 1, 1.075, 0.29166666666667
9124, 1, 1.15, 0.27083333333333
9125, 1, 1.125, 0.29166666666667
9126, 1, 1.2, 0.27083333333333
9127, 1, 1.175, 0.29166666666667
9128, 1, 1.25, 0.27083333333333
9129, 1, 1.225, 0.29166666666667
9130, 1, 1.3, 0.27083333333333
9131, 1, 1.275, 0.29166666666667
9132, 1, 1.325, 0.29166666666667
9133, 1, 0.2, 0.3125
9134, 1, 0.175, 0.33333333333333
9135, 1, 0.25, 0.3125
9136, 1, 0.225, 0.33333333333333
9137, 1, 0.3, 0.3125
9138, 1, 0.275, 0.33333333333333
9139, 1, 0.35, 0.3125
9140, 1, 0.325, 0.33333333333333
9141, 1, 0.4, 0.3125
9142, 1, 0.375, 0.33333333333333
9143, 1, 0.45, 0.3125
9144, 1, 0.425, 0.33333333333333
9145, 1, 0.5, 0.3125
9146, 1, 0.475, 0.33333333333333
9147, 1, 0.55, 0.3125
9148, 1, 0.525, 0.33333333333333
9149, 1, 0.6, 0.3125
9150, 1, 0.575, 0.33333333333333
9151, 1, 0.65, 0.3125
9152, 1, 0.625, 0.33333333333333
9153, 1, 0.7, 0.3125
9154, 1, 0.675, 0.33333333333333
9155, 1, 0.75, 0.3125
9156, 1, 0.725, 0.33333333333333
9157, 1, 0.8, 0.3125
9158, 1, 0.775, 0.33333333333333
9159, 1, 0.85, 0.3125
9160, 1, 0.825, 0.33333333333333
9161, 1, 0.9, 0.3125
9162, 1, 0.875, 0.33333333333333
9163, 1, 0.95, 0.3125
9164, 1, 0.925, 0.33333333333333
9165, 1, 1, 0.3125
9166, 1, 0.975, 0.33333333333333
9167, 1, 1.05, 0.3125
9168, 1, 1.025, 0.33333333333333
9169, 1, 1.1, 0.3125
9170, 1, 1.075, 0.33333333333333
9171, 1, 1.15, 0.3125
9172, 1, 1.125, 0.33333333333333
9173, 1, 1.2, 0.3125
9174, 1, 1.175, 0.33333333333333
9175, 1, 1.25, 0.3125
9176, 1, 1.225, 0.33333333333333
9177, 1, 1.3, 0.3125
9178, 1, 1.275, 0.33333333333333
9179, 1, 1.325, 0.33333333333333
9180, 1, 0.2, 0.35416666666667
9181, 1, 0.175, 0.375
9182, 1, 0.25, 0.35416666666667
9183, 1, 0.225, 0.375
9184, 1, 0.3, 0.35416666666667
9185, 1, 0.275, 0.375
9186, 1, 0.35, 0.35416666666667
9187, 1, 0.325, 0.375
9188, 1, 0.4, 0.35416666666667
9189, 1, 0.375, 0.375
9190, 1, 0.45, 0.35416666666667
9191, 1, 0.425, 0.375
9192, 1, 0.5, 0.35416666666667
9193, 1, 0.475, 0.375
9194, 1, 0.55, 0.35416666666667
9195, 1, 0.525, 0.375
9196, 1, 0.6, 0.35416666666667
9197, 1, 0.575, 0.375
9198, 1, 0.65, 0.35416666666667
9199, 1, 0.625, 0.375
9200, 1, 0.7, 0.35416666666667
9201, 1, 0.675, 0.375
9202, 1, 0.75, 0.35416666666667
9203, 1, 0.725, 0.375
9204, 1, 0.8, 0.35416666666667
9205, 1, 0.775, 0.375
9206, 1, 0.85, 0.35416666666667
9207, 1, 0.825, 0.375
9208, 1, 0.9, 0.35416666666667
9209, 1, 0.875, 0.375
9210, 1, 0.95, 0.35416666666667
9211, 1, 0.925, 0.375
9212, 1, 1, 0.35416666666667
9213, 1, 0.975, 0.375
9214, 1, 1.05, 0.35416666666667
9215, 1, 1.025, 0.375
9216, 1, 1.1, 0.35416666666667
9217, 1, 1.075, 0.375
9218, 1, 1.15, 0.35416666666667
9219, 1, 1.125, 0.375
9220, 1, 1.2, 0.35416666666667
9221, 1, 1.175, 0.375
9222, 1, 1.25, 0.35416666666667
9223, 1, 1.225, 0.375
9224, 1, 1.3, 0.35416666666667
9225, 1, 1.275, 0.375
9226, 1, 1.325, 0.375
9227, 1, 0.2, 0.39583333333333
9228, 1, 0.175, 0.41666666666667
9229, 1, 0.25, 0.39583333333333
9230, 1, 0.225, 0.41666666666667
9231, 1, 0.3, 0.39583333333333
9232, 1, 0.275, 0.41666666666667
9233, 1, 0.35, 0.39583333333333
9234, 1, 0.325, 0.41666666666667
9235, 1, 0.4, 0.39583333333333
9236, 1, 0.375, 0.41666666666667
9237, 1, 0.45, 0.39583333333333
9238, 1, 0.425, 0.41666666666667
9239, 1, 0.5, 0.39583333333333
9240, 1, 0.475, 0.41666666666667
9241, 1, 0.55, 0.39583333333333
9242, 1, 0.525, 0.41666666666667
9243, 1, 0.6, 0.39583333333333
9244, 1, 0.575, 0.41666666666667
9245, 1, 0.65, 0.39583333333333
9246, 1, 0.625, 0.41666666666667
9247, 1, 0.7, 0.39583333333333
9248, 1, 0.675, 0.41666666666667
9249, 1, 0.75, 0.39583333333333
9250, 1, 0.725, 0.41666666666667
9251, 1, 0.8, 0.39583333333333
9252, 1, 0.775, 0.41666666666667
9253, 1, 0.85, 0.39583333333333
9254, 1, 0.825, 0.41666666666667
9255, 1, 0.9, 0.39583333333333
9256, 1, 0.875, 0.41666666666667
9257, 1, 0.95, 0.39583333333333
9258, 1, 0.925, 0.41666666666667
9259, 1, 1, 0.39583333333333
9260, 1, 0.975, 0.41666666666667
9261, 1, 1.05, 0.39583333333333
9262, 1, 1.025, 0.41666666666667
9263, 1, 1.1, 0.39583333333333
9264, 1, 1.075, 0.41666666666667
9265, 1, 1.15, 0.39583333333333
9266, 1, 1.125, 0.41666666666667
9267, 1, 1.2, 0.39583333333333
9268, 1, 1.175, 0.41666666666667
9269, 1, 1.25, 0.39583333333333
9270, 1, 1.225, 0.41666666666667
9271, 1, 1.3, 0.39583333333333
9272, 1, 1.275, 0.41666666666667
9273, 1, 1.325, 0.41666666666667
9274, 1, 0.2, 0.4375
9275, 1, 0.175, 0.45833333333333
9276, 1, 0.25, 0.4375
9277, 1, 0.225, 0.45833333333333
9278, 1, 0.3, 0.4375
9279, 1, 0.275, 0.45833333333333
9280, 1, 0.35, 0.4375
9281, 1, 0.325, 0.45833333333333
9282, 1, 0.4, 0.4375
9283, 1, 0.375, 0.45833333333333
9284, 1, 0.45, 0.4375
9285, 1, 0.425, 0.45833333333333
9286, 1, 0.5, 0.4375
9287, 1, 0.475, 0.45833333333333
9288, 1, 0.55, 0.4375
9289, 1, 0.525, 0.45833333333333
9290, 1, 0.6, 0.4375
9291, 1, 0.575, 0.45833333333333
9292, 1, 0.65, 0.4375
9293, 1, 0.625, 0.45833333333333
9294, 1, 0.7, 0.4375
9295, 1, 0.675, 0.45833333333333
9296, 1, 0.75, 0.4375
9297, 1, 0.725, 0.45833333333333
9298, 1, 0.8, 0.4375
9299, 1, 0.775, 0.45833333333333
9300, 1, 0.85, 0.4375
9301, 1, 0.825, 0.45833333333333
9302, 1, 0.9, 0.4375
9303, 1, 0.875, 0.45833333333333
9304, 1, 0.95, 0.4375
9305, 1, 0.925, 0.45833333333333
9306, 1, 1, 0.4375
9307, 1, 0.975, 0.45833333333333
9308, 1, 1.05, 0.4375
9309, 1, 1.025, 0.45833333333333
9310, 1, 1.1, 0.4375
9311, 1, 1.075, 0.45833333333333
9312, 1, 1.15, 0.4375
9313, 1, 1.125, 0.45833333333333
9314, 1, 1.2, 0.4375
9315, 1, 1.175, 0.45833333333333
9316, 1, 1.25, 0.4375
9317, 1, 1.225, 0.45833333333333
9318, 1, 1.3, 0.4375
9319, 1, 1.275, 0.45833333333333
9320, 1, 1.325, 0.45833333333333
9321, 1, 0.2, 0.47916666666667
9322, 1, 0.25, 0.47916666666667
9323, 1, 0.3, 0.47916666666667
9324, 1, 0.35, 0.47916666666667
9325, 1, 0.4, 0.47916666666667
9326, 1, 0.45, 0.47916666666667
9327, 1, 0.5, 0.47916666666667
9328, 1, 0.55, 0.47916666666667
9329, 1, 0.6, 0.47916666666667
9330, 1, 0.65, 0.47916666666667
9331, 1, 0.7, 0.47916666666667
9332, 1, 0.75, 0.47916666666667
9333, 1, 0.8, 0.47916666666667
9334, 1, 0.85, 0.47916666666667
9335, 1, 0.9, 0.47916666666667
9336, 1, 0.95, 0.47916666666667
9337, 1, 1, 0.47916666666667
9338, 1, 1.05, 0.47916666666667
9339, 1, 1.1, 0.47916666666667
9340, 1, 1.15, 0.47916666666667
9341, 1, 1.2, 0.47916666666667
9342, 1, 1.25, 0.47916666666667
9343, 1, 1.3, 0.47916666666667
9344, 0.041666666666667, 0.2, 0.5
9345, 0.041666666666667, 0.25, 0.5
9346, 0.041666666666667, 0.3, 0.5
9347, 0.041666666666667, 0.35, 0.5
9348, 0.041666666666667, 0.4, 0.5
9349, 0.041666666666667, 0.45, 0.5
9350, 0.041666666666667, 0.5, 0.5
9351, 0.041666666666667, 0.55, 0.5
9352, 0.041666666666667, 0.6, 0.5
9353, 0.041666666666667, 0.65, 0.5
9354, 0.041666666666667, 0.7, 0.5
9355, 0.041666666666667, 0.75, 0.5
9356, 0.041666666666667, 0.8, 0.5
9357, 0.041666666666667, 0.85, 0.5
9358, 0.041666666666667, 0.9, 0.5
9359, 0.041666666666667, 0.95, 0.5
9360, 0.041666666666667, 1, 0.5
9361, 0.041666666666667, 1.05, 0.5
9362, 0.041666666666667, 1.1, 0.5
9363, 0.041666666666667, 1.15, 0.5
9364, 0.041666666666667, 1.2, 0.5
9365, 0.041666666666667, 1.25, 0.5
9366, 0.041666666666667, 1.3, 0.5
9367, 0.083333333333333, 0.2, 0.5
9368, 0.083333333333333, 0.25, 0.5
9369, 0.083333333333333, 0.3, 0.5
9370, 0.083333333333333, 0.35, 0.5
9371, 0.083333333333333, 0.4, 0.5
9372, 0.083333333333333, 0.45, 0.5
9373, 0.083333333333333, 0.5, 0.5
9374, 0.083333333333333, 0.55, 0.5
9375, 0.083333333333333, 0.6, 0.5
9376, 0.083333333333333, 0.65, 0.5
9377, 0.083333333333333, 0.7, 0.5
9378, 0.083333333333333, 0.75, 0.5
9379, 0.083333333333333, 0.8, 0.5
9380, 0.083333333333333, 0.85, 0.5
9381, 0.083333333333333, 0.9, 0.5
9382, 0.083333333333333, 0.95, 0.5
9383, 0.083333333333333, 1, 0.5
9384, 0.083333333333333, 1.05, 0.5
9385, 0.083333333333333, 1.1, 0.5
9386, 0.083333333333333, 1.15, 0.5
9387, 0.083333333333333, 1.2, 0.5
9388, 0.083333333333333, 1.25, 0.5
9389, 0.083333333333333, 1.3, 0.5
9390, 0.125, 0.2, 0.5
9391, 0.125, 0.25, 0.5
9392, 0.125, 0.3, 0.5
9393, 0.125, 0.35, 0.5
9394, 0.125, 0.4, 0.5
9395, 0.125, 0.45, 0.5
9396, 0.125, 0.5, 0.5
9397, 0.125, 0.55, 0.5
9398, 0.125, 0.6, 0.5
9399, 0.125, 0.65, 0.5
9400, 0.125, 0.7, 0.5
9401, 0.125, 0.75, 0.5
9402, 0.125, 0.8, 0.5
9403, 0.125, 0.85, 0.5
9404, 0.125, 0.9, 0.5
9405, 0.125, 0.95, 0.5
9406, 0.125, 1, 0.5
9407, 0.125, 1.05, 0.5
9408, 0.125, 1.1, 0.5
9409, 0.125, 1.15, 0.5
9410, 0.125, 1.2, 0.5
9411, 0.125, 1.25, 0.5
9412, 0.125, 1.3, 0.5
9413, 0.16666666666667, 0.2, 0.5
9414, 0.16666666666667, 0.25, 0.5
9415, 0.16666666666667, 0.3, 0.5
9416, 0.16666666666667, 0.35, 0.5
9417, 0.16666666666667, 0.4, 0.5
9418, 0.16666666666667, 0.45, 0.5
9419, 0.16666666666667, 0.5, 0.5
9420, 0.16666666666667, 0.55, 0.5
9421, 0.16666666666667, 0.6, 0.5
9422, 0.16666666666667, 0.65, 0.5
9423, 0.16666666666667, 0.7, 0.5
9424, 0.16666666666667, 0.75, 0.5
9425, 0.16666666666667, 0.8, 0.5
9426, 0.16666666666667, 0.85, 0.5
9427, 0.16666666666667, 0.9, 0.5
9428, 0.16666666666667, 0.95, 0.5
9429, 0.16666666666667, 1, 0.5
9430, 0.16666666666667, 1.05, 0.5
9431, 0.16666666666667, 1.1, 0.5
9432, 0.16666666666667, 1.15, 0.5
9433, 0.16666666666667, 1.2, 0.5
9434, 0.16666666666667, 1.25, 0.5
9435, 0.16666666666667, 1.3, 0.5
9436, 0.20833333333333, 0.2, 0.5
9437, 0.20833333333333, 0.25, 0.5
9438, 0.20833333333333, 0.3, 0.5
9439, 0.20833333333333, 0.35, 0.5
9440, 0.20833333333333, 0.4, 0.5
9441, 0.20833333333333, 0.45, 0.5
9442, 0.20833333333333, 0.5, 0.5
9443, 0.20833333333333, 0.55, 0.5
9444, 0.20833333333333, 0.6, 0.5
9445, 0.20833333333333, 0.65, 0.5
9446, 0.20833333333333, 0.7, 0.5
9447, 0.20833333333333, 0.75, 0.5
9448, 0.20833333333333, 0.8, 0.5
9449, 0.20833333333333, 0.85, 0.5
9450, 0.20833333333333, 0.9, 0.5
9451, 0.20833333333333, 0.95, 0.5
9452, 0.20833333333333, 1, 0.5
9453, 0.20833333333333, 1.05, 0.5
9454, 0.20833333333333, 1.1, 0.5
9455, 0.20833333333333, 1.15, 0.5
9456, 0.20833333333333, 1.2, 0.5
9457, 0.20833333333333, 1.25, 0.5
9458, 0.20833333333333, 1.3, 0.5
9459, 0.25, 0.2, 0.5
9460, 0.25, 0.25, 0.5
9461, 0.25, 0.3, 0.5
9462, 0.25, 0.35, 0.5
9463, 0.25, 0.4, 0.5
9464, 0.25, 0.45, 0.5
9465, 0.25, 0.5, 0.5
9466, 0.25, 0.55, 0.5
9467, 0.25, 0.6, 0.5
9468, 0.25, 0.65, 0.5
9469, 0.25, 0.7, 0.5
9470, 0.25, 0.75, 0.5
9471, 0.25, 0.8, 0.5
9472, 0.25, 0.85, 0.5
9473, 0.25, 0.9, 0.5
9474, 0.25, 0.95, 0.5
9475, 0.25, 1, 0.5
9476, 0.25, 1.05, 0.5
9477, 0.25, 1.1, 0.5
9478, 0.25, 1.15, 0.5
9479, 0.25, 1.2, 0.5
9480, 0.25, 1.25, 0.5
9481, 0.25, 1.3, 0.5
9482, 0.29166666666667, 0.2, 0.5
9483, 0.29166666666667, 0.25, 0.5
9484, 0.29166666666667, 0.3, 0.5
9485, 0.29166666666667, 0.35, 0.5
9486, 0.29166666666667, 0.4, 0.5
9487, 0.29166666666667, 0.45, 0.5
9488, 0.29166666666667, 0.5, 0.5
9489, 0.29166666666667, 0.55, 0.5
9490, 0.29166666666667, 0.6, 0.5
9491, 0.29166666666667, 0.65, 0.5
9492, 0.29166666666667, 0.7, 0.5
9493, 0.29166666666667, 0.75, 0.5
9494, 0.29166666666667, 0.8, 0.5
9495, 0.29166666666667, 0.85, 0.5
9496, 0.29166666666667, 0.9, 0.5
9497, 0.29166666666667, 0.95, 0.5
9498, 0.29166666666667, 1, 0.5
9499, 0.29166666666667, 1.05, 0.5
9500, 0.29166666666667, 1.1, 0.5
9501, 0.29166666666667, 1.15, 0.5
9502, 0.29166666666667, 1.2, 0.5
9503, 0.29166666666667, 1.25, 0.5
9504, 0.29166666666667, 1.3, 0.5
9505, 0.33333333333333, 0.2, 0.5
9506, 0.33333333333333, 0.25, 0.5
9507, 0.33333333333333, 0.3, 0.5
9508, 0.33333333333333, 0.35, 0.5
9509, 0.33333333333333, 0.4, 0.5
9510, 0.33333333333333, 0.45, 0.5
9511, 0.33333333333333, 0.5, 0.5
9512, 0.33333333333333, 0.55, 0.5
9513, 0.33333333333333, 0.6, 0.5
9514, 0.33333333333333, 0.65, 0.5
9515, 0.33333333333333, 0.7, 0.5
9516, 0.33333333333333, 0.75, 0.5
9517, 0.33333333333333, 0.8, 0.5
9518, 0.33333333333333, 0.85, 0.5
9519, 0.33333333333333, 0.9, 0.5
9520, 0.33333333333333, 0.95, 0.5
9521, 0.33333333333333, 1, 0.5
9522, 0.33333333333333, 1.05, 0.5
9523, 0.33333333333333, 1.1, 0.5
9524, 0.33333333333333, 1.15, 0.5
9525, 0.33333333333333, 1.2, 0.5
9526, 0.33333333333333, 1.25, 0.5
9527, 0.33333333333333, 1.3, 0.5
9528, 0.375, 0.2, 0.5
9529, 0.375, 0.25, 0.5
9530, 0.375, 0.3, 0.5
9531, 0.375, 0.35, 0.5
9532, 0.375, 0.4, 0.5
9533, 0.375, 0.45, 0.5
9534, 0.375, 0.5, 0.5
9535, 0.375, 0.55, 0.5
9536, 0.375, 0.6, 0.5
9537, 0.375, 0.65, 0.5
9538, 0.375, 0.7, 0.5
9539, 0.375, 0.75, 0.5
9540, 0.375, 0.8, 0.5
9541, 0.375, 0.85, 0.5
9542, 0.375, 0.9, 0.5
9543, 0.375, 0.95, 0.5
9544, 0.375, 1, 0.5
9545, 0.375, 1.05, 0.5
9546, 0.375, 1.1, 0.5
9547, 0.375, 1.15, 0.5
9548, 0.375, 1.2, 0.5
9549, 0.375, 1.25, 0.5
9550, 0.375, 1.3, 0.5
9551, 0.41666666666667, 0.2, 0.5
9552, 0.41666666666667, 0.25, 0.5
9553, 0.41666666666667, 0.3, 0.5
9554, 0.41666666666667, 0.35, 0.5
9555, 0.41666666666667, 0.4, 0.5
9556, 0.41666666666667, 0.45, 0.5
9557, 0.41666666666667, 0.5, 0.5
9558, 0.41666666666667, 0.55, 0.5
9559, 0.41666666666667, 0.6, 0.5
9560, 0.41666666666667, 0.65, 0.5
9561, 0.41666666666667, 0.7, 0.5
9562, 0.41666666666667, 0.75, 0.5
9563, 0.41666666666667, 0.8, 0.5
9564, 0.41666666666667, 0.85, 0.5
9565, 0.41666666666667, 0.9, 0.5
9566, 0.41666666666667, 0.95, 0.5
9567, 0.41666666666667, 1, 0.5
9568, 0.41666666666667, 1.05, 0.5
9569, 0.41666666666667, 1.1, 0.5
9570, 0.41666666666667, 1.15, 0.5
9571, 0.41666666666667, 1.2, 0.5
9572, 0.41666666666667, 1.25, 0.5
9573, 0.41666666666667, 1.3, 0.5
9574, 0.45833333333333, 0.2, 0.5
9575, 0.45833333333333, 0.25, 0.5
9576, 0.45833333333333, 0.3, 0.5
9577, 0.45833333333333, 0.35, 0.5
9578, 0.45833333333333, 0.4, 0.5
9579, 0.45833333333333, 0.45, 0.5
9580, 0.45833333333333, 0.5, 0.5
9581, 0.45833333333333, 0.55, 0.5
9582, 0.45833333333333, 0.6, 0.5
9583, 0.45833333333333, 0.65, 0.5
9584, 0.45833333333333, 0.7, 0.5
9585, 0.45833333333333, 0.75, 0.5
9586, 0.45833333333333, 0.8, 0.5
9587, 0.45833333333333, 0.85, 0.5
9588, 0.45833333333333, 0.9, 0.5
9589, 0.45833333333333, 0.95, 0.5
9590, 0.45833333333333, 1, 0.5
9591, 0.45833333333333, 1.05, 0.5
9592, 0.45833333333333, 1.1, 0.5
9593, 0.45833333333333, 1.15, 0.5
9594, 0.45833333333333, 1.2, 0.5
9595, 0.45833333333333, 1.25, 0.5
9596, 0.45833333333333, 1.3, 0.5
9597, 0.5, 0.2, 0.5
9598, 0.5, 0.25, 0.5
9599, 0.5, 0.3, 0.5
9600, 0.5, 0.35, 0.5
9601, 0.5, 0.4, 0.5
9602, 0.5, 0.45, 0.5
9603, 0.5, 0.5, 0.5
9604, 0.5, 0.55, 0.5
9605, 0.5, 0.6, 0.5
9606, 0.5, 0.65, 0.5
9607, 0.5, 0.7, 0.5
9608, 0.5, 0.75, 0.5
9609, 0.5, 0.8, 0.5
9610, 0.5, 0.85, 0.5
9611, 0.5, 0.9, 0.5
9612, 0.5, 0.95, 0.5
9613, 0.5, 1, 0.5
9614, 0.5, 1.05, 0.5
9615, 0.5, 1.1, 0.5
9616, 0.5, 1.15, 0.5
9617, 0.5, 1.2, 0.5
9618, 0.5, 1.25, 0.5
9619, 0.5, 1.3, 0.5
9620, 0.54166666666667, 0.2, 0.5
9621, 0.54166666666667, 0.25, 0.5
9622, 0.54166666666667, 0.3, 0.5
9623, 0.54166666666667, 0.35, 0.5
9624, 0.54166666666667, 0.4, 0.5
9625, 0.54166666666667, 0.45, 0.5
9626, 0.54166666666667, 0.5, 0.5
9627, 0.54166666666667, 0.55, 0.5
9628, 0.54166666666667, 0.6, 0.5
9629, 0.54166666666667, 0.65, 0.5
9630, 0.54166666666667, 0.7, 0.5
9631, 0.54166666666667, 0.75, 0.5
9632, 0.54166666666667, 0.8, 0.5
9633, 0.54166666666667, 0.85, 0.5
9634, 0.54166666666667, 0.9, 0.5
9635, 0.54166666666667, 0.95, 0.5
9636, 0.54166666666667, 1, 0.5
9637, 0.54166666666667, 1.05, 0.5
9638, 0.54166666666667, 1.1, 0.5
9639, 0.54166666666667, 1.15, 0.5
9640, 0.54166666666667, 1.2, 0.5
9641, 0.54166666666667, 1.25, 0.5
9642, 0.54166666666667, 1.3, 0.5
9643, 0.58333333333333, 0.2, 0.5
9644, 0.58333333333333, 0.25, 0.5
9645, 0.58333333333333, 0.3, 0.5
9646, 0.58333333333333, 0.35, 0.5
9647, 0.58333333333333, 0.4, 0.5
9648, 0.58333333333333, 0.45, 0.5
9649, 0.58333333333333, 0.5, 0.5
