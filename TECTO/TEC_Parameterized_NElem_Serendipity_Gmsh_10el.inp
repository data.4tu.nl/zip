111294, 0.29166666666667, -0.18, 0.20833333333333
111295, 0.29166666666667, -0.02, 0.25
111296, 0.29166666666667, -0.04, 0.22916666666667
111297, 0.27083333333333, -0.04, 0.25
111298, 0.29166666666667, -0.06, 0.25
111299, 0.29166666666667, -0.08, 0.22916666666667
111300, 0.27083333333333, -0.08, 0.25
111301, 0.29166666666667, -0.1, 0.25
111302, 0.29166666666667, -0.12, 0.22916666666667
111303, 0.27083333333333, -0.12, 0.25
111304, 0.29166666666667, -0.14, 0.25
111305, 0.29166666666667, -0.16, 0.22916666666667
111306, 0.27083333333333, -0.16, 0.25
111307, 0.29166666666667, -0.18, 0.25
111308, 0.29166666666667, -0.02, 0.29166666666667
111309, 0.29166666666667, -0.04, 0.27083333333333
111310, 0.27083333333333, -0.04, 0.29166666666667
111311, 0.29166666666667, -0.06, 0.29166666666667
111312, 0.29166666666667, -0.08, 0.27083333333333
111313, 0.27083333333333, -0.08, 0.29166666666667
111314, 0.29166666666667, -0.1, 0.29166666666667
111315, 0.29166666666667, -0.12, 0.27083333333333
111316, 0.27083333333333, -0.12, 0.29166666666667
111317, 0.29166666666667, -0.14, 0.29166666666667
111318, 0.29166666666667, -0.16, 0.27083333333333
111319, 0.27083333333333, -0.16, 0.29166666666667
111320, 0.29166666666667, -0.18, 0.29166666666667
111321, 0.29166666666667, -0.02, 0.33333333333333
111322, 0.29166666666667, -0.04, 0.3125
111323, 0.27083333333333, -0.04, 0.33333333333333
111324, 0.29166666666667, -0.06, 0.33333333333333
111325, 0.29166666666667, -0.08, 0.3125
111326, 0.27083333333333, -0.08, 0.33333333333333
111327, 0.29166666666667, -0.1, 0.33333333333333
111328, 0.29166666666667, -0.12, 0.3125
111329, 0.27083333333333, -0.12, 0.33333333333333
111330, 0.29166666666667, -0.14, 0.33333333333333
111331, 0.29166666666667, -0.16, 0.3125
111332, 0.27083333333333, -0.16, 0.33333333333333
111333, 0.29166666666667, -0.18, 0.33333333333333
111334, 0.29166666666667, -0.02, 0.375
111335, 0.29166666666667, -0.04, 0.35416666666667
111336, 0.27083333333333, -0.04, 0.375
111337, 0.29166666666667, -0.06, 0.375
111338, 0.29166666666667, -0.08, 0.35416666666667
111339, 0.27083333333333, -0.08, 0.375
111340, 0.29166666666667, -0.1, 0.375
111341, 0.29166666666667, -0.12, 0.35416666666667
111342, 0.27083333333333, -0.12, 0.375
111343, 0.29166666666667, -0.14, 0.375
111344, 0.29166666666667, -0.16, 0.35416666666667
111345, 0.27083333333333, -0.16, 0.375
111346, 0.29166666666667, -0.18, 0.375
111347, 0.29166666666667, -0.02, 0.41666666666667
111348, 0.29166666666667, -0.04, 0.39583333333333
111349, 0.27083333333333, -0.04, 0.41666666666667
111350, 0.29166666666667, -0.06, 0.41666666666667
111351, 0.29166666666667, -0.08, 0.39583333333333
111352, 0.27083333333333, -0.08, 0.41666666666667
111353, 0.29166666666667, -0.1, 0.41666666666667
111354, 0.29166666666667, -0.12, 0.39583333333333
111355, 0.27083333333333, -0.12, 0.41666666666667
111356, 0.29166666666667, -0.14, 0.41666666666667
111357, 0.29166666666667, -0.16, 0.39583333333333
111358, 0.27083333333333, -0.16, 0.41666666666667
111359, 0.29166666666667, -0.18, 0.41666666666667
111360, 0.29166666666667, -0.02, 0.45833333333333
111361, 0.29166666666667, -0.04, 0.4375
111362, 0.27083333333333, -0.04, 0.45833333333333
111363, 0.29166666666667, -0.06, 0.45833333333333
111364, 0.29166666666667, -0.08, 0.4375
111365, 0.27083333333333, -0.08, 0.45833333333333
111366, 0.29166666666667, -0.1, 0.45833333333333
111367, 0.29166666666667, -0.12, 0.4375
111368, 0.27083333333333, -0.12, 0.45833333333333
111369, 0.29166666666667, -0.14, 0.45833333333333
111370, 0.29166666666667, -0.16, 0.4375
111371, 0.27083333333333, -0.16, 0.45833333333333
111372, 0.29166666666667, -0.18, 0.45833333333333
111373, 0.29166666666667, -0.04, 0.47916666666667
111374, 0.29166666666667, -0.08, 0.47916666666667
111375, 0.29166666666667, -0.12, 0.47916666666667
111376, 0.29166666666667, -0.16, 0.47916666666667
111377, 0.33333333333333, -0.02, 0.041666666666667
111378, 0.33333333333333, -0.04, 0.020833333333333
111379, 0.3125, -0.04, 0.041666666666667
111380, 0.33333333333333, -0.06, 0.041666666666667
111381, 0.33333333333333, -0.08, 0.020833333333333
111382, 0.3125, -0.08, 0.041666666666667
111383, 0.33333333333333, -0.1, 0.041666666666667
111384, 0.33333333333333, -0.12, 0.020833333333333
111385, 0.3125, -0.12, 0.041666666666667
111386, 0.33333333333333, -0.14, 0.041666666666667
111387, 0.33333333333333, -0.16, 0.020833333333333
111388, 0.3125, -0.16, 0.041666666666667
111389, 0.33333333333333, -0.18, 0.041666666666667
111390, 0.33333333333333, -0.02, 0.083333333333333
111391, 0.33333333333333, -0.04, 0.0625
111392, 0.3125, -0.04, 0.083333333333333
111393, 0.33333333333333, -0.06, 0.083333333333333
111394, 0.33333333333333, -0.08, 0.0625
111395, 0.3125, -0.08, 0.083333333333333
111396, 0.33333333333333, -0.1, 0.083333333333333
111397, 0.33333333333333, -0.12, 0.0625
111398, 0.3125, -0.12, 0.083333333333333
111399, 0.33333333333333, -0.14, 0.083333333333333
111400, 0.33333333333333, -0.16, 0.0625
111401, 0.3125, -0.16, 0.083333333333333
111402, 0.33333333333333, -0.18, 0.083333333333333
111403, 0.33333333333333, -0.02, 0.125
111404, 0.33333333333333, -0.04, 0.10416666666667
111405, 0.3125, -0.04, 0.125
111406, 0.33333333333333, -0.06, 0.125
111407, 0.33333333333333, -0.08, 0.10416666666667
111408, 0.3125, -0.08, 0.125
111409, 0.33333333333333, -0.1, 0.125
111410, 0.33333333333333, -0.12, 0.10416666666667
111411, 0.3125, -0.12, 0.125
111412, 0.33333333333333, -0.14, 0.125
111413, 0.33333333333333, -0.16, 0.10416666666667
111414, 0.3125, -0.16, 0.125
111415, 0.33333333333333, -0.18, 0.125
111416, 0.33333333333333, -0.02, 0.16666666666667
111417, 0.33333333333333, -0.04, 0.14583333333333
111418, 0.3125, -0.04, 0.16666666666667
111419, 0.33333333333333, -0.06, 0.16666666666667
111420, 0.33333333333333, -0.08, 0.14583333333333
111421, 0.3125, -0.08, 0.16666666666667
111422, 0.33333333333333, -0.1, 0.16666666666667
111423, 0.33333333333333, -0.12, 0.14583333333333
111424, 0.3125, -0.12, 0.16666666666667
111425, 0.33333333333333, -0.14, 0.16666666666667
111426, 0.33333333333333, -0.16, 0.14583333333333
111427, 0.3125, -0.16, 0.16666666666667
111428, 0.33333333333333, -0.18, 0.16666666666667
111429, 0.33333333333333, -0.02, 0.20833333333333
111430, 0.33333333333333, -0.04, 0.1875
111431, 0.3125, -0.04, 0.20833333333333
111432, 0.33333333333333, -0.06, 0.20833333333333
111433, 0.33333333333333, -0.08, 0.1875
111434, 0.3125, -0.08, 0.20833333333333
111435, 0.33333333333333, -0.1, 0.20833333333333
111436, 0.33333333333333, -0.12, 0.1875
111437, 0.3125, -0.12, 0.20833333333333
111438, 0.33333333333333, -0.14, 0.20833333333333
111439, 0.33333333333333, -0.16, 0.1875
111440, 0.3125, -0.16, 0.20833333333333
111441, 0.33333333333333, -0.18, 0.20833333333333
111442, 0.33333333333333, -0.02, 0.25
111443, 0.33333333333333, -0.04, 0.22916666666667
111444, 0.3125, -0.04, 0.25
111445, 0.33333333333333, -0.06, 0.25
111446, 0.33333333333333, -0.08, 0.22916666666667
111447, 0.3125, -0.08, 0.25
111448, 0.33333333333333, -0.1, 0.25
111449, 0.33333333333333, -0.12, 0.22916666666667
111450, 0.3125, -0.12, 0.25
111451, 0.33333333333333, -0.14, 0.25
111452, 0.33333333333333, -0.16, 0.22916666666667
111453, 0.3125, -0.16, 0.25
111454, 0.33333333333333, -0.18, 0.25
111455, 0.33333333333333, -0.02, 0.29166666666667
111456, 0.33333333333333, -0.04, 0.27083333333333
111457, 0.3125, -0.04, 0.29166666666667
111458, 0.33333333333333, -0.06, 0.29166666666667
111459, 0.33333333333333, -0.08, 0.27083333333333
111460, 0.3125, -0.08, 0.29166666666667
111461, 0.33333333333333, -0.1, 0.29166666666667
111462, 0.33333333333333, -0.12, 0.27083333333333
111463, 0.3125, -0.12, 0.29166666666667
111464, 0.33333333333333, -0.14, 0.29166666666667
111465, 0.33333333333333, -0.16, 0.27083333333333
111466, 0.3125, -0.16, 0.29166666666667
111467, 0.33333333333333, -0.18, 0.29166666666667
111468, 0.33333333333333, -0.02, 0.33333333333333
111469, 0.33333333333333, -0.04, 0.3125
111470, 0.3125, -0.04, 0.33333333333333
111471, 0.33333333333333, -0.06, 0.33333333333333
111472, 0.33333333333333, -0.08, 0.3125
111473, 0.3125, -0.08, 0.33333333333333
111474, 0.33333333333333, -0.1, 0.33333333333333
111475, 0.33333333333333, -0.12, 0.3125
111476, 0.3125, -0.12, 0.33333333333333
111477, 0.33333333333333, -0.14, 0.33333333333333
111478, 0.33333333333333, -0.16, 0.3125
111479, 0.3125, -0.16, 0.33333333333333
111480, 0.33333333333333, -0.18, 0.33333333333333
111481, 0.33333333333333, -0.02, 0.375
111482, 0.33333333333333, -0.04, 0.35416666666667
111483, 0.3125, -0.04, 0.375
111484, 0.33333333333333, -0.06, 0.375
111485, 0.33333333333333, -0.08, 0.35416666666667
111486, 0.3125, -0.08, 0.375
111487, 0.33333333333333, -0.1, 0.375
111488, 0.33333333333333, -0.12, 0.35416666666667
111489, 0.3125, -0.12, 0.375
111490, 0.33333333333333, -0.14, 0.375
111491, 0.33333333333333, -0.16, 0.35416666666667
111492, 0.3125, -0.16, 0.375
111493, 0.33333333333333, -0.18, 0.375
111494, 0.33333333333333, -0.02, 0.41666666666667
111495, 0.33333333333333, -0.04, 0.39583333333333
111496, 0.3125, -0.04, 0.41666666666667
111497, 0.33333333333333, -0.06, 0.41666666666667
111498, 0.33333333333333, -0.08, 0.39583333333333
111499, 0.3125, -0.08, 0.41666666666667
111500, 0.33333333333333, -0.1, 0.41666666666667
111501, 0.33333333333333, -0.12, 0.39583333333333
111502, 0.3125, -0.12, 0.41666666666667
111503, 0.33333333333333, -0.14, 0.41666666666667
111504, 0.33333333333333, -0.16, 0.39583333333333
111505, 0.3125, -0.16, 0.41666666666667
111506, 0.33333333333333, -0.18, 0.41666666666667
111507, 0.33333333333333, -0.02, 0.45833333333333
111508, 0.33333333333333, -0.04, 0.4375
111509, 0.3125, -0.04, 0.45833333333333
111510, 0.33333333333333, -0.06, 0.45833333333333
111511, 0.33333333333333, -0.08, 0.4375
111512, 0.3125, -0.08, 0.45833333333333
111513, 0.33333333333333, -0.1, 0.45833333333333
111514, 0.33333333333333, -0.12, 0.4375
111515, 0.3125, -0.12, 0.45833333333333
111516, 0.33333333333333, -0.14, 0.45833333333333
111517, 0.33333333333333, -0.16, 0.4375
111518, 0.3125, -0.16, 0.45833333333333
111519, 0.33333333333333, -0.18, 0.45833333333333
111520, 0.33333333333333, -0.04, 0.47916666666667
111521, 0.33333333333333, -0.08, 0.47916666666667
111522, 0.33333333333333, -0.12, 0.47916666666667
111523, 0.33333333333333, -0.16, 0.47916666666667
111524, 0.375, -0.02, 0.041666666666667
111525, 0.375, -0.04, 0.020833333333333
111526, 0.35416666666667, -0.04, 0.041666666666667
111527, 0.375, -0.06, 0.041666666666667
111528, 0.375, -0.08, 0.020833333333333
111529, 0.35416666666667, -0.08, 0.041666666666667
111530, 0.375, -0.1, 0.041666666666667
111531, 0.375, -0.12, 0.020833333333333
111532, 0.35416666666667, -0.12, 0.041666666666667
111533, 0.375, -0.14, 0.041666666666667
111534, 0.375, -0.16, 0.020833333333333
111535, 0.35416666666667, -0.16, 0.041666666666667
111536, 0.375, -0.18, 0.041666666666667
111537, 0.375, -0.02, 0.083333333333333
111538, 0.375, -0.04, 0.0625
111539, 0.35416666666667, -0.04, 0.083333333333333
111540, 0.375, -0.06, 0.083333333333333
111541, 0.375, -0.08, 0.0625
111542, 0.35416666666667, -0.08, 0.083333333333333
111543, 0.375, -0.1, 0.083333333333333
111544, 0.375, -0.12, 0.0625
111545, 0.35416666666667, -0.12, 0.083333333333333
111546, 0.375, -0.14, 0.083333333333333
111547, 0.375, -0.16, 0.0625
111548, 0.35416666666667, -0.16, 0.083333333333333
111549, 0.375, -0.18, 0.083333333333333
111550, 0.375, -0.02, 0.125
111551, 0.375, -0.04, 0.10416666666667
111552, 0.35416666666667, -0.04, 0.125
111553, 0.375, -0.06, 0.125
111554, 0.375, -0.08, 0.10416666666667
111555, 0.35416666666667, -0.08, 0.125
111556, 0.375, -0.1, 0.125
111557, 0.375, -0.12, 0.10416666666667
111558, 0.35416666666667, -0.12, 0.125
111559, 0.375, -0.14, 0.125
111560, 0.375, -0.16, 0.10416666666667
111561, 0.35416666666667, -0.16, 0.125
111562, 0.375, -0.18, 0.125
111563, 0.375, -0.02, 0.16666666666667
111564, 0.375, -0.04, 0.14583333333333
111565, 0.35416666666667, -0.04, 0.16666666666667
111566, 0.375, -0.06, 0.16666666666667
111567, 0.375, -0.08, 0.14583333333333
111568, 0.35416666666667, -0.08, 0.16666666666667
111569, 0.375, -0.1, 0.16666666666667
111570, 0.375, -0.12, 0.14583333333333
111571, 0.35416666666667, -0.12, 0.16666666666667
111572, 0.375, -0.14, 0.16666666666667
111573, 0.375, -0.16, 0.14583333333333
111574, 0.35416666666667, -0.16, 0.16666666666667
111575, 0.375, -0.18, 0.16666666666667
111576, 0.375, -0.02, 0.20833333333333
111577, 0.375, -0.04, 0.1875
111578, 0.35416666666667, -0.04, 0.20833333333333
111579, 0.375, -0.06, 0.20833333333333
111580, 0.375, -0.08, 0.1875
111581, 0.35416666666667, -0.08, 0.20833333333333
111582, 0.375, -0.1, 0.20833333333333
111583, 0.375, -0.12, 0.1875
111584, 0.35416666666667, -0.12, 0.20833333333333
111585, 0.375, -0.14, 0.20833333333333
111586, 0.375, -0.16, 0.1875
111587, 0.35416666666667, -0.16, 0.20833333333333
111588, 0.375, -0.18, 0.20833333333333
111589, 0.375, -0.02, 0.25
111590, 0.375, -0.04, 0.22916666666667
111591, 0.35416666666667, -0.04, 0.25
111592, 0.375, -0.06, 0.25
111593, 0.375, -0.08, 0.22916666666667
111594, 0.35416666666667, -0.08, 0.25
111595, 0.375, -0.1, 0.25
111596, 0.375, -0.12, 0.22916666666667
111597, 0.35416666666667, -0.12, 0.25
111598, 0.375, -0.14, 0.25
111599, 0.375, -0.16, 0.22916666666667
111600, 0.35416666666667, -0.16, 0.25
111601, 0.375, -0.18, 0.25
111602, 0.375, -0.02, 0.29166666666667
111603, 0.375, -0.04, 0.27083333333333
111604, 0.35416666666667, -0.04, 0.29166666666667
111605, 0.375, -0.06, 0.29166666666667
111606, 0.375, -0.08, 0.27083333333333
111607, 0.35416666666667, -0.08, 0.29166666666667
111608, 0.375, -0.1, 0.29166666666667
111609, 0.375, -0.12, 0.27083333333333
111610, 0.35416666666667, -0.12, 0.29166666666667
111611, 0.375, -0.14, 0.29166666666667
111612, 0.375, -0.16, 0.27083333333333
111613, 0.35416666666667, -0.16, 0.29166666666667
111614, 0.375, -0.18, 0.29166666666667
111615, 0.375, -0.02, 0.33333333333333
111616, 0.375, -0.04, 0.3125
111617, 0.35416666666667, -0.04, 0.33333333333333
111618, 0.375, -0.06, 0.33333333333333
111619, 0.375, -0.08, 0.3125
111620, 0.35416666666667, -0.08, 0.33333333333333
111621, 0.375, -0.1, 0.33333333333333
111622, 0.375, -0.12, 0.3125
111623, 0.35416666666667, -0.12, 0.33333333333333
111624, 0.375, -0.14, 0.33333333333333
111625, 0.375, -0.16, 0.3125
111626, 0.35416666666667, -0.16, 0.33333333333333
111627, 0.375, -0.18, 0.33333333333333
111628, 0.375, -0.02, 0.375
111629, 0.375, -0.04, 0.35416666666667
111630, 0.35416666666667, -0.04, 0.375
111631, 0.375, -0.06, 0.375
111632, 0.375, -0.08, 0.35416666666667
111633, 0.35416666666667, -0.08, 0.375
111634, 0.375, -0.1, 0.375
111635, 0.375, -0.12, 0.35416666666667
111636, 0.35416666666667, -0.12, 0.375
111637, 0.375, -0.14, 0.375
111638, 0.375, -0.16, 0.35416666666667
111639, 0.35416666666667, -0.16, 0.375
111640, 0.375, -0.18, 0.375
111641, 0.375, -0.02, 0.41666666666667
111642, 0.375, -0.04, 0.39583333333333
111643, 0.35416666666667, -0.04, 0.41666666666667
111644, 0.375, -0.06, 0.41666666666667
111645, 0.375, -0.08, 0.39583333333333
111646, 0.35416666666667, -0.08, 0.41666666666667
111647, 0.375, -0.1, 0.41666666666667
111648, 0.375, -0.12, 0.39583333333333
111649, 0.35416666666667, -0.12, 0.41666666666667
111650, 0.375, -0.14, 0.41666666666667
111651, 0.375, -0.16, 0.39583333333333
111652, 0.35416666666667, -0.16, 0.41666666666667
111653, 0.375, -0.18, 0.41666666666667
111654, 0.375, -0.02, 0.45833333333333
111655, 0.375, -0.04, 0.4375
111656, 0.35416666666667, -0.04, 0.45833333333333
111657, 0.375, -0.06, 0.45833333333333
111658, 0.375, -0.08, 0.4375
111659, 0.35416666666667, -0.08, 0.45833333333333
111660, 0.375, -0.1, 0.45833333333333
111661, 0.375, -0.12, 0.4375
111662, 0.35416666666667, -0.12, 0.45833333333333
111663, 0.375, -0.14, 0.45833333333333
111664, 0.375, -0.16, 0.4375
111665, 0.35416666666667, -0.16, 0.45833333333333
111666, 0.375, -0.18, 0.45833333333333
111667, 0.375, -0.04, 0.47916666666667
111668, 0.375, -0.08, 0.47916666666667
111669, 0.375, -0.12, 0.47916666666667
111670, 0.375, -0.16, 0.47916666666667
111671, 0.41666666666667, -0.02, 0.041666666666667
111672, 0.41666666666667, -0.04, 0.020833333333333
111673, 0.39583333333333, -0.04, 0.041666666666667
111674, 0.41666666666667, -0.06, 0.041666666666667
111675, 0.41666666666667, -0.08, 0.020833333333333
111676, 0.39583333333333, -0.08, 0.041666666666667
111677, 0.41666666666667, -0.1, 0.041666666666667
111678, 0.41666666666667, -0.12, 0.020833333333333
111679, 0.39583333333333, -0.12, 0.041666666666667
111680, 0.41666666666667, -0.14, 0.041666666666667
111681, 0.41666666666667, -0.16, 0.020833333333333
111682, 0.39583333333333, -0.16, 0.041666666666667
111683, 0.41666666666667, -0.18, 0.041666666666667
111684, 0.41666666666667, -0.02, 0.083333333333333
111685, 0.41666666666667, -0.04, 0.0625
111686, 0.39583333333333, -0.04, 0.083333333333333
111687, 0.41666666666667, -0.06, 0.083333333333333
111688, 0.41666666666667, -0.08, 0.0625
111689, 0.39583333333333, -0.08, 0.083333333333333
111690, 0.41666666666667, -0.1, 0.083333333333333
111691, 0.41666666666667, -0.12, 0.0625
111692, 0.39583333333333, -0.12, 0.083333333333333
111693, 0.41666666666667, -0.14, 0.083333333333333
111694, 0.41666666666667, -0.16, 0.0625
111695, 0.39583333333333, -0.16, 0.083333333333333
111696, 0.41666666666667, -0.18, 0.083333333333333
111697, 0.41666666666667, -0.02, 0.125
111698, 0.41666666666667, -0.04, 0.10416666666667
111699, 0.39583333333333, -0.04, 0.125
111700, 0.41666666666667, -0.06, 0.125
111701, 0.41666666666667, -0.08, 0.10416666666667
111702, 0.39583333333333, -0.08, 0.125
111703, 0.41666666666667, -0.1, 0.125
111704, 0.41666666666667, -0.12, 0.10416666666667
111705, 0.39583333333333, -0.12, 0.125
111706, 0.41666666666667, -0.14, 0.125
111707, 0.41666666666667, -0.16, 0.10416666666667
111708, 0.39583333333333, -0.16, 0.125
111709, 0.41666666666667, -0.18, 0.125
111710, 0.41666666666667, -0.02, 0.16666666666667
111711, 0.41666666666667, -0.04, 0.14583333333333
111712, 0.39583333333333, -0.04, 0.16666666666667
111713, 0.41666666666667, -0.06, 0.16666666666667
111714, 0.41666666666667, -0.08, 0.14583333333333
111715, 0.39583333333333, -0.08, 0.16666666666667
111716, 0.41666666666667, -0.1, 0.16666666666667
111717, 0.41666666666667, -0.12, 0.14583333333333
111718, 0.39583333333333, -0.12, 0.16666666666667
111719, 0.41666666666667, -0.14, 0.16666666666667
111720, 0.41666666666667, -0.16, 0.14583333333333
111721, 0.39583333333333, -0.16, 0.16666666666667
111722, 0.41666666666667, -0.18, 0.16666666666667
111723, 0.41666666666667, -0.02, 0.20833333333333
111724, 0.41666666666667, -0.04, 0.1875
111725, 0.39583333333333, -0.04, 0.20833333333333
111726, 0.41666666666667, -0.06, 0.20833333333333
111727, 0.41666666666667, -0.08, 0.1875
111728, 0.39583333333333, -0.08, 0.20833333333333
111729, 0.41666666666667, -0.1, 0.20833333333333
111730, 0.41666666666667, -0.12, 0.1875
111731, 0.39583333333333, -0.12, 0.20833333333333
111732, 0.41666666666667, -0.14, 0.20833333333333
111733, 0.41666666666667, -0.16, 0.1875
111734, 0.39583333333333, -0.16, 0.20833333333333
111735, 0.41666666666667, -0.18, 0.20833333333333
111736, 0.41666666666667, -0.02, 0.25
111737, 0.41666666666667, -0.04, 0.22916666666667
111738, 0.39583333333333, -0.04, 0.25
111739, 0.41666666666667, -0.06, 0.25
111740, 0.41666666666667, -0.08, 0.22916666666667
111741, 0.39583333333333, -0.08, 0.25
111742, 0.41666666666667, -0.1, 0.25
111743, 0.41666666666667, -0.12, 0.22916666666667
111744, 0.39583333333333, -0.12, 0.25
111745, 0.41666666666667, -0.14, 0.25
111746, 0.41666666666667, -0.16, 0.22916666666667
111747, 0.39583333333333, -0.16, 0.25
111748, 0.41666666666667, -0.18, 0.25
111749, 0.41666666666667, -0.02, 0.29166666666667
111750, 0.41666666666667, -0.04, 0.27083333333333
111751, 0.39583333333333, -0.04, 0.29166666666667
111752, 0.41666666666667, -0.06, 0.29166666666667
111753, 0.41666666666667, -0.08, 0.27083333333333
111754, 0.39583333333333, -0.08, 0.29166666666667
111755, 0.41666666666667, -0.1, 0.29166666666667
111756, 0.41666666666667, -0.12, 0.27083333333333
111757, 0.39583333333333, -0.12, 0.29166666666667
111758, 0.41666666666667, -0.14, 0.29166666666667
111759, 0.41666666666667, -0.16, 0.27083333333333
111760, 0.39583333333333, -0.16, 0.29166666666667
111761, 0.41666666666667, -0.18, 0.29166666666667
111762, 0.41666666666667, -0.02, 0.33333333333333
111763, 0.41666666666667, -0.04, 0.3125
111764, 0.39583333333333, -0.04, 0.33333333333333
111765, 0.41666666666667, -0.06, 0.33333333333333
111766, 0.41666666666667, -0.08, 0.3125
111767, 0.39583333333333, -0.08, 0.33333333333333
111768, 0.41666666666667, -0.1, 0.33333333333333
111769, 0.41666666666667, -0.12, 0.3125
111770, 0.39583333333333, -0.12, 0.33333333333333
111771, 0.41666666666667, -0.14, 0.33333333333333
111772, 0.41666666666667, -0.16, 0.3125
111773, 0.39583333333333, -0.16, 0.33333333333333
111774, 0.41666666666667, -0.18, 0.33333333333333
111775, 0.41666666666667, -0.02, 0.375
111776, 0.41666666666667, -0.04, 0.35416666666667
111777, 0.39583333333333, -0.04, 0.375
111778, 0.41666666666667, -0.06, 0.375
111779, 0.41666666666667, -0.08, 0.35416666666667
111780, 0.39583333333333, -0.08, 0.375
111781, 0.41666666666667, -0.1, 0.375
111782, 0.41666666666667, -0.12, 0.35416666666667
111783, 0.39583333333333, -0.12, 0.375
111784, 0.41666666666667, -0.14, 0.375
111785, 0.41666666666667, -0.16, 0.35416666666667
111786, 0.39583333333333, -0.16, 0.375
111787, 0.41666666666667, -0.18, 0.375
111788, 0.41666666666667, -0.02, 0.41666666666667
111789, 0.41666666666667, -0.04, 0.39583333333333
111790, 0.39583333333333, -0.04, 0.41666666666667
111791, 0.41666666666667, -0.06, 0.41666666666667
111792, 0.41666666666667, -0.08, 0.39583333333333
111793, 0.39583333333333, -0.08, 0.41666666666667
111794, 0.41666666666667, -0.1, 0.41666666666667
111795, 0.41666666666667, -0.12, 0.39583333333333
111796, 0.39583333333333, -0.12, 0.41666666666667
111797, 0.41666666666667, -0.14, 0.41666666666667
111798, 0.41666666666667, -0.16, 0.39583333333333
111799, 0.39583333333333, -0.16, 0.41666666666667
111800, 0.41666666666667, -0.18, 0.41666666666667
111801, 0.41666666666667, -0.02, 0.45833333333333
111802, 0.41666666666667, -0.04, 0.4375
111803, 0.39583333333333, -0.04, 0.45833333333333
111804, 0.41666666666667, -0.06, 0.45833333333333
111805, 0.41666666666667, -0.08, 0.4375
111806, 0.39583333333333, -0.08, 0.45833333333333
111807, 0.41666666666667, -0.1, 0.45833333333333
111808, 0.41666666666667, -0.12, 0.4375
111809, 0.39583333333333, -0.12, 0.45833333333333
111810, 0.41666666666667, -0.14, 0.45833333333333
111811, 0.41666666666667, -0.16, 0.4375
111812, 0.39583333333333, -0.16, 0.45833333333333
111813, 0.41666666666667, -0.18, 0.45833333333333
111814, 0.41666666666667, -0.04, 0.47916666666667
111815, 0.41666666666667, -0.08, 0.47916666666667
111816, 0.41666666666667, -0.12, 0.47916666666667
111817, 0.41666666666667, -0.16, 0.47916666666667
111818, 0.45833333333333, -0.02, 0.041666666666667
111819, 0.45833333333333, -0.04, 0.020833333333333
111820, 0.4375, -0.04, 0.041666666666667
111821, 0.45833333333333, -0.06, 0.041666666666667
111822, 0.45833333333333, -0.08, 0.020833333333333
111823, 0.4375, -0.08, 0.041666666666667
111824, 0.45833333333333, -0.1, 0.041666666666667
111825, 0.45833333333333, -0.12, 0.020833333333333
111826, 0.4375, -0.12, 0.041666666666667
111827, 0.45833333333333, -0.14, 0.041666666666667
111828, 0.45833333333333, -0.16, 0.020833333333333
111829, 0.4375, -0.16, 0.041666666666667
111830, 0.45833333333333, -0.18, 0.041666666666667
111831, 0.45833333333333, -0.02, 0.083333333333333
111832, 0.45833333333333, -0.04, 0.0625
111833, 0.4375, -0.04, 0.083333333333333
111834, 0.45833333333333, -0.06, 0.083333333333333
111835, 0.45833333333333, -0.08, 0.0625
111836, 0.4375, -0.08, 0.083333333333333
111837, 0.45833333333333, -0.1, 0.083333333333333
111838, 0.45833333333333, -0.12, 0.0625
111839, 0.4375, -0.12, 0.083333333333333
111840, 0.45833333333333, -0.14, 0.083333333333333
111841, 0.45833333333333, -0.16, 0.0625
111842, 0.4375, -0.16, 0.083333333333333
111843, 0.45833333333333, -0.18, 0.083333333333333
111844, 0.45833333333333, -0.02, 0.125
111845, 0.45833333333333, -0.04, 0.10416666666667
111846, 0.4375, -0.04, 0.125
111847, 0.45833333333333, -0.06, 0.125
111848, 0.45833333333333, -0.08, 0.10416666666667
111849, 0.4375, -0.08, 0.125
111850, 0.45833333333333, -0.1, 0.125
111851, 0.45833333333333, -0.12, 0.10416666666667
111852, 0.4375, -0.12, 0.125
111853, 0.45833333333333, -0.14, 0.125
111854, 0.45833333333333, -0.16, 0.10416666666667
111855, 0.4375, -0.16, 0.125
111856, 0.45833333333333, -0.18, 0.125
111857, 0.45833333333333, -0.02, 0.16666666666667
111858, 0.45833333333333, -0.04, 0.14583333333333
111859, 0.4375, -0.04, 0.16666666666667
111860, 0.45833333333333, -0.06, 0.16666666666667
111861, 0.45833333333333, -0.08, 0.14583333333333
111862, 0.4375, -0.08, 0.16666666666667
111863, 0.45833333333333, -0.1, 0.16666666666667
111864, 0.45833333333333, -0.12, 0.14583333333333
111865, 0.4375, -0.12, 0.16666666666667
111866, 0.45833333333333, -0.14, 0.16666666666667
111867, 0.45833333333333, -0.16, 0.14583333333333
111868, 0.4375, -0.16, 0.16666666666667
111869, 0.45833333333333, -0.18, 0.16666666666667
111870, 0.45833333333333, -0.02, 0.20833333333333
111871, 0.45833333333333, -0.04, 0.1875
111872, 0.4375, -0.04, 0.20833333333333
111873, 0.45833333333333, -0.06, 0.20833333333333
111874, 0.45833333333333, -0.08, 0.1875
111875, 0.4375, -0.08, 0.20833333333333
111876, 0.45833333333333, -0.1, 0.20833333333333
111877, 0.45833333333333, -0.12, 0.1875
111878, 0.4375, -0.12, 0.20833333333333
111879, 0.45833333333333, -0.14, 0.20833333333333
111880, 0.45833333333333, -0.16, 0.1875
111881, 0.4375, -0.16, 0.20833333333333
111882, 0.45833333333333, -0.18, 0.20833333333333
111883, 0.45833333333333, -0.02, 0.25
111884, 0.45833333333333, -0.04, 0.22916666666667
111885, 0.4375, -0.04, 0.25
111886, 0.45833333333333, -0.06, 0.25
111887, 0.45833333333333, -0.08, 0.22916666666667
111888, 0.4375, -0.08, 0.25
111889, 0.45833333333333, -0.1, 0.25
111890, 0.45833333333333, -0.12, 0.22916666666667
111891, 0.4375, -0.12, 0.25
111892, 0.45833333333333, -0.14, 0.25
111893, 0.45833333333333, -0.16, 0.22916666666667
111894, 0.4375, -0.16, 0.25
111895, 0.45833333333333, -0.18, 0.25
111896, 0.45833333333333, -0.02, 0.29166666666667
111897, 0.45833333333333, -0.04, 0.27083333333333
111898, 0.4375, -0.04, 0.29166666666667
111899, 0.45833333333333, -0.06, 0.29166666666667
111900, 0.45833333333333, -0.08, 0.27083333333333
111901, 0.4375, -0.08, 0.29166666666667
111902, 0.45833333333333, -0.1, 0.29166666666667
111903, 0.45833333333333, -0.12, 0.27083333333333
111904, 0.4375, -0.12, 0.29166666666667
111905, 0.45833333333333, -0.14, 0.29166666666667
111906, 0.45833333333333, -0.16, 0.27083333333333
111907, 0.4375, -0.16, 0.29166666666667
111908, 0.45833333333333, -0.18, 0.29166666666667
111909, 0.45833333333333, -0.02, 0.33333333333333
111910, 0.45833333333333, -0.04, 0.3125
111911, 0.4375, -0.04, 0.33333333333333
111912, 0.45833333333333, -0.06, 0.33333333333333
111913, 0.45833333333333, -0.08, 0.3125
111914, 0.4375, -0.08, 0.33333333333333
111915, 0.45833333333333, -0.1, 0.33333333333333
111916, 0.45833333333333, -0.12, 0.3125
111917, 0.4375, -0.12, 0.33333333333333
111918, 0.45833333333333, -0.14, 0.33333333333333
111919, 0.45833333333333, -0.16, 0.3125
111920, 0.4375, -0.16, 0.33333333333333
111921, 0.45833333333333, -0.18, 0.33333333333333
111922, 0.45833333333333, -0.02, 0.375
111923, 0.45833333333333, -0.04, 0.35416666666667
111924, 0.4375, -0.04, 0.375
111925, 0.45833333333333, -0.06, 0.375
111926, 0.45833333333333, -0.08, 0.35416666666667
111927, 0.4375, -0.08, 0.375
111928, 0.45833333333333, -0.1, 0.375
111929, 0.45833333333333, -0.12, 0.35416666666667
111930, 0.4375, -0.12, 0.375
111931, 0.45833333333333, -0.14, 0.375
111932, 0.45833333333333, -0.16, 0.35416666666667
111933, 0.4375, -0.16, 0.375
111934, 0.45833333333333, -0.18, 0.375
111935, 0.45833333333333, -0.02, 0.41666666666667
111936, 0.45833333333333, -0.04, 0.39583333333333
111937, 0.4375, -0.04, 0.41666666666667
111938, 0.45833333333333, -0.06, 0.41666666666667
111939, 0.45833333333333, -0.08, 0.39583333333333
111940, 0.4375, -0.08, 0.41666666666667
111941, 0.45833333333333, -0.1, 0.41666666666667
111942, 0.45833333333333, -0.12, 0.39583333333333
111943, 0.4375, -0.12, 0.41666666666667
111944, 0.45833333333333, -0.14, 0.41666666666667
111945, 0.45833333333333, -0.16, 0.39583333333333
111946, 0.4375, -0.16, 0.41666666666667
111947, 0.45833333333333, -0.18, 0.41666666666667
111948, 0.45833333333333, -0.02, 0.45833333333333
111949, 0.45833333333333, -0.04, 0.4375
111950, 0.4375, -0.04, 0.45833333333333
111951, 0.45833333333333, -0.06, 0.45833333333333
111952, 0.45833333333333, -0.08, 0.4375
111953, 0.4375, -0.08, 0.45833333333333
111954, 0.45833333333333, -0.1, 0.45833333333333
111955, 0.45833333333333, -0.12, 0.4375
111956, 0.4375, -0.12, 0.45833333333333
111957, 0.45833333333333, -0.14, 0.45833333333333
111958, 0.45833333333333, -0.16, 0.4375
111959, 0.4375, -0.16, 0.45833333333333
111960, 0.45833333333333, -0.18, 0.45833333333333
111961, 0.45833333333333, -0.04, 0.47916666666667
111962, 0.45833333333333, -0.08, 0.47916666666667
111963, 0.45833333333333, -0.12, 0.47916666666667
111964, 0.45833333333333, -0.16, 0.47916666666667
111965, 0.5, -0.02, 0.041666666666667
111966, 0.5, -0.04, 0.020833333333333
111967, 0.47916666666667, -0.04, 0.041666666666667
111968, 0.5, -0.06, 0.041666666666667
111969, 0.5, -0.08, 0.020833333333333
111970, 0.47916666666667, -0.08, 0.041666666666667
111971, 0.5, -0.1, 0.041666666666667
111972, 0.5, -0.12, 0.020833333333333
111973, 0.47916666666667, -0.12, 0.041666666666667
111974, 0.5, -0.14, 0.041666666666667
111975, 0.5, -0.16, 0.020833333333333
111976, 0.47916666666667, -0.16, 0.041666666666667
111977, 0.5, -0.18, 0.041666666666667
111978, 0.5, -0.02, 0.083333333333333
111979, 0.5, -0.04, 0.0625
111980, 0.47916666666667, -0.04, 0.083333333333333
111981, 0.5, -0.06, 0.083333333333333
111982, 0.5, -0.08, 0.0625
111983, 0.47916666666667, -0.08, 0.083333333333333
111984, 0.5, -0.1, 0.083333333333333
111985, 0.5, -0.12, 0.0625
111986, 0.47916666666667, -0.12, 0.083333333333333
111987, 0.5, -0.14, 0.083333333333333
111988, 0.5, -0.16, 0.0625
111989, 0.47916666666667, -0.16, 0.083333333333333
111990, 0.5, -0.18, 0.083333333333333
111991, 0.5, -0.02, 0.125
111992, 0.5, -0.04, 0.10416666666667
111993, 0.47916666666667, -0.04, 0.125
111994, 0.5, -0.06, 0.125
111995, 0.5, -0.08, 0.10416666666667
111996, 0.47916666666667, -0.08, 0.125
111997, 0.5, -0.1, 0.125
111998, 0.5, -0.12, 0.10416666666667
111999, 0.47916666666667, -0.12, 0.125
112000, 0.5, -0.14, 0.125
112001, 0.5, -0.16, 0.10416666666667
112002, 0.47916666666667, -0.16, 0.125
112003, 0.5, -0.18, 0.125
112004, 0.5, -0.02, 0.16666666666667
112005, 0.5, -0.04, 0.14583333333333
112006, 0.47916666666667, -0.04, 0.16666666666667
112007, 0.5, -0.06, 0.16666666666667
112008, 0.5, -0.08, 0.14583333333333
112009, 0.47916666666667, -0.08, 0.16666666666667
112010, 0.5, -0.1, 0.16666666666667
112011, 0.5, -0.12, 0.14583333333333
112012, 0.47916666666667, -0.12, 0.16666666666667
112013, 0.5, -0.14, 0.16666666666667
112014, 0.5, -0.16, 0.14583333333333
112015, 0.47916666666667, -0.16, 0.16666666666667
112016, 0.5, -0.18, 0.16666666666667
112017, 0.5, -0.02, 0.20833333333333
112018, 0.5, -0.04, 0.1875
112019, 0.47916666666667, -0.04, 0.20833333333333
112020, 0.5, -0.06, 0.20833333333333
112021, 0.5, -0.08, 0.1875
112022, 0.47916666666667, -0.08, 0.20833333333333
112023, 0.5, -0.1, 0.20833333333333
112024, 0.5, -0.12, 0.1875
112025, 0.47916666666667, -0.12, 0.20833333333333
112026, 0.5, -0.14, 0.20833333333333
112027, 0.5, -0.16, 0.1875
112028, 0.47916666666667, -0.16, 0.20833333333333
112029, 0.5, -0.18, 0.20833333333333
112030, 0.5, -0.02, 0.25
112031, 0.5, -0.04, 0.22916666666667
112032, 0.47916666666667, -0.04, 0.25
112033, 0.5, -0.06, 0.25
112034, 0.5, -0.08, 0.22916666666667
112035, 0.47916666666667, -0.08, 0.25
112036, 0.5, -0.1, 0.25
112037, 0.5, -0.12, 0.22916666666667
112038, 0.47916666666667, -0.12, 0.25
112039, 0.5, -0.14, 0.25
112040, 0.5, -0.16, 0.22916666666667
112041, 0.47916666666667, -0.16, 0.25
112042, 0.5, -0.18, 0.25
112043, 0.5, -0.02, 0.29166666666667
112044, 0.5, -0.04, 0.27083333333333
112045, 0.47916666666667, -0.04, 0.29166666666667
112046, 0.5, -0.06, 0.29166666666667
112047, 0.5, -0.08, 0.27083333333333
112048, 0.47916666666667, -0.08, 0.29166666666667
112049, 0.5, -0.1, 0.29166666666667
112050, 0.5, -0.12, 0.27083333333333
112051, 0.47916666666667, -0.12, 0.29166666666667
112052, 0.5, -0.14, 0.29166666666667
112053, 0.5, -0.16, 0.27083333333333
112054, 0.47916666666667, -0.16, 0.29166666666667
112055, 0.5, -0.18, 0.29166666666667
112056, 0.5, -0.02, 0.33333333333333
112057, 0.5, -0.04, 0.3125
112058, 0.47916666666667, -0.04, 0.33333333333333
112059, 0.5, -0.06, 0.33333333333333
112060, 0.5, -0.08, 0.3125
112061, 0.47916666666667, -0.08, 0.33333333333333
112062, 0.5, -0.1, 0.33333333333333
112063, 0.5, -0.12, 0.3125
112064, 0.47916666666667, -0.12, 0.33333333333333
112065, 0.5, -0.14, 0.33333333333333
112066, 0.5, -0.16, 0.3125
112067, 0.47916666666667, -0.16, 0.33333333333333
112068, 0.5, -0.18, 0.33333333333333
112069, 0.5, -0.02, 0.375
112070, 0.5, -0.04, 0.35416666666667
112071, 0.47916666666667, -0.04, 0.375
112072, 0.5, -0.06, 0.375
112073, 0.5, -0.08, 0.35416666666667
112074, 0.47916666666667, -0.08, 0.375
112075, 0.5, -0.1, 0.375
112076, 0.5, -0.12, 0.35416666666667
112077, 0.47916666666667, -0.12, 0.375
112078, 0.5, -0.14, 0.375
112079, 0.5, -0.16, 0.35416666666667
112080, 0.47916666666667, -0.16, 0.375
112081, 0.5, -0.18, 0.375
112082, 0.5, -0.02, 0.41666666666667
112083, 0.5, -0.04, 0.39583333333333
112084, 0.47916666666667, -0.04, 0.41666666666667
112085, 0.5, -0.06, 0.41666666666667
112086, 0.5, -0.08, 0.39583333333333
112087, 0.47916666666667, -0.08, 0.41666666666667
112088, 0.5, -0.1, 0.41666666666667
112089, 0.5, -0.12, 0.39583333333333
112090, 0.47916666666667, -0.12, 0.41666666666667
112091, 0.5, -0.14, 0.41666666666667
112092, 0.5, -0.16, 0.39583333333333
112093, 0.47916666666667, -0.16, 0.41666666666667
112094, 0.5, -0.18, 0.41666666666667
112095, 0.5, -0.02, 0.45833333333333
112096, 0.5, -0.04, 0.4375
112097, 0.47916666666667, -0.04, 0.45833333333333
112098, 0.5, -0.06, 0.45833333333333
112099, 0.5, -0.08, 0.4375
112100, 0.47916666666667, -0.08, 0.45833333333333
112101, 0.5, -0.1, 0.45833333333333
112102, 0.5, -0.12, 0.4375
112103, 0.47916666666667, -0.12, 0.45833333333333
112104, 0.5, -0.14, 0.45833333333333
112105, 0.5, -0.16, 0.4375
112106, 0.47916666666667, -0.16, 0.45833333333333
112107, 0.5, -0.18, 0.45833333333333
112108, 0.5, -0.04, 0.47916666666667
112109, 0.5, -0.08, 0.47916666666667
112110, 0.5, -0.12, 0.47916666666667
112111, 0.5, -0.16, 0.47916666666667
112112, 0.54166666666667, -0.02, 0.041666666666667
112113, 0.54166666666667, -0.04, 0.020833333333333
112114, 0.52083333333333, -0.04, 0.041666666666667
112115, 0.54166666666667, -0.06, 0.041666666666667
112116, 0.54166666666667, -0.08, 0.020833333333333
112117, 0.52083333333333, -0.08, 0.041666666666667
112118, 0.54166666666667, -0.1, 0.041666666666667
112119, 0.54166666666667, -0.12, 0.020833333333333
112120, 0.52083333333333, -0.12, 0.041666666666667
112121, 0.54166666666667, -0.14, 0.041666666666667
112122, 0.54166666666667, -0.16, 0.020833333333333
112123, 0.52083333333333, -0.16, 0.041666666666667
112124, 0.54166666666667, -0.18, 0.041666666666667
112125, 0.54166666666667, -0.02, 0.083333333333333
112126, 0.54166666666667, -0.04, 0.0625
112127, 0.52083333333333, -0.04, 0.083333333333333
112128, 0.54166666666667, -0.06, 0.083333333333333
112129, 0.54166666666667, -0.08, 0.0625
112130, 0.52083333333333, -0.08, 0.083333333333333
112131, 0.54166666666667, -0.1, 0.083333333333333
112132, 0.54166666666667, -0.12, 0.0625
112133, 0.52083333333333, -0.12, 0.083333333333333
112134, 0.54166666666667, -0.14, 0.083333333333333
112135, 0.54166666666667, -0.16, 0.0625
112136, 0.52083333333333, -0.16, 0.083333333333333
112137, 0.54166666666667, -0.18, 0.083333333333333
112138, 0.54166666666667, -0.02, 0.125
112139, 0.54166666666667, -0.04, 0.10416666666667
112140, 0.52083333333333, -0.04, 0.125
112141, 0.54166666666667, -0.06, 0.125
112142, 0.54166666666667, -0.08, 0.10416666666667
112143, 0.52083333333333, -0.08, 0.125
112144, 0.54166666666667, -0.1, 0.125
112145, 0.54166666666667, -0.12, 0.10416666666667
112146, 0.52083333333333, -0.12, 0.125
112147, 0.54166666666667, -0.14, 0.125
112148, 0.54166666666667, -0.16, 0.10416666666667
112149, 0.52083333333333, -0.16, 0.125
112150, 0.54166666666667, -0.18, 0.125
112151, 0.54166666666667, -0.02, 0.16666666666667
112152, 0.54166666666667, -0.04, 0.14583333333333
112153, 0.52083333333333, -0.04, 0.16666666666667
112154, 0.54166666666667, -0.06, 0.16666666666667
112155, 0.54166666666667, -0.08, 0.14583333333333
112156, 0.52083333333333, -0.08, 0.16666666666667
112157, 0.54166666666667, -0.1, 0.16666666666667
112158, 0.54166666666667, -0.12, 0.14583333333333
112159, 0.52083333333333, -0.12, 0.16666666666667
112160, 0.54166666666667, -0.14, 0.16666666666667
112161, 0.54166666666667, -0.16, 0.14583333333333
112162, 0.52083333333333, -0.16, 0.16666666666667
112163, 0.54166666666667, -0.18, 0.16666666666667
112164, 0.54166666666667, -0.02, 0.20833333333333
112165, 0.54166666666667, -0.04, 0.1875
112166, 0.52083333333333, -0.04, 0.20833333333333
112167, 0.54166666666667, -0.06, 0.20833333333333
112168, 0.54166666666667, -0.08, 0.1875
112169, 0.52083333333333, -0.08, 0.20833333333333
112170, 0.54166666666667, -0.1, 0.20833333333333
112171, 0.54166666666667, -0.12, 0.1875
112172, 0.52083333333333, -0.12, 0.20833333333333
112173, 0.54166666666667, -0.14, 0.20833333333333
112174, 0.54166666666667, -0.16, 0.1875
112175, 0.52083333333333, -0.16, 0.20833333333333
112176, 0.54166666666667, -0.18, 0.20833333333333
112177, 0.54166666666667, -0.02, 0.25
112178, 0.54166666666667, -0.04, 0.22916666666667
112179, 0.52083333333333, -0.04, 0.25
112180, 0.54166666666667, -0.06, 0.25
112181, 0.54166666666667, -0.08, 0.22916666666667
112182, 0.52083333333333, -0.08, 0.25
112183, 0.54166666666667, -0.1, 0.25
112184, 0.54166666666667, -0.12, 0.22916666666667
112185, 0.52083333333333, -0.12, 0.25
112186, 0.54166666666667, -0.14, 0.25
112187, 0.54166666666667, -0.16, 0.22916666666667
112188, 0.52083333333333, -0.16, 0.25
112189, 0.54166666666667, -0.18, 0.25
112190, 0.54166666666667, -0.02, 0.29166666666667
112191, 0.54166666666667, -0.04, 0.27083333333333
112192, 0.52083333333333, -0.04, 0.29166666666667
112193, 0.54166666666667, -0.06, 0.29166666666667
112194, 0.54166666666667, -0.08, 0.27083333333333
112195, 0.52083333333333, -0.08, 0.29166666666667
112196, 0.54166666666667, -0.1, 0.29166666666667
112197, 0.54166666666667, -0.12, 0.27083333333333
112198, 0.52083333333333, -0.12, 0.29166666666667
112199, 0.54166666666667, -0.14, 0.29166666666667
112200, 0.54166666666667, -0.16, 0.27083333333333
112201, 0.52083333333333, -0.16, 0.29166666666667
112202, 0.54166666666667, -0.18, 0.29166666666667
112203, 0.54166666666667, -0.02, 0.33333333333333
112204, 0.54166666666667, -0.04, 0.3125
112205, 0.52083333333333, -0.04, 0.33333333333333
112206, 0.54166666666667, -0.06, 0.33333333333333
112207, 0.54166666666667, -0.08, 0.3125
112208, 0.52083333333333, -0.08, 0.33333333333333
112209, 0.54166666666667, -0.1, 0.33333333333333
112210, 0.54166666666667, -0.12, 0.3125
112211, 0.52083333333333, -0.12, 0.33333333333333
112212, 0.54166666666667, -0.14, 0.33333333333333
112213, 0.54166666666667, -0.16, 0.3125
112214, 0.52083333333333, -0.16, 0.33333333333333
112215, 0.54166666666667, -0.18, 0.33333333333333
112216, 0.54166666666667, -0.02, 0.375
112217, 0.54166666666667, -0.04, 0.35416666666667
112218, 0.52083333333333, -0.04, 0.375
112219, 0.54166666666667, -0.06, 0.375
112220, 0.54166666666667, -0.08, 0.35416666666667
112221, 0.52083333333333, -0.08, 0.375
112222, 0.54166666666667, -0.1, 0.375
112223, 0.54166666666667, -0.12, 0.35416666666667
112224, 0.52083333333333, -0.12, 0.375
112225, 0.54166666666667, -0.14, 0.375
112226, 0.54166666666667, -0.16, 0.35416666666667
112227, 0.52083333333333, -0.16, 0.375
112228, 0.54166666666667, -0.18, 0.375
112229, 0.54166666666667, -0.02, 0.41666666666667
112230, 0.54166666666667, -0.04, 0.39583333333333
112231, 0.52083333333333, -0.04, 0.41666666666667
112232, 0.54166666666667, -0.06, 0.41666666666667
112233, 0.54166666666667, -0.08, 0.39583333333333
112234, 0.52083333333333, -0.08, 0.41666666666667
112235, 0.54166666666667, -0.1, 0.41666666666667
112236, 0.54166666666667, -0.12, 0.39583333333333
112237, 0.52083333333333, -0.12, 0.41666666666667
112238, 0.54166666666667, -0.14, 0.41666666666667
112239, 0.54166666666667, -0.16, 0.39583333333333
112240, 0.52083333333333, -0.16, 0.41666666666667
112241, 0.54166666666667, -0.18, 0.41666666666667
112242, 0.54166666666667, -0.02, 0.45833333333333
112243, 0.54166666666667, -0.04, 0.4375
112244, 0.52083333333333, -0.04, 0.45833333333333
112245, 0.54166666666667, -0.06, 0.45833333333333
112246, 0.54166666666667, -0.08, 0.4375
112247, 0.52083333333333, -0.08, 0.45833333333333
112248, 0.54166666666667, -0.1, 0.45833333333333
112249, 0.54166666666667, -0.12, 0.4375
112250, 0.52083333333333, -0.12, 0.45833333333333
112251, 0.54166666666667, -0.14, 0.45833333333333
112252, 0.54166666666667, -0.16, 0.4375
112253, 0.52083333333333, -0.16, 0.45833333333333
112254, 0.54166666666667, -0.18, 0.45833333333333
112255, 0.54166666666667, -0.04, 0.47916666666667
112256, 0.54166666666667, -0.08, 0.47916666666667
112257, 0.54166666666667, -0.12, 0.47916666666667
112258, 0.54166666666667, -0.16, 0.47916666666667
112259, 0.58333333333333, -0.02, 0.041666666666667
112260, 0.58333333333333, -0.04, 0.020833333333333
112261, 0.5625, -0.04, 0.041666666666667
112262, 0.58333333333333, -0.06, 0.041666666666667
112263, 0.58333333333333, -0.08, 0.020833333333333
112264, 0.5625, -0.08, 0.041666666666667
112265, 0.58333333333333, -0.1, 0.041666666666667
112266, 0.58333333333333, -0.12, 0.020833333333333
112267, 0.5625, -0.12, 0.041666666666667
112268, 0.58333333333333, -0.14, 0.041666666666667
112269, 0.58333333333333, -0.16, 0.020833333333333
112270, 0.5625, -0.16, 0.041666666666667
112271, 0.58333333333333, -0.18, 0.041666666666667
112272, 0.58333333333333, -0.02, 0.083333333333333
112273, 0.58333333333333, -0.04, 0.0625
112274, 0.5625, -0.04, 0.083333333333333
112275, 0.58333333333333, -0.06, 0.083333333333333
112276, 0.58333333333333, -0.08, 0.0625
112277, 0.5625, -0.08, 0.083333333333333
112278, 0.58333333333333, -0.1, 0.083333333333333
112279, 0.58333333333333, -0.12, 0.0625
112280, 0.5625, -0.12, 0.083333333333333
112281, 0.58333333333333, -0.14, 0.083333333333333
112282, 0.58333333333333, -0.16, 0.0625
112283, 0.5625, -0.16, 0.083333333333333
112284, 0.58333333333333, -0.18, 0.083333333333333
112285, 0.58333333333333, -0.02, 0.125
112286, 0.58333333333333, -0.04, 0.10416666666667
112287, 0.5625, -0.04, 0.125
112288, 0.58333333333333, -0.06, 0.125
112289, 0.58333333333333, -0.08, 0.10416666666667
112290, 0.5625, -0.08, 0.125
112291, 0.58333333333333, -0.1, 0.125
112292, 0.58333333333333, -0.12, 0.10416666666667
112293, 0.5625, -0.12, 0.125
112294, 0.58333333333333, -0.14, 0.125
112295, 0.58333333333333, -0.16, 0.10416666666667
112296, 0.5625, -0.16, 0.125
112297, 0.58333333333333, -0.18, 0.125
112298, 0.58333333333333, -0.02, 0.16666666666667
112299, 0.58333333333333, -0.04, 0.14583333333333
112300, 0.5625, -0.04, 0.16666666666667
112301, 0.58333333333333, -0.06, 0.16666666666667
112302, 0.58333333333333, -0.08, 0.14583333333333
112303, 0.5625, -0.08, 0.16666666666667
112304, 0.58333333333333, -0.1, 0.16666666666667
112305, 0.58333333333333, -0.12, 0.14583333333333
112306, 0.5625, -0.12, 0.16666666666667
112307, 0.58333333333333, -0.14, 0.16666666666667
112308, 0.58333333333333, -0.16, 0.14583333333333
112309, 0.5625, -0.16, 0.16666666666667
112310, 0.58333333333333, -0.18, 0.16666666666667
112311, 0.58333333333333, -0.02, 0.20833333333333
112312, 0.58333333333333, -0.04, 0.1875
112313, 0.5625, -0.04, 0.20833333333333
112314, 0.58333333333333, -0.06, 0.20833333333333
112315, 0.58333333333333, -0.08, 0.1875
112316, 0.5625, -0.08, 0.20833333333333
112317, 0.58333333333333, -0.1, 0.20833333333333
112318, 0.58333333333333, -0.12, 0.1875
112319, 0.5625, -0.12, 0.20833333333333
112320, 0.58333333333333, -0.14, 0.20833333333333
112321, 0.58333333333333, -0.16, 0.1875
112322, 0.5625, -0.16, 0.20833333333333
112323, 0.58333333333333, -0.18, 0.20833333333333
112324, 0.58333333333333, -0.02, 0.25
112325, 0.58333333333333, -0.04, 0.22916666666667
112326, 0.5625, -0.04, 0.25
112327, 0.58333333333333, -0.06, 0.25
112328, 0.58333333333333, -0.08, 0.22916666666667
112329, 0.5625, -0.08, 0.25
112330, 0.58333333333333, -0.1, 0.25
112331, 0.58333333333333, -0.12, 0.22916666666667
112332, 0.5625, -0.12, 0.25
112333, 0.58333333333333, -0.14, 0.25
112334, 0.58333333333333, -0.16, 0.22916666666667
112335, 0.5625, -0.16, 0.25
112336, 0.58333333333333, -0.18, 0.25
112337, 0.58333333333333, -0.02, 0.29166666666667
112338, 0.58333333333333, -0.04, 0.27083333333333
112339, 0.5625, -0.04, 0.29166666666667
112340, 0.58333333333333, -0.06, 0.29166666666667
112341, 0.58333333333333, -0.08, 0.27083333333333
112342, 0.5625, -0.08, 0.29166666666667
112343, 0.58333333333333, -0.1, 0.29166666666667
112344, 0.58333333333333, -0.12, 0.27083333333333
112345, 0.5625, -0.12, 0.29166666666667
112346, 0.58333333333333, -0.14, 0.29166666666667
112347, 0.58333333333333, -0.16, 0.27083333333333
112348, 0.5625, -0.16, 0.29166666666667
112349, 0.58333333333333, -0.18, 0.29166666666667
112350, 0.58333333333333, -0.02, 0.33333333333333
112351, 0.58333333333333, -0.04, 0.3125
112352, 0.5625, -0.04, 0.33333333333333
112353, 0.58333333333333, -0.06, 0.33333333333333
112354, 0.58333333333333, -0.08, 0.3125
112355, 0.5625, -0.08, 0.33333333333333
112356, 0.58333333333333, -0.1, 0.33333333333333
112357, 0.58333333333333, -0.12, 0.3125
112358, 0.5625, -0.12, 0.33333333333333
112359, 0.58333333333333, -0.14, 0.33333333333333
112360, 0.58333333333333, -0.16, 0.3125
112361, 0.5625, -0.16, 0.33333333333333
112362, 0.58333333333333, -0.18, 0.33333333333333
112363, 0.58333333333333, -0.02, 0.375
112364, 0.58333333333333, -0.04, 0.35416666666667
112365, 0.5625, -0.04, 0.375
112366, 0.58333333333333, -0.06, 0.375
112367, 0.58333333333333, -0.08, 0.35416666666667
112368, 0.5625, -0.08, 0.375
112369, 0.58333333333333, -0.1, 0.375
112370, 0.58333333333333, -0.12, 0.35416666666667
112371, 0.5625, -0.12, 0.375
112372, 0.58333333333333, -0.14, 0.375
112373, 0.58333333333333, -0.16, 0.35416666666667
112374, 0.5625, -0.16, 0.375
112375, 0.58333333333333, -0.18, 0.375
112376, 0.58333333333333, -0.02, 0.41666666666667
112377, 0.58333333333333, -0.04, 0.39583333333333
112378, 0.5625, -0.04, 0.41666666666667
112379, 0.58333333333333, -0.06, 0.41666666666667
112380, 0.58333333333333, -0.08, 0.39583333333333
112381, 0.5625, -0.08, 0.41666666666667
112382, 0.58333333333333, -0.1, 0.41666666666667
112383, 0.58333333333333, -0.12, 0.39583333333333
112384, 0.5625, -0.12, 0.41666666666667
112385, 0.58333333333333, -0.14, 0.41666666666667
112386, 0.58333333333333, -0.16, 0.39583333333333
112387, 0.5625, -0.16, 0.41666666666667
112388, 0.58333333333333, -0.18, 0.41666666666667
112389, 0.58333333333333, -0.02, 0.45833333333333
112390, 0.58333333333333, -0.04, 0.4375
112391, 0.5625, -0.04, 0.45833333333333
112392, 0.58333333333333, -0.06, 0.45833333333333
112393, 0.58333333333333, -0.08, 0.4375
112394, 0.5625, -0.08, 0.45833333333333
112395, 0.58333333333333, -0.1, 0.45833333333333
112396, 0.58333333333333, -0.12, 0.4375
112397, 0.5625, -0.12, 0.45833333333333
112398, 0.58333333333333, -0.14, 0.45833333333333
112399, 0.58333333333333, -0.16, 0.4375
112400, 0.5625, -0.16, 0.45833333333333
112401, 0.58333333333333, -0.18, 0.45833333333333
112402, 0.58333333333333, -0.04, 0.47916666666667
112403, 0.58333333333333, -0.08, 0.47916666666667
112404, 0.58333333333333, -0.12, 0.47916666666667
112405, 0.58333333333333, -0.16, 0.47916666666667
112406, 0.625, -0.02, 0.041666666666667
112407, 0.625, -0.04, 0.020833333333333
112408, 0.60416666666667, -0.04, 0.041666666666667
112409, 0.625, -0.06, 0.041666666666667
112410, 0.625, -0.08, 0.020833333333333
112411, 0.60416666666667, -0.08, 0.041666666666667
112412, 0.625, -0.1, 0.041666666666667
112413, 0.625, -0.12, 0.020833333333333
112414, 0.60416666666667, -0.12, 0.041666666666667
112415, 0.625, -0.14, 0.041666666666667
112416, 0.625, -0.16, 0.020833333333333
112417, 0.60416666666667, -0.16, 0.041666666666667
112418, 0.625, -0.18, 0.041666666666667
112419, 0.625, -0.02, 0.083333333333333
112420, 0.625, -0.04, 0.0625
112421, 0.60416666666667, -0.04, 0.083333333333333
112422, 0.625, -0.06, 0.083333333333333
112423, 0.625, -0.08, 0.0625
112424, 0.60416666666667, -0.08, 0.083333333333333
112425, 0.625, -0.1, 0.083333333333333
112426, 0.625, -0.12, 0.0625
112427, 0.60416666666667, -0.12, 0.083333333333333
112428, 0.625, -0.14, 0.083333333333333
112429, 0.625, -0.16, 0.0625
112430, 0.60416666666667, -0.16, 0.083333333333333
112431, 0.625, -0.18, 0.083333333333333
112432, 0.625, -0.02, 0.125
112433, 0.625, -0.04, 0.10416666666667
112434, 0.60416666666667, -0.04, 0.125
112435, 0.625, -0.06, 0.125
112436, 0.625, -0.08, 0.10416666666667
112437, 0.60416666666667, -0.08, 0.125
112438, 0.625, -0.1, 0.125
112439, 0.625, -0.12, 0.10416666666667
112440, 0.60416666666667, -0.12, 0.125
112441, 0.625, -0.14, 0.125
112442, 0.625, -0.16, 0.10416666666667
112443, 0.60416666666667, -0.16, 0.125
112444, 0.625, -0.18, 0.125
112445, 0.625, -0.02, 0.16666666666667
112446, 0.625, -0.04, 0.14583333333333
112447, 0.60416666666667, -0.04, 0.16666666666667
112448, 0.625, -0.06, 0.16666666666667
112449, 0.625, -0.08, 0.14583333333333
112450, 0.60416666666667, -0.08, 0.16666666666667
112451, 0.625, -0.1, 0.16666666666667
112452, 0.625, -0.12, 0.14583333333333
112453, 0.60416666666667, -0.12, 0.16666666666667
112454, 0.625, -0.14, 0.16666666666667
112455, 0.625, -0.16, 0.14583333333333
112456, 0.60416666666667, -0.16, 0.16666666666667
112457, 0.625, -0.18, 0.16666666666667
112458, 0.625, -0.02, 0.20833333333333
112459, 0.625, -0.04, 0.1875
112460, 0.60416666666667, -0.04, 0.20833333333333
112461, 0.625, -0.06, 0.20833333333333
112462, 0.625, -0.08, 0.1875
112463, 0.60416666666667, -0.08, 0.20833333333333
112464, 0.625, -0.1, 0.20833333333333
112465, 0.625, -0.12, 0.1875
112466, 0.60416666666667, -0.12, 0.20833333333333
112467, 0.625, -0.14, 0.20833333333333
112468, 0.625, -0.16, 0.1875
112469, 0.60416666666667, -0.16, 0.20833333333333
112470, 0.625, -0.18, 0.20833333333333
112471, 0.625, -0.02, 0.25
112472, 0.625, -0.04, 0.22916666666667
112473, 0.60416666666667, -0.04, 0.25
112474, 0.625, -0.06, 0.25
112475, 0.625, -0.08, 0.22916666666667
112476, 0.60416666666667, -0.08, 0.25
112477, 0.625, -0.1, 0.25
112478, 0.625, -0.12, 0.22916666666667
112479, 0.60416666666667, -0.12, 0.25
112480, 0.625, -0.14, 0.25
112481, 0.625, -0.16, 0.22916666666667
112482, 0.60416666666667, -0.16, 0.25
112483, 0.625, -0.18, 0.25
112484, 0.625, -0.02, 0.29166666666667
112485, 0.625, -0.04, 0.27083333333333
112486, 0.60416666666667, -0.04, 0.29166666666667
112487, 0.625, -0.06, 0.29166666666667
112488, 0.625, -0.08, 0.27083333333333
112489, 0.60416666666667, -0.08, 0.29166666666667
112490, 0.625, -0.1, 0.29166666666667
112491, 0.625, -0.12, 0.27083333333333
112492, 0.60416666666667, -0.12, 0.29166666666667
112493, 0.625, -0.14, 0.29166666666667
112494, 0.625, -0.16, 0.27083333333333
112495, 0.60416666666667, -0.16, 0.29166666666667
112496, 0.625, -0.18, 0.29166666666667
112497, 0.625, -0.02, 0.33333333333333
112498, 0.625, -0.04, 0.3125
112499, 0.60416666666667, -0.04, 0.33333333333333
112500, 0.625, -0.06, 0.33333333333333
112501, 0.625, -0.08, 0.3125
112502, 0.60416666666667, -0.08, 0.33333333333333
112503, 0.625, -0.1, 0.33333333333333
112504, 0.625, -0.12, 0.3125
112505, 0.60416666666667, -0.12, 0.33333333333333
112506, 0.625, -0.14, 0.33333333333333
112507, 0.625, -0.16, 0.3125
112508, 0.60416666666667, -0.16, 0.33333333333333
112509, 0.625, -0.18, 0.33333333333333
112510, 0.625, -0.02, 0.375
112511, 0.625, -0.04, 0.35416666666667
112512, 0.60416666666667, -0.04, 0.375
112513, 0.625, -0.06, 0.375
112514, 0.625, -0.08, 0.35416666666667
112515, 0.60416666666667, -0.08, 0.375
112516, 0.625, -0.1, 0.375
112517, 0.625, -0.12, 0.35416666666667
112518, 0.60416666666667, -0.12, 0.375
112519, 0.625, -0.14, 0.375
112520, 0.625, -0.16, 0.35416666666667
112521, 0.60416666666667, -0.16, 0.375
112522, 0.625, -0.18, 0.375
112523, 0.625, -0.02, 0.41666666666667
112524, 0.625, -0.04, 0.39583333333333
112525, 0.60416666666667, -0.04, 0.41666666666667
112526, 0.625, -0.06, 0.41666666666667
112527, 0.625, -0.08, 0.39583333333333
112528, 0.60416666666667, -0.08, 0.41666666666667
112529, 0.625, -0.1, 0.41666666666667
112530, 0.625, -0.12, 0.39583333333333
112531, 0.60416666666667, -0.12, 0.41666666666667
112532, 0.625, -0.14, 0.41666666666667
112533, 0.625, -0.16, 0.39583333333333
112534, 0.60416666666667, -0.16, 0.41666666666667
112535, 0.625, -0.18, 0.41666666666667
112536, 0.625, -0.02, 0.45833333333333
112537, 0.625, -0.04, 0.4375
112538, 0.60416666666667, -0.04, 0.45833333333333
112539, 0.625, -0.06, 0.45833333333333
112540, 0.625, -0.08, 0.4375
112541, 0.60416666666667, -0.08, 0.45833333333333
112542, 0.625, -0.1, 0.45833333333333
112543, 0.625, -0.12, 0.4375
112544, 0.60416666666667, -0.12, 0.45833333333333
112545, 0.625, -0.14, 0.45833333333333
112546, 0.625, -0.16, 0.4375
112547, 0.60416666666667, -0.16, 0.45833333333333
112548, 0.625, -0.18, 0.45833333333333
112549, 0.625, -0.04, 0.47916666666667
112550, 0.625, -0.08, 0.47916666666667
112551, 0.625, -0.12, 0.47916666666667
112552, 0.625, -0.16, 0.47916666666667
112553, 0.66666666666667, -0.02, 0.041666666666667
112554, 0.66666666666667, -0.04, 0.020833333333333
112555, 0.64583333333333, -0.04, 0.041666666666667
112556, 0.66666666666667, -0.06, 0.041666666666667
112557, 0.66666666666667, -0.08, 0.020833333333333
112558, 0.64583333333333, -0.08, 0.041666666666667
112559, 0.66666666666667, -0.1, 0.041666666666667
112560, 0.66666666666667, -0.12, 0.020833333333333
112561, 0.64583333333333, -0.12, 0.041666666666667
112562, 0.66666666666667, -0.14, 0.041666666666667
112563, 0.66666666666667, -0.16, 0.020833333333333
112564, 0.64583333333333, -0.16, 0.041666666666667
112565, 0.66666666666667, -0.18, 0.041666666666667
112566, 0.66666666666667, -0.02, 0.083333333333333
112567, 0.66666666666667, -0.04, 0.0625
112568, 0.64583333333333, -0.04, 0.083333333333333
112569, 0.66666666666667, -0.06, 0.083333333333333
112570, 0.66666666666667, -0.08, 0.0625
112571, 0.64583333333333, -0.08, 0.083333333333333
112572, 0.66666666666667, -0.1, 0.083333333333333
112573, 0.66666666666667, -0.12, 0.0625
112574, 0.64583333333333, -0.12, 0.083333333333333
112575, 0.66666666666667, -0.14, 0.083333333333333
112576, 0.66666666666667, -0.16, 0.0625
112577, 0.64583333333333, -0.16, 0.083333333333333
112578, 0.66666666666667, -0.18, 0.083333333333333
112579, 0.66666666666667, -0.02, 0.125
112580, 0.66666666666667, -0.04, 0.10416666666667
112581, 0.64583333333333, -0.04, 0.125
112582, 0.66666666666667, -0.06, 0.125
112583, 0.66666666666667, -0.08, 0.10416666666667
112584, 0.64583333333333, -0.08, 0.125
112585, 0.66666666666667, -0.1, 0.125
112586, 0.66666666666667, -0.12, 0.10416666666667
112587, 0.64583333333333, -0.12, 0.125
112588, 0.66666666666667, -0.14, 0.125
112589, 0.66666666666667, -0.16, 0.10416666666667
112590, 0.64583333333333, -0.16, 0.125
112591, 0.66666666666667, -0.18, 0.125
112592, 0.66666666666667, -0.02, 0.16666666666667
112593, 0.66666666666667, -0.04, 0.14583333333333
112594, 0.64583333333333, -0.04, 0.16666666666667
112595, 0.66666666666667, -0.06, 0.16666666666667
112596, 0.66666666666667, -0.08, 0.14583333333333
112597, 0.64583333333333, -0.08, 0.16666666666667
112598, 0.66666666666667, -0.1, 0.16666666666667
112599, 0.66666666666667, -0.12, 0.14583333333333
112600, 0.64583333333333, -0.12, 0.16666666666667
112601, 0.66666666666667, -0.14, 0.16666666666667
112602, 0.66666666666667, -0.16, 0.14583333333333
112603, 0.64583333333333, -0.16, 0.16666666666667
112604, 0.66666666666667, -0.18, 0.16666666666667
112605, 0.66666666666667, -0.02, 0.20833333333333
112606, 0.66666666666667, -0.04, 0.1875
112607, 0.64583333333333, -0.04, 0.20833333333333
112608, 0.66666666666667, -0.06, 0.20833333333333
112609, 0.66666666666667, -0.08, 0.1875
112610, 0.64583333333333, -0.08, 0.20833333333333
112611, 0.66666666666667, -0.1, 0.20833333333333
112612, 0.66666666666667, -0.12, 0.1875
112613, 0.64583333333333, -0.12, 0.20833333333333
112614, 0.66666666666667, -0.14, 0.20833333333333
112615, 0.66666666666667, -0.16, 0.1875
112616, 0.64583333333333, -0.16, 0.20833333333333
112617, 0.66666666666667, -0.18, 0.20833333333333
112618, 0.66666666666667, -0.02, 0.25
112619, 0.66666666666667, -0.04, 0.22916666666667
112620, 0.64583333333333, -0.04, 0.25
112621, 0.66666666666667, -0.06, 0.25
112622, 0.66666666666667, -0.08, 0.22916666666667
112623, 0.64583333333333, -0.08, 0.25
112624, 0.66666666666667, -0.1, 0.25
112625, 0.66666666666667, -0.12, 0.22916666666667
112626, 0.64583333333333, -0.12, 0.25
112627, 0.66666666666667, -0.14, 0.25
112628, 0.66666666666667, -0.16, 0.22916666666667
112629, 0.64583333333333, -0.16, 0.25
112630, 0.66666666666667, -0.18, 0.25
112631, 0.66666666666667, -0.02, 0.29166666666667
112632, 0.66666666666667, -0.04, 0.27083333333333
112633, 0.64583333333333, -0.04, 0.29166666666667
112634, 0.66666666666667, -0.06, 0.29166666666667
112635, 0.66666666666667, -0.08, 0.27083333333333
112636, 0.64583333333333, -0.08, 0.29166666666667
112637, 0.66666666666667, -0.1, 0.29166666666667
112638, 0.66666666666667, -0.12, 0.27083333333333
112639, 0.64583333333333, -0.12, 0.29166666666667
112640, 0.66666666666667, -0.14, 0.29166666666667
112641, 0.66666666666667, -0.16, 0.27083333333333
112642, 0.64583333333333, -0.16, 0.29166666666667
112643, 0.66666666666667, -0.18, 0.29166666666667
112644, 0.66666666666667, -0.02, 0.33333333333333
112645, 0.66666666666667, -0.04, 0.3125
112646, 0.64583333333333, -0.04, 0.33333333333333
112647, 0.66666666666667, -0.06, 0.33333333333333
112648, 0.66666666666667, -0.08, 0.3125
112649, 0.64583333333333, -0.08, 0.33333333333333
112650, 0.66666666666667, -0.1, 0.33333333333333
112651, 0.66666666666667, -0.12, 0.3125
112652, 0.64583333333333, -0.12, 0.33333333333333
112653, 0.66666666666667, -0.14, 0.33333333333333
112654, 0.66666666666667, -0.16, 0.3125
112655, 0.64583333333333, -0.16, 0.33333333333333
112656, 0.66666666666667, -0.18, 0.33333333333333
112657, 0.66666666666667, -0.02, 0.375
112658, 0.66666666666667, -0.04, 0.35416666666667
112659, 0.64583333333333, -0.04, 0.375
112660, 0.66666666666667, -0.06, 0.375
112661, 0.66666666666667, -0.08, 0.35416666666667
112662, 0.64583333333333, -0.08, 0.375
112663, 0.66666666666667, -0.1, 0.375
112664, 0.66666666666667, -0.12, 0.35416666666667
112665, 0.64583333333333, -0.12, 0.375
112666, 0.66666666666667, -0.14, 0.375
112667, 0.66666666666667, -0.16, 0.35416666666667
112668, 0.64583333333333, -0.16, 0.375
112669, 0.66666666666667, -0.18, 0.375
112670, 0.66666666666667, -0.02, 0.41666666666667
112671, 0.66666666666667, -0.04, 0.39583333333333
112672, 0.64583333333333, -0.04, 0.41666666666667
112673, 0.66666666666667, -0.06, 0.41666666666667
112674, 0.66666666666667, -0.08, 0.39583333333333
112675, 0.64583333333333, -0.08, 0.41666666666667
112676, 0.66666666666667, -0.1, 0.41666666666667
112677, 0.66666666666667, -0.12, 0.39583333333333
112678, 0.64583333333333, -0.12, 0.41666666666667
112679, 0.66666666666667, -0.14, 0.41666666666667
112680, 0.66666666666667, -0.16, 0.39583333333333
112681, 0.64583333333333, -0.16, 0.41666666666667
112682, 0.66666666666667, -0.18, 0.41666666666667
112683, 0.66666666666667, -0.02, 0.45833333333333
112684, 0.66666666666667, -0.04, 0.4375
112685, 0.64583333333333, -0.04, 0.45833333333333
112686, 0.66666666666667, -0.06, 0.45833333333333
112687, 0.66666666666667, -0.08, 0.4375
112688, 0.64583333333333, -0.08, 0.45833333333333
112689, 0.66666666666667, -0.1, 0.45833333333333
112690, 0.66666666666667, -0.12, 0.4375
112691, 0.64583333333333, -0.12, 0.45833333333333
112692, 0.66666666666667, -0.14, 0.45833333333333
112693, 0.66666666666667, -0.16, 0.4375
112694, 0.64583333333333, -0.16, 0.45833333333333
112695, 0.66666666666667, -0.18, 0.45833333333333
112696, 0.66666666666667, -0.04, 0.47916666666667
112697, 0.66666666666667, -0.08, 0.47916666666667
112698, 0.66666666666667, -0.12, 0.47916666666667
112699, 0.66666666666667, -0.16, 0.47916666666667
112700, 0.70833333333333, -0.02, 0.041666666666667
112701, 0.70833333333333, -0.04, 0.020833333333333
112702, 0.6875, -0.04, 0.041666666666667
112703, 0.70833333333333, -0.06, 0.041666666666667
112704, 0.70833333333333, -0.08, 0.020833333333333
112705, 0.6875, -0.08, 0.041666666666667
112706, 0.70833333333333, -0.1, 0.041666666666667
112707, 0.70833333333333, -0.12, 0.020833333333333
112708, 0.6875, -0.12, 0.041666666666667
112709, 0.70833333333333, -0.14, 0.041666666666667
112710, 0.70833333333333, -0.16, 0.020833333333333
112711, 0.6875, -0.16, 0.041666666666667
112712, 0.70833333333333, -0.18, 0.041666666666667
112713, 0.70833333333333, -0.02, 0.083333333333333
112714, 0.70833333333333, -0.04, 0.0625
112715, 0.6875, -0.04, 0.083333333333333
112716, 0.70833333333333, -0.06, 0.083333333333333
112717, 0.70833333333333, -0.08, 0.0625
112718, 0.6875, -0.08, 0.083333333333333
112719, 0.70833333333333, -0.1, 0.083333333333333
112720, 0.70833333333333, -0.12, 0.0625
112721, 0.6875, -0.12, 0.083333333333333
112722, 0.70833333333333, -0.14, 0.083333333333333
112723, 0.70833333333333, -0.16, 0.0625
112724, 0.6875, -0.16, 0.083333333333333
112725, 0.70833333333333, -0.18, 0.083333333333333
112726, 0.70833333333333, -0.02, 0.125
112727, 0.70833333333333, -0.04, 0.10416666666667
112728, 0.6875, -0.04, 0.125
112729, 0.70833333333333, -0.06, 0.125
112730, 0.70833333333333, -0.08, 0.10416666666667
112731, 0.6875, -0.08, 0.125
112732, 0.70833333333333, -0.1, 0.125
112733, 0.70833333333333, -0.12, 0.10416666666667
112734, 0.6875, -0.12, 0.125
112735, 0.70833333333333, -0.14, 0.125
112736, 0.70833333333333, -0.16, 0.10416666666667
112737, 0.6875, -0.16, 0.125
112738, 0.70833333333333, -0.18, 0.125
112739, 0.70833333333333, -0.02, 0.16666666666667
112740, 0.70833333333333, -0.04, 0.14583333333333
112741, 0.6875, -0.04, 0.16666666666667
112742, 0.70833333333333, -0.06, 0.16666666666667
112743, 0.70833333333333, -0.08, 0.14583333333333
112744, 0.6875, -0.08, 0.16666666666667
112745, 0.70833333333333, -0.1, 0.16666666666667
112746, 0.70833333333333, -0.12, 0.14583333333333
112747, 0.6875, -0.12, 0.16666666666667
112748, 0.70833333333333, -0.14, 0.16666666666667
112749, 0.70833333333333, -0.16, 0.14583333333333
112750, 0.6875, -0.16, 0.16666666666667
112751, 0.70833333333333, -0.18, 0.16666666666667
112752, 0.70833333333333, -0.02, 0.20833333333333
112753, 0.70833333333333, -0.04, 0.1875
112754, 0.6875, -0.04, 0.20833333333333
112755, 0.70833333333333, -0.06, 0.20833333333333
112756, 0.70833333333333, -0.08, 0.1875
112757, 0.6875, -0.08, 0.20833333333333
112758, 0.70833333333333, -0.1, 0.20833333333333
112759, 0.70833333333333, -0.12, 0.1875
112760, 0.6875, -0.12, 0.20833333333333
112761, 0.70833333333333, -0.14, 0.20833333333333
112762, 0.70833333333333, -0.16, 0.1875
112763, 0.6875, -0.16, 0.20833333333333
112764, 0.70833333333333, -0.18, 0.20833333333333
112765, 0.70833333333333, -0.02, 0.25
112766, 0.70833333333333, -0.04, 0.22916666666667
112767, 0.6875, -0.04, 0.25
112768, 0.70833333333333, -0.06, 0.25
112769, 0.70833333333333, -0.08, 0.22916666666667
112770, 0.6875, -0.08, 0.25
112771, 0.70833333333333, -0.1, 0.25
112772, 0.70833333333333, -0.12, 0.22916666666667
112773, 0.6875, -0.12, 0.25
112774, 0.70833333333333, -0.14, 0.25
112775, 0.70833333333333, -0.16, 0.22916666666667
112776, 0.6875, -0.16, 0.25
112777, 0.70833333333333, -0.18, 0.25
112778, 0.70833333333333, -0.02, 0.29166666666667
112779, 0.70833333333333, -0.04, 0.27083333333333
112780, 0.6875, -0.04, 0.29166666666667
112781, 0.70833333333333, -0.06, 0.29166666666667
112782, 0.70833333333333, -0.08, 0.27083333333333
112783, 0.6875, -0.08, 0.29166666666667
112784, 0.70833333333333, -0.1, 0.29166666666667
112785, 0.70833333333333, -0.12, 0.27083333333333
112786, 0.6875, -0.12, 0.29166666666667
112787, 0.70833333333333, -0.14, 0.29166666666667
112788, 0.70833333333333, -0.16, 0.27083333333333
112789, 0.6875, -0.16, 0.29166666666667
112790, 0.70833333333333, -0.18, 0.29166666666667
112791, 0.70833333333333, -0.02, 0.33333333333333
112792, 0.70833333333333, -0.04, 0.3125
112793, 0.6875, -0.04, 0.33333333333333
112794, 0.70833333333333, -0.06, 0.33333333333333
112795, 0.70833333333333, -0.08, 0.3125
112796, 0.6875, -0.08, 0.33333333333333
112797, 0.70833333333333, -0.1, 0.33333333333333
112798, 0.70833333333333, -0.12, 0.3125
112799, 0.6875, -0.12, 0.33333333333333
112800, 0.70833333333333, -0.14, 0.33333333333333
112801, 0.70833333333333, -0.16, 0.3125
112802, 0.6875, -0.16, 0.33333333333333
112803, 0.70833333333333, -0.18, 0.33333333333333
112804, 0.70833333333333, -0.02, 0.375
112805, 0.70833333333333, -0.04, 0.35416666666667
112806, 0.6875, -0.04, 0.375
112807, 0.70833333333333, -0.06, 0.375
112808, 0.70833333333333, -0.08, 0.35416666666667
112809, 0.6875, -0.08, 0.375
112810, 0.70833333333333, -0.1, 0.375
112811, 0.70833333333333, -0.12, 0.35416666666667
112812, 0.6875, -0.12, 0.375
112813, 0.70833333333333, -0.14, 0.375
112814, 0.70833333333333, -0.16, 0.35416666666667
112815, 0.6875, -0.16, 0.375
112816, 0.70833333333333, -0.18, 0.375
112817, 0.70833333333333, -0.02, 0.41666666666667
112818, 0.70833333333333, -0.04, 0.39583333333333
112819, 0.6875, -0.04, 0.41666666666667
112820, 0.70833333333333, -0.06, 0.41666666666667
112821, 0.70833333333333, -0.08, 0.39583333333333
112822, 0.6875, -0.08, 0.41666666666667
112823, 0.70833333333333, -0.1, 0.41666666666667
112824, 0.70833333333333, -0.12, 0.39583333333333
112825, 0.6875, -0.12, 0.41666666666667
112826, 0.70833333333333, -0.14, 0.41666666666667
112827, 0.70833333333333, -0.16, 0.39583333333333
112828, 0.6875, -0.16, 0.41666666666667
112829, 0.70833333333333, -0.18, 0.41666666666667
112830, 0.70833333333333, -0.02, 0.45833333333333
112831, 0.70833333333333, -0.04, 0.4375
112832, 0.6875, -0.04, 0.45833333333333
112833, 0.70833333333333, -0.06, 0.45833333333333
112834, 0.70833333333333, -0.08, 0.4375
112835, 0.6875, -0.08, 0.45833333333333
112836, 0.70833333333333, -0.1, 0.45833333333333
112837, 0.70833333333333, -0.12, 0.4375
112838, 0.6875, -0.12, 0.45833333333333
112839, 0.70833333333333, -0.14, 0.45833333333333
112840, 0.70833333333333, -0.16, 0.4375
112841, 0.6875, -0.16, 0.45833333333333
112842, 0.70833333333333, -0.18, 0.45833333333333
112843, 0.70833333333333, -0.04, 0.47916666666667
112844, 0.70833333333333, -0.08, 0.47916666666667
112845, 0.70833333333333, -0.12, 0.47916666666667
112846, 0.70833333333333, -0.16, 0.47916666666667
112847, 0.75, -0.02, 0.041666666666667
112848, 0.75, -0.04, 0.020833333333333
112849, 0.72916666666667, -0.04, 0.041666666666667
112850, 0.75, -0.06, 0.041666666666667
112851, 0.75, -0.08, 0.020833333333333
112852, 0.72916666666667, -0.08, 0.041666666666667
112853, 0.75, -0.1, 0.041666666666667
112854, 0.75, -0.12, 0.020833333333333
112855, 0.72916666666667, -0.12, 0.041666666666667
112856, 0.75, -0.14, 0.041666666666667
112857, 0.75, -0.16, 0.020833333333333
112858, 0.72916666666667, -0.16, 0.041666666666667
112859, 0.75, -0.18, 0.041666666666667
112860, 0.75, -0.02, 0.083333333333333
112861, 0.75, -0.04, 0.0625
112862, 0.72916666666667, -0.04, 0.083333333333333
112863, 0.75, -0.06, 0.083333333333333
112864, 0.75, -0.08, 0.0625
112865, 0.72916666666667, -0.08, 0.083333333333333
112866, 0.75, -0.1, 0.083333333333333
112867, 0.75, -0.12, 0.0625
112868, 0.72916666666667, -0.12, 0.083333333333333
112869, 0.75, -0.14, 0.083333333333333
112870, 0.75, -0.16, 0.0625
112871, 0.72916666666667, -0.16, 0.083333333333333
112872, 0.75, -0.18, 0.083333333333333
112873, 0.75, -0.02, 0.125
112874, 0.75, -0.04, 0.10416666666667
112875, 0.72916666666667, -0.04, 0.125
112876, 0.75, -0.06, 0.125
112877, 0.75, -0.08, 0.10416666666667
112878, 0.72916666666667, -0.08, 0.125
112879, 0.75, -0.1, 0.125
112880, 0.75, -0.12, 0.10416666666667
112881, 0.72916666666667, -0.12, 0.125
112882, 0.75, -0.14, 0.125
112883, 0.75, -0.16, 0.10416666666667
112884, 0.72916666666667, -0.16, 0.125
112885, 0.75, -0.18, 0.125
112886, 0.75, -0.02, 0.16666666666667
112887, 0.75, -0.04, 0.14583333333333
112888, 0.72916666666667, -0.04, 0.16666666666667
112889, 0.75, -0.06, 0.16666666666667
112890, 0.75, -0.08, 0.14583333333333
112891, 0.72916666666667, -0.08, 0.16666666666667
112892, 0.75, -0.1, 0.16666666666667
112893, 0.75, -0.12, 0.14583333333333
112894, 0.72916666666667, -0.12, 0.16666666666667
112895, 0.75, -0.14, 0.16666666666667
112896, 0.75, -0.16, 0.14583333333333
112897, 0.72916666666667, -0.16, 0.16666666666667
112898, 0.75, -0.18, 0.16666666666667
112899, 0.75, -0.02, 0.20833333333333
112900, 0.75, -0.04, 0.1875
112901, 0.72916666666667, -0.04, 0.20833333333333
112902, 0.75, -0.06, 0.20833333333333
112903, 0.75, -0.08, 0.1875
112904, 0.72916666666667, -0.08, 0.20833333333333
112905, 0.75, -0.1, 0.20833333333333
112906, 0.75, -0.12, 0.1875
112907, 0.72916666666667, -0.12, 0.20833333333333
112908, 0.75, -0.14, 0.20833333333333
112909, 0.75, -0.16, 0.1875
112910, 0.72916666666667, -0.16, 0.20833333333333
112911, 0.75, -0.18, 0.20833333333333
112912, 0.75, -0.02, 0.25
112913, 0.75, -0.04, 0.22916666666667
112914, 0.72916666666667, -0.04, 0.25
112915, 0.75, -0.06, 0.25
112916, 0.75, -0.08, 0.22916666666667
112917, 0.72916666666667, -0.08, 0.25
112918, 0.75, -0.1, 0.25
112919, 0.75, -0.12, 0.22916666666667
112920, 0.72916666666667, -0.12, 0.25
112921, 0.75, -0.14, 0.25
112922, 0.75, -0.16, 0.22916666666667
112923, 0.72916666666667, -0.16, 0.25
112924, 0.75, -0.18, 0.25
112925, 0.75, -0.02, 0.29166666666667
112926, 0.75, -0.04, 0.27083333333333
112927, 0.72916666666667, -0.04, 0.29166666666667
112928, 0.75, -0.06, 0.29166666666667
112929, 0.75, -0.08, 0.27083333333333
112930, 0.72916666666667, -0.08, 0.29166666666667
112931, 0.75, -0.1, 0.29166666666667
112932, 0.75, -0.12, 0.27083333333333
112933, 0.72916666666667, -0.12, 0.29166666666667
112934, 0.75, -0.14, 0.29166666666667
112935, 0.75, -0.16, 0.27083333333333
112936, 0.72916666666667, -0.16, 0.29166666666667
112937, 0.75, -0.18, 0.29166666666667
112938, 0.75, -0.02, 0.33333333333333
112939, 0.75, -0.04, 0.3125
112940, 0.72916666666667, -0.04, 0.33333333333333
112941, 0.75, -0.06, 0.33333333333333
112942, 0.75, -0.08, 0.3125
112943, 0.72916666666667, -0.08, 0.33333333333333
112944, 0.75, -0.1, 0.33333333333333
112945, 0.75, -0.12, 0.3125
112946, 0.72916666666667, -0.12, 0.33333333333333
112947, 0.75, -0.14, 0.33333333333333
112948, 0.75, -0.16, 0.3125
112949, 0.72916666666667, -0.16, 0.33333333333333
112950, 0.75, -0.18, 0.33333333333333
112951, 0.75, -0.02, 0.375
112952, 0.75, -0.04, 0.35416666666667
112953, 0.72916666666667, -0.04, 0.375
112954, 0.75, -0.06, 0.375
112955, 0.75, -0.08, 0.35416666666667
112956, 0.72916666666667, -0.08, 0.375
112957, 0.75, -0.1, 0.375
112958, 0.75, -0.12, 0.35416666666667
112959, 0.72916666666667, -0.12, 0.375
112960, 0.75, -0.14, 0.375
112961, 0.75, -0.16, 0.35416666666667
112962, 0.72916666666667, -0.16, 0.375
112963, 0.75, -0.18, 0.375
112964, 0.75, -0.02, 0.41666666666667
112965, 0.75, -0.04, 0.39583333333333
112966, 0.72916666666667, -0.04, 0.41666666666667
112967, 0.75, -0.06, 0.41666666666667
112968, 0.75, -0.08, 0.39583333333333
112969, 0.72916666666667, -0.08, 0.41666666666667
112970, 0.75, -0.1, 0.41666666666667
112971, 0.75, -0.12, 0.39583333333333
112972, 0.72916666666667, -0.12, 0.41666666666667
112973, 0.75, -0.14, 0.41666666666667
112974, 0.75, -0.16, 0.39583333333333
112975, 0.72916666666667, -0.16, 0.41666666666667
112976, 0.75, -0.18, 0.41666666666667
112977, 0.75, -0.02, 0.45833333333333
112978, 0.75, -0.04, 0.4375
112979, 0.72916666666667, -0.04, 0.45833333333333
112980, 0.75, -0.06, 0.45833333333333
112981, 0.75, -0.08, 0.4375
112982, 0.72916666666667, -0.08, 0.45833333333333
112983, 0.75, -0.1, 0.45833333333333
112984, 0.75, -0.12, 0.4375
112985, 0.72916666666667, -0.12, 0.45833333333333
112986, 0.75, -0.14, 0.45833333333333
112987, 0.75, -0.16, 0.4375
112988, 0.72916666666667, -0.16, 0.45833333333333
112989, 0.75, -0.18, 0.45833333333333
112990, 0.75, -0.04, 0.47916666666667
112991, 0.75, -0.08, 0.47916666666667
112992, 0.75, -0.12, 0.47916666666667
112993, 0.75, -0.16, 0.47916666666667
112994, 0.79166666666667, -0.02, 0.041666666666667
112995, 0.79166666666667, -0.04, 0.020833333333333
112996, 0.77083333333333, -0.04, 0.041666666666667
112997, 0.79166666666667, -0.06, 0.041666666666667
112998, 0.79166666666667, -0.08, 0.020833333333333
112999, 0.77083333333333, -0.08, 0.041666666666667
113000, 0.79166666666667, -0.1, 0.041666666666667
113001, 0.79166666666667, -0.12, 0.020833333333333
113002, 0.77083333333333, -0.12, 0.041666666666667
113003, 0.79166666666667, -0.14, 0.041666666666667
113004, 0.79166666666667, -0.16, 0.020833333333333
113005, 0.77083333333333, -0.16, 0.041666666666667
113006, 0.79166666666667, -0.18, 0.041666666666667
113007, 0.79166666666667, -0.02, 0.083333333333333
113008, 0.79166666666667, -0.04, 0.0625
113009, 0.77083333333333, -0.04, 0.083333333333333
113010, 0.79166666666667, -0.06, 0.083333333333333
113011, 0.79166666666667, -0.08, 0.0625
113012, 0.77083333333333, -0.08, 0.083333333333333
113013, 0.79166666666667, -0.1, 0.083333333333333
113014, 0.79166666666667, -0.12, 0.0625
113015, 0.77083333333333, -0.12, 0.083333333333333
113016, 0.79166666666667, -0.14, 0.083333333333333
113017, 0.79166666666667, -0.16, 0.0625
113018, 0.77083333333333, -0.16, 0.083333333333333
113019, 0.79166666666667, -0.18, 0.083333333333333
113020, 0.79166666666667, -0.02, 0.125
113021, 0.79166666666667, -0.04, 0.10416666666667
113022, 0.77083333333333, -0.04, 0.125
113023, 0.79166666666667, -0.06, 0.125
113024, 0.79166666666667, -0.08, 0.10416666666667
113025, 0.77083333333333, -0.08, 0.125
113026, 0.79166666666667, -0.1, 0.125
113027, 0.79166666666667, -0.12, 0.10416666666667
113028, 0.77083333333333, -0.12, 0.125
113029, 0.79166666666667, -0.14, 0.125
113030, 0.79166666666667, -0.16, 0.10416666666667
113031, 0.77083333333333, -0.16, 0.125
113032, 0.79166666666667, -0.18, 0.125
113033, 0.79166666666667, -0.02, 0.16666666666667
113034, 0.79166666666667, -0.04, 0.14583333333333
113035, 0.77083333333333, -0.04, 0.16666666666667
113036, 0.79166666666667, -0.06, 0.16666666666667
113037, 0.79166666666667, -0.08, 0.14583333333333
113038, 0.77083333333333, -0.08, 0.16666666666667
113039, 0.79166666666667, -0.1, 0.16666666666667
113040, 0.79166666666667, -0.12, 0.14583333333333
113041, 0.77083333333333, -0.12, 0.16666666666667
113042, 0.79166666666667, -0.14, 0.16666666666667
113043, 0.79166666666667, -0.16, 0.14583333333333
113044, 0.77083333333333, -0.16, 0.16666666666667
113045, 0.79166666666667, -0.18, 0.16666666666667
113046, 0.79166666666667, -0.02, 0.20833333333333
113047, 0.79166666666667, -0.04, 0.1875
113048, 0.77083333333333, -0.04, 0.20833333333333
113049, 0.79166666666667, -0.06, 0.20833333333333
113050, 0.79166666666667, -0.08, 0.1875
113051, 0.77083333333333, -0.08, 0.20833333333333
113052, 0.79166666666667, -0.1, 0.20833333333333
113053, 0.79166666666667, -0.12, 0.1875
113054, 0.77083333333333, -0.12, 0.20833333333333
113055, 0.79166666666667, -0.14, 0.20833333333333
113056, 0.79166666666667, -0.16, 0.1875
113057, 0.77083333333333, -0.16, 0.20833333333333
113058, 0.79166666666667, -0.18, 0.20833333333333
113059, 0.79166666666667, -0.02, 0.25
113060, 0.79166666666667, -0.04, 0.22916666666667
113061, 0.77083333333333, -0.04, 0.25
113062, 0.79166666666667, -0.06, 0.25
113063, 0.79166666666667, -0.08, 0.22916666666667
113064, 0.77083333333333, -0.08, 0.25
113065, 0.79166666666667, -0.1, 0.25
113066, 0.79166666666667, -0.12, 0.22916666666667
113067, 0.77083333333333, -0.12, 0.25
113068, 0.79166666666667, -0.14, 0.25
113069, 0.79166666666667, -0.16, 0.22916666666667
113070, 0.77083333333333, -0.16, 0.25
113071, 0.79166666666667, -0.18, 0.25
113072, 0.79166666666667, -0.02, 0.29166666666667
113073, 0.79166666666667, -0.04, 0.27083333333333
113074, 0.77083333333333, -0.04, 0.29166666666667
113075, 0.79166666666667, -0.06, 0.29166666666667
113076, 0.79166666666667, -0.08, 0.27083333333333
113077, 0.77083333333333, -0.08, 0.29166666666667
113078, 0.79166666666667, -0.1, 0.29166666666667
113079, 0.79166666666667, -0.12, 0.27083333333333
113080, 0.77083333333333, -0.12, 0.29166666666667
113081, 0.79166666666667, -0.14, 0.29166666666667
113082, 0.79166666666667, -0.16, 0.27083333333333
113083, 0.77083333333333, -0.16, 0.29166666666667
113084, 0.79166666666667, -0.18, 0.29166666666667
113085, 0.79166666666667, -0.02, 0.33333333333333
113086, 0.79166666666667, -0.04, 0.3125
113087, 0.77083333333333, -0.04, 0.33333333333333
113088, 0.79166666666667, -0.06, 0.33333333333333
113089, 0.79166666666667, -0.08, 0.3125
113090, 0.77083333333333, -0.08, 0.33333333333333
113091, 0.79166666666667, -0.1, 0.33333333333333
113092, 0.79166666666667, -0.12, 0.3125
113093, 0.77083333333333, -0.12, 0.33333333333333
113094, 0.79166666666667, -0.14, 0.33333333333333
113095, 0.79166666666667, -0.16, 0.3125
113096, 0.77083333333333, -0.16, 0.33333333333333
113097, 0.79166666666667, -0.18, 0.33333333333333
113098, 0.79166666666667, -0.02, 0.375
113099, 0.79166666666667, -0.04, 0.35416666666667
113100, 0.77083333333333, -0.04, 0.375
113101, 0.79166666666667, -0.06, 0.375
113102, 0.79166666666667, -0.08, 0.35416666666667
113103, 0.77083333333333, -0.08, 0.375
113104, 0.79166666666667, -0.1, 0.375
113105, 0.79166666666667, -0.12, 0.35416666666667
113106, 0.77083333333333, -0.12, 0.375
113107, 0.79166666666667, -0.14, 0.375
113108, 0.79166666666667, -0.16, 0.35416666666667
113109, 0.77083333333333, -0.16, 0.375
113110, 0.79166666666667, -0.18, 0.375
113111, 0.79166666666667, -0.02, 0.41666666666667
113112, 0.79166666666667, -0.04, 0.39583333333333
113113, 0.77083333333333, -0.04, 0.41666666666667
113114, 0.79166666666667, -0.06, 0.41666666666667
113115, 0.79166666666667, -0.08, 0.39583333333333
113116, 0.77083333333333, -0.08, 0.41666666666667
113117, 0.79166666666667, -0.1, 0.41666666666667
113118, 0.79166666666667, -0.12, 0.39583333333333
113119, 0.77083333333333, -0.12, 0.41666666666667
113120, 0.79166666666667, -0.14, 0.41666666666667
113121, 0.79166666666667, -0.16, 0.39583333333333
113122, 0.77083333333333, -0.16, 0.41666666666667
113123, 0.79166666666667, -0.18, 0.41666666666667
113124, 0.79166666666667, -0.02, 0.45833333333333
113125, 0.79166666666667, -0.04, 0.4375
113126, 0.77083333333333, -0.04, 0.45833333333333
113127, 0.79166666666667, -0.06, 0.45833333333333
113128, 0.79166666666667, -0.08, 0.4375
113129, 0.77083333333333, -0.08, 0.45833333333333
113130, 0.79166666666667, -0.1, 0.45833333333333
113131, 0.79166666666667, -0.12, 0.4375
113132, 0.77083333333333, -0.12, 0.45833333333333
113133, 0.79166666666667, -0.14, 0.45833333333333
113134, 0.79166666666667, -0.16, 0.4375
113135, 0.77083333333333, -0.16, 0.45833333333333
113136, 0.79166666666667, -0.18, 0.45833333333333
113137, 0.79166666666667, -0.04, 0.47916666666667
113138, 0.79166666666667, -0.08, 0.47916666666667
113139, 0.79166666666667, -0.12, 0.47916666666667
113140, 0.79166666666667, -0.16, 0.47916666666667
113141, 0.83333333333333, -0.02, 0.041666666666667
113142, 0.83333333333333, -0.04, 0.020833333333333
113143, 0.8125, -0.04, 0.041666666666667
113144, 0.83333333333333, -0.06, 0.041666666666667
113145, 0.83333333333333, -0.08, 0.020833333333333
113146, 0.8125, -0.08, 0.041666666666667
113147, 0.83333333333333, -0.1, 0.041666666666667
113148, 0.83333333333333, -0.12, 0.020833333333333
113149, 0.8125, -0.12, 0.041666666666667
113150, 0.83333333333333, -0.14, 0.041666666666667
113151, 0.83333333333333, -0.16, 0.020833333333333
113152, 0.8125, -0.16, 0.041666666666667
113153, 0.83333333333333, -0.18, 0.041666666666667
113154, 0.83333333333333, -0.02, 0.083333333333333
113155, 0.83333333333333, -0.04, 0.0625
113156, 0.8125, -0.04, 0.083333333333333
113157, 0.83333333333333, -0.06, 0.083333333333333
113158, 0.83333333333333, -0.08, 0.0625
113159, 0.8125, -0.08, 0.083333333333333
113160, 0.83333333333333, -0.1, 0.083333333333333
113161, 0.83333333333333, -0.12, 0.0625
113162, 0.8125, -0.12, 0.083333333333333
113163, 0.83333333333333, -0.14, 0.083333333333333
113164, 0.83333333333333, -0.16, 0.0625
113165, 0.8125, -0.16, 0.083333333333333
113166, 0.83333333333333, -0.18, 0.083333333333333
113167, 0.83333333333333, -0.02, 0.125
113168, 0.83333333333333, -0.04, 0.10416666666667
113169, 0.8125, -0.04, 0.125
113170, 0.83333333333333, -0.06, 0.125
113171, 0.83333333333333, -0.08, 0.10416666666667
113172, 0.8125, -0.08, 0.125
113173, 0.83333333333333, -0.1, 0.125
113174, 0.83333333333333, -0.12, 0.10416666666667
113175, 0.8125, -0.12, 0.125
113176, 0.83333333333333, -0.14, 0.125
113177, 0.83333333333333, -0.16, 0.10416666666667
113178, 0.8125, -0.16, 0.125
113179, 0.83333333333333, -0.18, 0.125
113180, 0.83333333333333, -0.02, 0.16666666666667
113181, 0.83333333333333, -0.04, 0.14583333333333
113182, 0.8125, -0.04, 0.16666666666667
113183, 0.83333333333333, -0.06, 0.16666666666667
113184, 0.83333333333333, -0.08, 0.14583333333333
113185, 0.8125, -0.08, 0.16666666666667
113186, 0.83333333333333, -0.1, 0.16666666666667
113187, 0.83333333333333, -0.12, 0.14583333333333
113188, 0.8125, -0.12, 0.16666666666667
113189, 0.83333333333333, -0.14, 0.16666666666667
113190, 0.83333333333333, -0.16, 0.14583333333333
113191, 0.8125, -0.16, 0.16666666666667
113192, 0.83333333333333, -0.18, 0.16666666666667
113193, 0.83333333333333, -0.02, 0.20833333333333
113194, 0.83333333333333, -0.04, 0.1875
113195, 0.8125, -0.04, 0.20833333333333
113196, 0.83333333333333, -0.06, 0.20833333333333
113197, 0.83333333333333, -0.08, 0.1875
113198, 0.8125, -0.08, 0.20833333333333
113199, 0.83333333333333, -0.1, 0.20833333333333
113200, 0.83333333333333, -0.12, 0.1875
113201, 0.8125, -0.12, 0.20833333333333
113202, 0.83333333333333, -0.14, 0.20833333333333
113203, 0.83333333333333, -0.16, 0.1875
113204, 0.8125, -0.16, 0.20833333333333
113205, 0.83333333333333, -0.18, 0.20833333333333
113206, 0.83333333333333, -0.02, 0.25
113207, 0.83333333333333, -0.04, 0.22916666666667
113208, 0.8125, -0.04, 0.25
113209, 0.83333333333333, -0.06, 0.25
113210, 0.83333333333333, -0.08, 0.22916666666667
113211, 0.8125, -0.08, 0.25
113212, 0.83333333333333, -0.1, 0.25
113213, 0.83333333333333, -0.12, 0.22916666666667
113214, 0.8125, -0.12, 0.25
113215, 0.83333333333333, -0.14, 0.25
113216, 0.83333333333333, -0.16, 0.22916666666667
113217, 0.8125, -0.16, 0.25
113218, 0.83333333333333, -0.18, 0.25
113219, 0.83333333333333, -0.02, 0.29166666666667
113220, 0.83333333333333, -0.04, 0.27083333333333
113221, 0.8125, -0.04, 0.29166666666667
113222, 0.83333333333333, -0.06, 0.29166666666667
113223, 0.83333333333333, -0.08, 0.27083333333333
113224, 0.8125, -0.08, 0.29166666666667
113225, 0.83333333333333, -0.1, 0.29166666666667
113226, 0.83333333333333, -0.12, 0.27083333333333
113227, 0.8125, -0.12, 0.29166666666667
113228, 0.83333333333333, -0.14, 0.29166666666667
113229, 0.83333333333333, -0.16, 0.27083333333333
113230, 0.8125, -0.16, 0.29166666666667
113231, 0.83333333333333, -0.18, 0.29166666666667
113232, 0.83333333333333, -0.02, 0.33333333333333
113233, 0.83333333333333, -0.04, 0.3125
113234, 0.8125, -0.04, 0.33333333333333
113235, 0.83333333333333, -0.06, 0.33333333333333
113236, 0.83333333333333, -0.08, 0.3125
113237, 0.8125, -0.08, 0.33333333333333
113238, 0.83333333333333, -0.1, 0.33333333333333
113239, 0.83333333333333, -0.12, 0.3125
113240, 0.8125, -0.12, 0.33333333333333
113241, 0.83333333333333, -0.14, 0.33333333333333
113242, 0.83333333333333, -0.16, 0.3125
113243, 0.8125, -0.16, 0.33333333333333
113244, 0.83333333333333, -0.18, 0.33333333333333
113245, 0.83333333333333, -0.02, 0.375
113246, 0.83333333333333, -0.04, 0.35416666666667
113247, 0.8125, -0.04, 0.375
113248, 0.83333333333333, -0.06, 0.375
113249, 0.83333333333333, -0.08, 0.35416666666667
113250, 0.8125, -0.08, 0.375
113251, 0.83333333333333, -0.1, 0.375
113252, 0.83333333333333, -0.12, 0.35416666666667
113253, 0.8125, -0.12, 0.375
113254, 0.83333333333333, -0.14, 0.375
113255, 0.83333333333333, -0.16, 0.35416666666667
113256, 0.8125, -0.16, 0.375
113257, 0.83333333333333, -0.18, 0.375
113258, 0.83333333333333, -0.02, 0.41666666666667
113259, 0.83333333333333, -0.04, 0.39583333333333
113260, 0.8125, -0.04, 0.41666666666667
113261, 0.83333333333333, -0.06, 0.41666666666667
113262, 0.83333333333333, -0.08, 0.39583333333333
113263, 0.8125, -0.08, 0.41666666666667
113264, 0.83333333333333, -0.1, 0.41666666666667
113265, 0.83333333333333, -0.12, 0.39583333333333
113266, 0.8125, -0.12, 0.41666666666667
113267, 0.83333333333333, -0.14, 0.41666666666667
113268, 0.83333333333333, -0.16, 0.39583333333333
113269, 0.8125, -0.16, 0.41666666666667
113270, 0.83333333333333, -0.18, 0.41666666666667
113271, 0.83333333333333, -0.02, 0.45833333333333
113272, 0.83333333333333, -0.04, 0.4375
113273, 0.8125, -0.04, 0.45833333333333
113274, 0.83333333333333, -0.06, 0.45833333333333
113275, 0.83333333333333, -0.08, 0.4375
113276, 0.8125, -0.08, 0.45833333333333
113277, 0.83333333333333, -0.1, 0.45833333333333
113278, 0.83333333333333, -0.12, 0.4375
113279, 0.8125, -0.12, 0.45833333333333
113280, 0.83333333333333, -0.14, 0.45833333333333
113281, 0.83333333333333, -0.16, 0.4375
113282, 0.8125, -0.16, 0.45833333333333
113283, 0.83333333333333, -0.18, 0.45833333333333
113284, 0.83333333333333, -0.04, 0.47916666666667
113285, 0.83333333333333, -0.08, 0.47916666666667
113286, 0.83333333333333, -0.12, 0.47916666666667
113287, 0.83333333333333, -0.16, 0.47916666666667
113288, 0.875, -0.02, 0.041666666666667
113289, 0.875, -0.04, 0.020833333333333
113290, 0.85416666666667, -0.04, 0.041666666666667
113291, 0.875, -0.06, 0.041666666666667
113292, 0.875, -0.08, 0.020833333333333
113293, 0.85416666666667, -0.08, 0.041666666666667
113294, 0.875, -0.1, 0.041666666666667
113295, 0.875, -0.12, 0.020833333333333
113296, 0.85416666666667, -0.12, 0.041666666666667
113297, 0.875, -0.14, 0.041666666666667
113298, 0.875, -0.16, 0.020833333333333
113299, 0.85416666666667, -0.16, 0.041666666666667
113300, 0.875, -0.18, 0.041666666666667
113301, 0.875, -0.02, 0.083333333333333
113302, 0.875, -0.04, 0.0625
113303, 0.85416666666667, -0.04, 0.083333333333333
113304, 0.875, -0.06, 0.083333333333333
113305, 0.875, -0.08, 0.0625
113306, 0.85416666666667, -0.08, 0.083333333333333
113307, 0.875, -0.1, 0.083333333333333
113308, 0.875, -0.12, 0.0625
113309, 0.85416666666667, -0.12, 0.083333333333333
113310, 0.875, -0.14, 0.083333333333333
113311, 0.875, -0.16, 0.0625
113312, 0.85416666666667, -0.16, 0.083333333333333
113313, 0.875, -0.18, 0.083333333333333
113314, 0.875, -0.02, 0.125
113315, 0.875, -0.04, 0.10416666666667
113316, 0.85416666666667, -0.04, 0.125
113317, 0.875, -0.06, 0.125
113318, 0.875, -0.08, 0.10416666666667
113319, 0.85416666666667, -0.08, 0.125
113320, 0.875, -0.1, 0.125
113321, 0.875, -0.12, 0.10416666666667
113322, 0.85416666666667, -0.12, 0.125
113323, 0.875, -0.14, 0.125
113324, 0.875, -0.16, 0.10416666666667
113325, 0.85416666666667, -0.16, 0.125
113326, 0.875, -0.18, 0.125
113327, 0.875, -0.02, 0.16666666666667
113328, 0.875, -0.04, 0.14583333333333
113329, 0.85416666666667, -0.04, 0.16666666666667
113330, 0.875, -0.06, 0.16666666666667
113331, 0.875, -0.08, 0.14583333333333
113332, 0.85416666666667, -0.08, 0.16666666666667
113333, 0.875, -0.1, 0.16666666666667
113334, 0.875, -0.12, 0.14583333333333
113335, 0.85416666666667, -0.12, 0.16666666666667
113336, 0.875, -0.14, 0.16666666666667
113337, 0.875, -0.16, 0.14583333333333
113338, 0.85416666666667, -0.16, 0.16666666666667
113339, 0.875, -0.18, 0.16666666666667
113340, 0.875, -0.02, 0.20833333333333
113341, 0.875, -0.04, 0.1875
113342, 0.85416666666667, -0.04, 0.20833333333333
113343, 0.875, -0.06, 0.20833333333333
113344, 0.875, -0.08, 0.1875
113345, 0.85416666666667, -0.08, 0.20833333333333
113346, 0.875, -0.1, 0.20833333333333
113347, 0.875, -0.12, 0.1875
113348, 0.85416666666667, -0.12, 0.20833333333333
113349, 0.875, -0.14, 0.20833333333333
113350, 0.875, -0.16, 0.1875
113351, 0.85416666666667, -0.16, 0.20833333333333
113352, 0.875, -0.18, 0.20833333333333
113353, 0.875, -0.02, 0.25
113354, 0.875, -0.04, 0.22916666666667
113355, 0.85416666666667, -0.04, 0.25
113356, 0.875, -0.06, 0.25
113357, 0.875, -0.08, 0.22916666666667
113358, 0.85416666666667, -0.08, 0.25
113359, 0.875, -0.1, 0.25
113360, 0.875, -0.12, 0.22916666666667
113361, 0.85416666666667, -0.12, 0.25
113362, 0.875, -0.14, 0.25
113363, 0.875, -0.16, 0.22916666666667
113364, 0.85416666666667, -0.16, 0.25
113365, 0.875, -0.18, 0.25
113366, 0.875, -0.02, 0.29166666666667
113367, 0.875, -0.04, 0.27083333333333
113368, 0.85416666666667, -0.04, 0.29166666666667
113369, 0.875, -0.06, 0.29166666666667
113370, 0.875, -0.08, 0.27083333333333
113371, 0.85416666666667, -0.08, 0.29166666666667
113372, 0.875, -0.1, 0.29166666666667
113373, 0.875, -0.12, 0.27083333333333
113374, 0.85416666666667, -0.12, 0.29166666666667
113375, 0.875, -0.14, 0.29166666666667
113376, 0.875, -0.16, 0.27083333333333
113377, 0.85416666666667, -0.16, 0.29166666666667
113378, 0.875, -0.18, 0.29166666666667
113379, 0.875, -0.02, 0.33333333333333
113380, 0.875, -0.04, 0.3125
113381, 0.85416666666667, -0.04, 0.33333333333333
113382, 0.875, -0.06, 0.33333333333333
113383, 0.875, -0.08, 0.3125
113384, 0.85416666666667, -0.08, 0.33333333333333
113385, 0.875, -0.1, 0.33333333333333
113386, 0.875, -0.12, 0.3125
113387, 0.85416666666667, -0.12, 0.33333333333333
113388, 0.875, -0.14, 0.33333333333333
113389, 0.875, -0.16, 0.3125
113390, 0.85416666666667, -0.16, 0.33333333333333
113391, 0.875, -0.18, 0.33333333333333
113392, 0.875, -0.02, 0.375
113393, 0.875, -0.04, 0.35416666666667
113394, 0.85416666666667, -0.04, 0.375
113395, 0.875, -0.06, 0.375
113396, 0.875, -0.08, 0.35416666666667
113397, 0.85416666666667, -0.08, 0.375
113398, 0.875, -0.1, 0.375
113399, 0.875, -0.12, 0.35416666666667
113400, 0.85416666666667, -0.12, 0.375
113401, 0.875, -0.14, 0.375
113402, 0.875, -0.16, 0.35416666666667
113403, 0.85416666666667, -0.16, 0.375
113404, 0.875, -0.18, 0.375
113405, 0.875, -0.02, 0.41666666666667
113406, 0.875, -0.04, 0.39583333333333
113407, 0.85416666666667, -0.04, 0.41666666666667
113408, 0.875, -0.06, 0.41666666666667
113409, 0.875, -0.08, 0.39583333333333
113410, 0.85416666666667, -0.08, 0.41666666666667
113411, 0.875, -0.1, 0.41666666666667
113412, 0.875, -0.12, 0.39583333333333
113413, 0.85416666666667, -0.12, 0.41666666666667
113414, 0.875, -0.14, 0.41666666666667
113415, 0.875, -0.16, 0.39583333333333
113416, 0.85416666666667, -0.16, 0.41666666666667
113417, 0.875, -0.18, 0.41666666666667
113418, 0.875, -0.02, 0.45833333333333
113419, 0.875, -0.04, 0.4375
113420, 0.85416666666667, -0.04, 0.45833333333333
113421, 0.875, -0.06, 0.45833333333333
113422, 0.875, -0.08, 0.4375
113423, 0.85416666666667, -0.08, 0.45833333333333
113424, 0.875, -0.1, 0.45833333333333
113425, 0.875, -0.12, 0.4375
113426, 0.85416666666667, -0.12, 0.45833333333333
113427, 0.875, -0.14, 0.45833333333333
113428, 0.875, -0.16, 0.4375
113429, 0.85416666666667, -0.16, 0.45833333333333
113430, 0.875, -0.18, 0.45833333333333
113431, 0.875, -0.04, 0.47916666666667
113432, 0.875, -0.08, 0.47916666666667
113433, 0.875, -0.12, 0.47916666666667
113434, 0.875, -0.16, 0.47916666666667
113435, 0.91666666666667, -0.02, 0.041666666666667
113436, 0.91666666666667, -0.04, 0.020833333333333
113437, 0.89583333333333, -0.04, 0.041666666666667
113438, 0.91666666666667, -0.06, 0.041666666666667
113439, 0.91666666666667, -0.08, 0.020833333333333
113440, 0.89583333333333, -0.08, 0.041666666666667
113441, 0.91666666666667, -0.1, 0.041666666666667
113442, 0.91666666666667, -0.12, 0.020833333333333
113443, 0.89583333333333, -0.12, 0.041666666666667
113444, 0.91666666666667, -0.14, 0.041666666666667
113445, 0.91666666666667, -0.16, 0.020833333333333
113446, 0.89583333333333, -0.16, 0.041666666666667
113447, 0.91666666666667, -0.18, 0.041666666666667
113448, 0.91666666666667, -0.02, 0.083333333333333
113449, 0.91666666666667, -0.04, 0.0625
113450, 0.89583333333333, -0.04, 0.083333333333333
113451, 0.91666666666667, -0.06, 0.083333333333333
113452, 0.91666666666667, -0.08, 0.0625
113453, 0.89583333333333, -0.08, 0.083333333333333
113454, 0.91666666666667, -0.1, 0.083333333333333
113455, 0.91666666666667, -0.12, 0.0625
113456, 0.89583333333333, -0.12, 0.083333333333333
113457, 0.91666666666667, -0.14, 0.083333333333333
113458, 0.91666666666667, -0.16, 0.0625
113459, 0.89583333333333, -0.16, 0.083333333333333
113460, 0.91666666666667, -0.18, 0.083333333333333
113461, 0.91666666666667, -0.02, 0.125
113462, 0.91666666666667, -0.04, 0.10416666666667
113463, 0.89583333333333, -0.04, 0.125
113464, 0.91666666666667, -0.06, 0.125
113465, 0.91666666666667, -0.08, 0.10416666666667
113466, 0.89583333333333, -0.08, 0.125
113467, 0.91666666666667, -0.1, 0.125
113468, 0.91666666666667, -0.12, 0.10416666666667
113469, 0.89583333333333, -0.12, 0.125
113470, 0.91666666666667, -0.14, 0.125
113471, 0.91666666666667, -0.16, 0.10416666666667
113472, 0.89583333333333, -0.16, 0.125
113473, 0.91666666666667, -0.18, 0.125
113474, 0.91666666666667, -0.02, 0.16666666666667
113475, 0.91666666666667, -0.04, 0.14583333333333
113476, 0.89583333333333, -0.04, 0.16666666666667
113477, 0.91666666666667, -0.06, 0.16666666666667
113478, 0.91666666666667, -0.08, 0.14583333333333
113479, 0.89583333333333, -0.08, 0.16666666666667
113480, 0.91666666666667, -0.1, 0.16666666666667
113481, 0.91666666666667, -0.12, 0.14583333333333
113482, 0.89583333333333, -0.12, 0.16666666666667
113483, 0.91666666666667, -0.14, 0.16666666666667
113484, 0.91666666666667, -0.16, 0.14583333333333
113485, 0.89583333333333, -0.16, 0.16666666666667
113486, 0.91666666666667, -0.18, 0.16666666666667
113487, 0.91666666666667, -0.02, 0.20833333333333
113488, 0.91666666666667, -0.04, 0.1875
113489, 0.89583333333333, -0.04, 0.20833333333333
113490, 0.91666666666667, -0.06, 0.20833333333333
113491, 0.91666666666667, -0.08, 0.1875
113492, 0.89583333333333, -0.08, 0.20833333333333
113493, 0.91666666666667, -0.1, 0.20833333333333
113494, 0.91666666666667, -0.12, 0.1875
113495, 0.89583333333333, -0.12, 0.20833333333333
113496, 0.91666666666667, -0.14, 0.20833333333333
113497, 0.91666666666667, -0.16, 0.1875
113498, 0.89583333333333, -0.16, 0.20833333333333
113499, 0.91666666666667, -0.18, 0.20833333333333
113500, 0.91666666666667, -0.02, 0.25
113501, 0.91666666666667, -0.04, 0.22916666666667
113502, 0.89583333333333, -0.04, 0.25
113503, 0.91666666666667, -0.06, 0.25
113504, 0.91666666666667, -0.08, 0.22916666666667
113505, 0.89583333333333, -0.08, 0.25
113506, 0.91666666666667, -0.1, 0.25
113507, 0.91666666666667, -0.12, 0.22916666666667
113508, 0.89583333333333, -0.12, 0.25
113509, 0.91666666666667, -0.14, 0.25
113510, 0.91666666666667, -0.16, 0.22916666666667
113511, 0.89583333333333, -0.16, 0.25
113512, 0.91666666666667, -0.18, 0.25
113513, 0.91666666666667, -0.02, 0.29166666666667
113514, 0.91666666666667, -0.04, 0.27083333333333
113515, 0.89583333333333, -0.04, 0.29166666666667
113516, 0.91666666666667, -0.06, 0.29166666666667
113517, 0.91666666666667, -0.08, 0.27083333333333
113518, 0.89583333333333, -0.08, 0.29166666666667
113519, 0.91666666666667, -0.1, 0.29166666666667
113520, 0.91666666666667, -0.12, 0.27083333333333
113521, 0.89583333333333, -0.12, 0.29166666666667
113522, 0.91666666666667, -0.14, 0.29166666666667
113523, 0.91666666666667, -0.16, 0.27083333333333
113524, 0.89583333333333, -0.16, 0.29166666666667
113525, 0.91666666666667, -0.18, 0.29166666666667
113526, 0.91666666666667, -0.02, 0.33333333333333
113527, 0.91666666666667, -0.04, 0.3125
113528, 0.89583333333333, -0.04, 0.33333333333333
113529, 0.91666666666667, -0.06, 0.33333333333333
113530, 0.91666666666667, -0.08, 0.3125
113531, 0.89583333333333, -0.08, 0.33333333333333
113532, 0.91666666666667, -0.1, 0.33333333333333
113533, 0.91666666666667, -0.12, 0.3125
113534, 0.89583333333333, -0.12, 0.33333333333333
113535, 0.91666666666667, -0.14, 0.33333333333333
113536, 0.91666666666667, -0.16, 0.3125
113537, 0.89583333333333, -0.16, 0.33333333333333
113538, 0.91666666666667, -0.18, 0.33333333333333
113539, 0.91666666666667, -0.02, 0.375
113540, 0.91666666666667, -0.04, 0.35416666666667
113541, 0.89583333333333, -0.04, 0.375
113542, 0.91666666666667, -0.06, 0.375
113543, 0.91666666666667, -0.08, 0.35416666666667
113544, 0.89583333333333, -0.08, 0.375
113545, 0.91666666666667, -0.1, 0.375
113546, 0.91666666666667, -0.12, 0.35416666666667
113547, 0.89583333333333, -0.12, 0.375
113548, 0.91666666666667, -0.14, 0.375
113549, 0.91666666666667, -0.16, 0.35416666666667
113550, 0.89583333333333, -0.16, 0.375
113551, 0.91666666666667, -0.18, 0.375
113552, 0.91666666666667, -0.02, 0.41666666666667
113553, 0.91666666666667, -0.04, 0.39583333333333
113554, 0.89583333333333, -0.04, 0.41666666666667
113555, 0.91666666666667, -0.06, 0.41666666666667
113556, 0.91666666666667, -0.08, 0.39583333333333
113557, 0.89583333333333, -0.08, 0.41666666666667
113558, 0.91666666666667, -0.1, 0.41666666666667
113559, 0.91666666666667, -0.12, 0.39583333333333
113560, 0.89583333333333, -0.12, 0.41666666666667
113561, 0.91666666666667, -0.14, 0.41666666666667
113562, 0.91666666666667, -0.16, 0.39583333333333
113563, 0.89583333333333, -0.16, 0.41666666666667
113564, 0.91666666666667, -0.18, 0.41666666666667
113565, 0.91666666666667, -0.02, 0.45833333333333
113566, 0.91666666666667, -0.04, 0.4375
113567, 0.89583333333333, -0.04, 0.45833333333333
113568, 0.91666666666667, -0.06, 0.45833333333333
113569, 0.91666666666667, -0.08, 0.4375
113570, 0.89583333333333, -0.08, 0.45833333333333
113571, 0.91666666666667, -0.1, 0.45833333333333
113572, 0.91666666666667, -0.12, 0.4375
113573, 0.89583333333333, -0.12, 0.45833333333333
113574, 0.91666666666667, -0.14, 0.45833333333333
113575, 0.91666666666667, -0.16, 0.4375
113576, 0.89583333333333, -0.16, 0.45833333333333
113577, 0.91666666666667, -0.18, 0.45833333333333
113578, 0.91666666666667, -0.04, 0.47916666666667
113579, 0.91666666666667, -0.08, 0.47916666666667
113580, 0.91666666666667, -0.12, 0.47916666666667
113581, 0.91666666666667, -0.16, 0.47916666666667
113582, 0.95833333333333, -0.02, 0.041666666666667
113583, 0.95833333333333, -0.04, 0.020833333333333
113584, 0.9375, -0.04, 0.041666666666667
113585, 0.95833333333333, -0.06, 0.041666666666667
113586, 0.95833333333333, -0.08, 0.020833333333333
113587, 0.9375, -0.08, 0.041666666666667
113588, 0.95833333333333, -0.1, 0.041666666666667
113589, 0.95833333333333, -0.12, 0.020833333333333
113590, 0.9375, -0.12, 0.041666666666667
113591, 0.95833333333333, -0.14, 0.041666666666667
113592, 0.95833333333333, -0.16, 0.020833333333333
113593, 0.9375, -0.16, 0.041666666666667
113594, 0.95833333333333, -0.18, 0.041666666666667
113595, 0.95833333333333, -0.02, 0.083333333333333
113596, 0.95833333333333, -0.04, 0.0625
113597, 0.9375, -0.04, 0.083333333333333
113598, 0.95833333333333, -0.06, 0.083333333333333
113599, 0.95833333333333, -0.08, 0.0625
113600, 0.9375, -0.08, 0.083333333333333
