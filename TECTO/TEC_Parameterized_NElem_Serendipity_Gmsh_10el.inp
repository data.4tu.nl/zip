25620, 68942, 16449, 16472, 68988, 68943, 16450, 16473, 68989, 70501, 16954, 70664, 70619, 70502, 16956, 70665, 
70622, 70458, 16908, 16955, 70621
25621, 68943, 16450, 16473, 68989, 68944, 16451, 16474, 68990, 70502, 16956, 70665, 70622, 70503, 16958, 70666, 
70625, 70461, 16910, 16957, 70624
25622, 68944, 16451, 16474, 68990, 68945, 16452, 16475, 68991, 70503, 16958, 70666, 70625, 70504, 16960, 70667, 
70628, 70464, 16912, 16959, 70627
25623, 68945, 16452, 16475, 68991, 68946, 16453, 16476, 68992, 70504, 16960, 70667, 70628, 70505, 16962, 70668, 
70631, 70467, 16914, 16961, 70630
25624, 68946, 16453, 16476, 68992, 68947, 16454, 16477, 68993, 70505, 16962, 70668, 70631, 70506, 16964, 70669, 
70634, 70470, 16916, 16963, 70633
25625, 68947, 16454, 16477, 68993, 68948, 16455, 16478, 68994, 70506, 16964, 70669, 70634, 70507, 16966, 70670, 
70637, 70473, 16918, 16965, 70636
25626, 68948, 16455, 16478, 68994, 68949, 16456, 16479, 68995, 70507, 16966, 70670, 70637, 70508, 16968, 70671, 
70640, 70476, 16920, 16967, 70639
25627, 68949, 16456, 16479, 68995, 68950, 16457, 16480, 68996, 70508, 16968, 70671, 70640, 70509, 16970, 70672, 
70643, 70479, 16922, 16969, 70642
25628, 68950, 16457, 16480, 68996, 68951, 16458, 16481, 68997, 70509, 16970, 70672, 70643, 70510, 16972, 70673, 
70646, 70482, 16924, 16971, 70645
25629, 68951, 16458, 16481, 68997, 68952, 16459, 16482, 68998, 70510, 16972, 70673, 70646, 70511, 16974, 70674, 
70649, 70485, 16926, 16973, 70648
25630, 68952, 16459, 16482, 68998, 17063, 1494, 1495, 17065, 70511, 16974, 70674, 70649, 17112, 1506, 17117, 
17115, 70488, 16928, 16975, 70651
25631, 1228, 15073, 15075, 1229, 15667, 68953, 68999, 15690, 15123, 15127, 15128, 1240, 70514, 70676, 70677, 
16183, 16137, 70512, 70675, 16184
25632, 15667, 68953, 68999, 15690, 15668, 68954, 69000, 15691, 70514, 70676, 70677, 16183, 70517, 70679, 70680, 
16185, 16139, 70515, 70678, 16186
25633, 15668, 68954, 69000, 15691, 15669, 68955, 69001, 15692, 70517, 70679, 70680, 16185, 70520, 70682, 70683, 
16187, 16141, 70518, 70681, 16188
25634, 15669, 68955, 69001, 15692, 15670, 68956, 69002, 15693, 70520, 70682, 70683, 16187, 70523, 70685, 70686, 
16189, 16143, 70521, 70684, 16190
25635, 15670, 68956, 69002, 15693, 15671, 68957, 69003, 15694, 70523, 70685, 70686, 16189, 70526, 70688, 70689, 
16191, 16145, 70524, 70687, 16192
25636, 15671, 68957, 69003, 15694, 15672, 68958, 69004, 15695, 70526, 70688, 70689, 16191, 70529, 70691, 70692, 
16193, 16147, 70527, 70690, 16194
25637, 15672, 68958, 69004, 15695, 15673, 68959, 69005, 15696, 70529, 70691, 70692, 16193, 70532, 70694, 70695, 
16195, 16149, 70530, 70693, 16196
25638, 15673, 68959, 69005, 15696, 15674, 68960, 69006, 15697, 70532, 70694, 70695, 16195, 70535, 70697, 70698, 
16197, 16151, 70533, 70696, 16198
25639, 15674, 68960, 69006, 15697, 15675, 68961, 69007, 15698, 70535, 70697, 70698, 16197, 70538, 70700, 70701, 
16199, 16153, 70536, 70699, 16200
25640, 15675, 68961, 69007, 15698, 15676, 68962, 69008, 15699, 70538, 70700, 70701, 16199, 70541, 70703, 70704, 
16201, 16155, 70539, 70702, 16202
25641, 15676, 68962, 69008, 15699, 15677, 68963, 69009, 15700, 70541, 70703, 70704, 16201, 70544, 70706, 70707, 
16203, 16157, 70542, 70705, 16204
25642, 15677, 68963, 69009, 15700, 15678, 68964, 69010, 15701, 70544, 70706, 70707, 16203, 70547, 70709, 70710, 
16205, 16159, 70545, 70708, 16206
25643, 15678, 68964, 69010, 15701, 15679, 68965, 69011, 15702, 70547, 70709, 70710, 16205, 70550, 70712, 70713, 
16207, 16161, 70548, 70711, 16208
25644, 15679, 68965, 69011, 15702, 15680, 68966, 69012, 15703, 70550, 70712, 70713, 16207, 70553, 70715, 70716, 
16209, 16163, 70551, 70714, 16210
25645, 15680, 68966, 69012, 15703, 15681, 68967, 69013, 15704, 70553, 70715, 70716, 16209, 70556, 70718, 70719, 
16211, 16165, 70554, 70717, 16212
25646, 15681, 68967, 69013, 15704, 15682, 68968, 69014, 15705, 70556, 70718, 70719, 16211, 70559, 70721, 70722, 
16213, 16167, 70557, 70720, 16214
25647, 15682, 68968, 69014, 15705, 15683, 68969, 69015, 15706, 70559, 70721, 70722, 16213, 70562, 70724, 70725, 
16215, 16169, 70560, 70723, 16216
25648, 15683, 68969, 69015, 15706, 15684, 68970, 69016, 15707, 70562, 70724, 70725, 16215, 70565, 70727, 70728, 
16217, 16171, 70563, 70726, 16218
25649, 15684, 68970, 69016, 15707, 15685, 68971, 69017, 15708, 70565, 70727, 70728, 16217, 70568, 70730, 70731, 
16219, 16173, 70566, 70729, 16220
25650, 15685, 68971, 69017, 15708, 15686, 68972, 69018, 15709, 70568, 70730, 70731, 16219, 70571, 70733, 70734, 
16221, 16175, 70569, 70732, 16222
25651, 15686, 68972, 69018, 15709, 15687, 68973, 69019, 15710, 70571, 70733, 70734, 16221, 70574, 70736, 70737, 
16223, 16177, 70572, 70735, 16224
25652, 15687, 68973, 69019, 15710, 15688, 68974, 69020, 15711, 70574, 70736, 70737, 16223, 70577, 70739, 70740, 
16225, 16179, 70575, 70738, 16226
25653, 15688, 68974, 69020, 15711, 15689, 68975, 69021, 15712, 70577, 70739, 70740, 16225, 70580, 70742, 70743, 
16227, 16181, 70578, 70741, 16228
25654, 15689, 68975, 69021, 15712, 1472, 17064, 17066, 1473, 70580, 70742, 70743, 16227, 17114, 17118, 17119, 
1484, 16182, 70581, 70744, 16229
25655, 15073, 15074, 15076, 15075, 68953, 68976, 69022, 68999, 15125, 15129, 15130, 15127, 70584, 70746, 70747, 
70676, 70512, 70582, 70745, 70675
25656, 68953, 68976, 69022, 68999, 68954, 68977, 69023, 69000, 70584, 70746, 70747, 70676, 70587, 70749, 70750, 
70679, 70515, 70585, 70748, 70678
25657, 68954, 68977, 69023, 69000, 68955, 68978, 69024, 69001, 70587, 70749, 70750, 70679, 70590, 70752, 70753, 
70682, 70518, 70588, 70751, 70681
25658, 68955, 68978, 69024, 69001, 68956, 68979, 69025, 69002, 70590, 70752, 70753, 70682, 70593, 70755, 70756, 
70685, 70521, 70591, 70754, 70684
25659, 68956, 68979, 69025, 69002, 68957, 68980, 69026, 69003, 70593, 70755, 70756, 70685, 70596, 70758, 70759, 
70688, 70524, 70594, 70757, 70687
25660, 68957, 68980, 69026, 69003, 68958, 68981, 69027, 69004, 70596, 70758, 70759, 70688, 70599, 70761, 70762, 
70691, 70527, 70597, 70760, 70690
25661, 68958, 68981, 69027, 69004, 68959, 68982, 69028, 69005, 70599, 70761, 70762, 70691, 70602, 70764, 70765, 
70694, 70530, 70600, 70763, 70693
25662, 68959, 68982, 69028, 69005, 68960, 68983, 69029, 69006, 70602, 70764, 70765, 70694, 70605, 70767, 70768, 
70697, 70533, 70603, 70766, 70696
25663, 68960, 68983, 69029, 69006, 68961, 68984, 69030, 69007, 70605, 70767, 70768, 70697, 70608, 70770, 70771, 
70700, 70536, 70606, 70769, 70699
25664, 68961, 68984, 69030, 69007, 68962, 68985, 69031, 69008, 70608, 70770, 70771, 70700, 70611, 70773, 70774, 
70703, 70539, 70609, 70772, 70702
25665, 68962, 68985, 69031, 69008, 68963, 68986, 69032, 69009, 70611, 70773, 70774, 70703, 70614, 70776, 70777, 
70706, 70542, 70612, 70775, 70705
25666, 68963, 68986, 69032, 69009, 68964, 68987, 69033, 69010, 70614, 70776, 70777, 70706, 70617, 70779, 70780, 
70709, 70545, 70615, 70778, 70708
25667, 68964, 68987, 69033, 69010, 68965, 68988, 69034, 69011, 70617, 70779, 70780, 70709, 70620, 70782, 70783, 
70712, 70548, 70618, 70781, 70711
25668, 68965, 68988, 69034, 69011, 68966, 68989, 69035, 69012, 70620, 70782, 70783, 70712, 70623, 70785, 70786, 
70715, 70551, 70621, 70784, 70714
25669, 68966, 68989, 69035, 69012, 68967, 68990, 69036, 69013, 70623, 70785, 70786, 70715, 70626, 70788, 70789, 
70718, 70554, 70624, 70787, 70717
25670, 68967, 68990, 69036, 69013, 68968, 68991, 69037, 69014, 70626, 70788, 70789, 70718, 70629, 70791, 70792, 
70721, 70557, 70627, 70790, 70720
25671, 68968, 68991, 69037, 69014, 68969, 68992, 69038, 69015, 70629, 70791, 70792, 70721, 70632, 70794, 70795, 
70724, 70560, 70630, 70793, 70723
25672, 68969, 68992, 69038, 69015, 68970, 68993, 69039, 69016, 70632, 70794, 70795, 70724, 70635, 70797, 70798, 
70727, 70563, 70633, 70796, 70726
25673, 68970, 68993, 69039, 69016, 68971, 68994, 69040, 69017, 70635, 70797, 70798, 70727, 70638, 70800, 70801, 
70730, 70566, 70636, 70799, 70729
25674, 68971, 68994, 69040, 69017, 68972, 68995, 69041, 69018, 70638, 70800, 70801, 70730, 70641, 70803, 70804, 
70733, 70569, 70639, 70802, 70732
25675, 68972, 68995, 69041, 69018, 68973, 68996, 69042, 69019, 70641, 70803, 70804, 70733, 70644, 70806, 70807, 
70736, 70572, 70642, 70805, 70735
25676, 68973, 68996, 69042, 69019, 68974, 68997, 69043, 69020, 70644, 70806, 70807, 70736, 70647, 70809, 70810, 
70739, 70575, 70645, 70808, 70738
25677, 68974, 68997, 69043, 69020, 68975, 68998, 69044, 69021, 70647, 70809, 70810, 70739, 70650, 70812, 70813, 
70742, 70578, 70648, 70811, 70741
25678, 68975, 68998, 69044, 69021, 17064, 17065, 17067, 17066, 70650, 70812, 70813, 70742, 17116, 17120, 17121, 
17118, 70581, 70651, 70814, 70744
25679, 15074, 1251, 1252, 15076, 68976, 16460, 16483, 69022, 15126, 1263, 15131, 15129, 70652, 16977, 70815, 
70746, 70582, 16929, 16976, 70745
25680, 68976, 16460, 16483, 69022, 68977, 16461, 16484, 69023, 70652, 16977, 70815, 70746, 70653, 16979, 70816, 
70749, 70585, 16931, 16978, 70748
25681, 68977, 16461, 16484, 69023, 68978, 16462, 16485, 69024, 70653, 16979, 70816, 70749, 70654, 16981, 70817, 
70752, 70588, 16933, 16980, 70751
25682, 68978, 16462, 16485, 69024, 68979, 16463, 16486, 69025, 70654, 16981, 70817, 70752, 70655, 16983, 70818, 
70755, 70591, 16935, 16982, 70754
25683, 68979, 16463, 16486, 69025, 68980, 16464, 16487, 69026, 70655, 16983, 70818, 70755, 70656, 16985, 70819, 
70758, 70594, 16937, 16984, 70757
25684, 68980, 16464, 16487, 69026, 68981, 16465, 16488, 69027, 70656, 16985, 70819, 70758, 70657, 16987, 70820, 
70761, 70597, 16939, 16986, 70760
25685, 68981, 16465, 16488, 69027, 68982, 16466, 16489, 69028, 70657, 16987, 70820, 70761, 70658, 16989, 70821, 
70764, 70600, 16941, 16988, 70763
25686, 68982, 16466, 16489, 69028, 68983, 16467, 16490, 69029, 70658, 16989, 70821, 70764, 70659, 16991, 70822, 
70767, 70603, 16943, 16990, 70766
25687, 68983, 16467, 16490, 69029, 68984, 16468, 16491, 69030, 70659, 16991, 70822, 70767, 70660, 16993, 70823, 
70770, 70606, 16945, 16992, 70769
25688, 68984, 16468, 16491, 69030, 68985, 16469, 16492, 69031, 70660, 16993, 70823, 70770, 70661, 16995, 70824, 
70773, 70609, 16947, 16994, 70772
25689, 68985, 16469, 16492, 69031, 68986, 16470, 16493, 69032, 70661, 16995, 70824, 70773, 70662, 16997, 70825, 
70776, 70612, 16949, 16996, 70775
25690, 68986, 16470, 16493, 69032, 68987, 16471, 16494, 69033, 70662, 16997, 70825, 70776, 70663, 16999, 70826, 
70779, 70615, 16951, 16998, 70778
25691, 68987, 16471, 16494, 69033, 68988, 16472, 16495, 69034, 70663, 16999, 70826, 70779, 70664, 17001, 70827, 
70782, 70618, 16953, 17000, 70781
25692, 68988, 16472, 16495, 69034, 68989, 16473, 16496, 69035, 70664, 17001, 70827, 70782, 70665, 17003, 70828, 
70785, 70621, 16955, 17002, 70784
25693, 68989, 16473, 16496, 69035, 68990, 16474, 16497, 69036, 70665, 17003, 70828, 70785, 70666, 17005, 70829, 
70788, 70624, 16957, 17004, 70787
25694, 68990, 16474, 16497, 69036, 68991, 16475, 16498, 69037, 70666, 17005, 70829, 70788, 70667, 17007, 70830, 
70791, 70627, 16959, 17006, 70790
25695, 68991, 16475, 16498, 69037, 68992, 16476, 16499, 69038, 70667, 17007, 70830, 70791, 70668, 17009, 70831, 
70794, 70630, 16961, 17008, 70793
25696, 68992, 16476, 16499, 69038, 68993, 16477, 16500, 69039, 70668, 17009, 70831, 70794, 70669, 17011, 70832, 
70797, 70633, 16963, 17010, 70796
25697, 68993, 16477, 16500, 69039, 68994, 16478, 16501, 69040, 70669, 17011, 70832, 70797, 70670, 17013, 70833, 
70800, 70636, 16965, 17012, 70799
25698, 68994, 16478, 16501, 69040, 68995, 16479, 16502, 69041, 70670, 17013, 70833, 70800, 70671, 17015, 70834, 
70803, 70639, 16967, 17014, 70802
25699, 68995, 16479, 16502, 69041, 68996, 16480, 16503, 69042, 70671, 17015, 70834, 70803, 70672, 17017, 70835, 
70806, 70642, 16969, 17016, 70805
25700, 68996, 16480, 16503, 69042, 68997, 16481, 16504, 69043, 70672, 17017, 70835, 70806, 70673, 17019, 70836, 
70809, 70645, 16971, 17018, 70808
25701, 68997, 16481, 16504, 69043, 68998, 16482, 16505, 69044, 70673, 17019, 70836, 70809, 70674, 17021, 70837, 
70812, 70648, 16973, 17020, 70811
25702, 68998, 16482, 16505, 69044, 17065, 1495, 1496, 17067, 70674, 17021, 70837, 70812, 17117, 1507, 17122, 
17120, 70651, 16975, 17022, 70814
25703, 1229, 15075, 1191, 25, 15690, 68999, 15134, 1265, 15128, 15132, 1193, 1241, 70677, 70838, 15180, 
16230, 16184, 70675, 15181, 1288
25704, 15690, 68999, 15134, 1265, 15691, 69000, 15135, 1266, 70677, 70838, 15180, 16230, 70680, 70839, 15182, 
16231, 16186, 70678, 15183, 1289
25705, 15691, 69000, 15135, 1266, 15692, 69001, 15136, 1267, 70680, 70839, 15182, 16231, 70683, 70840, 15184, 
16232, 16188, 70681, 15185, 1290
25706, 15692, 69001, 15136, 1267, 15693, 69002, 15137, 1268, 70683, 70840, 15184, 16232, 70686, 70841, 15186, 
16233, 16190, 70684, 15187, 1291
25707, 15693, 69002, 15137, 1268, 15694, 69003, 15138, 1269, 70686, 70841, 15186, 16233, 70689, 70842, 15188, 
16234, 16192, 70687, 15189, 1292
25708, 15694, 69003, 15138, 1269, 15695, 69004, 15139, 1270, 70689, 70842, 15188, 16234, 70692, 70843, 15190, 
16235, 16194, 70690, 15191, 1293
25709, 15695, 69004, 15139, 1270, 15696, 69005, 15140, 1271, 70692, 70843, 15190, 16235, 70695, 70844, 15192, 
16236, 16196, 70693, 15193, 1294
25710, 15696, 69005, 15140, 1271, 15697, 69006, 15141, 1272, 70695, 70844, 15192, 16236, 70698, 70845, 15194, 
16237, 16198, 70696, 15195, 1295
25711, 15697, 69006, 15141, 1272, 15698, 69007, 15142, 1273, 70698, 70845, 15194, 16237, 70701, 70846, 15196, 
16238, 16200, 70699, 15197, 1296
25712, 15698, 69007, 15142, 1273, 15699, 69008, 15143, 1274, 70701, 70846, 15196, 16238, 70704, 70847, 15198, 
16239, 16202, 70702, 15199, 1297
25713, 15699, 69008, 15143, 1274, 15700, 69009, 15144, 1275, 70704, 70847, 15198, 16239, 70707, 70848, 15200, 
16240, 16204, 70705, 15201, 1298
25714, 15700, 69009, 15144, 1275, 15701, 69010, 15145, 1276, 70707, 70848, 15200, 16240, 70710, 70849, 15202, 
16241, 16206, 70708, 15203, 1299
25715, 15701, 69010, 15145, 1276, 15702, 69011, 15146, 1277, 70710, 70849, 15202, 16241, 70713, 70850, 15204, 
16242, 16208, 70711, 15205, 1300
25716, 15702, 69011, 15146, 1277, 15703, 69012, 15147, 1278, 70713, 70850, 15204, 16242, 70716, 70851, 15206, 
16243, 16210, 70714, 15207, 1301
25717, 15703, 69012, 15147, 1278, 15704, 69013, 15148, 1279, 70716, 70851, 15206, 16243, 70719, 70852, 15208, 
16244, 16212, 70717, 15209, 1302
25718, 15704, 69013, 15148, 1279, 15705, 69014, 15149, 1280, 70719, 70852, 15208, 16244, 70722, 70853, 15210, 
16245, 16214, 70720, 15211, 1303
25719, 15705, 69014, 15149, 1280, 15706, 69015, 15150, 1281, 70722, 70853, 15210, 16245, 70725, 70854, 15212, 
16246, 16216, 70723, 15213, 1304
25720, 15706, 69015, 15150, 1281, 15707, 69016, 15151, 1282, 70725, 70854, 15212, 16246, 70728, 70855, 15214, 
16247, 16218, 70726, 15215, 1305
25721, 15707, 69016, 15151, 1282, 15708, 69017, 15152, 1283, 70728, 70855, 15214, 16247, 70731, 70856, 15216, 
16248, 16220, 70729, 15217, 1306
25722, 15708, 69017, 15152, 1283, 15709, 69018, 15153, 1284, 70731, 70856, 15216, 16248, 70734, 70857, 15218, 
16249, 16222, 70732, 15219, 1307
25723, 15709, 69018, 15153, 1284, 15710, 69019, 15154, 1285, 70734, 70857, 15218, 16249, 70737, 70858, 15220, 
16250, 16224, 70735, 15221, 1308
25724, 15710, 69019, 15154, 1285, 15711, 69020, 15155, 1286, 70737, 70858, 15220, 16250, 70740, 70859, 15222, 
16251, 16226, 70738, 15223, 1309
25725, 15711, 69020, 15155, 1286, 15712, 69021, 15156, 1287, 70740, 70859, 15222, 16251, 70743, 70860, 15224, 
16252, 16228, 70741, 15225, 1310
25726, 15712, 69021, 15156, 1287, 1473, 17066, 1359, 29, 70743, 70860, 15224, 16252, 17119, 17123, 1361, 
1485, 16229, 70744, 15226, 1311
25727, 15075, 15076, 1192, 1191, 68999, 69022, 15157, 15134, 15130, 15133, 1194, 15132, 70747, 70861, 15227, 
70838, 70675, 70745, 15228, 15181
25728, 68999, 69022, 15157, 15134, 69000, 69023, 15158, 15135, 70747, 70861, 15227, 70838, 70750, 70862, 15229, 
70839, 70678, 70748, 15230, 15183
25729, 69000, 69023, 15158, 15135, 69001, 69024, 15159, 15136, 70750, 70862, 15229, 70839, 70753, 70863, 15231, 
70840, 70681, 70751, 15232, 15185
25730, 69001, 69024, 15159, 15136, 69002, 69025, 15160, 15137, 70753, 70863, 15231, 70840, 70756, 70864, 15233, 
70841, 70684, 70754, 15234, 15187
25731, 69002, 69025, 15160, 15137, 69003, 69026, 15161, 15138, 70756, 70864, 15233, 70841, 70759, 70865, 15235, 
70842, 70687, 70757, 15236, 15189
25732, 69003, 69026, 15161, 15138, 69004, 69027, 15162, 15139, 70759, 70865, 15235, 70842, 70762, 70866, 15237, 
70843, 70690, 70760, 15238, 15191
25733, 69004, 69027, 15162, 15139, 69005, 69028, 15163, 15140, 70762, 70866, 15237, 70843, 70765, 70867, 15239, 
70844, 70693, 70763, 15240, 15193
25734, 69005, 69028, 15163, 15140, 69006, 69029, 15164, 15141, 70765, 70867, 15239, 70844, 70768, 70868, 15241, 
70845, 70696, 70766, 15242, 15195
25735, 69006, 69029, 15164, 15141, 69007, 69030, 15165, 15142, 70768, 70868, 15241, 70845, 70771, 70869, 15243, 
70846, 70699, 70769, 15244, 15197
25736, 69007, 69030, 15165, 15142, 69008, 69031, 15166, 15143, 70771, 70869, 15243, 70846, 70774, 70870, 15245, 
70847, 70702, 70772, 15246, 15199
25737, 69008, 69031, 15166, 15143, 69009, 69032, 15167, 15144, 70774, 70870, 15245, 70847, 70777, 70871, 15247, 
70848, 70705, 70775, 15248, 15201
25738, 69009, 69032, 15167, 15144, 69010, 69033, 15168, 15145, 70777, 70871, 15247, 70848, 70780, 70872, 15249, 
70849, 70708, 70778, 15250, 15203
25739, 69010, 69033, 15168, 15145, 69011, 69034, 15169, 15146, 70780, 70872, 15249, 70849, 70783, 70873, 15251, 
70850, 70711, 70781, 15252, 15205
25740, 69011, 69034, 15169, 15146, 69012, 69035, 15170, 15147, 70783, 70873, 15251, 70850, 70786, 70874, 15253, 
70851, 70714, 70784, 15254, 15207
25741, 69012, 69035, 15170, 15147, 69013, 69036, 15171, 15148, 70786, 70874, 15253, 70851, 70789, 70875, 15255, 
70852, 70717, 70787, 15256, 15209
25742, 69013, 69036, 15171, 15148, 69014, 69037, 15172, 15149, 70789, 70875, 15255, 70852, 70792, 70876, 15257, 
70853, 70720, 70790, 15258, 15211
25743, 69014, 69037, 15172, 15149, 69015, 69038, 15173, 15150, 70792, 70876, 15257, 70853, 70795, 70877, 15259, 
70854, 70723, 70793, 15260, 15213
25744, 69015, 69038, 15173, 15150, 69016, 69039, 15174, 15151, 70795, 70877, 15259, 70854, 70798, 70878, 15261, 
70855, 70726, 70796, 15262, 15215
25745, 69016, 69039, 15174, 15151, 69017, 69040, 15175, 15152, 70798, 70878, 15261, 70855, 70801, 70879, 15263, 
70856, 70729, 70799, 15264, 15217
25746, 69017, 69040, 15175, 15152, 69018, 69041, 15176, 15153, 70801, 70879, 15263, 70856, 70804, 70880, 15265, 
70857, 70732, 70802, 15266, 15219
25747, 69018, 69041, 15176, 15153, 69019, 69042, 15177, 15154, 70804, 70880, 15265, 70857, 70807, 70881, 15267, 
70858, 70735, 70805, 15268, 15221
25748, 69019, 69042, 15177, 15154, 69020, 69043, 15178, 15155, 70807, 70881, 15267, 70858, 70810, 70882, 15269, 
70859, 70738, 70808, 15270, 15223
25749, 69020, 69043, 15178, 15155, 69021, 69044, 15179, 15156, 70810, 70882, 15269, 70859, 70813, 70883, 15271, 
70860, 70741, 70811, 15272, 15225
25750, 69021, 69044, 15179, 15156, 17066, 17067, 1360, 1359, 70813, 70883, 15271, 70860, 17121, 17124, 1362, 
17123, 70744, 70814, 15273, 15226
25751, 15076, 1252, 26, 1192, 69022, 16483, 1312, 15157, 15131, 1264, 1195, 15133, 70815, 17023, 15274, 
70861, 70745, 16976, 1335, 15228
25752, 69022, 16483, 1312, 15157, 69023, 16484, 1313, 15158, 70815, 17023, 15274, 70861, 70816, 17024, 15275, 
70862, 70748, 16978, 1336, 15230
25753, 69023, 16484, 1313, 15158, 69024, 16485, 1314, 15159, 70816, 17024, 15275, 70862, 70817, 17025, 15276, 
70863, 70751, 16980, 1337, 15232
25754, 69024, 16485, 1314, 15159, 69025, 16486, 1315, 15160, 70817, 17025, 15276, 70863, 70818, 17026, 15277, 
70864, 70754, 16982, 1338, 15234
25755, 69025, 16486, 1315, 15160, 69026, 16487, 1316, 15161, 70818, 17026, 15277, 70864, 70819, 17027, 15278, 
70865, 70757, 16984, 1339, 15236
25756, 69026, 16487, 1316, 15161, 69027, 16488, 1317, 15162, 70819, 17027, 15278, 70865, 70820, 17028, 15279, 
70866, 70760, 16986, 1340, 15238
25757, 69027, 16488, 1317, 15162, 69028, 16489, 1318, 15163, 70820, 17028, 15279, 70866, 70821, 17029, 15280, 
70867, 70763, 16988, 1341, 15240
25758, 69028, 16489, 1318, 15163, 69029, 16490, 1319, 15164, 70821, 17029, 15280, 70867, 70822, 17030, 15281, 
70868, 70766, 16990, 1342, 15242
25759, 69029, 16490, 1319, 15164, 69030, 16491, 1320, 15165, 70822, 17030, 15281, 70868, 70823, 17031, 15282, 
70869, 70769, 16992, 1343, 15244
25760, 69030, 16491, 1320, 15165, 69031, 16492, 1321, 15166, 70823, 17031, 15282, 70869, 70824, 17032, 15283, 
70870, 70772, 16994, 1344, 15246
25761, 69031, 16492, 1321, 15166, 69032, 16493, 1322, 15167, 70824, 17032, 15283, 70870, 70825, 17033, 15284, 
70871, 70775, 16996, 1345, 15248
25762, 69032, 16493, 1322, 15167, 69033, 16494, 1323, 15168, 70825, 17033, 15284, 70871, 70826, 17034, 15285, 
70872, 70778, 16998, 1346, 15250
25763, 69033, 16494, 1323, 15168, 69034, 16495, 1324, 15169, 70826, 17034, 15285, 70872, 70827, 17035, 15286, 
70873, 70781, 17000, 1347, 15252
25764, 69034, 16495, 1324, 15169, 69035, 16496, 1325, 15170, 70827, 17035, 15286, 70873, 70828, 17036, 15287, 
70874, 70784, 17002, 1348, 15254
25765, 69035, 16496, 1325, 15170, 69036, 16497, 1326, 15171, 70828, 17036, 15287, 70874, 70829, 17037, 15288, 
70875, 70787, 17004, 1349, 15256
25766, 69036, 16497, 1326, 15171, 69037, 16498, 1327, 15172, 70829, 17037, 15288, 70875, 70830, 17038, 15289, 
70876, 70790, 17006, 1350, 15258
25767, 69037, 16498, 1327, 15172, 69038, 16499, 1328, 15173, 70830, 17038, 15289, 70876, 70831, 17039, 15290, 
70877, 70793, 17008, 1351, 15260
25768, 69038, 16499, 1328, 15173, 69039, 16500, 1329, 15174, 70831, 17039, 15290, 70877, 70832, 17040, 15291, 
70878, 70796, 17010, 1352, 15262
25769, 69039, 16500, 1329, 15174, 69040, 16501, 1330, 15175, 70832, 17040, 15291, 70878, 70833, 17041, 15292, 
70879, 70799, 17012, 1353, 15264
25770, 69040, 16501, 1330, 15175, 69041, 16502, 1331, 15176, 70833, 17041, 15292, 70879, 70834, 17042, 15293, 
70880, 70802, 17014, 1354, 15266
25771, 69041, 16502, 1331, 15176, 69042, 16503, 1332, 15177, 70834, 17042, 15293, 70880, 70835, 17043, 15294, 
70881, 70805, 17016, 1355, 15268
25772, 69042, 16503, 1332, 15177, 69043, 16504, 1333, 15178, 70835, 17043, 15294, 70881, 70836, 17044, 15295, 
70882, 70808, 17018, 1356, 15270
25773, 69043, 16504, 1333, 15178, 69044, 16505, 1334, 15179, 70836, 17044, 15295, 70882, 70837, 17045, 15296, 
70883, 70811, 17020, 1357, 15272
25774, 69044, 16505, 1334, 15179, 17067, 1496, 30, 1360, 70837, 17045, 15296, 70883, 17122, 1508, 1363, 
17124, 70814, 17022, 1358, 15273
*ELEMENT, type=C3D20, ELSET=Volume8
25775, 27, 1364, 15460, 1219, 35, 1560, 17193, 1607, 1387, 15713, 15714, 1230, 1583, 17446, 17447, 
1618, 1558, 17148, 70884, 17171
25776, 1364, 1365, 15461, 15460, 1560, 1561, 17194, 17193, 1388, 15715, 15716, 15713, 1584, 17448, 17449, 
17446, 17148, 17149, 70885, 70884
25777, 1365, 1366, 15462, 15461, 1561, 1562, 17195, 17194, 1389, 15717, 15718, 15715, 1585, 17450, 17451, 
17448, 17149, 17150, 70886, 70885
25778, 1366, 1367, 15463, 15462, 1562, 1563, 17196, 17195, 1390, 15719, 15720, 15717, 1586, 17452, 17453, 
17450, 17150, 17151, 70887, 70886
25779, 1367, 1368, 15464, 15463, 1563, 1564, 17197, 17196, 1391, 15721, 15722, 15719, 1587, 17454, 17455, 
17452, 17151, 17152, 70888, 70887
25780, 1368, 1369, 15465, 15464, 1564, 1565, 17198, 17197, 1392, 15723, 15724, 15721, 1588, 17456, 17457, 
17454, 17152, 17153, 70889, 70888
25781, 1369, 1370, 15466, 15465, 1565, 1566, 17199, 17198, 1393, 15725, 15726, 15723, 1589, 17458, 17459, 
17456, 17153, 17154, 70890, 70889
25782, 1370, 1371, 15467, 15466, 1566, 1567, 17200, 17199, 1394, 15727, 15728, 15725, 1590, 17460, 17461, 
17458, 17154, 17155, 70891, 70890
25783, 1371, 1372, 15468, 15467, 1567, 1568, 17201, 17200, 1395, 15729, 15730, 15727, 1591, 17462, 17463, 
17460, 17155, 17156, 70892, 70891
25784, 1372, 1373, 15469, 15468, 1568, 1569, 17202, 17201, 1396, 15731, 15732, 15729, 1592, 17464, 17465, 
17462, 17156, 17157, 70893, 70892
25785, 1373, 1374, 15470, 15469, 1569, 1570, 17203, 17202, 1397, 15733, 15734, 15731, 1593, 17466, 17467, 
17464, 17157, 17158, 70894, 70893
25786, 1374, 1375, 15471, 15470, 1570, 1571, 17204, 17203, 1398, 15735, 15736, 15733, 1594, 17468, 17469, 
17466, 17158, 17159, 70895, 70894
25787, 1375, 1376, 15472, 15471, 1571, 1572, 17205, 17204, 1399, 15737, 15738, 15735, 1595, 17470, 17471, 
17468, 17159, 17160, 70896, 70895
25788, 1376, 1377, 15473, 15472, 1572, 1573, 17206, 17205, 1400, 15739, 15740, 15737, 1596, 17472, 17473, 
17470, 17160, 17161, 70897, 70896
25789, 1377, 1378, 15474, 15473, 1573, 1574, 17207, 17206, 1401, 15741, 15742, 15739, 1597, 17474, 17475, 
17472, 17161, 17162, 70898, 70897
25790, 1378, 1379, 15475, 15474, 1574, 1575, 17208, 17207, 1402, 15743, 15744, 15741, 1598, 17476, 17477, 
17474, 17162, 17163, 70899, 70898
25791, 1379, 1380, 15476, 15475, 1575, 1576, 17209, 17208, 1403, 15745, 15746, 15743, 1599, 17478, 17479, 
17476, 17163, 17164, 70900, 70899
25792, 1380, 1381, 15477, 15476, 1576, 1577, 17210, 17209, 1404, 15747, 15748, 15745, 1600, 17480, 17481, 
17478, 17164, 17165, 70901, 70900
25793, 1381, 1382, 15478, 15477, 1577, 1578, 17211, 17210, 1405, 15749, 15750, 15747, 1601, 17482, 17483, 
17480, 17165, 17166, 70902, 70901
25794, 1382, 1383, 15479, 15478, 1578, 1579, 17212, 17211, 1406, 15751, 15752, 15749, 1602, 17484, 17485, 
17482, 17166, 17167, 70903, 70902
25795, 1383, 1384, 15480, 15479, 1579, 1580, 17213, 17212, 1407, 15753, 15754, 15751, 1603, 17486, 17487, 
17484, 17167, 17168, 70904, 70903
25796, 1384, 1385, 15481, 15480, 1580, 1581, 17214, 17213, 1408, 15755, 15756, 15753, 1604, 17488, 17489, 
17486, 17168, 17169, 70905, 70904
25797, 1385, 1386, 15482, 15481, 1581, 1582, 17215, 17214, 1409, 15757, 15758, 15755, 1605, 17490, 17491, 
17488, 17169, 17170, 70906, 70905
25798, 1386, 31, 1463, 15482, 1582, 36, 1630, 17215, 1410, 1474, 15759, 15757, 1606, 1641, 17492, 
17490, 17170, 1559, 17182, 70906
25799, 1219, 15460, 15483, 1220, 1607, 17193, 17216, 1608, 15714, 15760, 15761, 1231, 17447, 17493, 17494, 
1619, 17171, 70884, 70907, 17172
25800, 15460, 15461, 15484, 15483, 17193, 17194, 17217, 17216, 15716, 15762, 15763, 15760, 17449, 17495, 17496, 
17493, 70884, 70885, 70908, 70907
25801, 15461, 15462, 15485, 15484, 17194, 17195, 17218, 17217, 15718, 15764, 15765, 15762, 17451, 17497, 17498, 
17495, 70885, 70886, 70909, 70908
25802, 15462, 15463, 15486, 15485, 17195, 17196, 17219, 17218, 15720, 15766, 15767, 15764, 17453, 17499, 17500, 
17497, 70886, 70887, 70910, 70909
25803, 15463, 15464, 15487, 15486, 17196, 17197, 17220, 17219, 15722, 15768, 15769, 15766, 17455, 17501, 17502, 
17499, 70887, 70888, 70911, 70910
25804, 15464, 15465, 15488, 15487, 17197, 17198, 17221, 17220, 15724, 15770, 15771, 15768, 17457, 17503, 17504, 
17501, 70888, 70889, 70912, 70911
25805, 15465, 15466, 15489, 15488, 17198, 17199, 17222, 17221, 15726, 15772, 15773, 15770, 17459, 17505, 17506, 
17503, 70889, 70890, 70913, 70912
25806, 15466, 15467, 15490, 15489, 17199, 17200, 17223, 17222, 15728, 15774, 15775, 15772, 17461, 17507, 17508, 
17505, 70890, 70891, 70914, 70913
25807, 15467, 15468, 15491, 15490, 17200, 17201, 17224, 17223, 15730, 15776, 15777, 15774, 17463, 17509, 17510, 
17507, 70891, 70892, 70915, 70914
25808, 15468, 15469, 15492, 15491, 17201, 17202, 17225, 17224, 15732, 15778, 15779, 15776, 17465, 17511, 17512, 
17509, 70892, 70893, 70916, 70915
25809, 15469, 15470, 15493, 15492, 17202, 17203, 17226, 17225, 15734, 15780, 15781, 15778, 17467, 17513, 17514, 
17511, 70893, 70894, 70917, 70916
25810, 15470, 15471, 15494, 15493, 17203, 17204, 17227, 17226, 15736, 15782, 15783, 15780, 17469, 17515, 17516, 
17513, 70894, 70895, 70918, 70917
25811, 15471, 15472, 15495, 15494, 17204, 17205, 17228, 17227, 15738, 15784, 15785, 15782, 17471, 17517, 17518, 
17515, 70895, 70896, 70919, 70918
25812, 15472, 15473, 15496, 15495, 17205, 17206, 17229, 17228, 15740, 15786, 15787, 15784, 17473, 17519, 17520, 
17517, 70896, 70897, 70920, 70919
25813, 15473, 15474, 15497, 15496, 17206, 17207, 17230, 17229, 15742, 15788, 15789, 15786, 17475, 17521, 17522, 
17519, 70897, 70898, 70921, 70920
25814, 15474, 15475, 15498, 15497, 17207, 17208, 17231, 17230, 15744, 15790, 15791, 15788, 17477, 17523, 17524, 
17521, 70898, 70899, 70922, 70921
25815, 15475, 15476, 15499, 15498, 17208, 17209, 17232, 17231, 15746, 15792, 15793, 15790, 17479, 17525, 17526, 
17523, 70899, 70900, 70923, 70922
25816, 15476, 15477, 15500, 15499, 17209, 17210, 17233, 17232, 15748, 15794, 15795, 15792, 17481, 17527, 17528, 
17525, 70900, 70901, 70924, 70923
25817, 15477, 15478, 15501, 15500, 17210, 17211, 17234, 17233, 15750, 15796, 15797, 15794, 17483, 17529, 17530, 
17527, 70901, 70902, 70925, 70924
25818, 15478, 15479, 15502, 15501, 17211, 17212, 17235, 17234, 15752, 15798, 15799, 15796, 17485, 17531, 17532, 
17529, 70902, 70903, 70926, 70925
25819, 15479, 15480, 15503, 15502, 17212, 17213, 17236, 17235, 15754, 15800, 15801, 15798, 17487, 17533, 17534, 
17531, 70903, 70904, 70927, 70926
25820, 15480, 15481, 15504, 15503, 17213, 17214, 17237, 17236, 15756, 15802, 15803, 15800, 17489, 17535, 17536, 
17533, 70904, 70905, 70928, 70927
25821, 15481, 15482, 15505, 15504, 17214, 17215, 17238, 17237, 15758, 15804, 15805, 15802, 17491, 17537, 17538, 
17535, 70905, 70906, 70929, 70928
25822, 15482, 1463, 1464, 15505, 17215, 1630, 1631, 17238, 15759, 1475, 15806, 15804, 17492, 1642, 17539, 
17537, 70906, 17182, 17183, 70929
25823, 1220, 15483, 15506, 1221, 1608, 17216, 17239, 1609, 15761, 15807, 15808, 1232, 17494, 17540, 17541, 
1620, 17172, 70907, 70930, 17173
25824, 15483, 15484, 15507, 15506, 17216, 17217, 17240, 17239, 15763, 15809, 15810, 15807, 17496, 17542, 17543, 
17540, 70907, 70908, 70931, 70930
25825, 15484, 15485, 15508, 15507, 17217, 17218, 17241, 17240, 15765, 15811, 15812, 15809, 17498, 17544, 17545, 
17542, 70908, 70909, 70932, 70931
25826, 15485, 15486, 15509, 15508, 17218, 17219, 17242, 17241, 15767, 15813, 15814, 15811, 17500, 17546, 17547, 
17544, 70909, 70910, 70933, 70932
25827, 15486, 15487, 15510, 15509, 17219, 17220, 17243, 17242, 15769, 15815, 15816, 15813, 17502, 17548, 17549, 
17546, 70910, 70911, 70934, 70933
25828, 15487, 15488, 15511, 15510, 17220, 17221, 17244, 17243, 15771, 15817, 15818, 15815, 17504, 17550, 17551, 
17548, 70911, 70912, 70935, 70934
25829, 15488, 15489, 15512, 15511, 17221, 17222, 17245, 17244, 15773, 15819, 15820, 15817, 17506, 17552, 17553, 
17550, 70912, 70913, 70936, 70935
25830, 15489, 15490, 15513, 15512, 17222, 17223, 17246, 17245, 15775, 15821, 15822, 15819, 17508, 17554, 17555, 
17552, 70913, 70914, 70937, 70936
25831, 15490, 15491, 15514, 15513, 17223, 17224, 17247, 17246, 15777, 15823, 15824, 15821, 17510, 17556, 17557, 
17554, 70914, 70915, 70938, 70937
25832, 15491, 15492, 15515, 15514, 17224, 17225, 17248, 17247, 15779, 15825, 15826, 15823, 17512, 17558, 17559, 
17556, 70915, 70916, 70939, 70938
25833, 15492, 15493, 15516, 15515, 17225, 17226, 17249, 17248, 15781, 15827, 15828, 15825, 17514, 17560, 17561, 
17558, 70916, 70917, 70940, 70939
25834, 15493, 15494, 15517, 15516, 17226, 17227, 17250, 17249, 15783, 15829, 15830, 15827, 17516, 17562, 17563, 
17560, 70917, 70918, 70941, 70940
25835, 15494, 15495, 15518, 15517, 17227, 17228, 17251, 17250, 15785, 15831, 15832, 15829, 17518, 17564, 17565, 
17562, 70918, 70919, 70942, 70941
25836, 15495, 15496, 15519, 15518, 17228, 17229, 17252, 17251, 15787, 15833, 15834, 15831, 17520, 17566, 17567, 
17564, 70919, 70920, 70943, 70942
25837, 15496, 15497, 15520, 15519, 17229, 17230, 17253, 17252, 15789, 15835, 15836, 15833, 17522, 17568, 17569, 
17566, 70920, 70921, 70944, 70943
25838, 15497, 15498, 15521, 15520, 17230, 17231, 17254, 17253, 15791, 15837, 15838, 15835, 17524, 17570, 17571, 
17568, 70921, 70922, 70945, 70944
25839, 15498, 15499, 15522, 15521, 17231, 17232, 17255, 17254, 15793, 15839, 15840, 15837, 17526, 17572, 17573, 
17570, 70922, 70923, 70946, 70945
25840, 15499, 15500, 15523, 15522, 17232, 17233, 17256, 17255, 15795, 15841, 15842, 15839, 17528, 17574, 17575, 
17572, 70923, 70924, 70947, 70946
25841, 15500, 15501, 15524, 15523, 17233, 17234, 17257, 17256, 15797, 15843, 15844, 15841, 17530, 17576, 17577, 
17574, 70924, 70925, 70948, 70947
25842, 15501, 15502, 15525, 15524, 17234, 17235, 17258, 17257, 15799, 15845, 15846, 15843, 17532, 17578, 17579, 
17576, 70925, 70926, 70949, 70948
25843, 15502, 15503, 15526, 15525, 17235, 17236, 17259, 17258, 15801, 15847, 15848, 15845, 17534, 17580, 17581, 
17578, 70926, 70927, 70950, 70949
25844, 15503, 15504, 15527, 15526, 17236, 17237, 17260, 17259, 15803, 15849, 15850, 15847, 17536, 17582, 17583, 
17580, 70927, 70928, 70951, 70950
25845, 15504, 15505, 15528, 15527, 17237, 17238, 17261, 17260, 15805, 15851, 15852, 15849, 17538, 17584, 17585, 
17582, 70928, 70929, 70952, 70951
25846, 15505, 1464, 1465, 15528, 17238, 1631, 1632, 17261, 15806, 1476, 15853, 15851, 17539, 1643, 17586, 
17584, 70929, 17183, 17184, 70952
25847, 1221, 15506, 15529, 1222, 1609, 17239, 17262, 1610, 15808, 15854, 15855, 1233, 17541, 17587, 17588, 
1621, 17173, 70930, 70953, 17174
25848, 15506, 15507, 15530, 15529, 17239, 17240, 17263, 17262, 15810, 15856, 15857, 15854, 17543, 17589, 17590, 
17587, 70930, 70931, 70954, 70953
25849, 15507, 15508, 15531, 15530, 17240, 17241, 17264, 17263, 15812, 15858, 15859, 15856, 17545, 17591, 17592, 
17589, 70931, 70932, 70955, 70954
25850, 15508, 15509, 15532, 15531, 17241, 17242, 17265, 17264, 15814, 15860, 15861, 15858, 17547, 17593, 17594, 
17591, 70932, 70933, 70956, 70955
25851, 15509, 15510, 15533, 15532, 17242, 17243, 17266, 17265, 15816, 15862, 15863, 15860, 17549, 17595, 17596, 
17593, 70933, 70934, 70957, 70956
25852, 15510, 15511, 15534, 15533, 17243, 17244, 17267, 17266, 15818, 15864, 15865, 15862, 17551, 17597, 17598, 
17595, 70934, 70935, 70958, 70957
25853, 15511, 15512, 15535, 15534, 17244, 17245, 17268, 17267, 15820, 15866, 15867, 15864, 17553, 17599, 17600, 
17597, 70935, 70936, 70959, 70958
25854, 15512, 15513, 15536, 15535, 17245, 17246, 17269, 17268, 15822, 15868, 15869, 15866, 17555, 17601, 17602, 
17599, 70936, 70937, 70960, 70959
25855, 15513, 15514, 15537, 15536, 17246, 17247, 17270, 17269, 15824, 15870, 15871, 15868, 17557, 17603, 17604, 
17601, 70937, 70938, 70961, 70960
25856, 15514, 15515, 15538, 15537, 17247, 17248, 17271, 17270, 15826, 15872, 15873, 15870, 17559, 17605, 17606, 
17603, 70938, 70939, 70962, 70961
25857, 15515, 15516, 15539, 15538, 17248, 17249, 17272, 17271, 15828, 15874, 15875, 15872, 17561, 17607, 17608, 
17605, 70939, 70940, 70963, 70962
25858, 15516, 15517, 15540, 15539, 17249, 17250, 17273, 17272, 15830, 15876, 15877, 15874, 17563, 17609, 17610, 
17607, 70940, 70941, 70964, 70963
25859, 15517, 15518, 15541, 15540, 17250, 17251, 17274, 17273, 15832, 15878, 15879, 15876, 17565, 17611, 17612, 
17609, 70941, 70942, 70965, 70964
25860, 15518, 15519, 15542, 15541, 17251, 17252, 17275, 17274, 15834, 15880, 15881, 15878, 17567, 17613, 17614, 
17611, 70942, 70943, 70966, 70965
25861, 15519, 15520, 15543, 15542, 17252, 17253, 17276, 17275, 15836, 15882, 15883, 15880, 17569, 17615, 17616, 
17613, 70943, 70944, 70967, 70966
25862, 15520, 15521, 15544, 15543, 17253, 17254, 17277, 17276, 15838, 15884, 15885, 15882, 17571, 17617, 17618, 
17615, 70944, 70945, 70968, 70967
25863, 15521, 15522, 15545, 15544, 17254, 17255, 17278, 17277, 15840, 15886, 15887, 15884, 17573, 17619, 17620, 
17617, 70945, 70946, 70969, 70968
25864, 15522, 15523, 15546, 15545, 17255, 17256, 17279, 17278, 15842, 15888, 15889, 15886, 17575, 17621, 17622, 
17619, 70946, 70947, 70970, 70969
25865, 15523, 15524, 15547, 15546, 17256, 17257, 17280, 17279, 15844, 15890, 15891, 15888, 17577, 17623, 17624, 
17621, 70947, 70948, 70971, 70970
25866, 15524, 15525, 15548, 15547, 17257, 17258, 17281, 17280, 15846, 15892, 15893, 15890, 17579, 17625, 17626, 
17623, 70948, 70949, 70972, 70971
25867, 15525, 15526, 15549, 15548, 17258, 17259, 17282, 17281, 15848, 15894, 15895, 15892, 17581, 17627, 17628, 
17625, 70949, 70950, 70973, 70972
25868, 15526, 15527, 15550, 15549, 17259, 17260, 17283, 17282, 15850, 15896, 15897, 15894, 17583, 17629, 17630, 
17627, 70950, 70951, 70974, 70973
25869, 15527, 15528, 15551, 15550, 17260, 17261, 17284, 17283, 15852, 15898, 15899, 15896, 17585, 17631, 17632, 
17629, 70951, 70952, 70975, 70974
25870, 15528, 1465, 1466, 15551, 17261, 1632, 1633, 17284, 15853, 1477, 15900, 15898, 17586, 1644, 17633, 
17631, 70952, 17184, 17185, 70975
25871, 1222, 15529, 15552, 1223, 1610, 17262, 17285, 1611, 15855, 15901, 15902, 1234, 17588, 17634, 17635, 
1622, 17174, 70953, 70976, 17175
25872, 15529, 15530, 15553, 15552, 17262, 17263, 17286, 17285, 15857, 15903, 15904, 15901, 17590, 17636, 17637, 
17634, 70953, 70954, 70977, 70976
25873, 15530, 15531, 15554, 15553, 17263, 17264, 17287, 17286, 15859, 15905, 15906, 15903, 17592, 17638, 17639, 
17636, 70954, 70955, 70978, 70977
25874, 15531, 15532, 15555, 15554, 17264, 17265, 17288, 17287, 15861, 15907, 15908, 15905, 17594, 17640, 17641, 
17638, 70955, 70956, 70979, 70978
25875, 15532, 15533, 15556, 15555, 17265, 17266, 17289, 17288, 15863, 15909, 15910, 15907, 17596, 17642, 17643, 
17640, 70956, 70957, 70980, 70979
25876, 15533, 15534, 15557, 15556, 17266, 17267, 17290, 17289, 15865, 15911, 15912, 15909, 17598, 17644, 17645, 
17642, 70957, 70958, 70981, 70980
25877, 15534, 15535, 15558, 15557, 17267, 17268, 17291, 17290, 15867, 15913, 15914, 15911, 17600, 17646, 17647, 
17644, 70958, 70959, 70982, 70981
25878, 15535, 15536, 15559, 15558, 17268, 17269, 17292, 17291, 15869, 15915, 15916, 15913, 17602, 17648, 17649, 
17646, 70959, 70960, 70983, 70982
25879, 15536, 15537, 15560, 15559, 17269, 17270, 17293, 17292, 15871, 15917, 15918, 15915, 17604, 17650, 17651, 
17648, 70960, 70961, 70984, 70983
25880, 15537, 15538, 15561, 15560, 17270, 17271, 17294, 17293, 15873, 15919, 15920, 15917, 17606, 17652, 17653, 
17650, 70961, 70962, 70985, 70984
25881, 15538, 15539, 15562, 15561, 17271, 17272, 17295, 17294, 15875, 15921, 15922, 15919, 17608, 17654, 17655, 
17652, 70962, 70963, 70986, 70985
25882, 15539, 15540, 15563, 15562, 17272, 17273, 17296, 17295, 15877, 15923, 15924, 15921, 17610, 17656, 17657, 
17654, 70963, 70964, 70987, 70986
25883, 15540, 15541, 15564, 15563, 17273, 17274, 17297, 17296, 15879, 15925, 15926, 15923, 17612, 17658, 17659, 
17656, 70964, 70965, 70988, 70987
25884, 15541, 15542, 15565, 15564, 17274, 17275, 17298, 17297, 15881, 15927, 15928, 15925, 17614, 17660, 17661, 
17658, 70965, 70966, 70989, 70988
25885, 15542, 15543, 15566, 15565, 17275, 17276, 17299, 17298, 15883, 15929, 15930, 15927, 17616, 17662, 17663, 
17660, 70966, 70967, 70990, 70989
25886, 15543, 15544, 15567, 15566, 17276, 17277, 17300, 17299, 15885, 15931, 15932, 15929, 17618, 17664, 17665, 
17662, 70967, 70968, 70991, 70990
25887, 15544, 15545, 15568, 15567, 17277, 17278, 17301, 17300, 15887, 15933, 15934, 15931, 17620, 17666, 17667, 
17664, 70968, 70969, 70992, 70991
25888, 15545, 15546, 15569, 15568, 17278, 17279, 17302, 17301, 15889, 15935, 15936, 15933, 17622, 17668, 17669, 
17666, 70969, 70970, 70993, 70992
25889, 15546, 15547, 15570, 15569, 17279, 17280, 17303, 17302, 15891, 15937, 15938, 15935, 17624, 17670, 17671, 
17668, 70970, 70971, 70994, 70993
25890, 15547, 15548, 15571, 15570, 17280, 17281, 17304, 17303, 15893, 15939, 15940, 15937, 17626, 17672, 17673, 
17670, 70971, 70972, 70995, 70994
25891, 15548, 15549, 15572, 15571, 17281, 17282, 17305, 17304, 15895, 15941, 15942, 15939, 17628, 17674, 17675, 
17672, 70972, 70973, 70996, 70995
25892, 15549, 15550, 15573, 15572, 17282, 17283, 17306, 17305, 15897, 15943, 15944, 15941, 17630, 17676, 17677, 
17674, 70973, 70974, 70997, 70996
25893, 15550, 15551, 15574, 15573, 17283, 17284, 17307, 17306, 15899, 15945, 15946, 15943, 17632, 17678, 17679, 
17676, 70974, 70975, 70998, 70997
25894, 15551, 1466, 1467, 15574, 17284, 1633, 1634, 17307, 15900, 1478, 15947, 15945, 17633, 1645, 17680, 
17678, 70975, 17185, 17186, 70998
25895, 1223, 15552, 15575, 1224, 1611, 17285, 17308, 1612, 15902, 15948, 15949, 1235, 17635, 17681, 17682, 
1623, 17175, 70976, 70999, 17176
25896, 15552, 15553, 15576, 15575, 17285, 17286, 17309, 17308, 15904, 15950, 15951, 15948, 17637, 17683, 17684, 
17681, 70976, 70977, 71000, 70999
25897, 15553, 15554, 15577, 15576, 17286, 17287, 17310, 17309, 15906, 15952, 15953, 15950, 17639, 17685, 17686, 
17683, 70977, 70978, 71001, 71000
25898, 15554, 15555, 15578, 15577, 17287, 17288, 17311, 17310, 15908, 15954, 15955, 15952, 17641, 17687, 17688, 
17685, 70978, 70979, 71002, 71001
25899, 15555, 15556, 15579, 15578, 17288, 17289, 17312, 17311, 15910, 15956, 15957, 15954, 17643, 17689, 17690, 
17687, 70979, 70980, 71003, 71002
25900, 15556, 15557, 15580, 15579, 17289, 17290, 17313, 17312, 15912, 15958, 15959, 15956, 17645, 17691, 17692, 
17689, 70980, 70981, 71004, 71003
25901, 15557, 15558, 15581, 15580, 17290, 17291, 17314, 17313, 15914, 15960, 15961, 15958, 17647, 17693, 17694, 
17691, 70981, 70982, 71005, 71004
25902, 15558, 15559, 15582, 15581, 17291, 17292, 17315, 17314, 15916, 15962, 15963, 15960, 17649, 17695, 17696, 
17693, 70982, 70983, 71006, 71005
25903, 15559, 15560, 15583, 15582, 17292, 17293, 17316, 17315, 15918, 15964, 15965, 15962, 17651, 17697, 17698, 
17695, 70983, 70984, 71007, 71006
25904, 15560, 15561, 15584, 15583, 17293, 17294, 17317, 17316, 15920, 15966, 15967, 15964, 17653, 17699, 17700, 
17697, 70984, 70985, 71008, 71007
25905, 15561, 15562, 15585, 15584, 17294, 17295, 17318, 17317, 15922, 15968, 15969, 15966, 17655, 17701, 17702, 
17699, 70985, 70986, 71009, 71008
25906, 15562, 15563, 15586, 15585, 17295, 17296, 17319, 17318, 15924, 15970, 15971, 15968, 17657, 17703, 17704, 
17701, 70986, 70987, 71010, 71009
25907, 15563, 15564, 15587, 15586, 17296, 17297, 17320, 17319, 15926, 15972, 15973, 15970, 17659, 17705, 17706, 
17703, 70987, 70988, 71011, 71010
25908, 15564, 15565, 15588, 15587, 17297, 17298, 17321, 17320, 15928, 15974, 15975, 15972, 17661, 17707, 17708, 
17705, 70988, 70989, 71012, 71011
25909, 15565, 15566, 15589, 15588, 17298, 17299, 17322, 17321, 15930, 15976, 15977, 15974, 17663, 17709, 17710, 
17707, 70989, 70990, 71013, 71012
25910, 15566, 15567, 15590, 15589, 17299, 17300, 17323, 17322, 15932, 15978, 15979, 15976, 17665, 17711, 17712, 
17709, 70990, 70991, 71014, 71013
25911, 15567, 15568, 15591, 15590, 17300, 17301, 17324, 17323, 15934, 15980, 15981, 15978, 17667, 17713, 17714, 
17711, 70991, 70992, 71015, 71014
25912, 15568, 15569, 15592, 15591, 17301, 17302, 17325, 17324, 15936, 15982, 15983, 15980, 17669, 17715, 17716, 
17713, 70992, 70993, 71016, 71015
25913, 15569, 15570, 15593, 15592, 17302, 17303, 17326, 17325, 15938, 15984, 15985, 15982, 17671, 17717, 17718, 
17715, 70993, 70994, 71017, 71016
25914, 15570, 15571, 15594, 15593, 17303, 17304, 17327, 17326, 15940, 15986, 15987, 15984, 17673, 17719, 17720, 
17717, 70994, 70995, 71018, 71017
25915, 15571, 15572, 15595, 15594, 17304, 17305, 17328, 17327, 15942, 15988, 15989, 15986, 17675, 17721, 17722, 
17719, 70995, 70996, 71019, 71018
25916, 15572, 15573, 15596, 15595, 17305, 17306, 17329, 17328, 15944, 15990, 15991, 15988, 17677, 17723, 17724, 
17721, 70996, 70997, 71020, 71019
25917, 15573, 15574, 15597, 15596, 17306, 17307, 17330, 17329, 15946, 15992, 15993, 15990, 17679, 17725, 17726, 
17723, 70997, 70998, 71021, 71020
25918, 15574, 1467, 1468, 15597, 17307, 1634, 1635, 17330, 15947, 1479, 15994, 15992, 17680, 1646, 17727, 
17725, 70998, 17186, 17187, 71021
25919, 1224, 15575, 15598, 1225, 1612, 17308, 17331, 1613, 15949, 15995, 15996, 1236, 17682, 17728, 17729, 
1624, 17176, 70999, 71022, 17177
25920, 15575, 15576, 15599, 15598, 17308, 17309, 17332, 17331, 15951, 15997, 15998, 15995, 17684, 17730, 17731, 
17728, 70999, 71000, 71023, 71022
25921, 15576, 15577, 15600, 15599, 17309, 17310, 17333, 17332, 15953, 15999, 16000, 15997, 17686, 17732, 17733, 
17730, 71000, 71001, 71024, 71023
25922, 15577, 15578, 15601, 15600, 17310, 17311, 17334, 17333, 15955, 16001, 16002, 15999, 17688, 17734, 17735, 
17732, 71001, 71002, 71025, 71024
25923, 15578, 15579, 15602, 15601, 17311, 17312, 17335, 17334, 15957, 16003, 16004, 16001, 17690, 17736, 17737, 
17734, 71002, 71003, 71026, 71025
25924, 15579, 15580, 15603, 15602, 17312, 17313, 17336, 17335, 15959, 16005, 16006, 16003, 17692, 17738, 17739, 
17736, 71003, 71004, 71027, 71026
25925, 15580, 15581, 15604, 15603, 17313, 17314, 17337, 17336, 15961, 16007, 16008, 16005, 17694, 17740, 17741, 
17738, 71004, 71005, 71028, 71027
25926, 15581, 15582, 15605, 15604, 17314, 17315, 17338, 17337, 15963, 16009, 16010, 16007, 17696, 17742, 17743, 
17740, 71005, 71006, 71029, 71028
25927, 15582, 15583, 15606, 15605, 17315, 17316, 17339, 17338, 15965, 16011, 16012, 16009, 17698, 17744, 17745, 
17742, 71006, 71007, 71030, 71029
25928, 15583, 15584, 15607, 15606, 17316, 17317, 17340, 17339, 15967, 16013, 16014, 16011, 17700, 17746, 17747, 
17744, 71007, 71008, 71031, 71030
25929, 15584, 15585, 15608, 15607, 17317, 17318, 17341, 17340, 15969, 16015, 16016, 16013, 17702, 17748, 17749, 
17746, 71008, 71009, 71032, 71031
25930, 15585, 15586, 15609, 15608, 17318, 17319, 17342, 17341, 15971, 16017, 16018, 16015, 17704, 17750, 17751, 
17748, 71009, 71010, 71033, 71032
25931, 15586, 15587, 15610, 15609, 17319, 17320, 17343, 17342, 15973, 16019, 16020, 16017, 17706, 17752, 17753, 
17750, 71010, 71011, 71034, 71033
25932, 15587, 15588, 15611, 15610, 17320, 17321, 17344, 17343, 15975, 16021, 16022, 16019, 17708, 17754, 17755, 
17752, 71011, 71012, 71035, 71034
25933, 15588, 15589, 15612, 15611, 17321, 17322, 17345, 17344, 15977, 16023, 16024, 16021, 17710, 17756, 17757, 
17754, 71012, 71013, 71036, 71035
25934, 15589, 15590, 15613, 15612, 17322, 17323, 17346, 17345, 15979, 16025, 16026, 16023, 17712, 17758, 17759, 
17756, 71013, 71014, 71037, 71036
25935, 15590, 15591, 15614, 15613, 17323, 17324, 17347, 17346, 15981, 16027, 16028, 16025, 17714, 17760, 17761, 
17758, 71014, 71015, 71038, 71037
25936, 15591, 15592, 15615, 15614, 17324, 17325, 17348, 17347, 15983, 16029, 16030, 16027, 17716, 17762, 17763, 
17760, 71015, 71016, 71039, 71038
25937, 15592, 15593, 15616, 15615, 17325, 17326, 17349, 17348, 15985, 16031, 16032, 16029, 17718, 17764, 17765, 
17762, 71016, 71017, 71040, 71039
25938, 15593, 15594, 15617, 15616, 17326, 17327, 17350, 17349, 15987, 16033, 16034, 16031, 17720, 17766, 17767, 
17764, 71017, 71018, 71041, 71040
25939, 15594, 15595, 15618, 15617, 17327, 17328, 17351, 17350, 15989, 16035, 16036, 16033, 17722, 17768, 17769, 
17766, 71018, 71019, 71042, 71041
25940, 15595, 15596, 15619, 15618, 17328, 17329, 17352, 17351, 15991, 16037, 16038, 16035, 17724, 17770, 17771, 
17768, 71019, 71020, 71043, 71042
25941, 15596, 15597, 15620, 15619, 17329, 17330, 17353, 17352, 15993, 16039, 16040, 16037, 17726, 17772, 17773, 
17770, 71020, 71021, 71044, 71043
25942, 15597, 1468, 1469, 15620, 17330, 1635, 1636, 17353, 15994, 1480, 16041, 16039, 17727, 1647, 17774, 
17772, 71021, 17187, 17188, 71044
25943, 1225, 15598, 15621, 1226, 1613, 17331, 17354, 1614, 15996, 16042, 16043, 1237, 17729, 17775, 17776, 
1625, 17177, 71022, 71045, 17178
25944, 15598, 15599, 15622, 15621, 17331, 17332, 17355, 17354, 15998, 16044, 16045, 16042, 17731, 17777, 17778, 
17775, 71022, 71023, 71046, 71045
25945, 15599, 15600, 15623, 15622, 17332, 17333, 17356, 17355, 16000, 16046, 16047, 16044, 17733, 17779, 17780, 
17777, 71023, 71024, 71047, 71046
25946, 15600, 15601, 15624, 15623, 17333, 17334, 17357, 17356, 16002, 16048, 16049, 16046, 17735, 17781, 17782, 
17779, 71024, 71025, 71048, 71047
25947, 15601, 15602, 15625, 15624, 17334, 17335, 17358, 17357, 16004, 16050, 16051, 16048, 17737, 17783, 17784, 
17781, 71025, 71026, 71049, 71048
25948, 15602, 15603, 15626, 15625, 17335, 17336, 17359, 17358, 16006, 16052, 16053, 16050, 17739, 17785, 17786, 
17783, 71026, 71027, 71050, 71049
25949, 15603, 15604, 15627, 15626, 17336, 17337, 17360, 17359, 16008, 16054, 16055, 16052, 17741, 17787, 17788, 
17785, 71027, 71028, 71051, 71050
25950, 15604, 15605, 15628, 15627, 17337, 17338, 17361, 17360, 16010, 16056, 16057, 16054, 17743, 17789, 17790, 
17787, 71028, 71029, 71052, 71051
25951, 15605, 15606, 15629, 15628, 17338, 17339, 17362, 17361, 16012, 16058, 16059, 16056, 17745, 17791, 17792, 
17789, 71029, 71030, 71053, 71052
25952, 15606, 15607, 15630, 15629, 17339, 17340, 17363, 17362, 16014, 16060, 16061, 16058, 17747, 17793, 17794, 
17791, 71030, 71031, 71054, 71053
25953, 15607, 15608, 15631, 15630, 17340, 17341, 17364, 17363, 16016, 16062, 16063, 16060, 17749, 17795, 17796, 
17793, 71031, 71032, 71055, 71054
25954, 15608, 15609, 15632, 15631, 17341, 17342, 17365, 17364, 16018, 16064, 16065, 16062, 17751, 17797, 17798, 
17795, 71032, 71033, 71056, 71055
25955, 15609, 15610, 15633, 15632, 17342, 17343, 17366, 17365, 16020, 16066, 16067, 16064, 17753, 17799, 17800, 
17797, 71033, 71034, 71057, 71056
25956, 15610, 15611, 15634, 15633, 17343, 17344, 17367, 17366, 16022, 16068, 16069, 16066, 17755, 17801, 17802, 
17799, 71034, 71035, 71058, 71057
25957, 15611, 15612, 15635, 15634, 17344, 17345, 17368, 17367, 16024, 16070, 16071, 16068, 17757, 17803, 17804, 
17801, 71035, 71036, 71059, 71058
25958, 15612, 15613, 15636, 15635, 17345, 17346, 17369, 17368, 16026, 16072, 16073, 16070, 17759, 17805, 17806, 
17803, 71036, 71037, 71060, 71059
25959, 15613, 15614, 15637, 15636, 17346, 17347, 17370, 17369, 16028, 16074, 16075, 16072, 17761, 17807, 17808, 
17805, 71037, 71038, 71061, 71060
25960, 15614, 15615, 15638, 15637, 17347, 17348, 17371, 17370, 16030, 16076, 16077, 16074, 17763, 17809, 17810, 
17807, 71038, 71039, 71062, 71061
25961, 15615, 15616, 15639, 15638, 17348, 17349, 17372, 17371, 16032, 16078, 16079, 16076, 17765, 17811, 17812, 
17809, 71039, 71040, 71063, 71062
25962, 15616, 15617, 15640, 15639, 17349, 17350, 17373, 17372, 16034, 16080, 16081, 16078, 17767, 17813, 17814, 
17811, 71040, 71041, 71064, 71063
25963, 15617, 15618, 15641, 15640, 17350, 17351, 17374, 17373, 16036, 16082, 16083, 16080, 17769, 17815, 17816, 
17813, 71041, 71042, 71065, 71064
25964, 15618, 15619, 15642, 15641, 17351, 17352, 17375, 17374, 16038, 16084, 16085, 16082, 17771, 17817, 17818, 
17815, 71042, 71043, 71066, 71065
25965, 15619, 15620, 15643, 15642, 17352, 17353, 17376, 17375, 16040, 16086, 16087, 16084, 17773, 17819, 17820, 
17817, 71043, 71044, 71067, 71066
25966, 15620, 1469, 1470, 15643, 17353, 1636, 1637, 17376, 16041, 1481, 16088, 16086, 17774, 1648, 17821, 
17819, 71044, 17188, 17189, 71067
25967, 1226, 15621, 15644, 1227, 1614, 17354, 17377, 1615, 16043, 16089, 16090, 1238, 17776, 17822, 17823, 
1626, 17178, 71045, 71068, 17179
25968, 15621, 15622, 15645, 15644, 17354, 17355, 17378, 17377, 16045, 16091, 16092, 16089, 17778, 17824, 17825, 
17822, 71045, 71046, 71069, 71068
25969, 15622, 15623, 15646, 15645, 17355, 17356, 17379, 17378, 16047, 16093, 16094, 16091, 17780, 17826, 17827, 
17824, 71046, 71047, 71070, 71069
25970, 15623, 15624, 15647, 15646, 17356, 17357, 17380, 17379, 16049, 16095, 16096, 16093, 17782, 17828, 17829, 
17826, 71047, 71048, 71071, 71070
25971, 15624, 15625, 15648, 15647, 17357, 17358, 17381, 17380, 16051, 16097, 16098, 16095, 17784, 17830, 17831, 
17828, 71048, 71049, 71072, 71071
25972, 15625, 15626, 15649, 15648, 17358, 17359, 17382, 17381, 16053, 16099, 16100, 16097, 17786, 17832, 17833, 
17830, 71049, 71050, 71073, 71072
25973, 15626, 15627, 15650, 15649, 17359, 17360, 17383, 17382, 16055, 16101, 16102, 16099, 17788, 17834, 17835, 
17832, 71050, 71051, 71074, 71073
25974, 15627, 15628, 15651, 15650, 17360, 17361, 17384, 17383, 16057, 16103, 16104, 16101, 17790, 17836, 17837, 
17834, 71051, 71052, 71075, 71074
25975, 15628, 15629, 15652, 15651, 17361, 17362, 17385, 17384, 16059, 16105, 16106, 16103, 17792, 17838, 17839, 
17836, 71052, 71053, 71076, 71075
25976, 15629, 15630, 15653, 15652, 17362, 17363, 17386, 17385, 16061, 16107, 16108, 16105, 17794, 17840, 17841, 
17838, 71053, 71054, 71077, 71076
25977, 15630, 15631, 15654, 15653, 17363, 17364, 17387, 17386, 16063, 16109, 16110, 16107, 17796, 17842, 17843, 
17840, 71054, 71055, 71078, 71077
25978, 15631, 15632, 15655, 15654, 17364, 17365, 17388, 17387, 16065, 16111, 16112, 16109, 17798, 17844, 17845, 
17842, 71055, 71056, 71079, 71078
25979, 15632, 15633, 15656, 15655, 17365, 17366, 17389, 17388, 16067, 16113, 16114, 16111, 17800, 17846, 17847, 
17844, 71056, 71057, 71080, 71079
25980, 15633, 15634, 15657, 15656, 17366, 17367, 17390, 17389, 16069, 16115, 16116, 16113, 17802, 17848, 17849, 
17846, 71057, 71058, 71081, 71080
25981, 15634, 15635, 15658, 15657, 17367, 17368, 17391, 17390, 16071, 16117, 16118, 16115, 17804, 17850, 17851, 
17848, 71058, 71059, 71082, 71081
25982, 15635, 15636, 15659, 15658, 17368, 17369, 17392, 17391, 16073, 16119, 16120, 16117, 17806, 17852, 17853, 
17850, 71059, 71060, 71083, 71082
25983, 15636, 15637, 15660, 15659, 17369, 17370, 17393, 17392, 16075, 16121, 16122, 16119, 17808, 17854, 17855, 
17852, 71060, 71061, 71084, 71083
25984, 15637, 15638, 15661, 15660, 17370, 17371, 17394, 17393, 16077, 16123, 16124, 16121, 17810, 17856, 17857, 
17854, 71061, 71062, 71085, 71084
25985, 15638, 15639, 15662, 15661, 17371, 17372, 17395, 17394, 16079, 16125, 16126, 16123, 17812, 17858, 17859, 
17856, 71062, 71063, 71086, 71085
25986, 15639, 15640, 15663, 15662, 17372, 17373, 17396, 17395, 16081, 16127, 16128, 16125, 17814, 17860, 17861, 
17858, 71063, 71064, 71087, 71086
25987, 15640, 15641, 15664, 15663, 17373, 17374, 17397, 17396, 16083, 16129, 16130, 16127, 17816, 17862, 17863, 
17860, 71064, 71065, 71088, 71087
25988, 15641, 15642, 15665, 15664, 17374, 17375, 17398, 17397, 16085, 16131, 16132, 16129, 17818, 17864, 17865, 
17862, 71065, 71066, 71089, 71088
25989, 15642, 15643, 15666, 15665, 17375, 17376, 17399, 17398, 16087, 16133, 16134, 16131, 17820, 17866, 17867, 
17864, 71066, 71067, 71090, 71089
25990, 15643, 1470, 1471, 15666, 17376, 1637, 1638, 17399, 16088, 1482, 16135, 16133, 17821, 1649, 17868, 
17866, 71067, 17189, 17190, 71090
25991, 1227, 15644, 15667, 1228, 1615, 17377, 17400, 1616, 16090, 16136, 16137, 1239, 17823, 17869, 17870, 
1627, 17179, 71068, 71091, 17180
25992, 15644, 15645, 15668, 15667, 17377, 17378, 17401, 17400, 16092, 16138, 16139, 16136, 17825, 17871, 17872, 
17869, 71068, 71069, 71092, 71091
25993, 15645, 15646, 15669, 15668, 17378, 17379, 17402, 17401, 16094, 16140, 16141, 16138, 17827, 17873, 17874, 
17871, 71069, 71070, 71093, 71092
25994, 15646, 15647, 15670, 15669, 17379, 17380, 17403, 17402, 16096, 16142, 16143, 16140, 17829, 17875, 17876, 
17873, 71070, 71071, 71094, 71093
25995, 15647, 15648, 15671, 15670, 17380, 17381, 17404, 17403, 16098, 16144, 16145, 16142, 17831, 17877, 17878, 
17875, 71071, 71072, 71095, 71094
25996, 15648, 15649, 15672, 15671, 17381, 17382, 17405, 17404, 16100, 16146, 16147, 16144, 17833, 17879, 17880, 
17877, 71072, 71073, 71096, 71095
25997, 15649, 15650, 15673, 15672, 17382, 17383, 17406, 17405, 16102, 16148, 16149, 16146, 17835, 17881, 17882, 
17879, 71073, 71074, 71097, 71096
25998, 15650, 15651, 15674, 15673, 17383, 17384, 17407, 17406, 16104, 16150, 16151, 16148, 17837, 17883, 17884, 
17881, 71074, 71075, 71098, 71097
25999, 15651, 15652, 15675, 15674, 17384, 17385, 17408, 17407, 16106, 16152, 16153, 16150, 17839, 17885, 17886, 
17883, 71075, 71076, 71099, 71098
26000, 15652, 15653, 15676, 15675, 17385, 17386, 17409, 17408, 16108, 16154, 16155, 16152, 17841, 17887, 17888, 
17885, 71076, 71077, 71100, 71099
26001, 15653, 15654, 15677, 15676, 17386, 17387, 17410, 17409, 16110, 16156, 16157, 16154, 17843, 17889, 17890, 
17887, 71077, 71078, 71101, 71100
26002, 15654, 15655, 15678, 15677, 17387, 17388, 17411, 17410, 16112, 16158, 16159, 16156, 17845, 17891, 17892, 
17889, 71078, 71079, 71102, 71101
26003, 15655, 15656, 15679, 15678, 17388, 17389, 17412, 17411, 16114, 16160, 16161, 16158, 17847, 17893, 17894, 
17891, 71079, 71080, 71103, 71102
26004, 15656, 15657, 15680, 15679, 17389, 17390, 17413, 17412, 16116, 16162, 16163, 16160, 17849, 17895, 17896, 
17893, 71080, 71081, 71104, 71103
26005, 15657, 15658, 15681, 15680, 17390, 17391, 17414, 17413, 16118, 16164, 16165, 16162, 17851, 17897, 17898, 
17895, 71081, 71082, 71105, 71104
26006, 15658, 15659, 15682, 15681, 17391, 17392, 17415, 17414, 16120, 16166, 16167, 16164, 17853, 17899, 17900, 
17897, 71082, 71083, 71106, 71105
26007, 15659, 15660, 15683, 15682, 17392, 17393, 17416, 17415, 16122, 16168, 16169, 16166, 17855, 17901, 17902, 
17899, 71083, 71084, 71107, 71106
26008, 15660, 15661, 15684, 15683, 17393, 17394, 17417, 17416, 16124, 16170, 16171, 16168, 17857, 17903, 17904, 
17901, 71084, 71085, 71108, 71107
26009, 15661, 15662, 15685, 15684, 17394, 17395, 17418, 17417, 16126, 16172, 16173, 16170, 17859, 17905, 17906, 
17903, 71085, 71086, 71109, 71108
26010, 15662, 15663, 15686, 15685, 17395, 17396, 17419, 17418, 16128, 16174, 16175, 16172, 17861, 17907, 17908, 
17905, 71086, 71087, 71110, 71109
26011, 15663, 15664, 15687, 15686, 17396, 17397, 17420, 17419, 16130, 16176, 16177, 16174, 17863, 17909, 17910, 
17907, 71087, 71088, 71111, 71110
26012, 15664, 15665, 15688, 15687, 17397, 17398, 17421, 17420, 16132, 16178, 16179, 16176, 17865, 17911, 17912, 
17909, 71088, 71089, 71112, 71111
26013, 15665, 15666, 15689, 15688, 17398, 17399, 17422, 17421, 16134, 16180, 16181, 16178, 17867, 17913, 17914, 
17911, 71089, 71090, 71113, 71112
26014, 15666, 1471, 1472, 15689, 17399, 1638, 1639, 17422, 16135, 1483, 16182, 16180, 17868, 1650, 17915, 
17913, 71090, 17190, 17191, 71113
26015, 1228, 15667, 15690, 1229, 1616, 17400, 17423, 1617, 16137, 16183, 16184, 1240, 17870, 17916, 17917, 
1628, 17180, 71091, 71114, 17181
26016, 15667, 15668, 15691, 15690, 17400, 17401, 17424, 17423, 16139, 16185, 16186, 16183, 17872, 17918, 17919, 
17916, 71091, 71092, 71115, 71114
26017, 15668, 15669, 15692, 15691, 17401, 17402, 17425, 17424, 16141, 16187, 16188, 16185, 17874, 17920, 17921, 
17918, 71092, 71093, 71116, 71115
26018, 15669, 15670, 15693, 15692, 17402, 17403, 17426, 17425, 16143, 16189, 16190, 16187, 17876, 17922, 17923, 
17920, 71093, 71094, 71117, 71116
26019, 15670, 15671, 15694, 15693, 17403, 17404, 17427, 17426, 16145, 16191, 16192, 16189, 17878, 17924, 17925, 
17922, 71094, 71095, 71118, 71117
26020, 15671, 15672, 15695, 15694, 17404, 17405, 17428, 17427, 16147, 16193, 16194, 16191, 17880, 17926, 17927, 
17924, 71095, 71096, 71119, 71118
26021, 15672, 15673, 15696, 15695, 17405, 17406, 17429, 17428, 16149, 16195, 16196, 16193, 17882, 17928, 17929, 
17926, 71096, 71097, 71120, 71119
26022, 15673, 15674, 15697, 15696, 17406, 17407, 17430, 17429, 16151, 16197, 16198, 16195, 17884, 17930, 17931, 
17928, 71097, 71098, 71121, 71120
26023, 15674, 15675, 15698, 15697, 17407, 17408, 17431, 17430, 16153, 16199, 16200, 16197, 17886, 17932, 17933, 
17930, 71098, 71099, 71122, 71121
26024, 15675, 15676, 15699, 15698, 17408, 17409, 17432, 17431, 16155, 16201, 16202, 16199, 17888, 17934, 17935, 
17932, 71099, 71100, 71123, 71122
26025, 15676, 15677, 15700, 15699, 17409, 17410, 17433, 17432, 16157, 16203, 16204, 16201, 17890, 17936, 17937, 
17934, 71100, 71101, 71124, 71123
26026, 15677, 15678, 15701, 15700, 17410, 17411, 17434, 17433, 16159, 16205, 16206, 16203, 17892, 17938, 17939, 
17936, 71101, 71102, 71125, 71124
26027, 15678, 15679, 15702, 15701, 17411, 17412, 17435, 17434, 16161, 16207, 16208, 16205, 17894, 17940, 17941, 
17938, 71102, 71103, 71126, 71125
26028, 15679, 15680, 15703, 15702, 17412, 17413, 17436, 17435, 16163, 16209, 16210, 16207, 17896, 17942, 17943, 
17940, 71103, 71104, 71127, 71126
26029, 15680, 15681, 15704, 15703, 17413, 17414, 17437, 17436, 16165, 16211, 16212, 16209, 17898, 17944, 17945, 
17942, 71104, 71105, 71128, 71127
26030, 15681, 15682, 15705, 15704, 17414, 17415, 17438, 17437, 16167, 16213, 16214, 16211, 17900, 17946, 17947, 
17944, 71105, 71106, 71129, 71128
26031, 15682, 15683, 15706, 15705, 17415, 17416, 17439, 17438, 16169, 16215, 16216, 16213, 17902, 17948, 17949, 
17946, 71106, 71107, 71130, 71129
26032, 15683, 15684, 15707, 15706, 17416, 17417, 17440, 17439, 16171, 16217, 16218, 16215, 17904, 17950, 17951, 
17948, 71107, 71108, 71131, 71130
26033, 15684, 15685, 15708, 15707, 17417, 17418, 17441, 17440, 16173, 16219, 16220, 16217, 17906, 17952, 17953, 
17950, 71108, 71109, 71132, 71131
26034, 15685, 15686, 15709, 15708, 17418, 17419, 17442, 17441, 16175, 16221, 16222, 16219, 17908, 17954, 17955, 
17952, 71109, 71110, 71133, 71132
26035, 15686, 15687, 15710, 15709, 17419, 17420, 17443, 17442, 16177, 16223, 16224, 16221, 17910, 17956, 17957, 
17954, 71110, 71111, 71134, 71133
26036, 15687, 15688, 15711, 15710, 17420, 17421, 17444, 17443, 16179, 16225, 16226, 16223, 17912, 17958, 17959, 
17956, 71111, 71112, 71135, 71134
26037, 15688, 15689, 15712, 15711, 17421, 17422, 17445, 17444, 16181, 16227, 16228, 16225, 17914, 17960, 17961, 
17958, 71112, 71113, 71136, 71135
26038, 15689, 1472, 1473, 15712, 17422, 1639, 1640, 17445, 16182, 1484, 16229, 16227, 17915, 1651, 17962, 
17960, 71113, 17191, 17192, 71136
26039, 1229, 15690, 1265, 25, 1617, 17423, 1511, 33, 16184, 16230, 1288, 1241, 17917, 17963, 1534, 
1629, 17181, 71114, 17125, 1509
26040, 15690, 15691, 1266, 1265, 17423, 17424, 1512, 1511, 16186, 16231, 1289, 16230, 17919, 17964, 1535, 
17963, 71114, 71115, 17126, 17125
26041, 15691, 15692, 1267, 1266, 17424, 17425, 1513, 1512, 16188, 16232, 1290, 16231, 17921, 17965, 1536, 
17964, 71115, 71116, 17127, 17126
26042, 15692, 15693, 1268, 1267, 17425, 17426, 1514, 1513, 16190, 16233, 1291, 16232, 17923, 17966, 1537, 
17965, 71116, 71117, 17128, 17127
26043, 15693, 15694, 1269, 1268, 17426, 17427, 1515, 1514, 16192, 16234, 1292, 16233, 17925, 17967, 1538, 
17966, 71117, 71118, 17129, 17128
26044, 15694, 15695, 1270, 1269, 17427, 17428, 1516, 1515, 16194, 16235, 1293, 16234, 17927, 17968, 1539, 
17967, 71118, 71119, 17130, 17129
26045, 15695, 15696, 1271, 1270, 17428, 17429, 1517, 1516, 16196, 16236, 1294, 16235, 17929, 17969, 1540, 
17968, 71119, 71120, 17131, 17130
26046, 15696, 15697, 1272, 1271, 17429, 17430, 1518, 1517, 16198, 16237, 1295, 16236, 17931, 17970, 1541, 
17969, 71120, 71121, 17132, 17131
26047, 15697, 15698, 1273, 1272, 17430, 17431, 1519, 1518, 16200, 16238, 1296, 16237, 17933, 17971, 1542, 
17970, 71121, 71122, 17133, 17132
26048, 15698, 15699, 1274, 1273, 17431, 17432, 1520, 1519, 16202, 16239, 1297, 16238, 17935, 17972, 1543, 
17971, 71122, 71123, 17134, 17133
26049, 15699, 15700, 1275, 1274, 17432, 17433, 1521, 1520, 16204, 16240, 1298, 16239, 17937, 17973, 1544, 
17972, 71123, 71124, 17135, 17134
26050, 15700, 15701, 1276, 1275, 17433, 17434, 1522, 1521, 16206, 16241, 1299, 16240, 17939, 17974, 1545, 
17973, 71124, 71125, 17136, 17135
26051, 15701, 15702, 1277, 1276, 17434, 17435, 1523, 1522, 16208, 16242, 1300, 16241, 17941, 17975, 1546, 
17974, 71125, 71126, 17137, 17136
26052, 15702, 15703, 1278, 1277, 17435, 17436, 1524, 1523, 16210, 16243, 1301, 16242, 17943, 17976, 1547, 
17975, 71126, 71127, 17138, 17137
26053, 15703, 15704, 1279, 1278, 17436, 17437, 1525, 1524, 16212, 16244, 1302, 16243, 17945, 17977, 1548, 
17976, 71127, 71128, 17139, 17138
26054, 15704, 15705, 1280, 1279, 17437, 17438, 1526, 1525, 16214, 16245, 1303, 16244, 17947, 17978, 1549, 
17977, 71128, 71129, 17140, 17139
26055, 15705, 15706, 1281, 1280, 17438, 17439, 1527, 1526, 16216, 16246, 1304, 16245, 17949, 17979, 1550, 
17978, 71129, 71130, 17141, 17140
26056, 15706, 15707, 1282, 1281, 17439, 17440, 1528, 1527, 16218, 16247, 1305, 16246, 17951, 17980, 1551, 
17979, 71130, 71131, 17142, 17141
26057, 15707, 15708, 1283, 1282, 17440, 17441, 1529, 1528, 16220, 16248, 1306, 16247, 17953, 17981, 1552, 
17980, 71131, 71132, 17143, 17142
26058, 15708, 15709, 1284, 1283, 17441, 17442, 1530, 1529, 16222, 16249, 1307, 16248, 17955, 17982, 1553, 
17981, 71132, 71133, 17144, 17143
26059, 15709, 15710, 1285, 1284, 17442, 17443, 1531, 1530, 16224, 16250, 1308, 16249, 17957, 17983, 1554, 
17982, 71133, 71134, 17145, 17144
26060, 15710, 15711, 1286, 1285, 17443, 17444, 1532, 1531, 16226, 16251, 1309, 16250, 17959, 17984, 1555, 
17983, 71134, 71135, 17146, 17145
26061, 15711, 15712, 1287, 1286, 17444, 17445, 1533, 1532, 16228, 16252, 1310, 16251, 17961, 17985, 1556, 
17984, 71135, 71136, 17147, 17146
26062, 15712, 1473, 29, 1287, 17445, 1640, 34, 1533, 16229, 1485, 1311, 16252, 17962, 1652, 1557, 
17985, 71136, 17192, 1510, 17147
*ELEMENT, type=C3D20, ELSET=Volume9
26063, 35, 1560, 17193, 1607, 1794, 19619, 71137, 21252, 1583, 17446, 17447, 1618, 20149, 76957, 76958, 
21505, 1817, 20148, 76956, 21506
26064, 1794, 19619, 71137, 21252, 1795, 19620, 71138, 21253, 20149, 76957, 76958, 21505, 20151, 76960, 76961, 
21507, 1818, 20150, 76959, 21508
26065, 1795, 19620, 71138, 21253, 1796, 19621, 71139, 21254, 20151, 76960, 76961, 21507, 20153, 76963, 76964, 
21509, 1819, 20152, 76962, 21510
26066, 1796, 19621, 71139, 21254, 1797, 19622, 71140, 21255, 20153, 76963, 76964, 21509, 20155, 76966, 76967, 
21511, 1820, 20154, 76965, 21512
26067, 1797, 19622, 71140, 21255, 1798, 19623, 71141, 21256, 20155, 76966, 76967, 21511, 20157, 76969, 76970, 
21513, 1821, 20156, 76968, 21514
26068, 1798, 19623, 71141, 21256, 1799, 19624, 71142, 21257, 20157, 76969, 76970, 21513, 20159, 76972, 76973, 
21515, 1822, 20158, 76971, 21516
26069, 1799, 19624, 71142, 21257, 1800, 19625, 71143, 21258, 20159, 76972, 76973, 21515, 20161, 76975, 76976, 
21517, 1823, 20160, 76974, 21518
26070, 1800, 19625, 71143, 21258, 1801, 19626, 71144, 21259, 20161, 76975, 76976, 21517, 20163, 76978, 76979, 
21519, 1824, 20162, 76977, 21520
26071, 1801, 19626, 71144, 21259, 1802, 19627, 71145, 21260, 20163, 76978, 76979, 21519, 20165, 76981, 76982, 
21521, 1825, 20164, 76980, 21522
26072, 1802, 19627, 71145, 21260, 1803, 19628, 71146, 21261, 20165, 76981, 76982, 21521, 20167, 76984, 76985, 
21523, 1826, 20166, 76983, 21524
26073, 1803, 19628, 71146, 21261, 1804, 19629, 71147, 21262, 20167, 76984, 76985, 21523, 20169, 76987, 76988, 
21525, 1827, 20168, 76986, 21526
26074, 1804, 19629, 71147, 21262, 1805, 19630, 71148, 21263, 20169, 76987, 76988, 21525, 20171, 76990, 76991, 
21527, 1828, 20170, 76989, 21528
26075, 1805, 19630, 71148, 21263, 1806, 19631, 71149, 21264, 20171, 76990, 76991, 21527, 20173, 76993, 76994, 
21529, 1829, 20172, 76992, 21530
26076, 1806, 19631, 71149, 21264, 1807, 19632, 71150, 21265, 20173, 76993, 76994, 21529, 20175, 76996, 76997, 
21531, 1830, 20174, 76995, 21532
26077, 1807, 19632, 71150, 21265, 1808, 19633, 71151, 21266, 20175, 76996, 76997, 21531, 20177, 76999, 77000, 
21533, 1831, 20176, 76998, 21534
26078, 1808, 19633, 71151, 21266, 1809, 19634, 71152, 21267, 20177, 76999, 77000, 21533, 20179, 77002, 77003, 
21535, 1832, 20178, 77001, 21536
26079, 1809, 19634, 71152, 21267, 1810, 19635, 71153, 21268, 20179, 77002, 77003, 21535, 20181, 77005, 77006, 
21537, 1833, 20180, 77004, 21538
26080, 1810, 19635, 71153, 21268, 1811, 19636, 71154, 21269, 20181, 77005, 77006, 21537, 20183, 77008, 77009, 
21539, 1834, 20182, 77007, 21540
26081, 1811, 19636, 71154, 21269, 1812, 19637, 71155, 21270, 20183, 77008, 77009, 21539, 20185, 77011, 77012, 
21541, 1835, 20184, 77010, 21542
26082, 1812, 19637, 71155, 21270, 1813, 19638, 71156, 21271, 20185, 77011, 77012, 21541, 20187, 77014, 77015, 
21543, 1836, 20186, 77013, 21544
26083, 1813, 19638, 71156, 21271, 1814, 19639, 71157, 21272, 20187, 77014, 77015, 21543, 20189, 77017, 77018, 
21545, 1837, 20188, 77016, 21546
26084, 1814, 19639, 71157, 21272, 1815, 19640, 71158, 21273, 20189, 77017, 77018, 21545, 20191, 77020, 77021, 
21547, 1838, 20190, 77019, 21548
26085, 1815, 19640, 71158, 21273, 1816, 19641, 71159, 21274, 20191, 77020, 77021, 21547, 20193, 77023, 77024, 
21549, 1839, 20192, 77022, 21550
26086, 1816, 19641, 71159, 21274, 39, 1888, 22838, 1935, 20193, 77023, 77024, 21549, 1911, 23091, 23092, 
1946, 1840, 20194, 77025, 21551
26087, 1560, 1561, 17194, 17193, 19619, 19642, 71160, 71137, 1584, 17448, 17449, 17446, 20196, 77027, 77028, 
76957, 20148, 20195, 77026, 76956
26088, 19619, 19642, 71160, 71137, 19620, 19643, 71161, 71138, 20196, 77027, 77028, 76957, 20198, 77030, 77031, 
76960, 20150, 20197, 77029, 76959
26089, 19620, 19643, 71161, 71138, 19621, 19644, 71162, 71139, 20198, 77030, 77031, 76960, 20200, 77033, 77034, 
76963, 20152, 20199, 77032, 76962
26090, 19621, 19644, 71162, 71139, 19622, 19645, 71163, 71140, 20200, 77033, 77034, 76963, 20202, 77036, 77037, 
76966, 20154, 20201, 77035, 76965
26091, 19622, 19645, 71163, 71140, 19623, 19646, 71164, 71141, 20202, 77036, 77037, 76966, 20204, 77039, 77040, 
76969, 20156, 20203, 77038, 76968
26092, 19623, 19646, 71164, 71141, 19624, 19647, 71165, 71142, 20204, 77039, 77040, 76969, 20206, 77042, 77043, 
76972, 20158, 20205, 77041, 76971
26093, 19624, 19647, 71165, 71142, 19625, 19648, 71166, 71143, 20206, 77042, 77043, 76972, 20208, 77045, 77046, 
76975, 20160, 20207, 77044, 76974
26094, 19625, 19648, 71166, 71143, 19626, 19649, 71167, 71144, 20208, 77045, 77046, 76975, 20210, 77048, 77049, 
76978, 20162, 20209, 77047, 76977
26095, 19626, 19649, 71167, 71144, 19627, 19650, 71168, 71145, 20210, 77048, 77049, 76978, 20212, 77051, 77052, 
76981, 20164, 20211, 77050, 76980
26096, 19627, 19650, 71168, 71145, 19628, 19651, 71169, 71146, 20212, 77051, 77052, 76981, 20214, 77054, 77055, 
76984, 20166, 20213, 77053, 76983
26097, 19628, 19651, 71169, 71146, 19629, 19652, 71170, 71147, 20214, 77054, 77055, 76984, 20216, 77057, 77058, 
76987, 20168, 20215, 77056, 76986
26098, 19629, 19652, 71170, 71147, 19630, 19653, 71171, 71148, 20216, 77057, 77058, 76987, 20218, 77060, 77061, 
76990, 20170, 20217, 77059, 76989
26099, 19630, 19653, 71171, 71148, 19631, 19654, 71172, 71149, 20218, 77060, 77061, 76990, 20220, 77063, 77064, 
76993, 20172, 20219, 77062, 76992
26100, 19631, 19654, 71172, 71149, 19632, 19655, 71173, 71150, 20220, 77063, 77064, 76993, 20222, 77066, 77067, 
76996, 20174, 20221, 77065, 76995
26101, 19632, 19655, 71173, 71150, 19633, 19656, 71174, 71151, 20222, 77066, 77067, 76996, 20224, 77069, 77070, 
76999, 20176, 20223, 77068, 76998
26102, 19633, 19656, 71174, 71151, 19634, 19657, 71175, 71152, 20224, 77069, 77070, 76999, 20226, 77072, 77073, 
77002, 20178, 20225, 77071, 77001
26103, 19634, 19657, 71175, 71152, 19635, 19658, 71176, 71153, 20226, 77072, 77073, 77002, 20228, 77075, 77076, 
77005, 20180, 20227, 77074, 77004
26104, 19635, 19658, 71176, 71153, 19636, 19659, 71177, 71154, 20228, 77075, 77076, 77005, 20230, 77078, 77079, 
77008, 20182, 20229, 77077, 77007
26105, 19636, 19659, 71177, 71154, 19637, 19660, 71178, 71155, 20230, 77078, 77079, 77008, 20232, 77081, 77082, 
77011, 20184, 20231, 77080, 77010
26106, 19637, 19660, 71178, 71155, 19638, 19661, 71179, 71156, 20232, 77081, 77082, 77011, 20234, 77084, 77085, 
77014, 20186, 20233, 77083, 77013
26107, 19638, 19661, 71179, 71156, 19639, 19662, 71180, 71157, 20234, 77084, 77085, 77014, 20236, 77087, 77088, 
77017, 20188, 20235, 77086, 77016
26108, 19639, 19662, 71180, 71157, 19640, 19663, 71181, 71158, 20236, 77087, 77088, 77017, 20238, 77090, 77091, 
77020, 20190, 20237, 77089, 77019
26109, 19640, 19663, 71181, 71158, 19641, 19664, 71182, 71159, 20238, 77090, 77091, 77020, 20240, 77093, 77094, 
77023, 20192, 20239, 77092, 77022
26110, 19641, 19664, 71182, 71159, 1888, 1889, 22839, 22838, 20240, 77093, 77094, 77023, 1912, 23093, 23094, 
23091, 20194, 20241, 77095, 77025
26111, 1561, 1562, 17195, 17194, 19642, 19665, 71183, 71160, 1585, 17450, 17451, 17448, 20243, 77097, 77098, 
77027, 20195, 20242, 77096, 77026
26112, 19642, 19665, 71183, 71160, 19643, 19666, 71184, 71161, 20243, 77097, 77098, 77027, 20245, 77100, 77101, 
77030, 20197, 20244, 77099, 77029
26113, 19643, 19666, 71184, 71161, 19644, 19667, 71185, 71162, 20245, 77100, 77101, 77030, 20247, 77103, 77104, 
77033, 20199, 20246, 77102, 77032
26114, 19644, 19667, 71185, 71162, 19645, 19668, 71186, 71163, 20247, 77103, 77104, 77033, 20249, 77106, 77107, 
77036, 20201, 20248, 77105, 77035
26115, 19645, 19668, 71186, 71163, 19646, 19669, 71187, 71164, 20249, 77106, 77107, 77036, 20251, 77109, 77110, 
77039, 20203, 20250, 77108, 77038
26116, 19646, 19669, 71187, 71164, 19647, 19670, 71188, 71165, 20251, 77109, 77110, 77039, 20253, 77112, 77113, 
77042, 20205, 20252, 77111, 77041
26117, 19647, 19670, 71188, 71165, 19648, 19671, 71189, 71166, 20253, 77112, 77113, 77042, 20255, 77115, 77116, 
77045, 20207, 20254, 77114, 77044
26118, 19648, 19671, 71189, 71166, 19649, 19672, 71190, 71167, 20255, 77115, 77116, 77045, 20257, 77118, 77119, 
77048, 20209, 20256, 77117, 77047
26119, 19649, 19672, 71190, 71167, 19650, 19673, 71191, 71168, 20257, 77118, 77119, 77048, 20259, 77121, 77122, 
77051, 20211, 20258, 77120, 77050
26120, 19650, 19673, 71191, 71168, 19651, 19674, 71192, 71169, 20259, 77121, 77122, 77051, 20261, 77124, 77125, 
77054, 20213, 20260, 77123, 77053
26121, 19651, 19674, 71192, 71169, 19652, 19675, 71193, 71170, 20261, 77124, 77125, 77054, 20263, 77127, 77128, 
77057, 20215, 20262, 77126, 77056
26122, 19652, 19675, 71193, 71170, 19653, 19676, 71194, 71171, 20263, 77127, 77128, 77057, 20265, 77130, 77131, 
77060, 20217, 20264, 77129, 77059
26123, 19653, 19676, 71194, 71171, 19654, 19677, 71195, 71172, 20265, 77130, 77131, 77060, 20267, 77133, 77134, 
77063, 20219, 20266, 77132, 77062
26124, 19654, 19677, 71195, 71172, 19655, 19678, 71196, 71173, 20267, 77133, 77134, 77063, 20269, 77136, 77137, 
77066, 20221, 20268, 77135, 77065
26125, 19655, 19678, 71196, 71173, 19656, 19679, 71197, 71174, 20269, 77136, 77137, 77066, 20271, 77139, 77140, 
77069, 20223, 20270, 77138, 77068
26126, 19656, 19679, 71197, 71174, 19657, 19680, 71198, 71175, 20271, 77139, 77140, 77069, 20273, 77142, 77143, 
77072, 20225, 20272, 77141, 77071
26127, 19657, 19680, 71198, 71175, 19658, 19681, 71199, 71176, 20273, 77142, 77143, 77072, 20275, 77145, 77146, 
77075, 20227, 20274, 77144, 77074
26128, 19658, 19681, 71199, 71176, 19659, 19682, 71200, 71177, 20275, 77145, 77146, 77075, 20277, 77148, 77149, 
77078, 20229, 20276, 77147, 77077
26129, 19659, 19682, 71200, 71177, 19660, 19683, 71201, 71178, 20277, 77148, 77149, 77078, 20279, 77151, 77152, 
77081, 20231, 20278, 77150, 77080
26130, 19660, 19683, 71201, 71178, 19661, 19684, 71202, 71179, 20279, 77151, 77152, 77081, 20281, 77154, 77155, 
77084, 20233, 20280, 77153, 77083
26131, 19661, 19684, 71202, 71179, 19662, 19685, 71203, 71180, 20281, 77154, 77155, 77084, 20283, 77157, 77158, 
77087, 20235, 20282, 77156, 77086
26132, 19662, 19685, 71203, 71180, 19663, 19686, 71204, 71181, 20283, 77157, 77158, 77087, 20285, 77160, 77161, 
77090, 20237, 20284, 77159, 77089
26133, 19663, 19686, 71204, 71181, 19664, 19687, 71205, 71182, 20285, 77160, 77161, 77090, 20287, 77163, 77164, 
77093, 20239, 20286, 77162, 77092
26134, 19664, 19687, 71205, 71182, 1889, 1890, 22840, 22839, 20287, 77163, 77164, 77093, 1913, 23095, 23096, 
23093, 20241, 20288, 77165, 77095
26135, 1562, 1563, 17196, 17195, 19665, 19688, 71206, 71183, 1586, 17452, 17453, 17450, 20290, 77167, 77168, 
77097, 20242, 20289, 77166, 77096
26136, 19665, 19688, 71206, 71183, 19666, 19689, 71207, 71184, 20290, 77167, 77168, 77097, 20292, 77170, 77171, 
77100, 20244, 20291, 77169, 77099
26137, 19666, 19689, 71207, 71184, 19667, 19690, 71208, 71185, 20292, 77170, 77171, 77100, 20294, 77173, 77174, 
77103, 20246, 20293, 77172, 77102
26138, 19667, 19690, 71208, 71185, 19668, 19691, 71209, 71186, 20294, 77173, 77174, 77103, 20296, 77176, 77177, 
77106, 20248, 20295, 77175, 77105
26139, 19668, 19691, 71209, 71186, 19669, 19692, 71210, 71187, 20296, 77176, 77177, 77106, 20298, 77179, 77180, 
77109, 20250, 20297, 77178, 77108
26140, 19669, 19692, 71210, 71187, 19670, 19693, 71211, 71188, 20298, 77179, 77180, 77109, 20300, 77182, 77183, 
77112, 20252, 20299, 77181, 77111
26141, 19670, 19693, 71211, 71188, 19671, 19694, 71212, 71189, 20300, 77182, 77183, 77112, 20302, 77185, 77186, 
77115, 20254, 20301, 77184, 77114
26142, 19671, 19694, 71212, 71189, 19672, 19695, 71213, 71190, 20302, 77185, 77186, 77115, 20304, 77188, 77189, 
77118, 20256, 20303, 77187, 77117
26143, 19672, 19695, 71213, 71190, 19673, 19696, 71214, 71191, 20304, 77188, 77189, 77118, 20306, 77191, 77192, 
77121, 20258, 20305, 77190, 77120
26144, 19673, 19696, 71214, 71191, 19674, 19697, 71215, 71192, 20306, 77191, 77192, 77121, 20308, 77194, 77195, 
77124, 20260, 20307, 77193, 77123
26145, 19674, 19697, 71215, 71192, 19675, 19698, 71216, 71193, 20308, 77194, 77195, 77124, 20310, 77197, 77198, 
77127, 20262, 20309, 77196, 77126
26146, 19675, 19698, 71216, 71193, 19676, 19699, 71217, 71194, 20310, 77197, 77198, 77127, 20312, 77200, 77201, 
77130, 20264, 20311, 77199, 77129
26147, 19676, 19699, 71217, 71194, 19677, 19700, 71218, 71195, 20312, 77200, 77201, 77130, 20314, 77203, 77204, 
77133, 20266, 20313, 77202, 77132
26148, 19677, 19700, 71218, 71195, 19678, 19701, 71219, 71196, 20314, 77203, 77204, 77133, 20316, 77206, 77207, 
77136, 20268, 20315, 77205, 77135
26149, 19678, 19701, 71219, 71196, 19679, 19702, 71220, 71197, 20316, 77206, 77207, 77136, 20318, 77209, 77210, 
77139, 20270, 20317, 77208, 77138
26150, 19679, 19702, 71220, 71197, 19680, 19703, 71221, 71198, 20318, 77209, 77210, 77139, 20320, 77212, 77213, 
77142, 20272, 20319, 77211, 77141
26151, 19680, 19703, 71221, 71198, 19681, 19704, 71222, 71199, 20320, 77212, 77213, 77142, 20322, 77215, 77216, 
77145, 20274, 20321, 77214, 77144
26152, 19681, 19704, 71222, 71199, 19682, 19705, 71223, 71200, 20322, 77215, 77216, 77145, 20324, 77218, 77219, 
77148, 20276, 20323, 77217, 77147
26153, 19682, 19705, 71223, 71200, 19683, 19706, 71224, 71201, 20324, 77218, 77219, 77148, 20326, 77221, 77222, 
77151, 20278, 20325, 77220, 77150
26154, 19683, 19706, 71224, 71201, 19684, 19707, 71225, 71202, 20326, 77221, 77222, 77151, 20328, 77224, 77225, 
77154, 20280, 20327, 77223, 77153
26155, 19684, 19707, 71225, 71202, 19685, 19708, 71226, 71203, 20328, 77224, 77225, 77154, 20330, 77227, 77228, 
77157, 20282, 20329, 77226, 77156
26156, 19685, 19708, 71226, 71203, 19686, 19709, 71227, 71204, 20330, 77227, 77228, 77157, 20332, 77230, 77231, 
77160, 20284, 20331, 77229, 77159
26157, 19686, 19709, 71227, 71204, 19687, 19710, 71228, 71205, 20332, 77230, 77231, 77160, 20334, 77233, 77234, 
77163, 20286, 20333, 77232, 77162
26158, 19687, 19710, 71228, 71205, 1890, 1891, 22841, 22840, 20334, 77233, 77234, 77163, 1914, 23097, 23098, 
23095, 20288, 20335, 77235, 77165
26159, 1563, 1564, 17197, 17196, 19688, 19711, 71229, 71206, 1587, 17454, 17455, 17452, 20337, 77237, 77238, 
77167, 20289, 20336, 77236, 77166
26160, 19688, 19711, 71229, 71206, 19689, 19712, 71230, 71207, 20337, 77237, 77238, 77167, 20339, 77240, 77241, 
77170, 20291, 20338, 77239, 77169
26161, 19689, 19712, 71230, 71207, 19690, 19713, 71231, 71208, 20339, 77240, 77241, 77170, 20341, 77243, 77244, 
77173, 20293, 20340, 77242, 77172
26162, 19690, 19713, 71231, 71208, 19691, 19714, 71232, 71209, 20341, 77243, 77244, 77173, 20343, 77246, 77247, 
77176, 20295, 20342, 77245, 77175
26163, 19691, 19714, 71232, 71209, 19692, 19715, 71233, 71210, 20343, 77246, 77247, 77176, 20345, 77249, 77250, 
77179, 20297, 20344, 77248, 77178
26164, 19692, 19715, 71233, 71210, 19693, 19716, 71234, 71211, 20345, 77249, 77250, 77179, 20347, 77252, 77253, 
77182, 20299, 20346, 77251, 77181
26165, 19693, 19716, 71234, 71211, 19694, 19717, 71235, 71212, 20347, 77252, 77253, 77182, 20349, 77255, 77256, 
77185, 20301, 20348, 77254, 77184
26166, 19694, 19717, 71235, 71212, 19695, 19718, 71236, 71213, 20349, 77255, 77256, 77185, 20351, 77258, 77259, 
77188, 20303, 20350, 77257, 77187
26167, 19695, 19718, 71236, 71213, 19696, 19719, 71237, 71214, 20351, 77258, 77259, 77188, 20353, 77261, 77262, 
77191, 20305, 20352, 77260, 77190
26168, 19696, 19719, 71237, 71214, 19697, 19720, 71238, 71215, 20353, 77261, 77262, 77191, 20355, 77264, 77265, 
77194, 20307, 20354, 77263, 77193
26169, 19697, 19720, 71238, 71215, 19698, 19721, 71239, 71216, 20355, 77264, 77265, 77194, 20357, 77267, 77268, 
77197, 20309, 20356, 77266, 77196
26170, 19698, 19721, 71239, 71216, 19699, 19722, 71240, 71217, 20357, 77267, 77268, 77197, 20359, 77270, 77271, 
77200, 20311, 20358, 77269, 77199
26171, 19699, 19722, 71240, 71217, 19700, 19723, 71241, 71218, 20359, 77270, 77271, 77200, 20361, 77273, 77274, 
77203, 20313, 20360, 77272, 77202
26172, 19700, 19723, 71241, 71218, 19701, 19724, 71242, 71219, 20361, 77273, 77274, 77203, 20363, 77276, 77277, 
77206, 20315, 20362, 77275, 77205
26173, 19701, 19724, 71242, 71219, 19702, 19725, 71243, 71220, 20363, 77276, 77277, 77206, 20365, 77279, 77280, 
77209, 20317, 20364, 77278, 77208
26174, 19702, 19725, 71243, 71220, 19703, 19726, 71244, 71221, 20365, 77279, 77280, 77209, 20367, 77282, 77283, 
77212, 20319, 20366, 77281, 77211
26175, 19703, 19726, 71244, 71221, 19704, 19727, 71245, 71222, 20367, 77282, 77283, 77212, 20369, 77285, 77286, 
77215, 20321, 20368, 77284, 77214
26176, 19704, 19727, 71245, 71222, 19705, 19728, 71246, 71223, 20369, 77285, 77286, 77215, 20371, 77288, 77289, 
77218, 20323, 20370, 77287, 77217
26177, 19705, 19728, 71246, 71223, 19706, 19729, 71247, 71224, 20371, 77288, 77289, 77218, 20373, 77291, 77292, 
77221, 20325, 20372, 77290, 77220
26178, 19706, 19729, 71247, 71224, 19707, 19730, 71248, 71225, 20373, 77291, 77292, 77221, 20375, 77294, 77295, 
77224, 20327, 20374, 77293, 77223
26179, 19707, 19730, 71248, 71225, 19708, 19731, 71249, 71226, 20375, 77294, 77295, 77224, 20377, 77297, 77298, 
77227, 20329, 20376, 77296, 77226
26180, 19708, 19731, 71249, 71226, 19709, 19732, 71250, 71227, 20377, 77297, 77298, 77227, 20379, 77300, 77301, 
77230, 20331, 20378, 77299, 77229
26181, 19709, 19732, 71250, 71227, 19710, 19733, 71251, 71228, 20379, 77300, 77301, 77230, 20381, 77303, 77304, 
77233, 20333, 20380, 77302, 77232
26182, 19710, 19733, 71251, 71228, 1891, 1892, 22842, 22841, 20381, 77303, 77304, 77233, 1915, 23099, 23100, 
23097, 20335, 20382, 77305, 77235
26183, 1564, 1565, 17198, 17197, 19711, 19734, 71252, 71229, 1588, 17456, 17457, 17454, 20384, 77307, 77308, 
77237, 20336, 20383, 77306, 77236
26184, 19711, 19734, 71252, 71229, 19712, 19735, 71253, 71230, 20384, 77307, 77308, 77237, 20386, 77310, 77311, 
77240, 20338, 20385, 77309, 77239
26185, 19712, 19735, 71253, 71230, 19713, 19736, 71254, 71231, 20386, 77310, 77311, 77240, 20388, 77313, 77314, 
77243, 20340, 20387, 77312, 77242
26186, 19713, 19736, 71254, 71231, 19714, 19737, 71255, 71232, 20388, 77313, 77314, 77243, 20390, 77316, 77317, 
77246, 20342, 20389, 77315, 77245
26187, 19714, 19737, 71255, 71232, 19715, 19738, 71256, 71233, 20390, 77316, 77317, 77246, 20392, 77319, 77320, 
77249, 20344, 20391, 77318, 77248
26188, 19715, 19738, 71256, 71233, 19716, 19739, 71257, 71234, 20392, 77319, 77320, 77249, 20394, 77322, 77323, 
77252, 20346, 20393, 77321, 77251
26189, 19716, 19739, 71257, 71234, 19717, 19740, 71258, 71235, 20394, 77322, 77323, 77252, 20396, 77325, 77326, 
77255, 20348, 20395, 77324, 77254
26190, 19717, 19740, 71258, 71235, 19718, 19741, 71259, 71236, 20396, 77325, 77326, 77255, 20398, 77328, 77329, 
77258, 20350, 20397, 77327, 77257
26191, 19718, 19741, 71259, 71236, 19719, 19742, 71260, 71237, 20398, 77328, 77329, 77258, 20400, 77331, 77332, 
77261, 20352, 20399, 77330, 77260
26192, 19719, 19742, 71260, 71237, 19720, 19743, 71261, 71238, 20400, 77331, 77332, 77261, 20402, 77334, 77335, 
77264, 20354, 20401, 77333, 77263
26193, 19720, 19743, 71261, 71238, 19721, 19744, 71262, 71239, 20402, 77334, 77335, 77264, 20404, 77337, 77338, 
77267, 20356, 20403, 77336, 77266
26194, 19721, 19744, 71262, 71239, 19722, 19745, 71263, 71240, 20404, 77337, 77338, 77267, 20406, 77340, 77341, 
77270, 20358, 20405, 77339, 77269
26195, 19722, 19745, 71263, 71240, 19723, 19746, 71264, 71241, 20406, 77340, 77341, 77270, 20408, 77343, 77344, 
77273, 20360, 20407, 77342, 77272
26196, 19723, 19746, 71264, 71241, 19724, 19747, 71265, 71242, 20408, 77343, 77344, 77273, 20410, 77346, 77347, 
77276, 20362, 20409, 77345, 77275
26197, 19724, 19747, 71265, 71242, 19725, 19748, 71266, 71243, 20410, 77346, 77347, 77276, 20412, 77349, 77350, 
77279, 20364, 20411, 77348, 77278
26198, 19725, 19748, 71266, 71243, 19726, 19749, 71267, 71244, 20412, 77349, 77350, 77279, 20414, 77352, 77353, 
77282, 20366, 20413, 77351, 77281
26199, 19726, 19749, 71267, 71244, 19727, 19750, 71268, 71245, 20414, 77352, 77353, 77282, 20416, 77355, 77356, 
77285, 20368, 20415, 77354, 77284
26200, 19727, 19750, 71268, 71245, 19728, 19751, 71269, 71246, 20416, 77355, 77356, 77285, 20418, 77358, 77359, 
77288, 20370, 20417, 77357, 77287
26201, 19728, 19751, 71269, 71246, 19729, 19752, 71270, 71247, 20418, 77358, 77359, 77288, 20420, 77361, 77362, 
77291, 20372, 20419, 77360, 77290
26202, 19729, 19752, 71270, 71247, 19730, 19753, 71271, 71248, 20420, 77361, 77362, 77291, 20422, 77364, 77365, 
77294, 20374, 20421, 77363, 77293
26203, 19730, 19753, 71271, 71248, 19731, 19754, 71272, 71249, 20422, 77364, 77365, 77294, 20424, 77367, 77368, 
77297, 20376, 20423, 77366, 77296
26204, 19731, 19754, 71272, 71249, 19732, 19755, 71273, 71250, 20424, 77367, 77368, 77297, 20426, 77370, 77371, 
77300, 20378, 20425, 77369, 77299
26205, 19732, 19755, 71273, 71250, 19733, 19756, 71274, 71251, 20426, 77370, 77371, 77300, 20428, 77373, 77374, 
77303, 20380, 20427, 77372, 77302
26206, 19733, 19756, 71274, 71251, 1892, 1893, 22843, 22842, 20428, 77373, 77374, 77303, 1916, 23101, 23102, 
23099, 20382, 20429, 77375, 77305
26207, 1565, 1566, 17199, 17198, 19734, 19757, 71275, 71252, 1589, 17458, 17459, 17456, 20431, 77377, 77378, 
77307, 20383, 20430, 77376, 77306
26208, 19734, 19757, 71275, 71252, 19735, 19758, 71276, 71253, 20431, 77377, 77378, 77307, 20433, 77380, 77381, 
77310, 20385, 20432, 77379, 77309
26209, 19735, 19758, 71276, 71253, 19736, 19759, 71277, 71254, 20433, 77380, 77381, 77310, 20435, 77383, 77384, 
77313, 20387, 20434, 77382, 77312
26210, 19736, 19759, 71277, 71254, 19737, 19760, 71278, 71255, 20435, 77383, 77384, 77313, 20437, 77386, 77387, 
77316, 20389, 20436, 77385, 77315
26211, 19737, 19760, 71278, 71255, 19738, 19761, 71279, 71256, 20437, 77386, 77387, 77316, 20439, 77389, 77390, 
77319, 20391, 20438, 77388, 77318
26212, 19738, 19761, 71279, 71256, 19739, 19762, 71280, 71257, 20439, 77389, 77390, 77319, 20441, 77392, 77393, 
77322, 20393, 20440, 77391, 77321
26213, 19739, 19762, 71280, 71257, 19740, 19763, 71281, 71258, 20441, 77392, 77393, 77322, 20443, 77395, 77396, 
77325, 20395, 20442, 77394, 77324
26214, 19740, 19763, 71281, 71258, 19741, 19764, 71282, 71259, 20443, 77395, 77396, 77325, 20445, 77398, 77399, 
77328, 20397, 20444, 77397, 77327
26215, 19741, 19764, 71282, 71259, 19742, 19765, 71283, 71260, 20445, 77398, 77399, 77328, 20447, 77401, 77402, 
77331, 20399, 20446, 77400, 77330
26216, 19742, 19765, 71283, 71260, 19743, 19766, 71284, 71261, 20447, 77401, 77402, 77331, 20449, 77404, 77405, 
77334, 20401, 20448, 77403, 77333
26217, 19743, 19766, 71284, 71261, 19744, 19767, 71285, 71262, 20449, 77404, 77405, 77334, 20451, 77407, 77408, 
77337, 20403, 20450, 77406, 77336
26218, 19744, 19767, 71285, 71262, 19745, 19768, 71286, 71263, 20451, 77407, 77408, 77337, 20453, 77410, 77411, 
77340, 20405, 20452, 77409, 77339
26219, 19745, 19768, 71286, 71263, 19746, 19769, 71287, 71264, 20453, 77410, 77411, 77340, 20455, 77413, 77414, 
77343, 20407, 20454, 77412, 77342
26220, 19746, 19769, 71287, 71264, 19747, 19770, 71288, 71265, 20455, 77413, 77414, 77343, 20457, 77416, 77417, 
77346, 20409, 20456, 77415, 77345
26221, 19747, 19770, 71288, 71265, 19748, 19771, 71289, 71266, 20457, 77416, 77417, 77346, 20459, 77419, 77420, 
77349, 20411, 20458, 77418, 77348
26222, 19748, 19771, 71289, 71266, 19749, 19772, 71290, 71267, 20459, 77419, 77420, 77349, 20461, 77422, 77423, 
77352, 20413, 20460, 77421, 77351
26223, 19749, 19772, 71290, 71267, 19750, 19773, 71291, 71268, 20461, 77422, 77423, 77352, 20463, 77425, 77426, 
77355, 20415, 20462, 77424, 77354
26224, 19750, 19773, 71291, 71268, 19751, 19774, 71292, 71269, 20463, 77425, 77426, 77355, 20465, 77428, 77429, 
77358, 20417, 20464, 77427, 77357
26225, 19751, 19774, 71292, 71269, 19752, 19775, 71293, 71270, 20465, 77428, 77429, 77358, 20467, 77431, 77432, 
77361, 20419, 20466, 77430, 77360
26226, 19752, 19775, 71293, 71270, 19753, 19776, 71294, 71271, 20467, 77431, 77432, 77361, 20469, 77434, 77435, 
77364, 20421, 20468, 77433, 77363
26227, 19753, 19776, 71294, 71271, 19754, 19777, 71295, 71272, 20469, 77434, 77435, 77364, 20471, 77437, 77438, 
77367, 20423, 20470, 77436, 77366
26228, 19754, 19777, 71295, 71272, 19755, 19778, 71296, 71273, 20471, 77437, 77438, 77367, 20473, 77440, 77441, 
77370, 20425, 20472, 77439, 77369
26229, 19755, 19778, 71296, 71273, 19756, 19779, 71297, 71274, 20473, 77440, 77441, 77370, 20475, 77443, 77444, 
77373, 20427, 20474, 77442, 77372
26230, 19756, 19779, 71297, 71274, 1893, 1894, 22844, 22843, 20475, 77443, 77444, 77373, 1917, 23103, 23104, 
23101, 20429, 20476, 77445, 77375
26231, 1566, 1567, 17200, 17199, 19757, 19780, 71298, 71275, 1590, 17460, 17461, 17458, 20478, 77447, 77448, 
77377, 20430, 20477, 77446, 77376
26232, 19757, 19780, 71298, 71275, 19758, 19781, 71299, 71276, 20478, 77447, 77448, 77377, 20480, 77450, 77451, 
77380, 20432, 20479, 77449, 77379
26233, 19758, 19781, 71299, 71276, 19759, 19782, 71300, 71277, 20480, 77450, 77451, 77380, 20482, 77453, 77454, 
77383, 20434, 20481, 77452, 77382
26234, 19759, 19782, 71300, 71277, 19760, 19783, 71301, 71278, 20482, 77453, 77454, 77383, 20484, 77456, 77457, 
77386, 20436, 20483, 77455, 77385
26235, 19760, 19783, 71301, 71278, 19761, 19784, 71302, 71279, 20484, 77456, 77457, 77386, 20486, 77459, 77460, 
77389, 20438, 20485, 77458, 77388
26236, 19761, 19784, 71302, 71279, 19762, 19785, 71303, 71280, 20486, 77459, 77460, 77389, 20488, 77462, 77463, 
77392, 20440, 20487, 77461, 77391
26237, 19762, 19785, 71303, 71280, 19763, 19786, 71304, 71281, 20488, 77462, 77463, 77392, 20490, 77465, 77466, 
77395, 20442, 20489, 77464, 77394
26238, 19763, 19786, 71304, 71281, 19764, 19787, 71305, 71282, 20490, 77465, 77466, 77395, 20492, 77468, 77469, 
77398, 20444, 20491, 77467, 77397
26239, 19764, 19787, 71305, 71282, 19765, 19788, 71306, 71283, 20492, 77468, 77469, 77398, 20494, 77471, 77472, 
77401, 20446, 20493, 77470, 77400
26240, 19765, 19788, 71306, 71283, 19766, 19789, 71307, 71284, 20494, 77471, 77472, 77401, 20496, 77474, 77475, 
77404, 20448, 20495, 77473, 77403
26241, 19766, 19789, 71307, 71284, 19767, 19790, 71308, 71285, 20496, 77474, 77475, 77404, 20498, 77477, 77478, 
77407, 20450, 20497, 77476, 77406
26242, 19767, 19790, 71308, 71285, 19768, 19791, 71309, 71286, 20498, 77477, 77478, 77407, 20500, 77480, 77481, 
77410, 20452, 20499, 77479, 77409
26243, 19768, 19791, 71309, 71286, 19769, 19792, 71310, 71287, 20500, 77480, 77481, 77410, 20502, 77483, 77484, 
77413, 20454, 20501, 77482, 77412
26244, 19769, 19792, 71310, 71287, 19770, 19793, 71311, 71288, 20502, 77483, 77484, 77413, 20504, 77486, 77487, 
77416, 20456, 20503, 77485, 77415
26245, 19770, 19793, 71311, 71288, 19771, 19794, 71312, 71289, 20504, 77486, 77487, 77416, 20506, 77489, 77490, 
77419, 20458, 20505, 77488, 77418
26246, 19771, 19794, 71312, 71289, 19772, 19795, 71313, 71290, 20506, 77489, 77490, 77419, 20508, 77492, 77493, 
77422, 20460, 20507, 77491, 77421
26247, 19772, 19795, 71313, 71290, 19773, 19796, 71314, 71291, 20508, 77492, 77493, 77422, 20510, 77495, 77496, 
77425, 20462, 20509, 77494, 77424
26248, 19773, 19796, 71314, 71291, 19774, 19797, 71315, 71292, 20510, 77495, 77496, 77425, 20512, 77498, 77499, 
77428, 20464, 20511, 77497, 77427
26249, 19774, 19797, 71315, 71292, 19775, 19798, 71316, 71293, 20512, 77498, 77499, 77428, 20514, 77501, 77502, 
77431, 20466, 20513, 77500, 77430
26250, 19775, 19798, 71316, 71293, 19776, 19799, 71317, 71294, 20514, 77501, 77502, 77431, 20516, 77504, 77505, 
77434, 20468, 20515, 77503, 77433
26251, 19776, 19799, 71317, 71294, 19777, 19800, 71318, 71295, 20516, 77504, 77505, 77434, 20518, 77507, 77508, 
77437, 20470, 20517, 77506, 77436
26252, 19777, 19800, 71318, 71295, 19778, 19801, 71319, 71296, 20518, 77507, 77508, 77437, 20520, 77510, 77511, 
77440, 20472, 20519, 77509, 77439
26253, 19778, 19801, 71319, 71296, 19779, 19802, 71320, 71297, 20520, 77510, 77511, 77440, 20522, 77513, 77514, 
77443, 20474, 20521, 77512, 77442
26254, 19779, 19802, 71320, 71297, 1894, 1895, 22845, 22844, 20522, 77513, 77514, 77443, 1918, 23105, 23106, 
23103, 20476, 20523, 77515, 77445
26255, 1567, 1568, 17201, 17200, 19780, 19803, 71321, 71298, 1591, 17462, 17463, 17460, 20525, 77517, 77518, 
77447, 20477, 20524, 77516, 77446
26256, 19780, 19803, 71321, 71298, 19781, 19804, 71322, 71299, 20525, 77517, 77518, 77447, 20527, 77520, 77521, 
77450, 20479, 20526, 77519, 77449
26257, 19781, 19804, 71322, 71299, 19782, 19805, 71323, 71300, 20527, 77520, 77521, 77450, 20529, 77523, 77524, 
77453, 20481, 20528, 77522, 77452
26258, 19782, 19805, 71323, 71300, 19783, 19806, 71324, 71301, 20529, 77523, 77524, 77453, 20531, 77526, 77527, 
77456, 20483, 20530, 77525, 77455
26259, 19783, 19806, 71324, 71301, 19784, 19807, 71325, 71302, 20531, 77526, 77527, 77456, 20533, 77529, 77530, 
77459, 20485, 20532, 77528, 77458
26260, 19784, 19807, 71325, 71302, 19785, 19808, 71326, 71303, 20533, 77529, 77530, 77459, 20535, 77532, 77533, 
77462, 20487, 20534, 77531, 77461
26261, 19785, 19808, 71326, 71303, 19786, 19809, 71327, 71304, 20535, 77532, 77533, 77462, 20537, 77535, 77536, 
77465, 20489, 20536, 77534, 77464
26262, 19786, 19809, 71327, 71304, 19787, 19810, 71328, 71305, 20537, 77535, 77536, 77465, 20539, 77538, 77539, 
77468, 20491, 20538, 77537, 77467
26263, 19787, 19810, 71328, 71305, 19788, 19811, 71329, 71306, 20539, 77538, 77539, 77468, 20541, 77541, 77542, 
77471, 20493, 20540, 77540, 77470
26264, 19788, 19811, 71329, 71306, 19789, 19812, 71330, 71307, 20541, 77541, 77542, 77471, 20543, 77544, 77545, 
77474, 20495, 20542, 77543, 77473
26265, 19789, 19812, 71330, 71307, 19790, 19813, 71331, 71308, 20543, 77544, 77545, 77474, 20545, 77547, 77548, 
77477, 20497, 20544, 77546, 77476
26266, 19790, 19813, 71331, 71308, 19791, 19814, 71332, 71309, 20545, 77547, 77548, 77477, 20547, 77550, 77551, 
77480, 20499, 20546, 77549, 77479
26267, 19791, 19814, 71332, 71309, 19792, 19815, 71333, 71310, 20547, 77550, 77551, 77480, 20549, 77553, 77554, 
77483, 20501, 20548, 77552, 77482
26268, 19792, 19815, 71333, 71310, 19793, 19816, 71334, 71311, 20549, 77553, 77554, 77483, 20551, 77556, 77557, 
77486, 20503, 20550, 77555, 77485
26269, 19793, 19816, 71334, 71311, 19794, 19817, 71335, 71312, 20551, 77556, 77557, 77486, 20553, 77559, 77560, 
77489, 20505, 20552, 77558, 77488
26270, 19794, 19817, 71335, 71312, 19795, 19818, 71336, 71313, 20553, 77559, 77560, 77489, 20555, 77562, 77563, 
77492, 20507, 20554, 77561, 77491
26271, 19795, 19818, 71336, 71313, 19796, 19819, 71337, 71314, 20555, 77562, 77563, 77492, 20557, 77565, 77566, 
77495, 20509, 20556, 77564, 77494
26272, 19796, 19819, 71337, 71314, 19797, 19820, 71338, 71315, 20557, 77565, 77566, 77495, 20559, 77568, 77569, 
77498, 20511, 20558, 77567, 77497
26273, 19797, 19820, 71338, 71315, 19798, 19821, 71339, 71316, 20559, 77568, 77569, 77498, 20561, 77571, 77572, 
77501, 20513, 20560, 77570, 77500
26274, 19798, 19821, 71339, 71316, 19799, 19822, 71340, 71317, 20561, 77571, 77572, 77501, 20563, 77574, 77575, 
77504, 20515, 20562, 77573, 77503
26275, 19799, 19822, 71340, 71317, 19800, 19823, 71341, 71318, 20563, 77574, 77575, 77504, 20565, 77577, 77578, 
77507, 20517, 20564, 77576, 77506
26276, 19800, 19823, 71341, 71318, 19801, 19824, 71342, 71319, 20565, 77577, 77578, 77507, 20567, 77580, 77581, 
77510, 20519, 20566, 77579, 77509
26277, 19801, 19824, 71342, 71319, 19802, 19825, 71343, 71320, 20567, 77580, 77581, 77510, 20569, 77583, 77584, 
77513, 20521, 20568, 77582, 77512
26278, 19802, 19825, 71343, 71320, 1895, 1896, 22846, 22845, 20569, 77583, 77584, 77513, 1919, 23107, 23108, 
23105, 20523, 20570, 77585, 77515
26279, 1568, 1569, 17202, 17201, 19803, 19826, 71344, 71321, 1592, 17464, 17465, 17462, 20572, 77587, 77588, 
77517, 20524, 20571, 77586, 77516
26280, 19803, 19826, 71344, 71321, 19804, 19827, 71345, 71322, 20572, 77587, 77588, 77517, 20574, 77590, 77591, 
77520, 20526, 20573, 77589, 77519
26281, 19804, 19827, 71345, 71322, 19805, 19828, 71346, 71323, 20574, 77590, 77591, 77520, 20576, 77593, 77594, 
77523, 20528, 20575, 77592, 77522
26282, 19805, 19828, 71346, 71323, 19806, 19829, 71347, 71324, 20576, 77593, 77594, 77523, 20578, 77596, 77597, 
77526, 20530, 20577, 77595, 77525
26283, 19806, 19829, 71347, 71324, 19807, 19830, 71348, 71325, 20578, 77596, 77597, 77526, 20580, 77599, 77600, 
77529, 20532, 20579, 77598, 77528
26284, 19807, 19830, 71348, 71325, 19808, 19831, 71349, 71326, 20580, 77599, 77600, 77529, 20582, 77602, 77603, 
77532, 20534, 20581, 77601, 77531
26285, 19808, 19831, 71349, 71326, 19809, 19832, 71350, 71327, 20582, 77602, 77603, 77532, 20584, 77605, 77606, 
77535, 20536, 20583, 77604, 77534
26286, 19809, 19832, 71350, 71327, 19810, 19833, 71351, 71328, 20584, 77605, 77606, 77535, 20586, 77608, 77609, 
77538, 20538, 20585, 77607, 77537
26287, 19810, 19833, 71351, 71328, 19811, 19834, 71352, 71329, 20586, 77608, 77609, 77538, 20588, 77611, 77612, 
77541, 20540, 20587, 77610, 77540
26288, 19811, 19834, 71352, 71329, 19812, 19835, 71353, 71330, 20588, 77611, 77612, 77541, 20590, 77614, 77615, 
77544, 20542, 20589, 77613, 77543
26289, 19812, 19835, 71353, 71330, 19813, 19836, 71354, 71331, 20590, 77614, 77615, 77544, 20592, 77617, 77618, 
77547, 20544, 20591, 77616, 77546
26290, 19813, 19836, 71354, 71331, 19814, 19837, 71355, 71332, 20592, 77617, 77618, 77547, 20594, 77620, 77621, 
77550, 20546, 20593, 77619, 77549
26291, 19814, 19837, 71355, 71332, 19815, 19838, 71356, 71333, 20594, 77620, 77621, 77550, 20596, 77623, 77624, 
77553, 20548, 20595, 77622, 77552
26292, 19815, 19838, 71356, 71333, 19816, 19839, 71357, 71334, 20596, 77623, 77624, 77553, 20598, 77626, 77627, 
77556, 20550, 20597, 77625, 77555
26293, 19816, 19839, 71357, 71334, 19817, 19840, 71358, 71335, 20598, 77626, 77627, 77556, 20600, 77629, 77630, 
77559, 20552, 20599, 77628, 77558
26294, 19817, 19840, 71358, 71335, 19818, 19841, 71359, 71336, 20600, 77629, 77630, 77559, 20602, 77632, 77633, 
77562, 20554, 20601, 77631, 77561
26295, 19818, 19841, 71359, 71336, 19819, 19842, 71360, 71337, 20602, 77632, 77633, 77562, 20604, 77635, 77636, 
77565, 20556, 20603, 77634, 77564
26296, 19819, 19842, 71360, 71337, 19820, 19843, 71361, 71338, 20604, 77635, 77636, 77565, 20606, 77638, 77639, 
77568, 20558, 20605, 77637, 77567
26297, 19820, 19843, 71361, 71338, 19821, 19844, 71362, 71339, 20606, 77638, 77639, 77568, 20608, 77641, 77642, 
77571, 20560, 20607, 77640, 77570
26298, 19821, 19844, 71362, 71339, 19822, 19845, 71363, 71340, 20608, 77641, 77642, 77571, 20610, 77644, 77645, 
77574, 20562, 20609, 77643, 77573
26299, 19822, 19845, 71363, 71340, 19823, 19846, 71364, 71341, 20610, 77644, 77645, 77574, 20612, 77647, 77648, 
77577, 20564, 20611, 77646, 77576
26300, 19823, 19846, 71364, 71341, 19824, 19847, 71365, 71342, 20612, 77647, 77648, 77577, 20614, 77650, 77651, 
77580, 20566, 20613, 77649, 77579
26301, 19824, 19847, 71365, 71342, 19825, 19848, 71366, 71343, 20614, 77650, 77651, 77580, 20616, 77653, 77654, 
77583, 20568, 20615, 77652, 77582
26302, 19825, 19848, 71366, 71343, 1896, 1897, 22847, 22846, 20616, 77653, 77654, 77583, 1920, 23109, 23110, 
23107, 20570, 20617, 77655, 77585
26303, 1569, 1570, 17203, 17202, 19826, 19849, 71367, 71344, 1593, 17466, 17467, 17464, 20619, 77657, 77658, 
77587, 20571, 20618, 77656, 77586
26304, 19826, 19849, 71367, 71344, 19827, 19850, 71368, 71345, 20619, 77657, 77658, 77587, 20621, 77660, 77661, 
77590, 20573, 20620, 77659, 77589
