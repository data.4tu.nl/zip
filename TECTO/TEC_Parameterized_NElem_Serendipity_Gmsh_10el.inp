68334, 1.02, 1.4666666666667, 0.20833333333333
68335, 1.04, 1.4666666666667, 0.1875
68336, 1.04, 1.45, 0.20833333333333
68337, 1.06, 1.4666666666667, 0.20833333333333
68338, 1.08, 1.4666666666667, 0.1875
68339, 1.08, 1.45, 0.20833333333333
68340, 1.1, 1.4666666666667, 0.20833333333333
68341, 1.12, 1.4666666666667, 0.1875
68342, 1.12, 1.45, 0.20833333333333
68343, 1.14, 1.4666666666667, 0.20833333333333
68344, 1.16, 1.4666666666667, 0.1875
68345, 1.16, 1.45, 0.20833333333333
68346, 1.18, 1.4666666666667, 0.20833333333333
68347, 1.04, 1.4833333333333, 0.20833333333333
68348, 1.08, 1.4833333333333, 0.20833333333333
68349, 1.12, 1.4833333333333, 0.20833333333333
68350, 1.16, 1.4833333333333, 0.20833333333333
68351, 1.02, 1.4333333333333, 0.25
68352, 1.04, 1.4333333333333, 0.22916666666667
68353, 1.04, 1.4166666666667, 0.25
68354, 1.06, 1.4333333333333, 0.25
68355, 1.08, 1.4333333333333, 0.22916666666667
68356, 1.08, 1.4166666666667, 0.25
68357, 1.1, 1.4333333333333, 0.25
68358, 1.12, 1.4333333333333, 0.22916666666667
68359, 1.12, 1.4166666666667, 0.25
68360, 1.14, 1.4333333333333, 0.25
68361, 1.16, 1.4333333333333, 0.22916666666667
68362, 1.16, 1.4166666666667, 0.25
68363, 1.18, 1.4333333333333, 0.25
68364, 1.02, 1.4666666666667, 0.25
68365, 1.04, 1.4666666666667, 0.22916666666667
68366, 1.04, 1.45, 0.25
68367, 1.06, 1.4666666666667, 0.25
68368, 1.08, 1.4666666666667, 0.22916666666667
68369, 1.08, 1.45, 0.25
68370, 1.1, 1.4666666666667, 0.25
68371, 1.12, 1.4666666666667, 0.22916666666667
68372, 1.12, 1.45, 0.25
68373, 1.14, 1.4666666666667, 0.25
68374, 1.16, 1.4666666666667, 0.22916666666667
68375, 1.16, 1.45, 0.25
68376, 1.18, 1.4666666666667, 0.25
68377, 1.04, 1.4833333333333, 0.25
68378, 1.08, 1.4833333333333, 0.25
68379, 1.12, 1.4833333333333, 0.25
68380, 1.16, 1.4833333333333, 0.25
68381, 1.02, 1.4333333333333, 0.29166666666667
68382, 1.04, 1.4333333333333, 0.27083333333333
68383, 1.04, 1.4166666666667, 0.29166666666667
68384, 1.06, 1.4333333333333, 0.29166666666667
68385, 1.08, 1.4333333333333, 0.27083333333333
68386, 1.08, 1.4166666666667, 0.29166666666667
68387, 1.1, 1.4333333333333, 0.29166666666667
68388, 1.12, 1.4333333333333, 0.27083333333333
68389, 1.12, 1.4166666666667, 0.29166666666667
68390, 1.14, 1.4333333333333, 0.29166666666667
68391, 1.16, 1.4333333333333, 0.27083333333333
68392, 1.16, 1.4166666666667, 0.29166666666667
68393, 1.18, 1.4333333333333, 0.29166666666667
68394, 1.02, 1.4666666666667, 0.29166666666667
68395, 1.04, 1.4666666666667, 0.27083333333333
68396, 1.04, 1.45, 0.29166666666667
68397, 1.06, 1.4666666666667, 0.29166666666667
68398, 1.08, 1.4666666666667, 0.27083333333333
68399, 1.08, 1.45, 0.29166666666667
68400, 1.1, 1.4666666666667, 0.29166666666667
68401, 1.12, 1.4666666666667, 0.27083333333333
68402, 1.12, 1.45, 0.29166666666667
68403, 1.14, 1.4666666666667, 0.29166666666667
68404, 1.16, 1.4666666666667, 0.27083333333333
68405, 1.16, 1.45, 0.29166666666667
68406, 1.18, 1.4666666666667, 0.29166666666667
68407, 1.04, 1.4833333333333, 0.29166666666667
68408, 1.08, 1.4833333333333, 0.29166666666667
68409, 1.12, 1.4833333333333, 0.29166666666667
68410, 1.16, 1.4833333333333, 0.29166666666667
68411, 1.02, 1.4333333333333, 0.33333333333333
68412, 1.04, 1.4333333333333, 0.3125
68413, 1.04, 1.4166666666667, 0.33333333333333
68414, 1.06, 1.4333333333333, 0.33333333333333
68415, 1.08, 1.4333333333333, 0.3125
68416, 1.08, 1.4166666666667, 0.33333333333333
68417, 1.1, 1.4333333333333, 0.33333333333333
68418, 1.12, 1.4333333333333, 0.3125
68419, 1.12, 1.4166666666667, 0.33333333333333
68420, 1.14, 1.4333333333333, 0.33333333333333
68421, 1.16, 1.4333333333333, 0.3125
68422, 1.16, 1.4166666666667, 0.33333333333333
68423, 1.18, 1.4333333333333, 0.33333333333333
68424, 1.02, 1.4666666666667, 0.33333333333333
68425, 1.04, 1.4666666666667, 0.3125
68426, 1.04, 1.45, 0.33333333333333
68427, 1.06, 1.4666666666667, 0.33333333333333
68428, 1.08, 1.4666666666667, 0.3125
68429, 1.08, 1.45, 0.33333333333333
68430, 1.1, 1.4666666666667, 0.33333333333333
68431, 1.12, 1.4666666666667, 0.3125
68432, 1.12, 1.45, 0.33333333333333
68433, 1.14, 1.4666666666667, 0.33333333333333
68434, 1.16, 1.4666666666667, 0.3125
68435, 1.16, 1.45, 0.33333333333333
68436, 1.18, 1.4666666666667, 0.33333333333333
68437, 1.04, 1.4833333333333, 0.33333333333333
68438, 1.08, 1.4833333333333, 0.33333333333333
68439, 1.12, 1.4833333333333, 0.33333333333333
68440, 1.16, 1.4833333333333, 0.33333333333333
68441, 1.02, 1.4333333333333, 0.375
68442, 1.04, 1.4333333333333, 0.35416666666667
68443, 1.04, 1.4166666666667, 0.375
68444, 1.06, 1.4333333333333, 0.375
68445, 1.08, 1.4333333333333, 0.35416666666667
68446, 1.08, 1.4166666666667, 0.375
68447, 1.1, 1.4333333333333, 0.375
68448, 1.12, 1.4333333333333, 0.35416666666667
68449, 1.12, 1.4166666666667, 0.375
68450, 1.14, 1.4333333333333, 0.375
68451, 1.16, 1.4333333333333, 0.35416666666667
68452, 1.16, 1.4166666666667, 0.375
68453, 1.18, 1.4333333333333, 0.375
68454, 1.02, 1.4666666666667, 0.375
68455, 1.04, 1.4666666666667, 0.35416666666667
68456, 1.04, 1.45, 0.375
68457, 1.06, 1.4666666666667, 0.375
68458, 1.08, 1.4666666666667, 0.35416666666667
68459, 1.08, 1.45, 0.375
68460, 1.1, 1.4666666666667, 0.375
68461, 1.12, 1.4666666666667, 0.35416666666667
68462, 1.12, 1.45, 0.375
68463, 1.14, 1.4666666666667, 0.375
68464, 1.16, 1.4666666666667, 0.35416666666667
68465, 1.16, 1.45, 0.375
68466, 1.18, 1.4666666666667, 0.375
68467, 1.04, 1.4833333333333, 0.375
68468, 1.08, 1.4833333333333, 0.375
68469, 1.12, 1.4833333333333, 0.375
68470, 1.16, 1.4833333333333, 0.375
68471, 1.02, 1.4333333333333, 0.41666666666667
68472, 1.04, 1.4333333333333, 0.39583333333333
68473, 1.04, 1.4166666666667, 0.41666666666667
68474, 1.06, 1.4333333333333, 0.41666666666667
68475, 1.08, 1.4333333333333, 0.39583333333333
68476, 1.08, 1.4166666666667, 0.41666666666667
68477, 1.1, 1.4333333333333, 0.41666666666667
68478, 1.12, 1.4333333333333, 0.39583333333333
68479, 1.12, 1.4166666666667, 0.41666666666667
68480, 1.14, 1.4333333333333, 0.41666666666667
68481, 1.16, 1.4333333333333, 0.39583333333333
68482, 1.16, 1.4166666666667, 0.41666666666667
68483, 1.18, 1.4333333333333, 0.41666666666667
68484, 1.02, 1.4666666666667, 0.41666666666667
68485, 1.04, 1.4666666666667, 0.39583333333333
68486, 1.04, 1.45, 0.41666666666667
68487, 1.06, 1.4666666666667, 0.41666666666667
68488, 1.08, 1.4666666666667, 0.39583333333333
68489, 1.08, 1.45, 0.41666666666667
68490, 1.1, 1.4666666666667, 0.41666666666667
68491, 1.12, 1.4666666666667, 0.39583333333333
68492, 1.12, 1.45, 0.41666666666667
68493, 1.14, 1.4666666666667, 0.41666666666667
68494, 1.16, 1.4666666666667, 0.39583333333333
68495, 1.16, 1.45, 0.41666666666667
68496, 1.18, 1.4666666666667, 0.41666666666667
68497, 1.04, 1.4833333333333, 0.41666666666667
68498, 1.08, 1.4833333333333, 0.41666666666667
68499, 1.12, 1.4833333333333, 0.41666666666667
68500, 1.16, 1.4833333333333, 0.41666666666667
68501, 1.02, 1.4333333333333, 0.45833333333333
68502, 1.04, 1.4333333333333, 0.4375
68503, 1.04, 1.4166666666667, 0.45833333333333
68504, 1.06, 1.4333333333333, 0.45833333333333
68505, 1.08, 1.4333333333333, 0.4375
68506, 1.08, 1.4166666666667, 0.45833333333333
68507, 1.1, 1.4333333333333, 0.45833333333333
68508, 1.12, 1.4333333333333, 0.4375
68509, 1.12, 1.4166666666667, 0.45833333333333
68510, 1.14, 1.4333333333333, 0.45833333333333
68511, 1.16, 1.4333333333333, 0.4375
68512, 1.16, 1.4166666666667, 0.45833333333333
68513, 1.18, 1.4333333333333, 0.45833333333333
68514, 1.02, 1.4666666666667, 0.45833333333333
68515, 1.04, 1.4666666666667, 0.4375
68516, 1.04, 1.45, 0.45833333333333
68517, 1.06, 1.4666666666667, 0.45833333333333
68518, 1.08, 1.4666666666667, 0.4375
68519, 1.08, 1.45, 0.45833333333333
68520, 1.1, 1.4666666666667, 0.45833333333333
68521, 1.12, 1.4666666666667, 0.4375
68522, 1.12, 1.45, 0.45833333333333
68523, 1.14, 1.4666666666667, 0.45833333333333
68524, 1.16, 1.4666666666667, 0.4375
68525, 1.16, 1.45, 0.45833333333333
68526, 1.18, 1.4666666666667, 0.45833333333333
68527, 1.04, 1.4833333333333, 0.45833333333333
68528, 1.08, 1.4833333333333, 0.45833333333333
68529, 1.12, 1.4833333333333, 0.45833333333333
68530, 1.16, 1.4833333333333, 0.45833333333333
68531, 1.04, 1.4333333333333, 0.47916666666667
68532, 1.08, 1.4333333333333, 0.47916666666667
68533, 1.12, 1.4333333333333, 0.47916666666667
68534, 1.16, 1.4333333333333, 0.47916666666667
68535, 1.04, 1.4666666666667, 0.47916666666667
68536, 1.08, 1.4666666666667, 0.47916666666667
68537, 1.12, 1.4666666666667, 0.47916666666667
68538, 1.16, 1.4666666666667, 0.47916666666667
68539, 1.2416666666667, 1.4333333333333, 0.041666666666667
68540, 1.2833333333333, 1.4333333333333, 0.041666666666667
68541, 1.325, 1.4333333333333, 0.041666666666667
68542, 1.3666666666667, 1.4333333333333, 0.041666666666667
68543, 1.4083333333333, 1.4333333333333, 0.041666666666667
68544, 1.45, 1.4333333333333, 0.041666666666667
68545, 1.4916666666667, 1.4333333333333, 0.041666666666667
68546, 1.5333333333333, 1.4333333333333, 0.041666666666667
68547, 1.575, 1.4333333333333, 0.041666666666667
68548, 1.6166666666667, 1.4333333333333, 0.041666666666667
68549, 1.6583333333333, 1.4333333333333, 0.041666666666667
68550, 1.7, 1.4333333333333, 0.041666666666667
68551, 1.7416666666667, 1.4333333333333, 0.041666666666667
68552, 1.7833333333333, 1.4333333333333, 0.041666666666667
68553, 1.825, 1.4333333333333, 0.041666666666667
68554, 1.8666666666667, 1.4333333333333, 0.041666666666667
68555, 1.9083333333333, 1.4333333333333, 0.041666666666667
68556, 1.95, 1.4333333333333, 0.041666666666667
68557, 1.9916666666667, 1.4333333333333, 0.041666666666667
68558, 2.0333333333333, 1.4333333333333, 0.041666666666667
68559, 2.075, 1.4333333333333, 0.041666666666667
68560, 2.1166666666667, 1.4333333333333, 0.041666666666667
68561, 2.1583333333333, 1.4333333333333, 0.041666666666667
68562, 1.2416666666667, 1.4666666666667, 0.041666666666667
68563, 1.2833333333333, 1.4666666666667, 0.041666666666667
68564, 1.325, 1.4666666666667, 0.041666666666667
68565, 1.3666666666667, 1.4666666666667, 0.041666666666667
68566, 1.4083333333333, 1.4666666666667, 0.041666666666667
68567, 1.45, 1.4666666666667, 0.041666666666667
68568, 1.4916666666667, 1.4666666666667, 0.041666666666667
68569, 1.5333333333333, 1.4666666666667, 0.041666666666667
68570, 1.575, 1.4666666666667, 0.041666666666667
68571, 1.6166666666667, 1.4666666666667, 0.041666666666667
68572, 1.6583333333333, 1.4666666666667, 0.041666666666667
68573, 1.7, 1.4666666666667, 0.041666666666667
68574, 1.7416666666667, 1.4666666666667, 0.041666666666667
68575, 1.7833333333333, 1.4666666666667, 0.041666666666667
68576, 1.825, 1.4666666666667, 0.041666666666667
68577, 1.8666666666667, 1.4666666666667, 0.041666666666667
68578, 1.9083333333333, 1.4666666666667, 0.041666666666667
68579, 1.95, 1.4666666666667, 0.041666666666667
68580, 1.9916666666667, 1.4666666666667, 0.041666666666667
68581, 2.0333333333333, 1.4666666666667, 0.041666666666667
68582, 2.075, 1.4666666666667, 0.041666666666667
68583, 2.1166666666667, 1.4666666666667, 0.041666666666667
68584, 2.1583333333333, 1.4666666666667, 0.041666666666667
68585, 1.2416666666667, 1.4333333333333, 0.083333333333333
68586, 1.2833333333333, 1.4333333333333, 0.083333333333333
68587, 1.325, 1.4333333333333, 0.083333333333333
68588, 1.3666666666667, 1.4333333333333, 0.083333333333333
68589, 1.4083333333333, 1.4333333333333, 0.083333333333333
68590, 1.45, 1.4333333333333, 0.083333333333333
68591, 1.4916666666667, 1.4333333333333, 0.083333333333333
68592, 1.5333333333333, 1.4333333333333, 0.083333333333333
68593, 1.575, 1.4333333333333, 0.083333333333333
68594, 1.6166666666667, 1.4333333333333, 0.083333333333333
68595, 1.6583333333333, 1.4333333333333, 0.083333333333333
68596, 1.7, 1.4333333333333, 0.083333333333333
68597, 1.7416666666667, 1.4333333333333, 0.083333333333333
68598, 1.7833333333333, 1.4333333333333, 0.083333333333333
68599, 1.825, 1.4333333333333, 0.083333333333333
68600, 1.8666666666667, 1.4333333333333, 0.083333333333333
68601, 1.9083333333333, 1.4333333333333, 0.083333333333333
68602, 1.95, 1.4333333333333, 0.083333333333333
68603, 1.9916666666667, 1.4333333333333, 0.083333333333333
68604, 2.0333333333333, 1.4333333333333, 0.083333333333333
68605, 2.075, 1.4333333333333, 0.083333333333333
68606, 2.1166666666667, 1.4333333333333, 0.083333333333333
68607, 2.1583333333333, 1.4333333333333, 0.083333333333333
68608, 1.2416666666667, 1.4666666666667, 0.083333333333333
68609, 1.2833333333333, 1.4666666666667, 0.083333333333333
68610, 1.325, 1.4666666666667, 0.083333333333333
68611, 1.3666666666667, 1.4666666666667, 0.083333333333333
68612, 1.4083333333333, 1.4666666666667, 0.083333333333333
68613, 1.45, 1.4666666666667, 0.083333333333333
68614, 1.4916666666667, 1.4666666666667, 0.083333333333333
68615, 1.5333333333333, 1.4666666666667, 0.083333333333333
68616, 1.575, 1.4666666666667, 0.083333333333333
68617, 1.6166666666667, 1.4666666666667, 0.083333333333333
68618, 1.6583333333333, 1.4666666666667, 0.083333333333333
68619, 1.7, 1.4666666666667, 0.083333333333333
68620, 1.7416666666667, 1.4666666666667, 0.083333333333333
68621, 1.7833333333333, 1.4666666666667, 0.083333333333333
68622, 1.825, 1.4666666666667, 0.083333333333333
68623, 1.8666666666667, 1.4666666666667, 0.083333333333333
68624, 1.9083333333333, 1.4666666666667, 0.083333333333333
68625, 1.95, 1.4666666666667, 0.083333333333333
68626, 1.9916666666667, 1.4666666666667, 0.083333333333333
68627, 2.0333333333333, 1.4666666666667, 0.083333333333333
68628, 2.075, 1.4666666666667, 0.083333333333333
68629, 2.1166666666667, 1.4666666666667, 0.083333333333333
68630, 2.1583333333333, 1.4666666666667, 0.083333333333333
68631, 1.2416666666667, 1.4333333333333, 0.125
68632, 1.2833333333333, 1.4333333333333, 0.125
68633, 1.325, 1.4333333333333, 0.125
68634, 1.3666666666667, 1.4333333333333, 0.125
68635, 1.4083333333333, 1.4333333333333, 0.125
68636, 1.45, 1.4333333333333, 0.125
68637, 1.4916666666667, 1.4333333333333, 0.125
68638, 1.5333333333333, 1.4333333333333, 0.125
68639, 1.575, 1.4333333333333, 0.125
68640, 1.6166666666667, 1.4333333333333, 0.125
68641, 1.6583333333333, 1.4333333333333, 0.125
68642, 1.7, 1.4333333333333, 0.125
68643, 1.7416666666667, 1.4333333333333, 0.125
68644, 1.7833333333333, 1.4333333333333, 0.125
68645, 1.825, 1.4333333333333, 0.125
68646, 1.8666666666667, 1.4333333333333, 0.125
68647, 1.9083333333333, 1.4333333333333, 0.125
68648, 1.95, 1.4333333333333, 0.125
68649, 1.9916666666667, 1.4333333333333, 0.125
68650, 2.0333333333333, 1.4333333333333, 0.125
68651, 2.075, 1.4333333333333, 0.125
68652, 2.1166666666667, 1.4333333333333, 0.125
68653, 2.1583333333333, 1.4333333333333, 0.125
68654, 1.2416666666667, 1.4666666666667, 0.125
68655, 1.2833333333333, 1.4666666666667, 0.125
68656, 1.325, 1.4666666666667, 0.125
68657, 1.3666666666667, 1.4666666666667, 0.125
68658, 1.4083333333333, 1.4666666666667, 0.125
68659, 1.45, 1.4666666666667, 0.125
68660, 1.4916666666667, 1.4666666666667, 0.125
68661, 1.5333333333333, 1.4666666666667, 0.125
68662, 1.575, 1.4666666666667, 0.125
68663, 1.6166666666667, 1.4666666666667, 0.125
68664, 1.6583333333333, 1.4666666666667, 0.125
68665, 1.7, 1.4666666666667, 0.125
68666, 1.7416666666667, 1.4666666666667, 0.125
68667, 1.7833333333333, 1.4666666666667, 0.125
68668, 1.825, 1.4666666666667, 0.125
68669, 1.8666666666667, 1.4666666666667, 0.125
68670, 1.9083333333333, 1.4666666666667, 0.125
68671, 1.95, 1.4666666666667, 0.125
68672, 1.9916666666667, 1.4666666666667, 0.125
68673, 2.0333333333333, 1.4666666666667, 0.125
68674, 2.075, 1.4666666666667, 0.125
68675, 2.1166666666667, 1.4666666666667, 0.125
68676, 2.1583333333333, 1.4666666666667, 0.125
68677, 1.2416666666667, 1.4333333333333, 0.16666666666667
68678, 1.2833333333333, 1.4333333333333, 0.16666666666667
68679, 1.325, 1.4333333333333, 0.16666666666667
68680, 1.3666666666667, 1.4333333333333, 0.16666666666667
68681, 1.4083333333333, 1.4333333333333, 0.16666666666667
68682, 1.45, 1.4333333333333, 0.16666666666667
68683, 1.4916666666667, 1.4333333333333, 0.16666666666667
68684, 1.5333333333333, 1.4333333333333, 0.16666666666667
68685, 1.575, 1.4333333333333, 0.16666666666667
68686, 1.6166666666667, 1.4333333333333, 0.16666666666667
68687, 1.6583333333333, 1.4333333333333, 0.16666666666667
68688, 1.7, 1.4333333333333, 0.16666666666667
68689, 1.7416666666667, 1.4333333333333, 0.16666666666667
68690, 1.7833333333333, 1.4333333333333, 0.16666666666667
68691, 1.825, 1.4333333333333, 0.16666666666667
68692, 1.8666666666667, 1.4333333333333, 0.16666666666667
68693, 1.9083333333333, 1.4333333333333, 0.16666666666667
68694, 1.95, 1.4333333333333, 0.16666666666667
68695, 1.9916666666667, 1.4333333333333, 0.16666666666667
68696, 2.0333333333333, 1.4333333333333, 0.16666666666667
68697, 2.075, 1.4333333333333, 0.16666666666667
68698, 2.1166666666667, 1.4333333333333, 0.16666666666667
68699, 2.1583333333333, 1.4333333333333, 0.16666666666667
68700, 1.2416666666667, 1.4666666666667, 0.16666666666667
68701, 1.2833333333333, 1.4666666666667, 0.16666666666667
68702, 1.325, 1.4666666666667, 0.16666666666667
68703, 1.3666666666667, 1.4666666666667, 0.16666666666667
68704, 1.4083333333333, 1.4666666666667, 0.16666666666667
68705, 1.45, 1.4666666666667, 0.16666666666667
68706, 1.4916666666667, 1.4666666666667, 0.16666666666667
68707, 1.5333333333333, 1.4666666666667, 0.16666666666667
68708, 1.575, 1.4666666666667, 0.16666666666667
68709, 1.6166666666667, 1.4666666666667, 0.16666666666667
68710, 1.6583333333333, 1.4666666666667, 0.16666666666667
68711, 1.7, 1.4666666666667, 0.16666666666667
68712, 1.7416666666667, 1.4666666666667, 0.16666666666667
68713, 1.7833333333333, 1.4666666666667, 0.16666666666667
68714, 1.825, 1.4666666666667, 0.16666666666667
68715, 1.8666666666667, 1.4666666666667, 0.16666666666667
68716, 1.9083333333333, 1.4666666666667, 0.16666666666667
68717, 1.95, 1.4666666666667, 0.16666666666667
68718, 1.9916666666667, 1.4666666666667, 0.16666666666667
68719, 2.0333333333333, 1.4666666666667, 0.16666666666667
68720, 2.075, 1.4666666666667, 0.16666666666667
68721, 2.1166666666667, 1.4666666666667, 0.16666666666667
68722, 2.1583333333333, 1.4666666666667, 0.16666666666667
68723, 1.2416666666667, 1.4333333333333, 0.20833333333333
68724, 1.2833333333333, 1.4333333333333, 0.20833333333333
68725, 1.325, 1.4333333333333, 0.20833333333333
68726, 1.3666666666667, 1.4333333333333, 0.20833333333333
68727, 1.4083333333333, 1.4333333333333, 0.20833333333333
68728, 1.45, 1.4333333333333, 0.20833333333333
68729, 1.4916666666667, 1.4333333333333, 0.20833333333333
68730, 1.5333333333333, 1.4333333333333, 0.20833333333333
68731, 1.575, 1.4333333333333, 0.20833333333333
68732, 1.6166666666667, 1.4333333333333, 0.20833333333333
68733, 1.6583333333333, 1.4333333333333, 0.20833333333333
68734, 1.7, 1.4333333333333, 0.20833333333333
68735, 1.7416666666667, 1.4333333333333, 0.20833333333333
68736, 1.7833333333333, 1.4333333333333, 0.20833333333333
68737, 1.825, 1.4333333333333, 0.20833333333333
68738, 1.8666666666667, 1.4333333333333, 0.20833333333333
68739, 1.9083333333333, 1.4333333333333, 0.20833333333333
68740, 1.95, 1.4333333333333, 0.20833333333333
68741, 1.9916666666667, 1.4333333333333, 0.20833333333333
68742, 2.0333333333333, 1.4333333333333, 0.20833333333333
68743, 2.075, 1.4333333333333, 0.20833333333333
68744, 2.1166666666667, 1.4333333333333, 0.20833333333333
68745, 2.1583333333333, 1.4333333333333, 0.20833333333333
68746, 1.2416666666667, 1.4666666666667, 0.20833333333333
68747, 1.2833333333333, 1.4666666666667, 0.20833333333333
68748, 1.325, 1.4666666666667, 0.20833333333333
68749, 1.3666666666667, 1.4666666666667, 0.20833333333333
68750, 1.4083333333333, 1.4666666666667, 0.20833333333333
68751, 1.45, 1.4666666666667, 0.20833333333333
68752, 1.4916666666667, 1.4666666666667, 0.20833333333333
68753, 1.5333333333333, 1.4666666666667, 0.20833333333333
68754, 1.575, 1.4666666666667, 0.20833333333333
68755, 1.6166666666667, 1.4666666666667, 0.20833333333333
68756, 1.6583333333333, 1.4666666666667, 0.20833333333333
68757, 1.7, 1.4666666666667, 0.20833333333333
68758, 1.7416666666667, 1.4666666666667, 0.20833333333333
68759, 1.7833333333333, 1.4666666666667, 0.20833333333333
68760, 1.825, 1.4666666666667, 0.20833333333333
68761, 1.8666666666667, 1.4666666666667, 0.20833333333333
68762, 1.9083333333333, 1.4666666666667, 0.20833333333333
68763, 1.95, 1.4666666666667, 0.20833333333333
68764, 1.9916666666667, 1.4666666666667, 0.20833333333333
68765, 2.0333333333333, 1.4666666666667, 0.20833333333333
68766, 2.075, 1.4666666666667, 0.20833333333333
68767, 2.1166666666667, 1.4666666666667, 0.20833333333333
68768, 2.1583333333333, 1.4666666666667, 0.20833333333333
68769, 1.2416666666667, 1.4333333333333, 0.25
68770, 1.2833333333333, 1.4333333333333, 0.25
68771, 1.325, 1.4333333333333, 0.25
68772, 1.3666666666667, 1.4333333333333, 0.25
68773, 1.4083333333333, 1.4333333333333, 0.25
68774, 1.45, 1.4333333333333, 0.25
68775, 1.4916666666667, 1.4333333333333, 0.25
68776, 1.5333333333333, 1.4333333333333, 0.25
68777, 1.575, 1.4333333333333, 0.25
68778, 1.6166666666667, 1.4333333333333, 0.25
68779, 1.6583333333333, 1.4333333333333, 0.25
68780, 1.7, 1.4333333333333, 0.25
68781, 1.7416666666667, 1.4333333333333, 0.25
68782, 1.7833333333333, 1.4333333333333, 0.25
68783, 1.825, 1.4333333333333, 0.25
68784, 1.8666666666667, 1.4333333333333, 0.25
68785, 1.9083333333333, 1.4333333333333, 0.25
68786, 1.95, 1.4333333333333, 0.25
68787, 1.9916666666667, 1.4333333333333, 0.25
68788, 2.0333333333333, 1.4333333333333, 0.25
68789, 2.075, 1.4333333333333, 0.25
68790, 2.1166666666667, 1.4333333333333, 0.25
68791, 2.1583333333333, 1.4333333333333, 0.25
68792, 1.2416666666667, 1.4666666666667, 0.25
68793, 1.2833333333333, 1.4666666666667, 0.25
68794, 1.325, 1.4666666666667, 0.25
68795, 1.3666666666667, 1.4666666666667, 0.25
68796, 1.4083333333333, 1.4666666666667, 0.25
68797, 1.45, 1.4666666666667, 0.25
68798, 1.4916666666667, 1.4666666666667, 0.25
68799, 1.5333333333333, 1.4666666666667, 0.25
68800, 1.575, 1.4666666666667, 0.25
68801, 1.6166666666667, 1.4666666666667, 0.25
68802, 1.6583333333333, 1.4666666666667, 0.25
68803, 1.7, 1.4666666666667, 0.25
68804, 1.7416666666667, 1.4666666666667, 0.25
68805, 1.7833333333333, 1.4666666666667, 0.25
68806, 1.825, 1.4666666666667, 0.25
68807, 1.8666666666667, 1.4666666666667, 0.25
68808, 1.9083333333333, 1.4666666666667, 0.25
68809, 1.95, 1.4666666666667, 0.25
68810, 1.9916666666667, 1.4666666666667, 0.25
68811, 2.0333333333333, 1.4666666666667, 0.25
68812, 2.075, 1.4666666666667, 0.25
68813, 2.1166666666667, 1.4666666666667, 0.25
68814, 2.1583333333333, 1.4666666666667, 0.25
68815, 1.2416666666667, 1.4333333333333, 0.29166666666667
68816, 1.2833333333333, 1.4333333333333, 0.29166666666667
68817, 1.325, 1.4333333333333, 0.29166666666667
68818, 1.3666666666667, 1.4333333333333, 0.29166666666667
68819, 1.4083333333333, 1.4333333333333, 0.29166666666667
68820, 1.45, 1.4333333333333, 0.29166666666667
68821, 1.4916666666667, 1.4333333333333, 0.29166666666667
68822, 1.5333333333333, 1.4333333333333, 0.29166666666667
68823, 1.575, 1.4333333333333, 0.29166666666667
68824, 1.6166666666667, 1.4333333333333, 0.29166666666667
68825, 1.6583333333333, 1.4333333333333, 0.29166666666667
68826, 1.7, 1.4333333333333, 0.29166666666667
68827, 1.7416666666667, 1.4333333333333, 0.29166666666667
68828, 1.7833333333333, 1.4333333333333, 0.29166666666667
68829, 1.825, 1.4333333333333, 0.29166666666667
68830, 1.8666666666667, 1.4333333333333, 0.29166666666667
68831, 1.9083333333333, 1.4333333333333, 0.29166666666667
68832, 1.95, 1.4333333333333, 0.29166666666667
68833, 1.9916666666667, 1.4333333333333, 0.29166666666667
68834, 2.0333333333333, 1.4333333333333, 0.29166666666667
68835, 2.075, 1.4333333333333, 0.29166666666667
68836, 2.1166666666667, 1.4333333333333, 0.29166666666667
68837, 2.1583333333333, 1.4333333333333, 0.29166666666667
68838, 1.2416666666667, 1.4666666666667, 0.29166666666667
68839, 1.2833333333333, 1.4666666666667, 0.29166666666667
68840, 1.325, 1.4666666666667, 0.29166666666667
68841, 1.3666666666667, 1.4666666666667, 0.29166666666667
68842, 1.4083333333333, 1.4666666666667, 0.29166666666667
68843, 1.45, 1.4666666666667, 0.29166666666667
68844, 1.4916666666667, 1.4666666666667, 0.29166666666667
68845, 1.5333333333333, 1.4666666666667, 0.29166666666667
68846, 1.575, 1.4666666666667, 0.29166666666667
68847, 1.6166666666667, 1.4666666666667, 0.29166666666667
68848, 1.6583333333333, 1.4666666666667, 0.29166666666667
68849, 1.7, 1.4666666666667, 0.29166666666667
68850, 1.7416666666667, 1.4666666666667, 0.29166666666667
68851, 1.7833333333333, 1.4666666666667, 0.29166666666667
68852, 1.825, 1.4666666666667, 0.29166666666667
68853, 1.8666666666667, 1.4666666666667, 0.29166666666667
68854, 1.9083333333333, 1.4666666666667, 0.29166666666667
68855, 1.95, 1.4666666666667, 0.29166666666667
68856, 1.9916666666667, 1.4666666666667, 0.29166666666667
68857, 2.0333333333333, 1.4666666666667, 0.29166666666667
68858, 2.075, 1.4666666666667, 0.29166666666667
68859, 2.1166666666667, 1.4666666666667, 0.29166666666667
68860, 2.1583333333333, 1.4666666666667, 0.29166666666667
68861, 1.2416666666667, 1.4333333333333, 0.33333333333333
68862, 1.2833333333333, 1.4333333333333, 0.33333333333333
68863, 1.325, 1.4333333333333, 0.33333333333333
68864, 1.3666666666667, 1.4333333333333, 0.33333333333333
68865, 1.4083333333333, 1.4333333333333, 0.33333333333333
68866, 1.45, 1.4333333333333, 0.33333333333333
68867, 1.4916666666667, 1.4333333333333, 0.33333333333333
68868, 1.5333333333333, 1.4333333333333, 0.33333333333333
68869, 1.575, 1.4333333333333, 0.33333333333333
68870, 1.6166666666667, 1.4333333333333, 0.33333333333333
68871, 1.6583333333333, 1.4333333333333, 0.33333333333333
68872, 1.7, 1.4333333333333, 0.33333333333333
68873, 1.7416666666667, 1.4333333333333, 0.33333333333333
68874, 1.7833333333333, 1.4333333333333, 0.33333333333333
68875, 1.825, 1.4333333333333, 0.33333333333333
68876, 1.8666666666667, 1.4333333333333, 0.33333333333333
68877, 1.9083333333333, 1.4333333333333, 0.33333333333333
68878, 1.95, 1.4333333333333, 0.33333333333333
68879, 1.9916666666667, 1.4333333333333, 0.33333333333333
68880, 2.0333333333333, 1.4333333333333, 0.33333333333333
68881, 2.075, 1.4333333333333, 0.33333333333333
68882, 2.1166666666667, 1.4333333333333, 0.33333333333333
68883, 2.1583333333333, 1.4333333333333, 0.33333333333333
68884, 1.2416666666667, 1.4666666666667, 0.33333333333333
68885, 1.2833333333333, 1.4666666666667, 0.33333333333333
68886, 1.325, 1.4666666666667, 0.33333333333333
68887, 1.3666666666667, 1.4666666666667, 0.33333333333333
68888, 1.4083333333333, 1.4666666666667, 0.33333333333333
68889, 1.45, 1.4666666666667, 0.33333333333333
68890, 1.4916666666667, 1.4666666666667, 0.33333333333333
68891, 1.5333333333333, 1.4666666666667, 0.33333333333333
68892, 1.575, 1.4666666666667, 0.33333333333333
68893, 1.6166666666667, 1.4666666666667, 0.33333333333333
68894, 1.6583333333333, 1.4666666666667, 0.33333333333333
68895, 1.7, 1.4666666666667, 0.33333333333333
68896, 1.7416666666667, 1.4666666666667, 0.33333333333333
68897, 1.7833333333333, 1.4666666666667, 0.33333333333333
68898, 1.825, 1.4666666666667, 0.33333333333333
68899, 1.8666666666667, 1.4666666666667, 0.33333333333333
68900, 1.9083333333333, 1.4666666666667, 0.33333333333333
68901, 1.95, 1.4666666666667, 0.33333333333333
68902, 1.9916666666667, 1.4666666666667, 0.33333333333333
68903, 2.0333333333333, 1.4666666666667, 0.33333333333333
68904, 2.075, 1.4666666666667, 0.33333333333333
68905, 2.1166666666667, 1.4666666666667, 0.33333333333333
68906, 2.1583333333333, 1.4666666666667, 0.33333333333333
68907, 1.2416666666667, 1.4333333333333, 0.375
68908, 1.2833333333333, 1.4333333333333, 0.375
68909, 1.325, 1.4333333333333, 0.375
68910, 1.3666666666667, 1.4333333333333, 0.375
68911, 1.4083333333333, 1.4333333333333, 0.375
68912, 1.45, 1.4333333333333, 0.375
68913, 1.4916666666667, 1.4333333333333, 0.375
68914, 1.5333333333333, 1.4333333333333, 0.375
68915, 1.575, 1.4333333333333, 0.375
68916, 1.6166666666667, 1.4333333333333, 0.375
68917, 1.6583333333333, 1.4333333333333, 0.375
68918, 1.7, 1.4333333333333, 0.375
68919, 1.7416666666667, 1.4333333333333, 0.375
68920, 1.7833333333333, 1.4333333333333, 0.375
68921, 1.825, 1.4333333333333, 0.375
68922, 1.8666666666667, 1.4333333333333, 0.375
68923, 1.9083333333333, 1.4333333333333, 0.375
68924, 1.95, 1.4333333333333, 0.375
68925, 1.9916666666667, 1.4333333333333, 0.375
68926, 2.0333333333333, 1.4333333333333, 0.375
68927, 2.075, 1.4333333333333, 0.375
68928, 2.1166666666667, 1.4333333333333, 0.375
68929, 2.1583333333333, 1.4333333333333, 0.375
68930, 1.2416666666667, 1.4666666666667, 0.375
68931, 1.2833333333333, 1.4666666666667, 0.375
68932, 1.325, 1.4666666666667, 0.375
68933, 1.3666666666667, 1.4666666666667, 0.375
68934, 1.4083333333333, 1.4666666666667, 0.375
68935, 1.45, 1.4666666666667, 0.375
68936, 1.4916666666667, 1.4666666666667, 0.375
68937, 1.5333333333333, 1.4666666666667, 0.375
68938, 1.575, 1.4666666666667, 0.375
68939, 1.6166666666667, 1.4666666666667, 0.375
68940, 1.6583333333333, 1.4666666666667, 0.375
68941, 1.7, 1.4666666666667, 0.375
68942, 1.7416666666667, 1.4666666666667, 0.375
68943, 1.7833333333333, 1.4666666666667, 0.375
68944, 1.825, 1.4666666666667, 0.375
68945, 1.8666666666667, 1.4666666666667, 0.375
68946, 1.9083333333333, 1.4666666666667, 0.375
68947, 1.95, 1.4666666666667, 0.375
68948, 1.9916666666667, 1.4666666666667, 0.375
68949, 2.0333333333333, 1.4666666666667, 0.375
68950, 2.075, 1.4666666666667, 0.375
68951, 2.1166666666667, 1.4666666666667, 0.375
68952, 2.1583333333333, 1.4666666666667, 0.375
68953, 1.2416666666667, 1.4333333333333, 0.41666666666667
68954, 1.2833333333333, 1.4333333333333, 0.41666666666667
68955, 1.325, 1.4333333333333, 0.41666666666667
68956, 1.3666666666667, 1.4333333333333, 0.41666666666667
68957, 1.4083333333333, 1.4333333333333, 0.41666666666667
68958, 1.45, 1.4333333333333, 0.41666666666667
68959, 1.4916666666667, 1.4333333333333, 0.41666666666667
68960, 1.5333333333333, 1.4333333333333, 0.41666666666667
68961, 1.575, 1.4333333333333, 0.41666666666667
68962, 1.6166666666667, 1.4333333333333, 0.41666666666667
68963, 1.6583333333333, 1.4333333333333, 0.41666666666667
68964, 1.7, 1.4333333333333, 0.41666666666667
68965, 1.7416666666667, 1.4333333333333, 0.41666666666667
68966, 1.7833333333333, 1.4333333333333, 0.41666666666667
68967, 1.825, 1.4333333333333, 0.41666666666667
68968, 1.8666666666667, 1.4333333333333, 0.41666666666667
68969, 1.9083333333333, 1.4333333333333, 0.41666666666667
68970, 1.95, 1.4333333333333, 0.41666666666667
68971, 1.9916666666667, 1.4333333333333, 0.41666666666667
68972, 2.0333333333333, 1.4333333333333, 0.41666666666667
68973, 2.075, 1.4333333333333, 0.41666666666667
68974, 2.1166666666667, 1.4333333333333, 0.41666666666667
68975, 2.1583333333333, 1.4333333333333, 0.41666666666667
68976, 1.2416666666667, 1.4666666666667, 0.41666666666667
68977, 1.2833333333333, 1.4666666666667, 0.41666666666667
68978, 1.325, 1.4666666666667, 0.41666666666667
68979, 1.3666666666667, 1.4666666666667, 0.41666666666667
68980, 1.4083333333333, 1.4666666666667, 0.41666666666667
68981, 1.45, 1.4666666666667, 0.41666666666667
68982, 1.4916666666667, 1.4666666666667, 0.41666666666667
68983, 1.5333333333333, 1.4666666666667, 0.41666666666667
68984, 1.575, 1.4666666666667, 0.41666666666667
68985, 1.6166666666667, 1.4666666666667, 0.41666666666667
68986, 1.6583333333333, 1.4666666666667, 0.41666666666667
68987, 1.7, 1.4666666666667, 0.41666666666667
68988, 1.7416666666667, 1.4666666666667, 0.41666666666667
68989, 1.7833333333333, 1.4666666666667, 0.41666666666667
68990, 1.825, 1.4666666666667, 0.41666666666667
68991, 1.8666666666667, 1.4666666666667, 0.41666666666667
68992, 1.9083333333333, 1.4666666666667, 0.41666666666667
68993, 1.95, 1.4666666666667, 0.41666666666667
68994, 1.9916666666667, 1.4666666666667, 0.41666666666667
68995, 2.0333333333333, 1.4666666666667, 0.41666666666667
68996, 2.075, 1.4666666666667, 0.41666666666667
68997, 2.1166666666667, 1.4666666666667, 0.41666666666667
68998, 2.1583333333333, 1.4666666666667, 0.41666666666667
68999, 1.2416666666667, 1.4333333333333, 0.45833333333333
69000, 1.2833333333333, 1.4333333333333, 0.45833333333333
69001, 1.325, 1.4333333333333, 0.45833333333333
69002, 1.3666666666667, 1.4333333333333, 0.45833333333333
69003, 1.4083333333333, 1.4333333333333, 0.45833333333333
69004, 1.45, 1.4333333333333, 0.45833333333333
69005, 1.4916666666667, 1.4333333333333, 0.45833333333333
69006, 1.5333333333333, 1.4333333333333, 0.45833333333333
69007, 1.575, 1.4333333333333, 0.45833333333333
69008, 1.6166666666667, 1.4333333333333, 0.45833333333333
69009, 1.6583333333333, 1.4333333333333, 0.45833333333333
69010, 1.7, 1.4333333333333, 0.45833333333333
69011, 1.7416666666667, 1.4333333333333, 0.45833333333333
69012, 1.7833333333333, 1.4333333333333, 0.45833333333333
69013, 1.825, 1.4333333333333, 0.45833333333333
69014, 1.8666666666667, 1.4333333333333, 0.45833333333333
69015, 1.9083333333333, 1.4333333333333, 0.45833333333333
69016, 1.95, 1.4333333333333, 0.45833333333333
69017, 1.9916666666667, 1.4333333333333, 0.45833333333333
69018, 2.0333333333333, 1.4333333333333, 0.45833333333333
69019, 2.075, 1.4333333333333, 0.45833333333333
69020, 2.1166666666667, 1.4333333333333, 0.45833333333333
69021, 2.1583333333333, 1.4333333333333, 0.45833333333333
69022, 1.2416666666667, 1.4666666666667, 0.45833333333333
69023, 1.2833333333333, 1.4666666666667, 0.45833333333333
69024, 1.325, 1.4666666666667, 0.45833333333333
69025, 1.3666666666667, 1.4666666666667, 0.45833333333333
69026, 1.4083333333333, 1.4666666666667, 0.45833333333333
69027, 1.45, 1.4666666666667, 0.45833333333333
69028, 1.4916666666667, 1.4666666666667, 0.45833333333333
69029, 1.5333333333333, 1.4666666666667, 0.45833333333333
69030, 1.575, 1.4666666666667, 0.45833333333333
69031, 1.6166666666667, 1.4666666666667, 0.45833333333333
69032, 1.6583333333333, 1.4666666666667, 0.45833333333333
69033, 1.7, 1.4666666666667, 0.45833333333333
69034, 1.7416666666667, 1.4666666666667, 0.45833333333333
69035, 1.7833333333333, 1.4666666666667, 0.45833333333333
69036, 1.825, 1.4666666666667, 0.45833333333333
69037, 1.8666666666667, 1.4666666666667, 0.45833333333333
69038, 1.9083333333333, 1.4666666666667, 0.45833333333333
69039, 1.95, 1.4666666666667, 0.45833333333333
69040, 1.9916666666667, 1.4666666666667, 0.45833333333333
69041, 2.0333333333333, 1.4666666666667, 0.45833333333333
69042, 2.075, 1.4666666666667, 0.45833333333333
69043, 2.1166666666667, 1.4666666666667, 0.45833333333333
69044, 2.1583333333333, 1.4666666666667, 0.45833333333333
69045, 1.2208333333333, 1.4333333333333, 0.041666666666667
69046, 1.2416666666667, 1.4333333333333, 0.020833333333333
69047, 1.2416666666667, 1.4166666666667, 0.041666666666667
69048, 1.2625, 1.4333333333333, 0.041666666666667
69049, 1.2833333333333, 1.4333333333333, 0.020833333333333
69050, 1.2833333333333, 1.4166666666667, 0.041666666666667
69051, 1.3041666666667, 1.4333333333333, 0.041666666666667
69052, 1.325, 1.4333333333333, 0.020833333333333
69053, 1.325, 1.4166666666667, 0.041666666666667
69054, 1.3458333333333, 1.4333333333333, 0.041666666666667
69055, 1.3666666666667, 1.4333333333333, 0.020833333333333
69056, 1.3666666666667, 1.4166666666667, 0.041666666666667
69057, 1.3875, 1.4333333333333, 0.041666666666667
69058, 1.4083333333333, 1.4333333333333, 0.020833333333333
69059, 1.4083333333333, 1.4166666666667, 0.041666666666667
69060, 1.4291666666667, 1.4333333333333, 0.041666666666667
69061, 1.45, 1.4333333333333, 0.020833333333333
69062, 1.45, 1.4166666666667, 0.041666666666667
69063, 1.4708333333333, 1.4333333333333, 0.041666666666667
69064, 1.4916666666667, 1.4333333333333, 0.020833333333333
69065, 1.4916666666667, 1.4166666666667, 0.041666666666667
69066, 1.5125, 1.4333333333333, 0.041666666666667
69067, 1.5333333333333, 1.4333333333333, 0.020833333333333
69068, 1.5333333333333, 1.4166666666667, 0.041666666666667
69069, 1.5541666666667, 1.4333333333333, 0.041666666666667
69070, 1.575, 1.4333333333333, 0.020833333333333
69071, 1.575, 1.4166666666667, 0.041666666666667
69072, 1.5958333333333, 1.4333333333333, 0.041666666666667
69073, 1.6166666666667, 1.4333333333333, 0.020833333333333
69074, 1.6166666666667, 1.4166666666667, 0.041666666666667
69075, 1.6375, 1.4333333333333, 0.041666666666667
69076, 1.6583333333333, 1.4333333333333, 0.020833333333333
69077, 1.6583333333333, 1.4166666666667, 0.041666666666667
69078, 1.6791666666667, 1.4333333333333, 0.041666666666667
69079, 1.7, 1.4333333333333, 0.020833333333333
69080, 1.7, 1.4166666666667, 0.041666666666667
69081, 1.7208333333333, 1.4333333333333, 0.041666666666667
69082, 1.7416666666667, 1.4333333333333, 0.020833333333333
69083, 1.7416666666667, 1.4166666666667, 0.041666666666667
69084, 1.7625, 1.4333333333333, 0.041666666666667
69085, 1.7833333333333, 1.4333333333333, 0.020833333333333
69086, 1.7833333333333, 1.4166666666667, 0.041666666666667
69087, 1.8041666666667, 1.4333333333333, 0.041666666666667
69088, 1.825, 1.4333333333333, 0.020833333333333
69089, 1.825, 1.4166666666667, 0.041666666666667
69090, 1.8458333333333, 1.4333333333333, 0.041666666666667
69091, 1.8666666666667, 1.4333333333333, 0.020833333333333
69092, 1.8666666666667, 1.4166666666667, 0.041666666666667
69093, 1.8875, 1.4333333333333, 0.041666666666667
69094, 1.9083333333333, 1.4333333333333, 0.020833333333333
69095, 1.9083333333333, 1.4166666666667, 0.041666666666667
69096, 1.9291666666667, 1.4333333333333, 0.041666666666667
69097, 1.95, 1.4333333333333, 0.020833333333333
69098, 1.95, 1.4166666666667, 0.041666666666667
69099, 1.9708333333333, 1.4333333333333, 0.041666666666667
69100, 1.9916666666667, 1.4333333333333, 0.020833333333333
69101, 1.9916666666667, 1.4166666666667, 0.041666666666667
69102, 2.0125, 1.4333333333333, 0.041666666666667
69103, 2.0333333333333, 1.4333333333333, 0.020833333333333
69104, 2.0333333333333, 1.4166666666667, 0.041666666666667
69105, 2.0541666666667, 1.4333333333333, 0.041666666666667
69106, 2.075, 1.4333333333333, 0.020833333333333
69107, 2.075, 1.4166666666667, 0.041666666666667
69108, 2.0958333333333, 1.4333333333333, 0.041666666666667
69109, 2.1166666666667, 1.4333333333333, 0.020833333333333
69110, 2.1166666666667, 1.4166666666667, 0.041666666666667
69111, 2.1375, 1.4333333333333, 0.041666666666667
69112, 2.1583333333333, 1.4333333333333, 0.020833333333333
69113, 2.1583333333333, 1.4166666666667, 0.041666666666667
69114, 2.1791666666667, 1.4333333333333, 0.041666666666667
69115, 1.2208333333333, 1.4666666666667, 0.041666666666667
69116, 1.2416666666667, 1.4666666666667, 0.020833333333333
69117, 1.2416666666667, 1.45, 0.041666666666667
69118, 1.2625, 1.4666666666667, 0.041666666666667
69119, 1.2833333333333, 1.4666666666667, 0.020833333333333
69120, 1.2833333333333, 1.45, 0.041666666666667
69121, 1.3041666666667, 1.4666666666667, 0.041666666666667
69122, 1.325, 1.4666666666667, 0.020833333333333
69123, 1.325, 1.45, 0.041666666666667
69124, 1.3458333333333, 1.4666666666667, 0.041666666666667
69125, 1.3666666666667, 1.4666666666667, 0.020833333333333
69126, 1.3666666666667, 1.45, 0.041666666666667
69127, 1.3875, 1.4666666666667, 0.041666666666667
69128, 1.4083333333333, 1.4666666666667, 0.020833333333333
69129, 1.4083333333333, 1.45, 0.041666666666667
69130, 1.4291666666667, 1.4666666666667, 0.041666666666667
69131, 1.45, 1.4666666666667, 0.020833333333333
69132, 1.45, 1.45, 0.041666666666667
69133, 1.4708333333333, 1.4666666666667, 0.041666666666667
69134, 1.4916666666667, 1.4666666666667, 0.020833333333333
69135, 1.4916666666667, 1.45, 0.041666666666667
69136, 1.5125, 1.4666666666667, 0.041666666666667
69137, 1.5333333333333, 1.4666666666667, 0.020833333333333
69138, 1.5333333333333, 1.45, 0.041666666666667
69139, 1.5541666666667, 1.4666666666667, 0.041666666666667
69140, 1.575, 1.4666666666667, 0.020833333333333
69141, 1.575, 1.45, 0.041666666666667
69142, 1.5958333333333, 1.4666666666667, 0.041666666666667
69143, 1.6166666666667, 1.4666666666667, 0.020833333333333
69144, 1.6166666666667, 1.45, 0.041666666666667
69145, 1.6375, 1.4666666666667, 0.041666666666667
69146, 1.6583333333333, 1.4666666666667, 0.020833333333333
69147, 1.6583333333333, 1.45, 0.041666666666667
69148, 1.6791666666667, 1.4666666666667, 0.041666666666667
69149, 1.7, 1.4666666666667, 0.020833333333333
69150, 1.7, 1.45, 0.041666666666667
69151, 1.7208333333333, 1.4666666666667, 0.041666666666667
69152, 1.7416666666667, 1.4666666666667, 0.020833333333333
69153, 1.7416666666667, 1.45, 0.041666666666667
69154, 1.7625, 1.4666666666667, 0.041666666666667
69155, 1.7833333333333, 1.4666666666667, 0.020833333333333
69156, 1.7833333333333, 1.45, 0.041666666666667
69157, 1.8041666666667, 1.4666666666667, 0.041666666666667
69158, 1.825, 1.4666666666667, 0.020833333333333
69159, 1.825, 1.45, 0.041666666666667
69160, 1.8458333333333, 1.4666666666667, 0.041666666666667
69161, 1.8666666666667, 1.4666666666667, 0.020833333333333
69162, 1.8666666666667, 1.45, 0.041666666666667
69163, 1.8875, 1.4666666666667, 0.041666666666667
69164, 1.9083333333333, 1.4666666666667, 0.020833333333333
69165, 1.9083333333333, 1.45, 0.041666666666667
69166, 1.9291666666667, 1.4666666666667, 0.041666666666667
69167, 1.95, 1.4666666666667, 0.020833333333333
69168, 1.95, 1.45, 0.041666666666667
69169, 1.9708333333333, 1.4666666666667, 0.041666666666667
69170, 1.9916666666667, 1.4666666666667, 0.020833333333333
69171, 1.9916666666667, 1.45, 0.041666666666667
69172, 2.0125, 1.4666666666667, 0.041666666666667
69173, 2.0333333333333, 1.4666666666667, 0.020833333333333
69174, 2.0333333333333, 1.45, 0.041666666666667
69175, 2.0541666666667, 1.4666666666667, 0.041666666666667
69176, 2.075, 1.4666666666667, 0.020833333333333
69177, 2.075, 1.45, 0.041666666666667
69178, 2.0958333333333, 1.4666666666667, 0.041666666666667
69179, 2.1166666666667, 1.4666666666667, 0.020833333333333
69180, 2.1166666666667, 1.45, 0.041666666666667
69181, 2.1375, 1.4666666666667, 0.041666666666667
69182, 2.1583333333333, 1.4666666666667, 0.020833333333333
69183, 2.1583333333333, 1.45, 0.041666666666667
69184, 2.1791666666667, 1.4666666666667, 0.041666666666667
69185, 1.2416666666667, 1.4833333333333, 0.041666666666667
69186, 1.2833333333333, 1.4833333333333, 0.041666666666667
69187, 1.325, 1.4833333333333, 0.041666666666667
69188, 1.3666666666667, 1.4833333333333, 0.041666666666667
69189, 1.4083333333333, 1.4833333333333, 0.041666666666667
69190, 1.45, 1.4833333333333, 0.041666666666667
69191, 1.4916666666667, 1.4833333333333, 0.041666666666667
69192, 1.5333333333333, 1.4833333333333, 0.041666666666667
69193, 1.575, 1.4833333333333, 0.041666666666667
69194, 1.6166666666667, 1.4833333333333, 0.041666666666667
69195, 1.6583333333333, 1.4833333333333, 0.041666666666667
69196, 1.7, 1.4833333333333, 0.041666666666667
69197, 1.7416666666667, 1.4833333333333, 0.041666666666667
69198, 1.7833333333333, 1.4833333333333, 0.041666666666667
69199, 1.825, 1.4833333333333, 0.041666666666667
69200, 1.8666666666667, 1.4833333333333, 0.041666666666667
69201, 1.9083333333333, 1.4833333333333, 0.041666666666667
69202, 1.95, 1.4833333333333, 0.041666666666667
69203, 1.9916666666667, 1.4833333333333, 0.041666666666667
69204, 2.0333333333333, 1.4833333333333, 0.041666666666667
69205, 2.075, 1.4833333333333, 0.041666666666667
69206, 2.1166666666667, 1.4833333333333, 0.041666666666667
69207, 2.1583333333333, 1.4833333333333, 0.041666666666667
69208, 1.2208333333333, 1.4333333333333, 0.083333333333333
69209, 1.2416666666667, 1.4333333333333, 0.0625
69210, 1.2416666666667, 1.4166666666667, 0.083333333333333
69211, 1.2625, 1.4333333333333, 0.083333333333333
69212, 1.2833333333333, 1.4333333333333, 0.0625
69213, 1.2833333333333, 1.4166666666667, 0.083333333333333
69214, 1.3041666666667, 1.4333333333333, 0.083333333333333
69215, 1.325, 1.4333333333333, 0.0625
69216, 1.325, 1.4166666666667, 0.083333333333333
69217, 1.3458333333333, 1.4333333333333, 0.083333333333333
69218, 1.3666666666667, 1.4333333333333, 0.0625
69219, 1.3666666666667, 1.4166666666667, 0.083333333333333
69220, 1.3875, 1.4333333333333, 0.083333333333333
69221, 1.4083333333333, 1.4333333333333, 0.0625
69222, 1.4083333333333, 1.4166666666667, 0.083333333333333
69223, 1.4291666666667, 1.4333333333333, 0.083333333333333
69224, 1.45, 1.4333333333333, 0.0625
69225, 1.45, 1.4166666666667, 0.083333333333333
69226, 1.4708333333333, 1.4333333333333, 0.083333333333333
69227, 1.4916666666667, 1.4333333333333, 0.0625
69228, 1.4916666666667, 1.4166666666667, 0.083333333333333
69229, 1.5125, 1.4333333333333, 0.083333333333333
69230, 1.5333333333333, 1.4333333333333, 0.0625
69231, 1.5333333333333, 1.4166666666667, 0.083333333333333
69232, 1.5541666666667, 1.4333333333333, 0.083333333333333
69233, 1.575, 1.4333333333333, 0.0625
69234, 1.575, 1.4166666666667, 0.083333333333333
69235, 1.5958333333333, 1.4333333333333, 0.083333333333333
69236, 1.6166666666667, 1.4333333333333, 0.0625
69237, 1.6166666666667, 1.4166666666667, 0.083333333333333
69238, 1.6375, 1.4333333333333, 0.083333333333333
69239, 1.6583333333333, 1.4333333333333, 0.0625
69240, 1.6583333333333, 1.4166666666667, 0.083333333333333
69241, 1.6791666666667, 1.4333333333333, 0.083333333333333
69242, 1.7, 1.4333333333333, 0.0625
69243, 1.7, 1.4166666666667, 0.083333333333333
69244, 1.7208333333333, 1.4333333333333, 0.083333333333333
69245, 1.7416666666667, 1.4333333333333, 0.0625
69246, 1.7416666666667, 1.4166666666667, 0.083333333333333
69247, 1.7625, 1.4333333333333, 0.083333333333333
69248, 1.7833333333333, 1.4333333333333, 0.0625
69249, 1.7833333333333, 1.4166666666667, 0.083333333333333
69250, 1.8041666666667, 1.4333333333333, 0.083333333333333
69251, 1.825, 1.4333333333333, 0.0625
69252, 1.825, 1.4166666666667, 0.083333333333333
69253, 1.8458333333333, 1.4333333333333, 0.083333333333333
69254, 1.8666666666667, 1.4333333333333, 0.0625
69255, 1.8666666666667, 1.4166666666667, 0.083333333333333
69256, 1.8875, 1.4333333333333, 0.083333333333333
69257, 1.9083333333333, 1.4333333333333, 0.0625
69258, 1.9083333333333, 1.4166666666667, 0.083333333333333
69259, 1.9291666666667, 1.4333333333333, 0.083333333333333
69260, 1.95, 1.4333333333333, 0.0625
69261, 1.95, 1.4166666666667, 0.083333333333333
69262, 1.9708333333333, 1.4333333333333, 0.083333333333333
69263, 1.9916666666667, 1.4333333333333, 0.0625
69264, 1.9916666666667, 1.4166666666667, 0.083333333333333
69265, 2.0125, 1.4333333333333, 0.083333333333333
69266, 2.0333333333333, 1.4333333333333, 0.0625
69267, 2.0333333333333, 1.4166666666667, 0.083333333333333
69268, 2.0541666666667, 1.4333333333333, 0.083333333333333
69269, 2.075, 1.4333333333333, 0.0625
69270, 2.075, 1.4166666666667, 0.083333333333333
69271, 2.0958333333333, 1.4333333333333, 0.083333333333333
69272, 2.1166666666667, 1.4333333333333, 0.0625
69273, 2.1166666666667, 1.4166666666667, 0.083333333333333
69274, 2.1375, 1.4333333333333, 0.083333333333333
69275, 2.1583333333333, 1.4333333333333, 0.0625
69276, 2.1583333333333, 1.4166666666667, 0.083333333333333
69277, 2.1791666666667, 1.4333333333333, 0.083333333333333
69278, 1.2208333333333, 1.4666666666667, 0.083333333333333
69279, 1.2416666666667, 1.4666666666667, 0.0625
69280, 1.2416666666667, 1.45, 0.083333333333333
69281, 1.2625, 1.4666666666667, 0.083333333333333
69282, 1.2833333333333, 1.4666666666667, 0.0625
69283, 1.2833333333333, 1.45, 0.083333333333333
69284, 1.3041666666667, 1.4666666666667, 0.083333333333333
69285, 1.325, 1.4666666666667, 0.0625
69286, 1.325, 1.45, 0.083333333333333
69287, 1.3458333333333, 1.4666666666667, 0.083333333333333
69288, 1.3666666666667, 1.4666666666667, 0.0625
69289, 1.3666666666667, 1.45, 0.083333333333333
69290, 1.3875, 1.4666666666667, 0.083333333333333
69291, 1.4083333333333, 1.4666666666667, 0.0625
69292, 1.4083333333333, 1.45, 0.083333333333333
69293, 1.4291666666667, 1.4666666666667, 0.083333333333333
69294, 1.45, 1.4666666666667, 0.0625
69295, 1.45, 1.45, 0.083333333333333
69296, 1.4708333333333, 1.4666666666667, 0.083333333333333
69297, 1.4916666666667, 1.4666666666667, 0.0625
69298, 1.4916666666667, 1.45, 0.083333333333333
69299, 1.5125, 1.4666666666667, 0.083333333333333
69300, 1.5333333333333, 1.4666666666667, 0.0625
69301, 1.5333333333333, 1.45, 0.083333333333333
69302, 1.5541666666667, 1.4666666666667, 0.083333333333333
69303, 1.575, 1.4666666666667, 0.0625
69304, 1.575, 1.45, 0.083333333333333
69305, 1.5958333333333, 1.4666666666667, 0.083333333333333
69306, 1.6166666666667, 1.4666666666667, 0.0625
69307, 1.6166666666667, 1.45, 0.083333333333333
69308, 1.6375, 1.4666666666667, 0.083333333333333
69309, 1.6583333333333, 1.4666666666667, 0.0625
69310, 1.6583333333333, 1.45, 0.083333333333333
69311, 1.6791666666667, 1.4666666666667, 0.083333333333333
69312, 1.7, 1.4666666666667, 0.0625
69313, 1.7, 1.45, 0.083333333333333
69314, 1.7208333333333, 1.4666666666667, 0.083333333333333
69315, 1.7416666666667, 1.4666666666667, 0.0625
69316, 1.7416666666667, 1.45, 0.083333333333333
69317, 1.7625, 1.4666666666667, 0.083333333333333
69318, 1.7833333333333, 1.4666666666667, 0.0625
69319, 1.7833333333333, 1.45, 0.083333333333333
69320, 1.8041666666667, 1.4666666666667, 0.083333333333333
69321, 1.825, 1.4666666666667, 0.0625
69322, 1.825, 1.45, 0.083333333333333
69323, 1.8458333333333, 1.4666666666667, 0.083333333333333
69324, 1.8666666666667, 1.4666666666667, 0.0625
69325, 1.8666666666667, 1.45, 0.083333333333333
69326, 1.8875, 1.4666666666667, 0.083333333333333
69327, 1.9083333333333, 1.4666666666667, 0.0625
69328, 1.9083333333333, 1.45, 0.083333333333333
69329, 1.9291666666667, 1.4666666666667, 0.083333333333333
69330, 1.95, 1.4666666666667, 0.0625
69331, 1.95, 1.45, 0.083333333333333
69332, 1.9708333333333, 1.4666666666667, 0.083333333333333
69333, 1.9916666666667, 1.4666666666667, 0.0625
69334, 1.9916666666667, 1.45, 0.083333333333333
69335, 2.0125, 1.4666666666667, 0.083333333333333
69336, 2.0333333333333, 1.4666666666667, 0.0625
69337, 2.0333333333333, 1.45, 0.083333333333333
69338, 2.0541666666667, 1.4666666666667, 0.083333333333333
69339, 2.075, 1.4666666666667, 0.0625
69340, 2.075, 1.45, 0.083333333333333
69341, 2.0958333333333, 1.4666666666667, 0.083333333333333
69342, 2.1166666666667, 1.4666666666667, 0.0625
69343, 2.1166666666667, 1.45, 0.083333333333333
69344, 2.1375, 1.4666666666667, 0.083333333333333
69345, 2.1583333333333, 1.4666666666667, 0.0625
69346, 2.1583333333333, 1.45, 0.083333333333333
69347, 2.1791666666667, 1.4666666666667, 0.083333333333333
69348, 1.2416666666667, 1.4833333333333, 0.083333333333333
69349, 1.2833333333333, 1.4833333333333, 0.083333333333333
69350, 1.325, 1.4833333333333, 0.083333333333333
69351, 1.3666666666667, 1.4833333333333, 0.083333333333333
69352, 1.4083333333333, 1.4833333333333, 0.083333333333333
69353, 1.45, 1.4833333333333, 0.083333333333333
69354, 1.4916666666667, 1.4833333333333, 0.083333333333333
69355, 1.5333333333333, 1.4833333333333, 0.083333333333333
69356, 1.575, 1.4833333333333, 0.083333333333333
69357, 1.6166666666667, 1.4833333333333, 0.083333333333333
69358, 1.6583333333333, 1.4833333333333, 0.083333333333333
69359, 1.7, 1.4833333333333, 0.083333333333333
69360, 1.7416666666667, 1.4833333333333, 0.083333333333333
69361, 1.7833333333333, 1.4833333333333, 0.083333333333333
69362, 1.825, 1.4833333333333, 0.083333333333333
69363, 1.8666666666667, 1.4833333333333, 0.083333333333333
69364, 1.9083333333333, 1.4833333333333, 0.083333333333333
69365, 1.95, 1.4833333333333, 0.083333333333333
69366, 1.9916666666667, 1.4833333333333, 0.083333333333333
69367, 2.0333333333333, 1.4833333333333, 0.083333333333333
69368, 2.075, 1.4833333333333, 0.083333333333333
69369, 2.1166666666667, 1.4833333333333, 0.083333333333333
69370, 2.1583333333333, 1.4833333333333, 0.083333333333333
69371, 1.2208333333333, 1.4333333333333, 0.125
69372, 1.2416666666667, 1.4333333333333, 0.10416666666667
69373, 1.2416666666667, 1.4166666666667, 0.125
69374, 1.2625, 1.4333333333333, 0.125
69375, 1.2833333333333, 1.4333333333333, 0.10416666666667
69376, 1.2833333333333, 1.4166666666667, 0.125
69377, 1.3041666666667, 1.4333333333333, 0.125
69378, 1.325, 1.4333333333333, 0.10416666666667
69379, 1.325, 1.4166666666667, 0.125
69380, 1.3458333333333, 1.4333333333333, 0.125
69381, 1.3666666666667, 1.4333333333333, 0.10416666666667
69382, 1.3666666666667, 1.4166666666667, 0.125
69383, 1.3875, 1.4333333333333, 0.125
69384, 1.4083333333333, 1.4333333333333, 0.10416666666667
69385, 1.4083333333333, 1.4166666666667, 0.125
69386, 1.4291666666667, 1.4333333333333, 0.125
69387, 1.45, 1.4333333333333, 0.10416666666667
69388, 1.45, 1.4166666666667, 0.125
69389, 1.4708333333333, 1.4333333333333, 0.125
69390, 1.4916666666667, 1.4333333333333, 0.10416666666667
69391, 1.4916666666667, 1.4166666666667, 0.125
69392, 1.5125, 1.4333333333333, 0.125
69393, 1.5333333333333, 1.4333333333333, 0.10416666666667
69394, 1.5333333333333, 1.4166666666667, 0.125
69395, 1.5541666666667, 1.4333333333333, 0.125
69396, 1.575, 1.4333333333333, 0.10416666666667
69397, 1.575, 1.4166666666667, 0.125
69398, 1.5958333333333, 1.4333333333333, 0.125
69399, 1.6166666666667, 1.4333333333333, 0.10416666666667
69400, 1.6166666666667, 1.4166666666667, 0.125
69401, 1.6375, 1.4333333333333, 0.125
69402, 1.6583333333333, 1.4333333333333, 0.10416666666667
69403, 1.6583333333333, 1.4166666666667, 0.125
69404, 1.6791666666667, 1.4333333333333, 0.125
69405, 1.7, 1.4333333333333, 0.10416666666667
69406, 1.7, 1.4166666666667, 0.125
69407, 1.7208333333333, 1.4333333333333, 0.125
69408, 1.7416666666667, 1.4333333333333, 0.10416666666667
69409, 1.7416666666667, 1.4166666666667, 0.125
69410, 1.7625, 1.4333333333333, 0.125
69411, 1.7833333333333, 1.4333333333333, 0.10416666666667
69412, 1.7833333333333, 1.4166666666667, 0.125
69413, 1.8041666666667, 1.4333333333333, 0.125
69414, 1.825, 1.4333333333333, 0.10416666666667
69415, 1.825, 1.4166666666667, 0.125
69416, 1.8458333333333, 1.4333333333333, 0.125
69417, 1.8666666666667, 1.4333333333333, 0.10416666666667
69418, 1.8666666666667, 1.4166666666667, 0.125
69419, 1.8875, 1.4333333333333, 0.125
69420, 1.9083333333333, 1.4333333333333, 0.10416666666667
69421, 1.9083333333333, 1.4166666666667, 0.125
69422, 1.9291666666667, 1.4333333333333, 0.125
69423, 1.95, 1.4333333333333, 0.10416666666667
69424, 1.95, 1.4166666666667, 0.125
69425, 1.9708333333333, 1.4333333333333, 0.125
69426, 1.9916666666667, 1.4333333333333, 0.10416666666667
69427, 1.9916666666667, 1.4166666666667, 0.125
69428, 2.0125, 1.4333333333333, 0.125
69429, 2.0333333333333, 1.4333333333333, 0.10416666666667
69430, 2.0333333333333, 1.4166666666667, 0.125
69431, 2.0541666666667, 1.4333333333333, 0.125
69432, 2.075, 1.4333333333333, 0.10416666666667
69433, 2.075, 1.4166666666667, 0.125
69434, 2.0958333333333, 1.4333333333333, 0.125
69435, 2.1166666666667, 1.4333333333333, 0.10416666666667
69436, 2.1166666666667, 1.4166666666667, 0.125
69437, 2.1375, 1.4333333333333, 0.125
69438, 2.1583333333333, 1.4333333333333, 0.10416666666667
69439, 2.1583333333333, 1.4166666666667, 0.125
69440, 2.1791666666667, 1.4333333333333, 0.125
69441, 1.2208333333333, 1.4666666666667, 0.125
69442, 1.2416666666667, 1.4666666666667, 0.10416666666667
69443, 1.2416666666667, 1.45, 0.125
69444, 1.2625, 1.4666666666667, 0.125
69445, 1.2833333333333, 1.4666666666667, 0.10416666666667
69446, 1.2833333333333, 1.45, 0.125
69447, 1.3041666666667, 1.4666666666667, 0.125
69448, 1.325, 1.4666666666667, 0.10416666666667
69449, 1.325, 1.45, 0.125
69450, 1.3458333333333, 1.4666666666667, 0.125
69451, 1.3666666666667, 1.4666666666667, 0.10416666666667
69452, 1.3666666666667, 1.45, 0.125
69453, 1.3875, 1.4666666666667, 0.125
69454, 1.4083333333333, 1.4666666666667, 0.10416666666667
69455, 1.4083333333333, 1.45, 0.125
69456, 1.4291666666667, 1.4666666666667, 0.125
69457, 1.45, 1.4666666666667, 0.10416666666667
69458, 1.45, 1.45, 0.125
69459, 1.4708333333333, 1.4666666666667, 0.125
69460, 1.4916666666667, 1.4666666666667, 0.10416666666667
69461, 1.4916666666667, 1.45, 0.125
69462, 1.5125, 1.4666666666667, 0.125
69463, 1.5333333333333, 1.4666666666667, 0.10416666666667
69464, 1.5333333333333, 1.45, 0.125
69465, 1.5541666666667, 1.4666666666667, 0.125
69466, 1.575, 1.4666666666667, 0.10416666666667
69467, 1.575, 1.45, 0.125
69468, 1.5958333333333, 1.4666666666667, 0.125
69469, 1.6166666666667, 1.4666666666667, 0.10416666666667
69470, 1.6166666666667, 1.45, 0.125
69471, 1.6375, 1.4666666666667, 0.125
69472, 1.6583333333333, 1.4666666666667, 0.10416666666667
69473, 1.6583333333333, 1.45, 0.125
69474, 1.6791666666667, 1.4666666666667, 0.125
69475, 1.7, 1.4666666666667, 0.10416666666667
69476, 1.7, 1.45, 0.125
69477, 1.7208333333333, 1.4666666666667, 0.125
69478, 1.7416666666667, 1.4666666666667, 0.10416666666667
69479, 1.7416666666667, 1.45, 0.125
69480, 1.7625, 1.4666666666667, 0.125
69481, 1.7833333333333, 1.4666666666667, 0.10416666666667
69482, 1.7833333333333, 1.45, 0.125
69483, 1.8041666666667, 1.4666666666667, 0.125
69484, 1.825, 1.4666666666667, 0.10416666666667
69485, 1.825, 1.45, 0.125
69486, 1.8458333333333, 1.4666666666667, 0.125
69487, 1.8666666666667, 1.4666666666667, 0.10416666666667
69488, 1.8666666666667, 1.45, 0.125
69489, 1.8875, 1.4666666666667, 0.125
69490, 1.9083333333333, 1.4666666666667, 0.10416666666667
69491, 1.9083333333333, 1.45, 0.125
69492, 1.9291666666667, 1.4666666666667, 0.125
69493, 1.95, 1.4666666666667, 0.10416666666667
69494, 1.95, 1.45, 0.125
69495, 1.9708333333333, 1.4666666666667, 0.125
69496, 1.9916666666667, 1.4666666666667, 0.10416666666667
69497, 1.9916666666667, 1.45, 0.125
69498, 2.0125, 1.4666666666667, 0.125
69499, 2.0333333333333, 1.4666666666667, 0.10416666666667
69500, 2.0333333333333, 1.45, 0.125
69501, 2.0541666666667, 1.4666666666667, 0.125
69502, 2.075, 1.4666666666667, 0.10416666666667
69503, 2.075, 1.45, 0.125
69504, 2.0958333333333, 1.4666666666667, 0.125
69505, 2.1166666666667, 1.4666666666667, 0.10416666666667
69506, 2.1166666666667, 1.45, 0.125
69507, 2.1375, 1.4666666666667, 0.125
69508, 2.1583333333333, 1.4666666666667, 0.10416666666667
69509, 2.1583333333333, 1.45, 0.125
69510, 2.1791666666667, 1.4666666666667, 0.125
69511, 1.2416666666667, 1.4833333333333, 0.125
69512, 1.2833333333333, 1.4833333333333, 0.125
69513, 1.325, 1.4833333333333, 0.125
69514, 1.3666666666667, 1.4833333333333, 0.125
69515, 1.4083333333333, 1.4833333333333, 0.125
69516, 1.45, 1.4833333333333, 0.125
69517, 1.4916666666667, 1.4833333333333, 0.125
69518, 1.5333333333333, 1.4833333333333, 0.125
69519, 1.575, 1.4833333333333, 0.125
69520, 1.6166666666667, 1.4833333333333, 0.125
69521, 1.6583333333333, 1.4833333333333, 0.125
69522, 1.7, 1.4833333333333, 0.125
69523, 1.7416666666667, 1.4833333333333, 0.125
69524, 1.7833333333333, 1.4833333333333, 0.125
69525, 1.825, 1.4833333333333, 0.125
69526, 1.8666666666667, 1.4833333333333, 0.125
69527, 1.9083333333333, 1.4833333333333, 0.125
69528, 1.95, 1.4833333333333, 0.125
69529, 1.9916666666667, 1.4833333333333, 0.125
69530, 2.0333333333333, 1.4833333333333, 0.125
69531, 2.075, 1.4833333333333, 0.125
69532, 2.1166666666667, 1.4833333333333, 0.125
69533, 2.1583333333333, 1.4833333333333, 0.125
69534, 1.2208333333333, 1.4333333333333, 0.16666666666667
69535, 1.2416666666667, 1.4333333333333, 0.14583333333333
69536, 1.2416666666667, 1.4166666666667, 0.16666666666667
69537, 1.2625, 1.4333333333333, 0.16666666666667
69538, 1.2833333333333, 1.4333333333333, 0.14583333333333
69539, 1.2833333333333, 1.4166666666667, 0.16666666666667
69540, 1.3041666666667, 1.4333333333333, 0.16666666666667
69541, 1.325, 1.4333333333333, 0.14583333333333
69542, 1.325, 1.4166666666667, 0.16666666666667
69543, 1.3458333333333, 1.4333333333333, 0.16666666666667
69544, 1.3666666666667, 1.4333333333333, 0.14583333333333
69545, 1.3666666666667, 1.4166666666667, 0.16666666666667
69546, 1.3875, 1.4333333333333, 0.16666666666667
69547, 1.4083333333333, 1.4333333333333, 0.14583333333333
69548, 1.4083333333333, 1.4166666666667, 0.16666666666667
69549, 1.4291666666667, 1.4333333333333, 0.16666666666667
69550, 1.45, 1.4333333333333, 0.14583333333333
69551, 1.45, 1.4166666666667, 0.16666666666667
69552, 1.4708333333333, 1.4333333333333, 0.16666666666667
69553, 1.4916666666667, 1.4333333333333, 0.14583333333333
69554, 1.4916666666667, 1.4166666666667, 0.16666666666667
69555, 1.5125, 1.4333333333333, 0.16666666666667
69556, 1.5333333333333, 1.4333333333333, 0.14583333333333
69557, 1.5333333333333, 1.4166666666667, 0.16666666666667
69558, 1.5541666666667, 1.4333333333333, 0.16666666666667
69559, 1.575, 1.4333333333333, 0.14583333333333
69560, 1.575, 1.4166666666667, 0.16666666666667
69561, 1.5958333333333, 1.4333333333333, 0.16666666666667
69562, 1.6166666666667, 1.4333333333333, 0.14583333333333
69563, 1.6166666666667, 1.4166666666667, 0.16666666666667
69564, 1.6375, 1.4333333333333, 0.16666666666667
69565, 1.6583333333333, 1.4333333333333, 0.14583333333333
69566, 1.6583333333333, 1.4166666666667, 0.16666666666667
69567, 1.6791666666667, 1.4333333333333, 0.16666666666667
69568, 1.7, 1.4333333333333, 0.14583333333333
69569, 1.7, 1.4166666666667, 0.16666666666667
69570, 1.7208333333333, 1.4333333333333, 0.16666666666667
69571, 1.7416666666667, 1.4333333333333, 0.14583333333333
69572, 1.7416666666667, 1.4166666666667, 0.16666666666667
69573, 1.7625, 1.4333333333333, 0.16666666666667
69574, 1.7833333333333, 1.4333333333333, 0.14583333333333
69575, 1.7833333333333, 1.4166666666667, 0.16666666666667
69576, 1.8041666666667, 1.4333333333333, 0.16666666666667
69577, 1.825, 1.4333333333333, 0.14583333333333
69578, 1.825, 1.4166666666667, 0.16666666666667
69579, 1.8458333333333, 1.4333333333333, 0.16666666666667
69580, 1.8666666666667, 1.4333333333333, 0.14583333333333
69581, 1.8666666666667, 1.4166666666667, 0.16666666666667
69582, 1.8875, 1.4333333333333, 0.16666666666667
69583, 1.9083333333333, 1.4333333333333, 0.14583333333333
69584, 1.9083333333333, 1.4166666666667, 0.16666666666667
69585, 1.9291666666667, 1.4333333333333, 0.16666666666667
69586, 1.95, 1.4333333333333, 0.14583333333333
69587, 1.95, 1.4166666666667, 0.16666666666667
69588, 1.9708333333333, 1.4333333333333, 0.16666666666667
69589, 1.9916666666667, 1.4333333333333, 0.14583333333333
69590, 1.9916666666667, 1.4166666666667, 0.16666666666667
69591, 2.0125, 1.4333333333333, 0.16666666666667
69592, 2.0333333333333, 1.4333333333333, 0.14583333333333
69593, 2.0333333333333, 1.4166666666667, 0.16666666666667
69594, 2.0541666666667, 1.4333333333333, 0.16666666666667
69595, 2.075, 1.4333333333333, 0.14583333333333
69596, 2.075, 1.4166666666667, 0.16666666666667
69597, 2.0958333333333, 1.4333333333333, 0.16666666666667
69598, 2.1166666666667, 1.4333333333333, 0.14583333333333
69599, 2.1166666666667, 1.4166666666667, 0.16666666666667
69600, 2.1375, 1.4333333333333, 0.16666666666667
69601, 2.1583333333333, 1.4333333333333, 0.14583333333333
69602, 2.1583333333333, 1.4166666666667, 0.16666666666667
69603, 2.1791666666667, 1.4333333333333, 0.16666666666667
69604, 1.2208333333333, 1.4666666666667, 0.16666666666667
69605, 1.2416666666667, 1.4666666666667, 0.14583333333333
69606, 1.2416666666667, 1.45, 0.16666666666667
69607, 1.2625, 1.4666666666667, 0.16666666666667
69608, 1.2833333333333, 1.4666666666667, 0.14583333333333
69609, 1.2833333333333, 1.45, 0.16666666666667
69610, 1.3041666666667, 1.4666666666667, 0.16666666666667
69611, 1.325, 1.4666666666667, 0.14583333333333
69612, 1.325, 1.45, 0.16666666666667
69613, 1.3458333333333, 1.4666666666667, 0.16666666666667
69614, 1.3666666666667, 1.4666666666667, 0.14583333333333
69615, 1.3666666666667, 1.45, 0.16666666666667
69616, 1.3875, 1.4666666666667, 0.16666666666667
69617, 1.4083333333333, 1.4666666666667, 0.14583333333333
69618, 1.4083333333333, 1.45, 0.16666666666667
69619, 1.4291666666667, 1.4666666666667, 0.16666666666667
69620, 1.45, 1.4666666666667, 0.14583333333333
69621, 1.45, 1.45, 0.16666666666667
69622, 1.4708333333333, 1.4666666666667, 0.16666666666667
69623, 1.4916666666667, 1.4666666666667, 0.14583333333333
69624, 1.4916666666667, 1.45, 0.16666666666667
69625, 1.5125, 1.4666666666667, 0.16666666666667
69626, 1.5333333333333, 1.4666666666667, 0.14583333333333
69627, 1.5333333333333, 1.45, 0.16666666666667
69628, 1.5541666666667, 1.4666666666667, 0.16666666666667
69629, 1.575, 1.4666666666667, 0.14583333333333
69630, 1.575, 1.45, 0.16666666666667
69631, 1.5958333333333, 1.4666666666667, 0.16666666666667
69632, 1.6166666666667, 1.4666666666667, 0.14583333333333
69633, 1.6166666666667, 1.45, 0.16666666666667
69634, 1.6375, 1.4666666666667, 0.16666666666667
69635, 1.6583333333333, 1.4666666666667, 0.14583333333333
69636, 1.6583333333333, 1.45, 0.16666666666667
69637, 1.6791666666667, 1.4666666666667, 0.16666666666667
69638, 1.7, 1.4666666666667, 0.14583333333333
69639, 1.7, 1.45, 0.16666666666667
69640, 1.7208333333333, 1.4666666666667, 0.16666666666667
69641, 1.7416666666667, 1.4666666666667, 0.14583333333333
69642, 1.7416666666667, 1.45, 0.16666666666667
69643, 1.7625, 1.4666666666667, 0.16666666666667
69644, 1.7833333333333, 1.4666666666667, 0.14583333333333
69645, 1.7833333333333, 1.45, 0.16666666666667
69646, 1.8041666666667, 1.4666666666667, 0.16666666666667
69647, 1.825, 1.4666666666667, 0.14583333333333
69648, 1.825, 1.45, 0.16666666666667
69649, 1.8458333333333, 1.4666666666667, 0.16666666666667
69650, 1.8666666666667, 1.4666666666667, 0.14583333333333
69651, 1.8666666666667, 1.45, 0.16666666666667
69652, 1.8875, 1.4666666666667, 0.16666666666667
69653, 1.9083333333333, 1.4666666666667, 0.14583333333333
69654, 1.9083333333333, 1.45, 0.16666666666667
69655, 1.9291666666667, 1.4666666666667, 0.16666666666667
69656, 1.95, 1.4666666666667, 0.14583333333333
69657, 1.95, 1.45, 0.16666666666667
69658, 1.9708333333333, 1.4666666666667, 0.16666666666667
69659, 1.9916666666667, 1.4666666666667, 0.14583333333333
69660, 1.9916666666667, 1.45, 0.16666666666667
69661, 2.0125, 1.4666666666667, 0.16666666666667
69662, 2.0333333333333, 1.4666666666667, 0.14583333333333
69663, 2.0333333333333, 1.45, 0.16666666666667
69664, 2.0541666666667, 1.4666666666667, 0.16666666666667
69665, 2.075, 1.4666666666667, 0.14583333333333
69666, 2.075, 1.45, 0.16666666666667
69667, 2.0958333333333, 1.4666666666667, 0.16666666666667
69668, 2.1166666666667, 1.4666666666667, 0.14583333333333
69669, 2.1166666666667, 1.45, 0.16666666666667
69670, 2.1375, 1.4666666666667, 0.16666666666667
69671, 2.1583333333333, 1.4666666666667, 0.14583333333333
69672, 2.1583333333333, 1.45, 0.16666666666667
69673, 2.1791666666667, 1.4666666666667, 0.16666666666667
69674, 1.2416666666667, 1.4833333333333, 0.16666666666667
69675, 1.2833333333333, 1.4833333333333, 0.16666666666667
69676, 1.325, 1.4833333333333, 0.16666666666667
69677, 1.3666666666667, 1.4833333333333, 0.16666666666667
69678, 1.4083333333333, 1.4833333333333, 0.16666666666667
69679, 1.45, 1.4833333333333, 0.16666666666667
69680, 1.4916666666667, 1.4833333333333, 0.16666666666667
69681, 1.5333333333333, 1.4833333333333, 0.16666666666667
69682, 1.575, 1.4833333333333, 0.16666666666667
69683, 1.6166666666667, 1.4833333333333, 0.16666666666667
69684, 1.6583333333333, 1.4833333333333, 0.16666666666667
69685, 1.7, 1.4833333333333, 0.16666666666667
69686, 1.7416666666667, 1.4833333333333, 0.16666666666667
69687, 1.7833333333333, 1.4833333333333, 0.16666666666667
69688, 1.825, 1.4833333333333, 0.16666666666667
69689, 1.8666666666667, 1.4833333333333, 0.16666666666667
69690, 1.9083333333333, 1.4833333333333, 0.16666666666667
69691, 1.95, 1.4833333333333, 0.16666666666667
69692, 1.9916666666667, 1.4833333333333, 0.16666666666667
69693, 2.0333333333333, 1.4833333333333, 0.16666666666667
69694, 2.075, 1.4833333333333, 0.16666666666667
69695, 2.1166666666667, 1.4833333333333, 0.16666666666667
69696, 2.1583333333333, 1.4833333333333, 0.16666666666667
69697, 1.2208333333333, 1.4333333333333, 0.20833333333333
69698, 1.2416666666667, 1.4333333333333, 0.1875
69699, 1.2416666666667, 1.4166666666667, 0.20833333333333
69700, 1.2625, 1.4333333333333, 0.20833333333333
69701, 1.2833333333333, 1.4333333333333, 0.1875
69702, 1.2833333333333, 1.4166666666667, 0.20833333333333
69703, 1.3041666666667, 1.4333333333333, 0.20833333333333
69704, 1.325, 1.4333333333333, 0.1875
69705, 1.325, 1.4166666666667, 0.20833333333333
69706, 1.3458333333333, 1.4333333333333, 0.20833333333333
69707, 1.3666666666667, 1.4333333333333, 0.1875
69708, 1.3666666666667, 1.4166666666667, 0.20833333333333
69709, 1.3875, 1.4333333333333, 0.20833333333333
69710, 1.4083333333333, 1.4333333333333, 0.1875
69711, 1.4083333333333, 1.4166666666667, 0.20833333333333
69712, 1.4291666666667, 1.4333333333333, 0.20833333333333
69713, 1.45, 1.4333333333333, 0.1875
69714, 1.45, 1.4166666666667, 0.20833333333333
69715, 1.4708333333333, 1.4333333333333, 0.20833333333333
69716, 1.4916666666667, 1.4333333333333, 0.1875
69717, 1.4916666666667, 1.4166666666667, 0.20833333333333
69718, 1.5125, 1.4333333333333, 0.20833333333333
69719, 1.5333333333333, 1.4333333333333, 0.1875
69720, 1.5333333333333, 1.4166666666667, 0.20833333333333
69721, 1.5541666666667, 1.4333333333333, 0.20833333333333
69722, 1.575, 1.4333333333333, 0.1875
69723, 1.575, 1.4166666666667, 0.20833333333333
69724, 1.5958333333333, 1.4333333333333, 0.20833333333333
69725, 1.6166666666667, 1.4333333333333, 0.1875
69726, 1.6166666666667, 1.4166666666667, 0.20833333333333
69727, 1.6375, 1.4333333333333, 0.20833333333333
69728, 1.6583333333333, 1.4333333333333, 0.1875
69729, 1.6583333333333, 1.4166666666667, 0.20833333333333
69730, 1.6791666666667, 1.4333333333333, 0.20833333333333
69731, 1.7, 1.4333333333333, 0.1875
69732, 1.7, 1.4166666666667, 0.20833333333333
69733, 1.7208333333333, 1.4333333333333, 0.20833333333333
69734, 1.7416666666667, 1.4333333333333, 0.1875
69735, 1.7416666666667, 1.4166666666667, 0.20833333333333
69736, 1.7625, 1.4333333333333, 0.20833333333333
69737, 1.7833333333333, 1.4333333333333, 0.1875
69738, 1.7833333333333, 1.4166666666667, 0.20833333333333
69739, 1.8041666666667, 1.4333333333333, 0.20833333333333
69740, 1.825, 1.4333333333333, 0.1875
69741, 1.825, 1.4166666666667, 0.20833333333333
69742, 1.8458333333333, 1.4333333333333, 0.20833333333333
69743, 1.8666666666667, 1.4333333333333, 0.1875
69744, 1.8666666666667, 1.4166666666667, 0.20833333333333
69745, 1.8875, 1.4333333333333, 0.20833333333333
69746, 1.9083333333333, 1.4333333333333, 0.1875
69747, 1.9083333333333, 1.4166666666667, 0.20833333333333
69748, 1.9291666666667, 1.4333333333333, 0.20833333333333
69749, 1.95, 1.4333333333333, 0.1875
69750, 1.95, 1.4166666666667, 0.20833333333333
69751, 1.9708333333333, 1.4333333333333, 0.20833333333333
69752, 1.9916666666667, 1.4333333333333, 0.1875
69753, 1.9916666666667, 1.4166666666667, 0.20833333333333
69754, 2.0125, 1.4333333333333, 0.20833333333333
69755, 2.0333333333333, 1.4333333333333, 0.1875
69756, 2.0333333333333, 1.4166666666667, 0.20833333333333
69757, 2.0541666666667, 1.4333333333333, 0.20833333333333
69758, 2.075, 1.4333333333333, 0.1875
69759, 2.075, 1.4166666666667, 0.20833333333333
69760, 2.0958333333333, 1.4333333333333, 0.20833333333333
69761, 2.1166666666667, 1.4333333333333, 0.1875
69762, 2.1166666666667, 1.4166666666667, 0.20833333333333
69763, 2.1375, 1.4333333333333, 0.20833333333333
69764, 2.1583333333333, 1.4333333333333, 0.1875
69765, 2.1583333333333, 1.4166666666667, 0.20833333333333
69766, 2.1791666666667, 1.4333333333333, 0.20833333333333
69767, 1.2208333333333, 1.4666666666667, 0.20833333333333
69768, 1.2416666666667, 1.4666666666667, 0.1875
69769, 1.2416666666667, 1.45, 0.20833333333333
69770, 1.2625, 1.4666666666667, 0.20833333333333
69771, 1.2833333333333, 1.4666666666667, 0.1875
69772, 1.2833333333333, 1.45, 0.20833333333333
69773, 1.3041666666667, 1.4666666666667, 0.20833333333333
69774, 1.325, 1.4666666666667, 0.1875
69775, 1.325, 1.45, 0.20833333333333
69776, 1.3458333333333, 1.4666666666667, 0.20833333333333
69777, 1.3666666666667, 1.4666666666667, 0.1875
69778, 1.3666666666667, 1.45, 0.20833333333333
69779, 1.3875, 1.4666666666667, 0.20833333333333
69780, 1.4083333333333, 1.4666666666667, 0.1875
69781, 1.4083333333333, 1.45, 0.20833333333333
69782, 1.4291666666667, 1.4666666666667, 0.20833333333333
69783, 1.45, 1.4666666666667, 0.1875
69784, 1.45, 1.45, 0.20833333333333
69785, 1.4708333333333, 1.4666666666667, 0.20833333333333
69786, 1.4916666666667, 1.4666666666667, 0.1875
69787, 1.4916666666667, 1.45, 0.20833333333333
69788, 1.5125, 1.4666666666667, 0.20833333333333
69789, 1.5333333333333, 1.4666666666667, 0.1875
69790, 1.5333333333333, 1.45, 0.20833333333333
69791, 1.5541666666667, 1.4666666666667, 0.20833333333333
69792, 1.575, 1.4666666666667, 0.1875
69793, 1.575, 1.45, 0.20833333333333
69794, 1.5958333333333, 1.4666666666667, 0.20833333333333
69795, 1.6166666666667, 1.4666666666667, 0.1875
69796, 1.6166666666667, 1.45, 0.20833333333333
69797, 1.6375, 1.4666666666667, 0.20833333333333
69798, 1.6583333333333, 1.4666666666667, 0.1875
69799, 1.6583333333333, 1.45, 0.20833333333333
69800, 1.6791666666667, 1.4666666666667, 0.20833333333333
69801, 1.7, 1.4666666666667, 0.1875
69802, 1.7, 1.45, 0.20833333333333
69803, 1.7208333333333, 1.4666666666667, 0.20833333333333
69804, 1.7416666666667, 1.4666666666667, 0.1875
69805, 1.7416666666667, 1.45, 0.20833333333333
69806, 1.7625, 1.4666666666667, 0.20833333333333
69807, 1.7833333333333, 1.4666666666667, 0.1875
69808, 1.7833333333333, 1.45, 0.20833333333333
69809, 1.8041666666667, 1.4666666666667, 0.20833333333333
69810, 1.825, 1.4666666666667, 0.1875
69811, 1.825, 1.45, 0.20833333333333
69812, 1.8458333333333, 1.4666666666667, 0.20833333333333
69813, 1.8666666666667, 1.4666666666667, 0.1875
69814, 1.8666666666667, 1.45, 0.20833333333333
69815, 1.8875, 1.4666666666667, 0.20833333333333
69816, 1.9083333333333, 1.4666666666667, 0.1875
69817, 1.9083333333333, 1.45, 0.20833333333333
69818, 1.9291666666667, 1.4666666666667, 0.20833333333333
69819, 1.95, 1.4666666666667, 0.1875
69820, 1.95, 1.45, 0.20833333333333
69821, 1.9708333333333, 1.4666666666667, 0.20833333333333
69822, 1.9916666666667, 1.4666666666667, 0.1875
69823, 1.9916666666667, 1.45, 0.20833333333333
69824, 2.0125, 1.4666666666667, 0.20833333333333
69825, 2.0333333333333, 1.4666666666667, 0.1875
69826, 2.0333333333333, 1.45, 0.20833333333333
69827, 2.0541666666667, 1.4666666666667, 0.20833333333333
69828, 2.075, 1.4666666666667, 0.1875
69829, 2.075, 1.45, 0.20833333333333
69830, 2.0958333333333, 1.4666666666667, 0.20833333333333
69831, 2.1166666666667, 1.4666666666667, 0.1875
69832, 2.1166666666667, 1.45, 0.20833333333333
69833, 2.1375, 1.4666666666667, 0.20833333333333
69834, 2.1583333333333, 1.4666666666667, 0.1875
69835, 2.1583333333333, 1.45, 0.20833333333333
69836, 2.1791666666667, 1.4666666666667, 0.20833333333333
69837, 1.2416666666667, 1.4833333333333, 0.20833333333333
69838, 1.2833333333333, 1.4833333333333, 0.20833333333333
69839, 1.325, 1.4833333333333, 0.20833333333333
69840, 1.3666666666667, 1.4833333333333, 0.20833333333333
69841, 1.4083333333333, 1.4833333333333, 0.20833333333333
69842, 1.45, 1.4833333333333, 0.20833333333333
69843, 1.4916666666667, 1.4833333333333, 0.20833333333333
69844, 1.5333333333333, 1.4833333333333, 0.20833333333333
69845, 1.575, 1.4833333333333, 0.20833333333333
69846, 1.6166666666667, 1.4833333333333, 0.20833333333333
69847, 1.6583333333333, 1.4833333333333, 0.20833333333333
69848, 1.7, 1.4833333333333, 0.20833333333333
69849, 1.7416666666667, 1.4833333333333, 0.20833333333333
69850, 1.7833333333333, 1.4833333333333, 0.20833333333333
69851, 1.825, 1.4833333333333, 0.20833333333333
69852, 1.8666666666667, 1.4833333333333, 0.20833333333333
69853, 1.9083333333333, 1.4833333333333, 0.20833333333333
69854, 1.95, 1.4833333333333, 0.20833333333333
69855, 1.9916666666667, 1.4833333333333, 0.20833333333333
69856, 2.0333333333333, 1.4833333333333, 0.20833333333333
69857, 2.075, 1.4833333333333, 0.20833333333333
69858, 2.1166666666667, 1.4833333333333, 0.20833333333333
69859, 2.1583333333333, 1.4833333333333, 0.20833333333333
69860, 1.2208333333333, 1.4333333333333, 0.25
69861, 1.2416666666667, 1.4333333333333, 0.22916666666667
69862, 1.2416666666667, 1.4166666666667, 0.25
69863, 1.2625, 1.4333333333333, 0.25
69864, 1.2833333333333, 1.4333333333333, 0.22916666666667
69865, 1.2833333333333, 1.4166666666667, 0.25
69866, 1.3041666666667, 1.4333333333333, 0.25
69867, 1.325, 1.4333333333333, 0.22916666666667
69868, 1.325, 1.4166666666667, 0.25
69869, 1.3458333333333, 1.4333333333333, 0.25
69870, 1.3666666666667, 1.4333333333333, 0.22916666666667
69871, 1.3666666666667, 1.4166666666667, 0.25
69872, 1.3875, 1.4333333333333, 0.25
69873, 1.4083333333333, 1.4333333333333, 0.22916666666667
69874, 1.4083333333333, 1.4166666666667, 0.25
69875, 1.4291666666667, 1.4333333333333, 0.25
69876, 1.45, 1.4333333333333, 0.22916666666667
69877, 1.45, 1.4166666666667, 0.25
69878, 1.4708333333333, 1.4333333333333, 0.25
69879, 1.4916666666667, 1.4333333333333, 0.22916666666667
69880, 1.4916666666667, 1.4166666666667, 0.25
69881, 1.5125, 1.4333333333333, 0.25
69882, 1.5333333333333, 1.4333333333333, 0.22916666666667
69883, 1.5333333333333, 1.4166666666667, 0.25
69884, 1.5541666666667, 1.4333333333333, 0.25
69885, 1.575, 1.4333333333333, 0.22916666666667
69886, 1.575, 1.4166666666667, 0.25
69887, 1.5958333333333, 1.4333333333333, 0.25
69888, 1.6166666666667, 1.4333333333333, 0.22916666666667
69889, 1.6166666666667, 1.4166666666667, 0.25
69890, 1.6375, 1.4333333333333, 0.25
69891, 1.6583333333333, 1.4333333333333, 0.22916666666667
69892, 1.6583333333333, 1.4166666666667, 0.25
69893, 1.6791666666667, 1.4333333333333, 0.25
69894, 1.7, 1.4333333333333, 0.22916666666667
69895, 1.7, 1.4166666666667, 0.25
69896, 1.7208333333333, 1.4333333333333, 0.25
69897, 1.7416666666667, 1.4333333333333, 0.22916666666667
69898, 1.7416666666667, 1.4166666666667, 0.25
69899, 1.7625, 1.4333333333333, 0.25
69900, 1.7833333333333, 1.4333333333333, 0.22916666666667
69901, 1.7833333333333, 1.4166666666667, 0.25
69902, 1.8041666666667, 1.4333333333333, 0.25
69903, 1.825, 1.4333333333333, 0.22916666666667
69904, 1.825, 1.4166666666667, 0.25
69905, 1.8458333333333, 1.4333333333333, 0.25
69906, 1.8666666666667, 1.4333333333333, 0.22916666666667
69907, 1.8666666666667, 1.4166666666667, 0.25
69908, 1.8875, 1.4333333333333, 0.25
69909, 1.9083333333333, 1.4333333333333, 0.22916666666667
69910, 1.9083333333333, 1.4166666666667, 0.25
69911, 1.9291666666667, 1.4333333333333, 0.25
69912, 1.95, 1.4333333333333, 0.22916666666667
69913, 1.95, 1.4166666666667, 0.25
69914, 1.9708333333333, 1.4333333333333, 0.25
69915, 1.9916666666667, 1.4333333333333, 0.22916666666667
69916, 1.9916666666667, 1.4166666666667, 0.25
69917, 2.0125, 1.4333333333333, 0.25
69918, 2.0333333333333, 1.4333333333333, 0.22916666666667
69919, 2.0333333333333, 1.4166666666667, 0.25
69920, 2.0541666666667, 1.4333333333333, 0.25
69921, 2.075, 1.4333333333333, 0.22916666666667
69922, 2.075, 1.4166666666667, 0.25
69923, 2.0958333333333, 1.4333333333333, 0.25
69924, 2.1166666666667, 1.4333333333333, 0.22916666666667
69925, 2.1166666666667, 1.4166666666667, 0.25
69926, 2.1375, 1.4333333333333, 0.25
69927, 2.1583333333333, 1.4333333333333, 0.22916666666667
69928, 2.1583333333333, 1.4166666666667, 0.25
69929, 2.1791666666667, 1.4333333333333, 0.25
69930, 1.2208333333333, 1.4666666666667, 0.25
69931, 1.2416666666667, 1.4666666666667, 0.22916666666667
69932, 1.2416666666667, 1.45, 0.25
69933, 1.2625, 1.4666666666667, 0.25
69934, 1.2833333333333, 1.4666666666667, 0.22916666666667
69935, 1.2833333333333, 1.45, 0.25
69936, 1.3041666666667, 1.4666666666667, 0.25
69937, 1.325, 1.4666666666667, 0.22916666666667
69938, 1.325, 1.45, 0.25
69939, 1.3458333333333, 1.4666666666667, 0.25
69940, 1.3666666666667, 1.4666666666667, 0.22916666666667
69941, 1.3666666666667, 1.45, 0.25
69942, 1.3875, 1.4666666666667, 0.25
69943, 1.4083333333333, 1.4666666666667, 0.22916666666667
69944, 1.4083333333333, 1.45, 0.25
69945, 1.4291666666667, 1.4666666666667, 0.25
69946, 1.45, 1.4666666666667, 0.22916666666667
69947, 1.45, 1.45, 0.25
69948, 1.4708333333333, 1.4666666666667, 0.25
69949, 1.4916666666667, 1.4666666666667, 0.22916666666667
69950, 1.4916666666667, 1.45, 0.25
69951, 1.5125, 1.4666666666667, 0.25
69952, 1.5333333333333, 1.4666666666667, 0.22916666666667
69953, 1.5333333333333, 1.45, 0.25
69954, 1.5541666666667, 1.4666666666667, 0.25
69955, 1.575, 1.4666666666667, 0.22916666666667
69956, 1.575, 1.45, 0.25
69957, 1.5958333333333, 1.4666666666667, 0.25
69958, 1.6166666666667, 1.4666666666667, 0.22916666666667
69959, 1.6166666666667, 1.45, 0.25
69960, 1.6375, 1.4666666666667, 0.25
69961, 1.6583333333333, 1.4666666666667, 0.22916666666667
69962, 1.6583333333333, 1.45, 0.25
69963, 1.6791666666667, 1.4666666666667, 0.25
69964, 1.7, 1.4666666666667, 0.22916666666667
69965, 1.7, 1.45, 0.25
69966, 1.7208333333333, 1.4666666666667, 0.25
69967, 1.7416666666667, 1.4666666666667, 0.22916666666667
69968, 1.7416666666667, 1.45, 0.25
69969, 1.7625, 1.4666666666667, 0.25
69970, 1.7833333333333, 1.4666666666667, 0.22916666666667
69971, 1.7833333333333, 1.45, 0.25
69972, 1.8041666666667, 1.4666666666667, 0.25
69973, 1.825, 1.4666666666667, 0.22916666666667
69974, 1.825, 1.45, 0.25
69975, 1.8458333333333, 1.4666666666667, 0.25
69976, 1.8666666666667, 1.4666666666667, 0.22916666666667
69977, 1.8666666666667, 1.45, 0.25
69978, 1.8875, 1.4666666666667, 0.25
69979, 1.9083333333333, 1.4666666666667, 0.22916666666667
69980, 1.9083333333333, 1.45, 0.25
69981, 1.9291666666667, 1.4666666666667, 0.25
69982, 1.95, 1.4666666666667, 0.22916666666667
69983, 1.95, 1.45, 0.25
69984, 1.9708333333333, 1.4666666666667, 0.25
69985, 1.9916666666667, 1.4666666666667, 0.22916666666667
69986, 1.9916666666667, 1.45, 0.25
69987, 2.0125, 1.4666666666667, 0.25
69988, 2.0333333333333, 1.4666666666667, 0.22916666666667
69989, 2.0333333333333, 1.45, 0.25
69990, 2.0541666666667, 1.4666666666667, 0.25
69991, 2.075, 1.4666666666667, 0.22916666666667
69992, 2.075, 1.45, 0.25
69993, 2.0958333333333, 1.4666666666667, 0.25
69994, 2.1166666666667, 1.4666666666667, 0.22916666666667
69995, 2.1166666666667, 1.45, 0.25
69996, 2.1375, 1.4666666666667, 0.25
69997, 2.1583333333333, 1.4666666666667, 0.22916666666667
69998, 2.1583333333333, 1.45, 0.25
69999, 2.1791666666667, 1.4666666666667, 0.25
70000, 1.2416666666667, 1.4833333333333, 0.25
70001, 1.2833333333333, 1.4833333333333, 0.25
70002, 1.325, 1.4833333333333, 0.25
70003, 1.3666666666667, 1.4833333333333, 0.25
70004, 1.4083333333333, 1.4833333333333, 0.25
70005, 1.45, 1.4833333333333, 0.25
70006, 1.4916666666667, 1.4833333333333, 0.25
70007, 1.5333333333333, 1.4833333333333, 0.25
70008, 1.575, 1.4833333333333, 0.25
70009, 1.6166666666667, 1.4833333333333, 0.25
70010, 1.6583333333333, 1.4833333333333, 0.25
70011, 1.7, 1.4833333333333, 0.25
70012, 1.7416666666667, 1.4833333333333, 0.25
70013, 1.7833333333333, 1.4833333333333, 0.25
70014, 1.825, 1.4833333333333, 0.25
70015, 1.8666666666667, 1.4833333333333, 0.25
70016, 1.9083333333333, 1.4833333333333, 0.25
70017, 1.95, 1.4833333333333, 0.25
70018, 1.9916666666667, 1.4833333333333, 0.25
70019, 2.0333333333333, 1.4833333333333, 0.25
70020, 2.075, 1.4833333333333, 0.25
70021, 2.1166666666667, 1.4833333333333, 0.25
70022, 2.1583333333333, 1.4833333333333, 0.25
70023, 1.2208333333333, 1.4333333333333, 0.29166666666667
70024, 1.2416666666667, 1.4333333333333, 0.27083333333333
70025, 1.2416666666667, 1.4166666666667, 0.29166666666667
70026, 1.2625, 1.4333333333333, 0.29166666666667
70027, 1.2833333333333, 1.4333333333333, 0.27083333333333
70028, 1.2833333333333, 1.4166666666667, 0.29166666666667
70029, 1.3041666666667, 1.4333333333333, 0.29166666666667
70030, 1.325, 1.4333333333333, 0.27083333333333
70031, 1.325, 1.4166666666667, 0.29166666666667
70032, 1.3458333333333, 1.4333333333333, 0.29166666666667
70033, 1.3666666666667, 1.4333333333333, 0.27083333333333
70034, 1.3666666666667, 1.4166666666667, 0.29166666666667
70035, 1.3875, 1.4333333333333, 0.29166666666667
70036, 1.4083333333333, 1.4333333333333, 0.27083333333333
70037, 1.4083333333333, 1.4166666666667, 0.29166666666667
70038, 1.4291666666667, 1.4333333333333, 0.29166666666667
70039, 1.45, 1.4333333333333, 0.27083333333333
70040, 1.45, 1.4166666666667, 0.29166666666667
70041, 1.4708333333333, 1.4333333333333, 0.29166666666667
70042, 1.4916666666667, 1.4333333333333, 0.27083333333333
70043, 1.4916666666667, 1.4166666666667, 0.29166666666667
70044, 1.5125, 1.4333333333333, 0.29166666666667
70045, 1.5333333333333, 1.4333333333333, 0.27083333333333
70046, 1.5333333333333, 1.4166666666667, 0.29166666666667
70047, 1.5541666666667, 1.4333333333333, 0.29166666666667
70048, 1.575, 1.4333333333333, 0.27083333333333
70049, 1.575, 1.4166666666667, 0.29166666666667
70050, 1.5958333333333, 1.4333333333333, 0.29166666666667
70051, 1.6166666666667, 1.4333333333333, 0.27083333333333
70052, 1.6166666666667, 1.4166666666667, 0.29166666666667
70053, 1.6375, 1.4333333333333, 0.29166666666667
70054, 1.6583333333333, 1.4333333333333, 0.27083333333333
70055, 1.6583333333333, 1.4166666666667, 0.29166666666667
70056, 1.6791666666667, 1.4333333333333, 0.29166666666667
70057, 1.7, 1.4333333333333, 0.27083333333333
70058, 1.7, 1.4166666666667, 0.29166666666667
70059, 1.7208333333333, 1.4333333333333, 0.29166666666667
70060, 1.7416666666667, 1.4333333333333, 0.27083333333333
70061, 1.7416666666667, 1.4166666666667, 0.29166666666667
70062, 1.7625, 1.4333333333333, 0.29166666666667
70063, 1.7833333333333, 1.4333333333333, 0.27083333333333
70064, 1.7833333333333, 1.4166666666667, 0.29166666666667
70065, 1.8041666666667, 1.4333333333333, 0.29166666666667
70066, 1.825, 1.4333333333333, 0.27083333333333
70067, 1.825, 1.4166666666667, 0.29166666666667
70068, 1.8458333333333, 1.4333333333333, 0.29166666666667
70069, 1.8666666666667, 1.4333333333333, 0.27083333333333
70070, 1.8666666666667, 1.4166666666667, 0.29166666666667
70071, 1.8875, 1.4333333333333, 0.29166666666667
70072, 1.9083333333333, 1.4333333333333, 0.27083333333333
70073, 1.9083333333333, 1.4166666666667, 0.29166666666667
70074, 1.9291666666667, 1.4333333333333, 0.29166666666667
70075, 1.95, 1.4333333333333, 0.27083333333333
70076, 1.95, 1.4166666666667, 0.29166666666667
70077, 1.9708333333333, 1.4333333333333, 0.29166666666667
70078, 1.9916666666667, 1.4333333333333, 0.27083333333333
70079, 1.9916666666667, 1.4166666666667, 0.29166666666667
70080, 2.0125, 1.4333333333333, 0.29166666666667
70081, 2.0333333333333, 1.4333333333333, 0.27083333333333
70082, 2.0333333333333, 1.4166666666667, 0.29166666666667
70083, 2.0541666666667, 1.4333333333333, 0.29166666666667
70084, 2.075, 1.4333333333333, 0.27083333333333
70085, 2.075, 1.4166666666667, 0.29166666666667
70086, 2.0958333333333, 1.4333333333333, 0.29166666666667
70087, 2.1166666666667, 1.4333333333333, 0.27083333333333
70088, 2.1166666666667, 1.4166666666667, 0.29166666666667
70089, 2.1375, 1.4333333333333, 0.29166666666667
70090, 2.1583333333333, 1.4333333333333, 0.27083333333333
70091, 2.1583333333333, 1.4166666666667, 0.29166666666667
70092, 2.1791666666667, 1.4333333333333, 0.29166666666667
70093, 1.2208333333333, 1.4666666666667, 0.29166666666667
70094, 1.2416666666667, 1.4666666666667, 0.27083333333333
70095, 1.2416666666667, 1.45, 0.29166666666667
70096, 1.2625, 1.4666666666667, 0.29166666666667
70097, 1.2833333333333, 1.4666666666667, 0.27083333333333
70098, 1.2833333333333, 1.45, 0.29166666666667
70099, 1.3041666666667, 1.4666666666667, 0.29166666666667
70100, 1.325, 1.4666666666667, 0.27083333333333
70101, 1.325, 1.45, 0.29166666666667
70102, 1.3458333333333, 1.4666666666667, 0.29166666666667
70103, 1.3666666666667, 1.4666666666667, 0.27083333333333
70104, 1.3666666666667, 1.45, 0.29166666666667
70105, 1.3875, 1.4666666666667, 0.29166666666667
70106, 1.4083333333333, 1.4666666666667, 0.27083333333333
70107, 1.4083333333333, 1.45, 0.29166666666667
70108, 1.4291666666667, 1.4666666666667, 0.29166666666667
70109, 1.45, 1.4666666666667, 0.27083333333333
70110, 1.45, 1.45, 0.29166666666667
70111, 1.4708333333333, 1.4666666666667, 0.29166666666667
70112, 1.4916666666667, 1.4666666666667, 0.27083333333333
70113, 1.4916666666667, 1.45, 0.29166666666667
70114, 1.5125, 1.4666666666667, 0.29166666666667
70115, 1.5333333333333, 1.4666666666667, 0.27083333333333
70116, 1.5333333333333, 1.45, 0.29166666666667
70117, 1.5541666666667, 1.4666666666667, 0.29166666666667
70118, 1.575, 1.4666666666667, 0.27083333333333
70119, 1.575, 1.45, 0.29166666666667
70120, 1.5958333333333, 1.4666666666667, 0.29166666666667
70121, 1.6166666666667, 1.4666666666667, 0.27083333333333
70122, 1.6166666666667, 1.45, 0.29166666666667
70123, 1.6375, 1.4666666666667, 0.29166666666667
70124, 1.6583333333333, 1.4666666666667, 0.27083333333333
70125, 1.6583333333333, 1.45, 0.29166666666667
70126, 1.6791666666667, 1.4666666666667, 0.29166666666667
70127, 1.7, 1.4666666666667, 0.27083333333333
70128, 1.7, 1.45, 0.29166666666667
70129, 1.7208333333333, 1.4666666666667, 0.29166666666667
70130, 1.7416666666667, 1.4666666666667, 0.27083333333333
70131, 1.7416666666667, 1.45, 0.29166666666667
70132, 1.7625, 1.4666666666667, 0.29166666666667
70133, 1.7833333333333, 1.4666666666667, 0.27083333333333
70134, 1.7833333333333, 1.45, 0.29166666666667
70135, 1.8041666666667, 1.4666666666667, 0.29166666666667
70136, 1.825, 1.4666666666667, 0.27083333333333
70137, 1.825, 1.45, 0.29166666666667
70138, 1.8458333333333, 1.4666666666667, 0.29166666666667
70139, 1.8666666666667, 1.4666666666667, 0.27083333333333
70140, 1.8666666666667, 1.45, 0.29166666666667
70141, 1.8875, 1.4666666666667, 0.29166666666667
70142, 1.9083333333333, 1.4666666666667, 0.27083333333333
70143, 1.9083333333333, 1.45, 0.29166666666667
70144, 1.9291666666667, 1.4666666666667, 0.29166666666667
70145, 1.95, 1.4666666666667, 0.27083333333333
70146, 1.95, 1.45, 0.29166666666667
70147, 1.9708333333333, 1.4666666666667, 0.29166666666667
70148, 1.9916666666667, 1.4666666666667, 0.27083333333333
70149, 1.9916666666667, 1.45, 0.29166666666667
70150, 2.0125, 1.4666666666667, 0.29166666666667
70151, 2.0333333333333, 1.4666666666667, 0.27083333333333
70152, 2.0333333333333, 1.45, 0.29166666666667
70153, 2.0541666666667, 1.4666666666667, 0.29166666666667
70154, 2.075, 1.4666666666667, 0.27083333333333
70155, 2.075, 1.45, 0.29166666666667
70156, 2.0958333333333, 1.4666666666667, 0.29166666666667
70157, 2.1166666666667, 1.4666666666667, 0.27083333333333
70158, 2.1166666666667, 1.45, 0.29166666666667
70159, 2.1375, 1.4666666666667, 0.29166666666667
70160, 2.1583333333333, 1.4666666666667, 0.27083333333333
70161, 2.1583333333333, 1.45, 0.29166666666667
70162, 2.1791666666667, 1.4666666666667, 0.29166666666667
70163, 1.2416666666667, 1.4833333333333, 0.29166666666667
70164, 1.2833333333333, 1.4833333333333, 0.29166666666667
70165, 1.325, 1.4833333333333, 0.29166666666667
70166, 1.3666666666667, 1.4833333333333, 0.29166666666667
70167, 1.4083333333333, 1.4833333333333, 0.29166666666667
70168, 1.45, 1.4833333333333, 0.29166666666667
70169, 1.4916666666667, 1.4833333333333, 0.29166666666667
70170, 1.5333333333333, 1.4833333333333, 0.29166666666667
70171, 1.575, 1.4833333333333, 0.29166666666667
70172, 1.6166666666667, 1.4833333333333, 0.29166666666667
70173, 1.6583333333333, 1.4833333333333, 0.29166666666667
70174, 1.7, 1.4833333333333, 0.29166666666667
70175, 1.7416666666667, 1.4833333333333, 0.29166666666667
70176, 1.7833333333333, 1.4833333333333, 0.29166666666667
70177, 1.825, 1.4833333333333, 0.29166666666667
70178, 1.8666666666667, 1.4833333333333, 0.29166666666667
70179, 1.9083333333333, 1.4833333333333, 0.29166666666667
70180, 1.95, 1.4833333333333, 0.29166666666667
70181, 1.9916666666667, 1.4833333333333, 0.29166666666667
70182, 2.0333333333333, 1.4833333333333, 0.29166666666667
70183, 2.075, 1.4833333333333, 0.29166666666667
70184, 2.1166666666667, 1.4833333333333, 0.29166666666667
70185, 2.1583333333333, 1.4833333333333, 0.29166666666667
70186, 1.2208333333333, 1.4333333333333, 0.33333333333333
70187, 1.2416666666667, 1.4333333333333, 0.3125
70188, 1.2416666666667, 1.4166666666667, 0.33333333333333
70189, 1.2625, 1.4333333333333, 0.33333333333333
70190, 1.2833333333333, 1.4333333333333, 0.3125
70191, 1.2833333333333, 1.4166666666667, 0.33333333333333
70192, 1.3041666666667, 1.4333333333333, 0.33333333333333
70193, 1.325, 1.4333333333333, 0.3125
70194, 1.325, 1.4166666666667, 0.33333333333333
70195, 1.3458333333333, 1.4333333333333, 0.33333333333333
70196, 1.3666666666667, 1.4333333333333, 0.3125
70197, 1.3666666666667, 1.4166666666667, 0.33333333333333
70198, 1.3875, 1.4333333333333, 0.33333333333333
70199, 1.4083333333333, 1.4333333333333, 0.3125
70200, 1.4083333333333, 1.4166666666667, 0.33333333333333
70201, 1.4291666666667, 1.4333333333333, 0.33333333333333
70202, 1.45, 1.4333333333333, 0.3125
70203, 1.45, 1.4166666666667, 0.33333333333333
70204, 1.4708333333333, 1.4333333333333, 0.33333333333333
70205, 1.4916666666667, 1.4333333333333, 0.3125
70206, 1.4916666666667, 1.4166666666667, 0.33333333333333
70207, 1.5125, 1.4333333333333, 0.33333333333333
70208, 1.5333333333333, 1.4333333333333, 0.3125
70209, 1.5333333333333, 1.4166666666667, 0.33333333333333
70210, 1.5541666666667, 1.4333333333333, 0.33333333333333
70211, 1.575, 1.4333333333333, 0.3125
70212, 1.575, 1.4166666666667, 0.33333333333333
70213, 1.5958333333333, 1.4333333333333, 0.33333333333333
70214, 1.6166666666667, 1.4333333333333, 0.3125
70215, 1.6166666666667, 1.4166666666667, 0.33333333333333
70216, 1.6375, 1.4333333333333, 0.33333333333333
70217, 1.6583333333333, 1.4333333333333, 0.3125
70218, 1.6583333333333, 1.4166666666667, 0.33333333333333
70219, 1.6791666666667, 1.4333333333333, 0.33333333333333
70220, 1.7, 1.4333333333333, 0.3125
70221, 1.7, 1.4166666666667, 0.33333333333333
70222, 1.7208333333333, 1.4333333333333, 0.33333333333333
70223, 1.7416666666667, 1.4333333333333, 0.3125
70224, 1.7416666666667, 1.4166666666667, 0.33333333333333
70225, 1.7625, 1.4333333333333, 0.33333333333333
70226, 1.7833333333333, 1.4333333333333, 0.3125
70227, 1.7833333333333, 1.4166666666667, 0.33333333333333
70228, 1.8041666666667, 1.4333333333333, 0.33333333333333
70229, 1.825, 1.4333333333333, 0.3125
70230, 1.825, 1.4166666666667, 0.33333333333333
70231, 1.8458333333333, 1.4333333333333, 0.33333333333333
70232, 1.8666666666667, 1.4333333333333, 0.3125
70233, 1.8666666666667, 1.4166666666667, 0.33333333333333
70234, 1.8875, 1.4333333333333, 0.33333333333333
70235, 1.9083333333333, 1.4333333333333, 0.3125
70236, 1.9083333333333, 1.4166666666667, 0.33333333333333
70237, 1.9291666666667, 1.4333333333333, 0.33333333333333
70238, 1.95, 1.4333333333333, 0.3125
70239, 1.95, 1.4166666666667, 0.33333333333333
70240, 1.9708333333333, 1.4333333333333, 0.33333333333333
70241, 1.9916666666667, 1.4333333333333, 0.3125
70242, 1.9916666666667, 1.4166666666667, 0.33333333333333
70243, 2.0125, 1.4333333333333, 0.33333333333333
70244, 2.0333333333333, 1.4333333333333, 0.3125
70245, 2.0333333333333, 1.4166666666667, 0.33333333333333
70246, 2.0541666666667, 1.4333333333333, 0.33333333333333
70247, 2.075, 1.4333333333333, 0.3125
70248, 2.075, 1.4166666666667, 0.33333333333333
70249, 2.0958333333333, 1.4333333333333, 0.33333333333333
70250, 2.1166666666667, 1.4333333333333, 0.3125
70251, 2.1166666666667, 1.4166666666667, 0.33333333333333
70252, 2.1375, 1.4333333333333, 0.33333333333333
70253, 2.1583333333333, 1.4333333333333, 0.3125
70254, 2.1583333333333, 1.4166666666667, 0.33333333333333
70255, 2.1791666666667, 1.4333333333333, 0.33333333333333
70256, 1.2208333333333, 1.4666666666667, 0.33333333333333
70257, 1.2416666666667, 1.4666666666667, 0.3125
70258, 1.2416666666667, 1.45, 0.33333333333333
70259, 1.2625, 1.4666666666667, 0.33333333333333
70260, 1.2833333333333, 1.4666666666667, 0.3125
70261, 1.2833333333333, 1.45, 0.33333333333333
70262, 1.3041666666667, 1.4666666666667, 0.33333333333333
70263, 1.325, 1.4666666666667, 0.3125
70264, 1.325, 1.45, 0.33333333333333
70265, 1.3458333333333, 1.4666666666667, 0.33333333333333
70266, 1.3666666666667, 1.4666666666667, 0.3125
70267, 1.3666666666667, 1.45, 0.33333333333333
70268, 1.3875, 1.4666666666667, 0.33333333333333
70269, 1.4083333333333, 1.4666666666667, 0.3125
70270, 1.4083333333333, 1.45, 0.33333333333333
70271, 1.4291666666667, 1.4666666666667, 0.33333333333333
70272, 1.45, 1.4666666666667, 0.3125
70273, 1.45, 1.45, 0.33333333333333
70274, 1.4708333333333, 1.4666666666667, 0.33333333333333
70275, 1.4916666666667, 1.4666666666667, 0.3125
70276, 1.4916666666667, 1.45, 0.33333333333333
70277, 1.5125, 1.4666666666667, 0.33333333333333
70278, 1.5333333333333, 1.4666666666667, 0.3125
70279, 1.5333333333333, 1.45, 0.33333333333333
70280, 1.5541666666667, 1.4666666666667, 0.33333333333333
70281, 1.575, 1.4666666666667, 0.3125
70282, 1.575, 1.45, 0.33333333333333
70283, 1.5958333333333, 1.4666666666667, 0.33333333333333
70284, 1.6166666666667, 1.4666666666667, 0.3125
70285, 1.6166666666667, 1.45, 0.33333333333333
70286, 1.6375, 1.4666666666667, 0.33333333333333
70287, 1.6583333333333, 1.4666666666667, 0.3125
70288, 1.6583333333333, 1.45, 0.33333333333333
70289, 1.6791666666667, 1.4666666666667, 0.33333333333333
70290, 1.7, 1.4666666666667, 0.3125
70291, 1.7, 1.45, 0.33333333333333
70292, 1.7208333333333, 1.4666666666667, 0.33333333333333
70293, 1.7416666666667, 1.4666666666667, 0.3125
70294, 1.7416666666667, 1.45, 0.33333333333333
70295, 1.7625, 1.4666666666667, 0.33333333333333
70296, 1.7833333333333, 1.4666666666667, 0.3125
70297, 1.7833333333333, 1.45, 0.33333333333333
70298, 1.8041666666667, 1.4666666666667, 0.33333333333333
70299, 1.825, 1.4666666666667, 0.3125
70300, 1.825, 1.45, 0.33333333333333
70301, 1.8458333333333, 1.4666666666667, 0.33333333333333
70302, 1.8666666666667, 1.4666666666667, 0.3125
70303, 1.8666666666667, 1.45, 0.33333333333333
70304, 1.8875, 1.4666666666667, 0.33333333333333
70305, 1.9083333333333, 1.4666666666667, 0.3125
70306, 1.9083333333333, 1.45, 0.33333333333333
70307, 1.9291666666667, 1.4666666666667, 0.33333333333333
70308, 1.95, 1.4666666666667, 0.3125
70309, 1.95, 1.45, 0.33333333333333
70310, 1.9708333333333, 1.4666666666667, 0.33333333333333
70311, 1.9916666666667, 1.4666666666667, 0.3125
70312, 1.9916666666667, 1.45, 0.33333333333333
70313, 2.0125, 1.4666666666667, 0.33333333333333
70314, 2.0333333333333, 1.4666666666667, 0.3125
70315, 2.0333333333333, 1.45, 0.33333333333333
70316, 2.0541666666667, 1.4666666666667, 0.33333333333333
70317, 2.075, 1.4666666666667, 0.3125
70318, 2.075, 1.45, 0.33333333333333
70319, 2.0958333333333, 1.4666666666667, 0.33333333333333
70320, 2.1166666666667, 1.4666666666667, 0.3125
70321, 2.1166666666667, 1.45, 0.33333333333333
70322, 2.1375, 1.4666666666667, 0.33333333333333
70323, 2.1583333333333, 1.4666666666667, 0.3125
70324, 2.1583333333333, 1.45, 0.33333333333333
70325, 2.1791666666667, 1.4666666666667, 0.33333333333333
70326, 1.2416666666667, 1.4833333333333, 0.33333333333333
70327, 1.2833333333333, 1.4833333333333, 0.33333333333333
70328, 1.325, 1.4833333333333, 0.33333333333333
70329, 1.3666666666667, 1.4833333333333, 0.33333333333333
70330, 1.4083333333333, 1.4833333333333, 0.33333333333333
70331, 1.45, 1.4833333333333, 0.33333333333333
70332, 1.4916666666667, 1.4833333333333, 0.33333333333333
70333, 1.5333333333333, 1.4833333333333, 0.33333333333333
70334, 1.575, 1.4833333333333, 0.33333333333333
70335, 1.6166666666667, 1.4833333333333, 0.33333333333333
70336, 1.6583333333333, 1.4833333333333, 0.33333333333333
70337, 1.7, 1.4833333333333, 0.33333333333333
