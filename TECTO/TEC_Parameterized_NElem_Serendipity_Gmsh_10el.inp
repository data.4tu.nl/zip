8266, 19803, 19826, 19827, 19804, 20572, 20573, 20574, 20526
8267, 19804, 19827, 19828, 19805, 20574, 20575, 20576, 20528
8268, 19805, 19828, 19829, 19806, 20576, 20577, 20578, 20530
8269, 19806, 19829, 19830, 19807, 20578, 20579, 20580, 20532
8270, 19807, 19830, 19831, 19808, 20580, 20581, 20582, 20534
8271, 19808, 19831, 19832, 19809, 20582, 20583, 20584, 20536
8272, 19809, 19832, 19833, 19810, 20584, 20585, 20586, 20538
8273, 19810, 19833, 19834, 19811, 20586, 20587, 20588, 20540
8274, 19811, 19834, 19835, 19812, 20588, 20589, 20590, 20542
8275, 19812, 19835, 19836, 19813, 20590, 20591, 20592, 20544
8276, 19813, 19836, 19837, 19814, 20592, 20593, 20594, 20546
8277, 19814, 19837, 19838, 19815, 20594, 20595, 20596, 20548
8278, 19815, 19838, 19839, 19816, 20596, 20597, 20598, 20550
8279, 19816, 19839, 19840, 19817, 20598, 20599, 20600, 20552
8280, 19817, 19840, 19841, 19818, 20600, 20601, 20602, 20554
8281, 19818, 19841, 19842, 19819, 20602, 20603, 20604, 20556
8282, 19819, 19842, 19843, 19820, 20604, 20605, 20606, 20558
8283, 19820, 19843, 19844, 19821, 20606, 20607, 20608, 20560
8284, 19821, 19844, 19845, 19822, 20608, 20609, 20610, 20562
8285, 19822, 19845, 19846, 19823, 20610, 20611, 20612, 20564
8286, 19823, 19846, 19847, 19824, 20612, 20613, 20614, 20566
8287, 19824, 19847, 19848, 19825, 20614, 20615, 20616, 20568
8288, 19825, 19848, 1897, 1896, 20616, 20617, 1920, 20570
8289, 1569, 1570, 19849, 19826, 1593, 20618, 20619, 20571
8290, 19826, 19849, 19850, 19827, 20619, 20620, 20621, 20573
8291, 19827, 19850, 19851, 19828, 20621, 20622, 20623, 20575
8292, 19828, 19851, 19852, 19829, 20623, 20624, 20625, 20577
8293, 19829, 19852, 19853, 19830, 20625, 20626, 20627, 20579
8294, 19830, 19853, 19854, 19831, 20627, 20628, 20629, 20581
8295, 19831, 19854, 19855, 19832, 20629, 20630, 20631, 20583
8296, 19832, 19855, 19856, 19833, 20631, 20632, 20633, 20585
8297, 19833, 19856, 19857, 19834, 20633, 20634, 20635, 20587
8298, 19834, 19857, 19858, 19835, 20635, 20636, 20637, 20589
8299, 19835, 19858, 19859, 19836, 20637, 20638, 20639, 20591
8300, 19836, 19859, 19860, 19837, 20639, 20640, 20641, 20593
8301, 19837, 19860, 19861, 19838, 20641, 20642, 20643, 20595
8302, 19838, 19861, 19862, 19839, 20643, 20644, 20645, 20597
8303, 19839, 19862, 19863, 19840, 20645, 20646, 20647, 20599
8304, 19840, 19863, 19864, 19841, 20647, 20648, 20649, 20601
8305, 19841, 19864, 19865, 19842, 20649, 20650, 20651, 20603
8306, 19842, 19865, 19866, 19843, 20651, 20652, 20653, 20605
8307, 19843, 19866, 19867, 19844, 20653, 20654, 20655, 20607
8308, 19844, 19867, 19868, 19845, 20655, 20656, 20657, 20609
8309, 19845, 19868, 19869, 19846, 20657, 20658, 20659, 20611
8310, 19846, 19869, 19870, 19847, 20659, 20660, 20661, 20613
8311, 19847, 19870, 19871, 19848, 20661, 20662, 20663, 20615
8312, 19848, 19871, 1898, 1897, 20663, 20664, 1921, 20617
8313, 1570, 1571, 19872, 19849, 1594, 20665, 20666, 20618
8314, 19849, 19872, 19873, 19850, 20666, 20667, 20668, 20620
8315, 19850, 19873, 19874, 19851, 20668, 20669, 20670, 20622
8316, 19851, 19874, 19875, 19852, 20670, 20671, 20672, 20624
8317, 19852, 19875, 19876, 19853, 20672, 20673, 20674, 20626
8318, 19853, 19876, 19877, 19854, 20674, 20675, 20676, 20628
8319, 19854, 19877, 19878, 19855, 20676, 20677, 20678, 20630
8320, 19855, 19878, 19879, 19856, 20678, 20679, 20680, 20632
8321, 19856, 19879, 19880, 19857, 20680, 20681, 20682, 20634
8322, 19857, 19880, 19881, 19858, 20682, 20683, 20684, 20636
8323, 19858, 19881, 19882, 19859, 20684, 20685, 20686, 20638
8324, 19859, 19882, 19883, 19860, 20686, 20687, 20688, 20640
8325, 19860, 19883, 19884, 19861, 20688, 20689, 20690, 20642
8326, 19861, 19884, 19885, 19862, 20690, 20691, 20692, 20644
8327, 19862, 19885, 19886, 19863, 20692, 20693, 20694, 20646
8328, 19863, 19886, 19887, 19864, 20694, 20695, 20696, 20648
8329, 19864, 19887, 19888, 19865, 20696, 20697, 20698, 20650
8330, 19865, 19888, 19889, 19866, 20698, 20699, 20700, 20652
8331, 19866, 19889, 19890, 19867, 20700, 20701, 20702, 20654
8332, 19867, 19890, 19891, 19868, 20702, 20703, 20704, 20656
8333, 19868, 19891, 19892, 19869, 20704, 20705, 20706, 20658
8334, 19869, 19892, 19893, 19870, 20706, 20707, 20708, 20660
8335, 19870, 19893, 19894, 19871, 20708, 20709, 20710, 20662
8336, 19871, 19894, 1899, 1898, 20710, 20711, 1922, 20664
8337, 1571, 1572, 19895, 19872, 1595, 20712, 20713, 20665
8338, 19872, 19895, 19896, 19873, 20713, 20714, 20715, 20667
8339, 19873, 19896, 19897, 19874, 20715, 20716, 20717, 20669
8340, 19874, 19897, 19898, 19875, 20717, 20718, 20719, 20671
8341, 19875, 19898, 19899, 19876, 20719, 20720, 20721, 20673
8342, 19876, 19899, 19900, 19877, 20721, 20722, 20723, 20675
8343, 19877, 19900, 19901, 19878, 20723, 20724, 20725, 20677
8344, 19878, 19901, 19902, 19879, 20725, 20726, 20727, 20679
8345, 19879, 19902, 19903, 19880, 20727, 20728, 20729, 20681
8346, 19880, 19903, 19904, 19881, 20729, 20730, 20731, 20683
8347, 19881, 19904, 19905, 19882, 20731, 20732, 20733, 20685
8348, 19882, 19905, 19906, 19883, 20733, 20734, 20735, 20687
8349, 19883, 19906, 19907, 19884, 20735, 20736, 20737, 20689
8350, 19884, 19907, 19908, 19885, 20737, 20738, 20739, 20691
8351, 19885, 19908, 19909, 19886, 20739, 20740, 20741, 20693
8352, 19886, 19909, 19910, 19887, 20741, 20742, 20743, 20695
8353, 19887, 19910, 19911, 19888, 20743, 20744, 20745, 20697
8354, 19888, 19911, 19912, 19889, 20745, 20746, 20747, 20699
8355, 19889, 19912, 19913, 19890, 20747, 20748, 20749, 20701
8356, 19890, 19913, 19914, 19891, 20749, 20750, 20751, 20703
8357, 19891, 19914, 19915, 19892, 20751, 20752, 20753, 20705
8358, 19892, 19915, 19916, 19893, 20753, 20754, 20755, 20707
8359, 19893, 19916, 19917, 19894, 20755, 20756, 20757, 20709
8360, 19894, 19917, 1900, 1899, 20757, 20758, 1923, 20711
8361, 1572, 1573, 19918, 19895, 1596, 20759, 20760, 20712
8362, 19895, 19918, 19919, 19896, 20760, 20761, 20762, 20714
8363, 19896, 19919, 19920, 19897, 20762, 20763, 20764, 20716
8364, 19897, 19920, 19921, 19898, 20764, 20765, 20766, 20718
8365, 19898, 19921, 19922, 19899, 20766, 20767, 20768, 20720
8366, 19899, 19922, 19923, 19900, 20768, 20769, 20770, 20722
8367, 19900, 19923, 19924, 19901, 20770, 20771, 20772, 20724
8368, 19901, 19924, 19925, 19902, 20772, 20773, 20774, 20726
8369, 19902, 19925, 19926, 19903, 20774, 20775, 20776, 20728
8370, 19903, 19926, 19927, 19904, 20776, 20777, 20778, 20730
8371, 19904, 19927, 19928, 19905, 20778, 20779, 20780, 20732
8372, 19905, 19928, 19929, 19906, 20780, 20781, 20782, 20734
8373, 19906, 19929, 19930, 19907, 20782, 20783, 20784, 20736
8374, 19907, 19930, 19931, 19908, 20784, 20785, 20786, 20738
8375, 19908, 19931, 19932, 19909, 20786, 20787, 20788, 20740
8376, 19909, 19932, 19933, 19910, 20788, 20789, 20790, 20742
8377, 19910, 19933, 19934, 19911, 20790, 20791, 20792, 20744
8378, 19911, 19934, 19935, 19912, 20792, 20793, 20794, 20746
8379, 19912, 19935, 19936, 19913, 20794, 20795, 20796, 20748
8380, 19913, 19936, 19937, 19914, 20796, 20797, 20798, 20750
8381, 19914, 19937, 19938, 19915, 20798, 20799, 20800, 20752
8382, 19915, 19938, 19939, 19916, 20800, 20801, 20802, 20754
8383, 19916, 19939, 19940, 19917, 20802, 20803, 20804, 20756
8384, 19917, 19940, 1901, 1900, 20804, 20805, 1924, 20758
8385, 1573, 1574, 19941, 19918, 1597, 20806, 20807, 20759
8386, 19918, 19941, 19942, 19919, 20807, 20808, 20809, 20761
8387, 19919, 19942, 19943, 19920, 20809, 20810, 20811, 20763
8388, 19920, 19943, 19944, 19921, 20811, 20812, 20813, 20765
8389, 19921, 19944, 19945, 19922, 20813, 20814, 20815, 20767
8390, 19922, 19945, 19946, 19923, 20815, 20816, 20817, 20769
8391, 19923, 19946, 19947, 19924, 20817, 20818, 20819, 20771
8392, 19924, 19947, 19948, 19925, 20819, 20820, 20821, 20773
8393, 19925, 19948, 19949, 19926, 20821, 20822, 20823, 20775
8394, 19926, 19949, 19950, 19927, 20823, 20824, 20825, 20777
8395, 19927, 19950, 19951, 19928, 20825, 20826, 20827, 20779
8396, 19928, 19951, 19952, 19929, 20827, 20828, 20829, 20781
8397, 19929, 19952, 19953, 19930, 20829, 20830, 20831, 20783
8398, 19930, 19953, 19954, 19931, 20831, 20832, 20833, 20785
8399, 19931, 19954, 19955, 19932, 20833, 20834, 20835, 20787
8400, 19932, 19955, 19956, 19933, 20835, 20836, 20837, 20789
8401, 19933, 19956, 19957, 19934, 20837, 20838, 20839, 20791
8402, 19934, 19957, 19958, 19935, 20839, 20840, 20841, 20793
8403, 19935, 19958, 19959, 19936, 20841, 20842, 20843, 20795
8404, 19936, 19959, 19960, 19937, 20843, 20844, 20845, 20797
8405, 19937, 19960, 19961, 19938, 20845, 20846, 20847, 20799
8406, 19938, 19961, 19962, 19939, 20847, 20848, 20849, 20801
8407, 19939, 19962, 19963, 19940, 20849, 20850, 20851, 20803
8408, 19940, 19963, 1902, 1901, 20851, 20852, 1925, 20805
8409, 1574, 1575, 19964, 19941, 1598, 20853, 20854, 20806
8410, 19941, 19964, 19965, 19942, 20854, 20855, 20856, 20808
8411, 19942, 19965, 19966, 19943, 20856, 20857, 20858, 20810
8412, 19943, 19966, 19967, 19944, 20858, 20859, 20860, 20812
8413, 19944, 19967, 19968, 19945, 20860, 20861, 20862, 20814
8414, 19945, 19968, 19969, 19946, 20862, 20863, 20864, 20816
8415, 19946, 19969, 19970, 19947, 20864, 20865, 20866, 20818
8416, 19947, 19970, 19971, 19948, 20866, 20867, 20868, 20820
8417, 19948, 19971, 19972, 19949, 20868, 20869, 20870, 20822
8418, 19949, 19972, 19973, 19950, 20870, 20871, 20872, 20824
8419, 19950, 19973, 19974, 19951, 20872, 20873, 20874, 20826
8420, 19951, 19974, 19975, 19952, 20874, 20875, 20876, 20828
8421, 19952, 19975, 19976, 19953, 20876, 20877, 20878, 20830
8422, 19953, 19976, 19977, 19954, 20878, 20879, 20880, 20832
8423, 19954, 19977, 19978, 19955, 20880, 20881, 20882, 20834
8424, 19955, 19978, 19979, 19956, 20882, 20883, 20884, 20836
8425, 19956, 19979, 19980, 19957, 20884, 20885, 20886, 20838
8426, 19957, 19980, 19981, 19958, 20886, 20887, 20888, 20840
8427, 19958, 19981, 19982, 19959, 20888, 20889, 20890, 20842
8428, 19959, 19982, 19983, 19960, 20890, 20891, 20892, 20844
8429, 19960, 19983, 19984, 19961, 20892, 20893, 20894, 20846
8430, 19961, 19984, 19985, 19962, 20894, 20895, 20896, 20848
8431, 19962, 19985, 19986, 19963, 20896, 20897, 20898, 20850
8432, 19963, 19986, 1903, 1902, 20898, 20899, 1926, 20852
8433, 1575, 1576, 19987, 19964, 1599, 20900, 20901, 20853
8434, 19964, 19987, 19988, 19965, 20901, 20902, 20903, 20855
8435, 19965, 19988, 19989, 19966, 20903, 20904, 20905, 20857
8436, 19966, 19989, 19990, 19967, 20905, 20906, 20907, 20859
8437, 19967, 19990, 19991, 19968, 20907, 20908, 20909, 20861
8438, 19968, 19991, 19992, 19969, 20909, 20910, 20911, 20863
8439, 19969, 19992, 19993, 19970, 20911, 20912, 20913, 20865
8440, 19970, 19993, 19994, 19971, 20913, 20914, 20915, 20867
8441, 19971, 19994, 19995, 19972, 20915, 20916, 20917, 20869
8442, 19972, 19995, 19996, 19973, 20917, 20918, 20919, 20871
8443, 19973, 19996, 19997, 19974, 20919, 20920, 20921, 20873
8444, 19974, 19997, 19998, 19975, 20921, 20922, 20923, 20875
8445, 19975, 19998, 19999, 19976, 20923, 20924, 20925, 20877
8446, 19976, 19999, 20000, 19977, 20925, 20926, 20927, 20879
8447, 19977, 20000, 20001, 19978, 20927, 20928, 20929, 20881
8448, 19978, 20001, 20002, 19979, 20929, 20930, 20931, 20883
8449, 19979, 20002, 20003, 19980, 20931, 20932, 20933, 20885
8450, 19980, 20003, 20004, 19981, 20933, 20934, 20935, 20887
8451, 19981, 20004, 20005, 19982, 20935, 20936, 20937, 20889
8452, 19982, 20005, 20006, 19983, 20937, 20938, 20939, 20891
8453, 19983, 20006, 20007, 19984, 20939, 20940, 20941, 20893
8454, 19984, 20007, 20008, 19985, 20941, 20942, 20943, 20895
8455, 19985, 20008, 20009, 19986, 20943, 20944, 20945, 20897
8456, 19986, 20009, 1904, 1903, 20945, 20946, 1927, 20899
8457, 1576, 1577, 20010, 19987, 1600, 20947, 20948, 20900
8458, 19987, 20010, 20011, 19988, 20948, 20949, 20950, 20902
8459, 19988, 20011, 20012, 19989, 20950, 20951, 20952, 20904
8460, 19989, 20012, 20013, 19990, 20952, 20953, 20954, 20906
8461, 19990, 20013, 20014, 19991, 20954, 20955, 20956, 20908
8462, 19991, 20014, 20015, 19992, 20956, 20957, 20958, 20910
8463, 19992, 20015, 20016, 19993, 20958, 20959, 20960, 20912
8464, 19993, 20016, 20017, 19994, 20960, 20961, 20962, 20914
8465, 19994, 20017, 20018, 19995, 20962, 20963, 20964, 20916
8466, 19995, 20018, 20019, 19996, 20964, 20965, 20966, 20918
8467, 19996, 20019, 20020, 19997, 20966, 20967, 20968, 20920
8468, 19997, 20020, 20021, 19998, 20968, 20969, 20970, 20922
8469, 19998, 20021, 20022, 19999, 20970, 20971, 20972, 20924
8470, 19999, 20022, 20023, 20000, 20972, 20973, 20974, 20926
8471, 20000, 20023, 20024, 20001, 20974, 20975, 20976, 20928
8472, 20001, 20024, 20025, 20002, 20976, 20977, 20978, 20930
8473, 20002, 20025, 20026, 20003, 20978, 20979, 20980, 20932
8474, 20003, 20026, 20027, 20004, 20980, 20981, 20982, 20934
8475, 20004, 20027, 20028, 20005, 20982, 20983, 20984, 20936
8476, 20005, 20028, 20029, 20006, 20984, 20985, 20986, 20938
8477, 20006, 20029, 20030, 20007, 20986, 20987, 20988, 20940
8478, 20007, 20030, 20031, 20008, 20988, 20989, 20990, 20942
8479, 20008, 20031, 20032, 20009, 20990, 20991, 20992, 20944
8480, 20009, 20032, 1905, 1904, 20992, 20993, 1928, 20946
8481, 1577, 1578, 20033, 20010, 1601, 20994, 20995, 20947
8482, 20010, 20033, 20034, 20011, 20995, 20996, 20997, 20949
8483, 20011, 20034, 20035, 20012, 20997, 20998, 20999, 20951
8484, 20012, 20035, 20036, 20013, 20999, 21000, 21001, 20953
8485, 20013, 20036, 20037, 20014, 21001, 21002, 21003, 20955
8486, 20014, 20037, 20038, 20015, 21003, 21004, 21005, 20957
8487, 20015, 20038, 20039, 20016, 21005, 21006, 21007, 20959
8488, 20016, 20039, 20040, 20017, 21007, 21008, 21009, 20961
8489, 20017, 20040, 20041, 20018, 21009, 21010, 21011, 20963
8490, 20018, 20041, 20042, 20019, 21011, 21012, 21013, 20965
8491, 20019, 20042, 20043, 20020, 21013, 21014, 21015, 20967
8492, 20020, 20043, 20044, 20021, 21015, 21016, 21017, 20969
8493, 20021, 20044, 20045, 20022, 21017, 21018, 21019, 20971
8494, 20022, 20045, 20046, 20023, 21019, 21020, 21021, 20973
8495, 20023, 20046, 20047, 20024, 21021, 21022, 21023, 20975
8496, 20024, 20047, 20048, 20025, 21023, 21024, 21025, 20977
8497, 20025, 20048, 20049, 20026, 21025, 21026, 21027, 20979
8498, 20026, 20049, 20050, 20027, 21027, 21028, 21029, 20981
8499, 20027, 20050, 20051, 20028, 21029, 21030, 21031, 20983
8500, 20028, 20051, 20052, 20029, 21031, 21032, 21033, 20985
8501, 20029, 20052, 20053, 20030, 21033, 21034, 21035, 20987
8502, 20030, 20053, 20054, 20031, 21035, 21036, 21037, 20989
8503, 20031, 20054, 20055, 20032, 21037, 21038, 21039, 20991
8504, 20032, 20055, 1906, 1905, 21039, 21040, 1929, 20993
8505, 1578, 1579, 20056, 20033, 1602, 21041, 21042, 20994
8506, 20033, 20056, 20057, 20034, 21042, 21043, 21044, 20996
8507, 20034, 20057, 20058, 20035, 21044, 21045, 21046, 20998
8508, 20035, 20058, 20059, 20036, 21046, 21047, 21048, 21000
8509, 20036, 20059, 20060, 20037, 21048, 21049, 21050, 21002
8510, 20037, 20060, 20061, 20038, 21050, 21051, 21052, 21004
8511, 20038, 20061, 20062, 20039, 21052, 21053, 21054, 21006
8512, 20039, 20062, 20063, 20040, 21054, 21055, 21056, 21008
8513, 20040, 20063, 20064, 20041, 21056, 21057, 21058, 21010
8514, 20041, 20064, 20065, 20042, 21058, 21059, 21060, 21012
8515, 20042, 20065, 20066, 20043, 21060, 21061, 21062, 21014
8516, 20043, 20066, 20067, 20044, 21062, 21063, 21064, 21016
8517, 20044, 20067, 20068, 20045, 21064, 21065, 21066, 21018
8518, 20045, 20068, 20069, 20046, 21066, 21067, 21068, 21020
8519, 20046, 20069, 20070, 20047, 21068, 21069, 21070, 21022
8520, 20047, 20070, 20071, 20048, 21070, 21071, 21072, 21024
8521, 20048, 20071, 20072, 20049, 21072, 21073, 21074, 21026
8522, 20049, 20072, 20073, 20050, 21074, 21075, 21076, 21028
8523, 20050, 20073, 20074, 20051, 21076, 21077, 21078, 21030
8524, 20051, 20074, 20075, 20052, 21078, 21079, 21080, 21032
8525, 20052, 20075, 20076, 20053, 21080, 21081, 21082, 21034
8526, 20053, 20076, 20077, 20054, 21082, 21083, 21084, 21036
8527, 20054, 20077, 20078, 20055, 21084, 21085, 21086, 21038
8528, 20055, 20078, 1907, 1906, 21086, 21087, 1930, 21040
8529, 1579, 1580, 20079, 20056, 1603, 21088, 21089, 21041
8530, 20056, 20079, 20080, 20057, 21089, 21090, 21091, 21043
8531, 20057, 20080, 20081, 20058, 21091, 21092, 21093, 21045
8532, 20058, 20081, 20082, 20059, 21093, 21094, 21095, 21047
8533, 20059, 20082, 20083, 20060, 21095, 21096, 21097, 21049
8534, 20060, 20083, 20084, 20061, 21097, 21098, 21099, 21051
8535, 20061, 20084, 20085, 20062, 21099, 21100, 21101, 21053
8536, 20062, 20085, 20086, 20063, 21101, 21102, 21103, 21055
8537, 20063, 20086, 20087, 20064, 21103, 21104, 21105, 21057
8538, 20064, 20087, 20088, 20065, 21105, 21106, 21107, 21059
8539, 20065, 20088, 20089, 20066, 21107, 21108, 21109, 21061
8540, 20066, 20089, 20090, 20067, 21109, 21110, 21111, 21063
8541, 20067, 20090, 20091, 20068, 21111, 21112, 21113, 21065
8542, 20068, 20091, 20092, 20069, 21113, 21114, 21115, 21067
8543, 20069, 20092, 20093, 20070, 21115, 21116, 21117, 21069
8544, 20070, 20093, 20094, 20071, 21117, 21118, 21119, 21071
8545, 20071, 20094, 20095, 20072, 21119, 21120, 21121, 21073
8546, 20072, 20095, 20096, 20073, 21121, 21122, 21123, 21075
8547, 20073, 20096, 20097, 20074, 21123, 21124, 21125, 21077
8548, 20074, 20097, 20098, 20075, 21125, 21126, 21127, 21079
8549, 20075, 20098, 20099, 20076, 21127, 21128, 21129, 21081
8550, 20076, 20099, 20100, 20077, 21129, 21130, 21131, 21083
8551, 20077, 20100, 20101, 20078, 21131, 21132, 21133, 21085
8552, 20078, 20101, 1908, 1907, 21133, 21134, 1931, 21087
8553, 1580, 1581, 20102, 20079, 1604, 21135, 21136, 21088
8554, 20079, 20102, 20103, 20080, 21136, 21137, 21138, 21090
8555, 20080, 20103, 20104, 20081, 21138, 21139, 21140, 21092
8556, 20081, 20104, 20105, 20082, 21140, 21141, 21142, 21094
8557, 20082, 20105, 20106, 20083, 21142, 21143, 21144, 21096
8558, 20083, 20106, 20107, 20084, 21144, 21145, 21146, 21098
8559, 20084, 20107, 20108, 20085, 21146, 21147, 21148, 21100
8560, 20085, 20108, 20109, 20086, 21148, 21149, 21150, 21102
8561, 20086, 20109, 20110, 20087, 21150, 21151, 21152, 21104
8562, 20087, 20110, 20111, 20088, 21152, 21153, 21154, 21106
8563, 20088, 20111, 20112, 20089, 21154, 21155, 21156, 21108
8564, 20089, 20112, 20113, 20090, 21156, 21157, 21158, 21110
8565, 20090, 20113, 20114, 20091, 21158, 21159, 21160, 21112
8566, 20091, 20114, 20115, 20092, 21160, 21161, 21162, 21114
8567, 20092, 20115, 20116, 20093, 21162, 21163, 21164, 21116
8568, 20093, 20116, 20117, 20094, 21164, 21165, 21166, 21118
8569, 20094, 20117, 20118, 20095, 21166, 21167, 21168, 21120
8570, 20095, 20118, 20119, 20096, 21168, 21169, 21170, 21122
8571, 20096, 20119, 20120, 20097, 21170, 21171, 21172, 21124
8572, 20097, 20120, 20121, 20098, 21172, 21173, 21174, 21126
8573, 20098, 20121, 20122, 20099, 21174, 21175, 21176, 21128
8574, 20099, 20122, 20123, 20100, 21176, 21177, 21178, 21130
8575, 20100, 20123, 20124, 20101, 21178, 21179, 21180, 21132
8576, 20101, 20124, 1909, 1908, 21180, 21181, 1932, 21134
8577, 1581, 1582, 20125, 20102, 1605, 21182, 21183, 21135
8578, 20102, 20125, 20126, 20103, 21183, 21184, 21185, 21137
8579, 20103, 20126, 20127, 20104, 21185, 21186, 21187, 21139
8580, 20104, 20127, 20128, 20105, 21187, 21188, 21189, 21141
8581, 20105, 20128, 20129, 20106, 21189, 21190, 21191, 21143
8582, 20106, 20129, 20130, 20107, 21191, 21192, 21193, 21145
8583, 20107, 20130, 20131, 20108, 21193, 21194, 21195, 21147
8584, 20108, 20131, 20132, 20109, 21195, 21196, 21197, 21149
8585, 20109, 20132, 20133, 20110, 21197, 21198, 21199, 21151
8586, 20110, 20133, 20134, 20111, 21199, 21200, 21201, 21153
8587, 20111, 20134, 20135, 20112, 21201, 21202, 21203, 21155
8588, 20112, 20135, 20136, 20113, 21203, 21204, 21205, 21157
8589, 20113, 20136, 20137, 20114, 21205, 21206, 21207, 21159
8590, 20114, 20137, 20138, 20115, 21207, 21208, 21209, 21161
8591, 20115, 20138, 20139, 20116, 21209, 21210, 21211, 21163
8592, 20116, 20139, 20140, 20117, 21211, 21212, 21213, 21165
8593, 20117, 20140, 20141, 20118, 21213, 21214, 21215, 21167
8594, 20118, 20141, 20142, 20119, 21215, 21216, 21217, 21169
8595, 20119, 20142, 20143, 20120, 21217, 21218, 21219, 21171
8596, 20120, 20143, 20144, 20121, 21219, 21220, 21221, 21173
8597, 20121, 20144, 20145, 20122, 21221, 21222, 21223, 21175
8598, 20122, 20145, 20146, 20123, 21223, 21224, 21225, 21177
8599, 20123, 20146, 20147, 20124, 21225, 21226, 21227, 21179
8600, 20124, 20147, 1910, 1909, 21227, 21228, 1933, 21181
8601, 1582, 36, 1841, 20125, 1606, 1864, 21229, 21182
8602, 20125, 1841, 1842, 20126, 21229, 1865, 21230, 21184
8603, 20126, 1842, 1843, 20127, 21230, 1866, 21231, 21186
8604, 20127, 1843, 1844, 20128, 21231, 1867, 21232, 21188
8605, 20128, 1844, 1845, 20129, 21232, 1868, 21233, 21190
8606, 20129, 1845, 1846, 20130, 21233, 1869, 21234, 21192
8607, 20130, 1846, 1847, 20131, 21234, 1870, 21235, 21194
8608, 20131, 1847, 1848, 20132, 21235, 1871, 21236, 21196
8609, 20132, 1848, 1849, 20133, 21236, 1872, 21237, 21198
8610, 20133, 1849, 1850, 20134, 21237, 1873, 21238, 21200
8611, 20134, 1850, 1851, 20135, 21238, 1874, 21239, 21202
8612, 20135, 1851, 1852, 20136, 21239, 1875, 21240, 21204
8613, 20136, 1852, 1853, 20137, 21240, 1876, 21241, 21206
8614, 20137, 1853, 1854, 20138, 21241, 1877, 21242, 21208
8615, 20138, 1854, 1855, 20139, 21242, 1878, 21243, 21210
8616, 20139, 1855, 1856, 20140, 21243, 1879, 21244, 21212
8617, 20140, 1856, 1857, 20141, 21244, 1880, 21245, 21214
8618, 20141, 1857, 1858, 20142, 21245, 1881, 21246, 21216
8619, 20142, 1858, 1859, 20143, 21246, 1882, 21247, 21218
8620, 20143, 1859, 1860, 20144, 21247, 1883, 21248, 21220
8621, 20144, 1860, 1861, 20145, 21248, 1884, 21249, 21222
8622, 20145, 1861, 1862, 20146, 21249, 1885, 21250, 21224
8623, 20146, 1862, 1863, 20147, 21250, 1886, 21251, 21226
8624, 20147, 1863, 40, 1910, 21251, 1887, 1934, 21228
*ELEMENT, type=CPS8, ELSET=Surface44
8625, 35, 1794, 21252, 1607, 1817, 21505, 21506, 1618
8626, 1794, 1795, 21253, 21252, 1818, 21507, 21508, 21505
8627, 1795, 1796, 21254, 21253, 1819, 21509, 21510, 21507
8628, 1796, 1797, 21255, 21254, 1820, 21511, 21512, 21509
8629, 1797, 1798, 21256, 21255, 1821, 21513, 21514, 21511
8630, 1798, 1799, 21257, 21256, 1822, 21515, 21516, 21513
8631, 1799, 1800, 21258, 21257, 1823, 21517, 21518, 21515
8632, 1800, 1801, 21259, 21258, 1824, 21519, 21520, 21517
8633, 1801, 1802, 21260, 21259, 1825, 21521, 21522, 21519
8634, 1802, 1803, 21261, 21260, 1826, 21523, 21524, 21521
8635, 1803, 1804, 21262, 21261, 1827, 21525, 21526, 21523
8636, 1804, 1805, 21263, 21262, 1828, 21527, 21528, 21525
8637, 1805, 1806, 21264, 21263, 1829, 21529, 21530, 21527
8638, 1806, 1807, 21265, 21264, 1830, 21531, 21532, 21529
8639, 1807, 1808, 21266, 21265, 1831, 21533, 21534, 21531
8640, 1808, 1809, 21267, 21266, 1832, 21535, 21536, 21533
8641, 1809, 1810, 21268, 21267, 1833, 21537, 21538, 21535
8642, 1810, 1811, 21269, 21268, 1834, 21539, 21540, 21537
8643, 1811, 1812, 21270, 21269, 1835, 21541, 21542, 21539
8644, 1812, 1813, 21271, 21270, 1836, 21543, 21544, 21541
8645, 1813, 1814, 21272, 21271, 1837, 21545, 21546, 21543
8646, 1814, 1815, 21273, 21272, 1838, 21547, 21548, 21545
8647, 1815, 1816, 21274, 21273, 1839, 21549, 21550, 21547
8648, 1816, 39, 1935, 21274, 1840, 1946, 21551, 21549
8649, 1607, 21252, 21275, 1608, 21506, 21552, 21553, 1619
8650, 21252, 21253, 21276, 21275, 21508, 21554, 21555, 21552
8651, 21253, 21254, 21277, 21276, 21510, 21556, 21557, 21554
8652, 21254, 21255, 21278, 21277, 21512, 21558, 21559, 21556
8653, 21255, 21256, 21279, 21278, 21514, 21560, 21561, 21558
8654, 21256, 21257, 21280, 21279, 21516, 21562, 21563, 21560
8655, 21257, 21258, 21281, 21280, 21518, 21564, 21565, 21562
8656, 21258, 21259, 21282, 21281, 21520, 21566, 21567, 21564
8657, 21259, 21260, 21283, 21282, 21522, 21568, 21569, 21566
8658, 21260, 21261, 21284, 21283, 21524, 21570, 21571, 21568
8659, 21261, 21262, 21285, 21284, 21526, 21572, 21573, 21570
8660, 21262, 21263, 21286, 21285, 21528, 21574, 21575, 21572
8661, 21263, 21264, 21287, 21286, 21530, 21576, 21577, 21574
8662, 21264, 21265, 21288, 21287, 21532, 21578, 21579, 21576
8663, 21265, 21266, 21289, 21288, 21534, 21580, 21581, 21578
8664, 21266, 21267, 21290, 21289, 21536, 21582, 21583, 21580
8665, 21267, 21268, 21291, 21290, 21538, 21584, 21585, 21582
8666, 21268, 21269, 21292, 21291, 21540, 21586, 21587, 21584
8667, 21269, 21270, 21293, 21292, 21542, 21588, 21589, 21586
8668, 21270, 21271, 21294, 21293, 21544, 21590, 21591, 21588
8669, 21271, 21272, 21295, 21294, 21546, 21592, 21593, 21590
8670, 21272, 21273, 21296, 21295, 21548, 21594, 21595, 21592
8671, 21273, 21274, 21297, 21296, 21550, 21596, 21597, 21594
8672, 21274, 1935, 1936, 21297, 21551, 1947, 21598, 21596
8673, 1608, 21275, 21298, 1609, 21553, 21599, 21600, 1620
8674, 21275, 21276, 21299, 21298, 21555, 21601, 21602, 21599
8675, 21276, 21277, 21300, 21299, 21557, 21603, 21604, 21601
8676, 21277, 21278, 21301, 21300, 21559, 21605, 21606, 21603
8677, 21278, 21279, 21302, 21301, 21561, 21607, 21608, 21605
8678, 21279, 21280, 21303, 21302, 21563, 21609, 21610, 21607
8679, 21280, 21281, 21304, 21303, 21565, 21611, 21612, 21609
8680, 21281, 21282, 21305, 21304, 21567, 21613, 21614, 21611
8681, 21282, 21283, 21306, 21305, 21569, 21615, 21616, 21613
8682, 21283, 21284, 21307, 21306, 21571, 21617, 21618, 21615
8683, 21284, 21285, 21308, 21307, 21573, 21619, 21620, 21617
8684, 21285, 21286, 21309, 21308, 21575, 21621, 21622, 21619
8685, 21286, 21287, 21310, 21309, 21577, 21623, 21624, 21621
8686, 21287, 21288, 21311, 21310, 21579, 21625, 21626, 21623
8687, 21288, 21289, 21312, 21311, 21581, 21627, 21628, 21625
8688, 21289, 21290, 21313, 21312, 21583, 21629, 21630, 21627
8689, 21290, 21291, 21314, 21313, 21585, 21631, 21632, 21629
8690, 21291, 21292, 21315, 21314, 21587, 21633, 21634, 21631
8691, 21292, 21293, 21316, 21315, 21589, 21635, 21636, 21633
8692, 21293, 21294, 21317, 21316, 21591, 21637, 21638, 21635
8693, 21294, 21295, 21318, 21317, 21593, 21639, 21640, 21637
8694, 21295, 21296, 21319, 21318, 21595, 21641, 21642, 21639
8695, 21296, 21297, 21320, 21319, 21597, 21643, 21644, 21641
8696, 21297, 1936, 1937, 21320, 21598, 1948, 21645, 21643
8697, 1609, 21298, 21321, 1610, 21600, 21646, 21647, 1621
8698, 21298, 21299, 21322, 21321, 21602, 21648, 21649, 21646
8699, 21299, 21300, 21323, 21322, 21604, 21650, 21651, 21648
8700, 21300, 21301, 21324, 21323, 21606, 21652, 21653, 21650
8701, 21301, 21302, 21325, 21324, 21608, 21654, 21655, 21652
8702, 21302, 21303, 21326, 21325, 21610, 21656, 21657, 21654
8703, 21303, 21304, 21327, 21326, 21612, 21658, 21659, 21656
8704, 21304, 21305, 21328, 21327, 21614, 21660, 21661, 21658
8705, 21305, 21306, 21329, 21328, 21616, 21662, 21663, 21660
8706, 21306, 21307, 21330, 21329, 21618, 21664, 21665, 21662
8707, 21307, 21308, 21331, 21330, 21620, 21666, 21667, 21664
8708, 21308, 21309, 21332, 21331, 21622, 21668, 21669, 21666
8709, 21309, 21310, 21333, 21332, 21624, 21670, 21671, 21668
8710, 21310, 21311, 21334, 21333, 21626, 21672, 21673, 21670
8711, 21311, 21312, 21335, 21334, 21628, 21674, 21675, 21672
8712, 21312, 21313, 21336, 21335, 21630, 21676, 21677, 21674
8713, 21313, 21314, 21337, 21336, 21632, 21678, 21679, 21676
8714, 21314, 21315, 21338, 21337, 21634, 21680, 21681, 21678
8715, 21315, 21316, 21339, 21338, 21636, 21682, 21683, 21680
8716, 21316, 21317, 21340, 21339, 21638, 21684, 21685, 21682
8717, 21317, 21318, 21341, 21340, 21640, 21686, 21687, 21684
8718, 21318, 21319, 21342, 21341, 21642, 21688, 21689, 21686
8719, 21319, 21320, 21343, 21342, 21644, 21690, 21691, 21688
8720, 21320, 1937, 1938, 21343, 21645, 1949, 21692, 21690
8721, 1610, 21321, 21344, 1611, 21647, 21693, 21694, 1622
8722, 21321, 21322, 21345, 21344, 21649, 21695, 21696, 21693
8723, 21322, 21323, 21346, 21345, 21651, 21697, 21698, 21695
8724, 21323, 21324, 21347, 21346, 21653, 21699, 21700, 21697
8725, 21324, 21325, 21348, 21347, 21655, 21701, 21702, 21699
8726, 21325, 21326, 21349, 21348, 21657, 21703, 21704, 21701
8727, 21326, 21327, 21350, 21349, 21659, 21705, 21706, 21703
8728, 21327, 21328, 21351, 21350, 21661, 21707, 21708, 21705
8729, 21328, 21329, 21352, 21351, 21663, 21709, 21710, 21707
8730, 21329, 21330, 21353, 21352, 21665, 21711, 21712, 21709
8731, 21330, 21331, 21354, 21353, 21667, 21713, 21714, 21711
8732, 21331, 21332, 21355, 21354, 21669, 21715, 21716, 21713
8733, 21332, 21333, 21356, 21355, 21671, 21717, 21718, 21715
8734, 21333, 21334, 21357, 21356, 21673, 21719, 21720, 21717
8735, 21334, 21335, 21358, 21357, 21675, 21721, 21722, 21719
8736, 21335, 21336, 21359, 21358, 21677, 21723, 21724, 21721
8737, 21336, 21337, 21360, 21359, 21679, 21725, 21726, 21723
8738, 21337, 21338, 21361, 21360, 21681, 21727, 21728, 21725
8739, 21338, 21339, 21362, 21361, 21683, 21729, 21730, 21727
8740, 21339, 21340, 21363, 21362, 21685, 21731, 21732, 21729
8741, 21340, 21341, 21364, 21363, 21687, 21733, 21734, 21731
8742, 21341, 21342, 21365, 21364, 21689, 21735, 21736, 21733
8743, 21342, 21343, 21366, 21365, 21691, 21737, 21738, 21735
8744, 21343, 1938, 1939, 21366, 21692, 1950, 21739, 21737
8745, 1611, 21344, 21367, 1612, 21694, 21740, 21741, 1623
8746, 21344, 21345, 21368, 21367, 21696, 21742, 21743, 21740
8747, 21345, 21346, 21369, 21368, 21698, 21744, 21745, 21742
8748, 21346, 21347, 21370, 21369, 21700, 21746, 21747, 21744
8749, 21347, 21348, 21371, 21370, 21702, 21748, 21749, 21746
8750, 21348, 21349, 21372, 21371, 21704, 21750, 21751, 21748
8751, 21349, 21350, 21373, 21372, 21706, 21752, 21753, 21750
8752, 21350, 21351, 21374, 21373, 21708, 21754, 21755, 21752
8753, 21351, 21352, 21375, 21374, 21710, 21756, 21757, 21754
8754, 21352, 21353, 21376, 21375, 21712, 21758, 21759, 21756
8755, 21353, 21354, 21377, 21376, 21714, 21760, 21761, 21758
8756, 21354, 21355, 21378, 21377, 21716, 21762, 21763, 21760
8757, 21355, 21356, 21379, 21378, 21718, 21764, 21765, 21762
8758, 21356, 21357, 21380, 21379, 21720, 21766, 21767, 21764
8759, 21357, 21358, 21381, 21380, 21722, 21768, 21769, 21766
8760, 21358, 21359, 21382, 21381, 21724, 21770, 21771, 21768
8761, 21359, 21360, 21383, 21382, 21726, 21772, 21773, 21770
8762, 21360, 21361, 21384, 21383, 21728, 21774, 21775, 21772
8763, 21361, 21362, 21385, 21384, 21730, 21776, 21777, 21774
8764, 21362, 21363, 21386, 21385, 21732, 21778, 21779, 21776
8765, 21363, 21364, 21387, 21386, 21734, 21780, 21781, 21778
8766, 21364, 21365, 21388, 21387, 21736, 21782, 21783, 21780
8767, 21365, 21366, 21389, 21388, 21738, 21784, 21785, 21782
8768, 21366, 1939, 1940, 21389, 21739, 1951, 21786, 21784
8769, 1612, 21367, 21390, 1613, 21741, 21787, 21788, 1624
8770, 21367, 21368, 21391, 21390, 21743, 21789, 21790, 21787
8771, 21368, 21369, 21392, 21391, 21745, 21791, 21792, 21789
8772, 21369, 21370, 21393, 21392, 21747, 21793, 21794, 21791
8773, 21370, 21371, 21394, 21393, 21749, 21795, 21796, 21793
8774, 21371, 21372, 21395, 21394, 21751, 21797, 21798, 21795
8775, 21372, 21373, 21396, 21395, 21753, 21799, 21800, 21797
8776, 21373, 21374, 21397, 21396, 21755, 21801, 21802, 21799
8777, 21374, 21375, 21398, 21397, 21757, 21803, 21804, 21801
8778, 21375, 21376, 21399, 21398, 21759, 21805, 21806, 21803
8779, 21376, 21377, 21400, 21399, 21761, 21807, 21808, 21805
8780, 21377, 21378, 21401, 21400, 21763, 21809, 21810, 21807
8781, 21378, 21379, 21402, 21401, 21765, 21811, 21812, 21809
8782, 21379, 21380, 21403, 21402, 21767, 21813, 21814, 21811
8783, 21380, 21381, 21404, 21403, 21769, 21815, 21816, 21813
8784, 21381, 21382, 21405, 21404, 21771, 21817, 21818, 21815
8785, 21382, 21383, 21406, 21405, 21773, 21819, 21820, 21817
8786, 21383, 21384, 21407, 21406, 21775, 21821, 21822, 21819
8787, 21384, 21385, 21408, 21407, 21777, 21823, 21824, 21821
8788, 21385, 21386, 21409, 21408, 21779, 21825, 21826, 21823
8789, 21386, 21387, 21410, 21409, 21781, 21827, 21828, 21825
8790, 21387, 21388, 21411, 21410, 21783, 21829, 21830, 21827
8791, 21388, 21389, 21412, 21411, 21785, 21831, 21832, 21829
8792, 21389, 1940, 1941, 21412, 21786, 1952, 21833, 21831
8793, 1613, 21390, 21413, 1614, 21788, 21834, 21835, 1625
8794, 21390, 21391, 21414, 21413, 21790, 21836, 21837, 21834
8795, 21391, 21392, 21415, 21414, 21792, 21838, 21839, 21836
8796, 21392, 21393, 21416, 21415, 21794, 21840, 21841, 21838
8797, 21393, 21394, 21417, 21416, 21796, 21842, 21843, 21840
8798, 21394, 21395, 21418, 21417, 21798, 21844, 21845, 21842
8799, 21395, 21396, 21419, 21418, 21800, 21846, 21847, 21844
8800, 21396, 21397, 21420, 21419, 21802, 21848, 21849, 21846
8801, 21397, 21398, 21421, 21420, 21804, 21850, 21851, 21848
8802, 21398, 21399, 21422, 21421, 21806, 21852, 21853, 21850
8803, 21399, 21400, 21423, 21422, 21808, 21854, 21855, 21852
8804, 21400, 21401, 21424, 21423, 21810, 21856, 21857, 21854
8805, 21401, 21402, 21425, 21424, 21812, 21858, 21859, 21856
8806, 21402, 21403, 21426, 21425, 21814, 21860, 21861, 21858
8807, 21403, 21404, 21427, 21426, 21816, 21862, 21863, 21860
8808, 21404, 21405, 21428, 21427, 21818, 21864, 21865, 21862
8809, 21405, 21406, 21429, 21428, 21820, 21866, 21867, 21864
8810, 21406, 21407, 21430, 21429, 21822, 21868, 21869, 21866
8811, 21407, 21408, 21431, 21430, 21824, 21870, 21871, 21868
8812, 21408, 21409, 21432, 21431, 21826, 21872, 21873, 21870
8813, 21409, 21410, 21433, 21432, 21828, 21874, 21875, 21872
8814, 21410, 21411, 21434, 21433, 21830, 21876, 21877, 21874
8815, 21411, 21412, 21435, 21434, 21832, 21878, 21879, 21876
8816, 21412, 1941, 1942, 21435, 21833, 1953, 21880, 21878
8817, 1614, 21413, 21436, 1615, 21835, 21881, 21882, 1626
8818, 21413, 21414, 21437, 21436, 21837, 21883, 21884, 21881
8819, 21414, 21415, 21438, 21437, 21839, 21885, 21886, 21883
8820, 21415, 21416, 21439, 21438, 21841, 21887, 21888, 21885
8821, 21416, 21417, 21440, 21439, 21843, 21889, 21890, 21887
8822, 21417, 21418, 21441, 21440, 21845, 21891, 21892, 21889
8823, 21418, 21419, 21442, 21441, 21847, 21893, 21894, 21891
8824, 21419, 21420, 21443, 21442, 21849, 21895, 21896, 21893
8825, 21420, 21421, 21444, 21443, 21851, 21897, 21898, 21895
8826, 21421, 21422, 21445, 21444, 21853, 21899, 21900, 21897
8827, 21422, 21423, 21446, 21445, 21855, 21901, 21902, 21899
8828, 21423, 21424, 21447, 21446, 21857, 21903, 21904, 21901
8829, 21424, 21425, 21448, 21447, 21859, 21905, 21906, 21903
8830, 21425, 21426, 21449, 21448, 21861, 21907, 21908, 21905
8831, 21426, 21427, 21450, 21449, 21863, 21909, 21910, 21907
8832, 21427, 21428, 21451, 21450, 21865, 21911, 21912, 21909
8833, 21428, 21429, 21452, 21451, 21867, 21913, 21914, 21911
8834, 21429, 21430, 21453, 21452, 21869, 21915, 21916, 21913
8835, 21430, 21431, 21454, 21453, 21871, 21917, 21918, 21915
8836, 21431, 21432, 21455, 21454, 21873, 21919, 21920, 21917
8837, 21432, 21433, 21456, 21455, 21875, 21921, 21922, 21919
8838, 21433, 21434, 21457, 21456, 21877, 21923, 21924, 21921
8839, 21434, 21435, 21458, 21457, 21879, 21925, 21926, 21923
8840, 21435, 1942, 1943, 21458, 21880, 1954, 21927, 21925
8841, 1615, 21436, 21459, 1616, 21882, 21928, 21929, 1627
8842, 21436, 21437, 21460, 21459, 21884, 21930, 21931, 21928
8843, 21437, 21438, 21461, 21460, 21886, 21932, 21933, 21930
8844, 21438, 21439, 21462, 21461, 21888, 21934, 21935, 21932
8845, 21439, 21440, 21463, 21462, 21890, 21936, 21937, 21934
8846, 21440, 21441, 21464, 21463, 21892, 21938, 21939, 21936
8847, 21441, 21442, 21465, 21464, 21894, 21940, 21941, 21938
8848, 21442, 21443, 21466, 21465, 21896, 21942, 21943, 21940
8849, 21443, 21444, 21467, 21466, 21898, 21944, 21945, 21942
8850, 21444, 21445, 21468, 21467, 21900, 21946, 21947, 21944
8851, 21445, 21446, 21469, 21468, 21902, 21948, 21949, 21946
8852, 21446, 21447, 21470, 21469, 21904, 21950, 21951, 21948
8853, 21447, 21448, 21471, 21470, 21906, 21952, 21953, 21950
8854, 21448, 21449, 21472, 21471, 21908, 21954, 21955, 21952
8855, 21449, 21450, 21473, 21472, 21910, 21956, 21957, 21954
8856, 21450, 21451, 21474, 21473, 21912, 21958, 21959, 21956
8857, 21451, 21452, 21475, 21474, 21914, 21960, 21961, 21958
8858, 21452, 21453, 21476, 21475, 21916, 21962, 21963, 21960
8859, 21453, 21454, 21477, 21476, 21918, 21964, 21965, 21962
8860, 21454, 21455, 21478, 21477, 21920, 21966, 21967, 21964
8861, 21455, 21456, 21479, 21478, 21922, 21968, 21969, 21966
8862, 21456, 21457, 21480, 21479, 21924, 21970, 21971, 21968
8863, 21457, 21458, 21481, 21480, 21926, 21972, 21973, 21970
8864, 21458, 1943, 1944, 21481, 21927, 1955, 21974, 21972
8865, 1616, 21459, 21482, 1617, 21929, 21975, 21976, 1628
8866, 21459, 21460, 21483, 21482, 21931, 21977, 21978, 21975
8867, 21460, 21461, 21484, 21483, 21933, 21979, 21980, 21977
8868, 21461, 21462, 21485, 21484, 21935, 21981, 21982, 21979
8869, 21462, 21463, 21486, 21485, 21937, 21983, 21984, 21981
8870, 21463, 21464, 21487, 21486, 21939, 21985, 21986, 21983
8871, 21464, 21465, 21488, 21487, 21941, 21987, 21988, 21985
8872, 21465, 21466, 21489, 21488, 21943, 21989, 21990, 21987
8873, 21466, 21467, 21490, 21489, 21945, 21991, 21992, 21989
8874, 21467, 21468, 21491, 21490, 21947, 21993, 21994, 21991
8875, 21468, 21469, 21492, 21491, 21949, 21995, 21996, 21993
8876, 21469, 21470, 21493, 21492, 21951, 21997, 21998, 21995
8877, 21470, 21471, 21494, 21493, 21953, 21999, 22000, 21997
8878, 21471, 21472, 21495, 21494, 21955, 22001, 22002, 21999
8879, 21472, 21473, 21496, 21495, 21957, 22003, 22004, 22001
8880, 21473, 21474, 21497, 21496, 21959, 22005, 22006, 22003
8881, 21474, 21475, 21498, 21497, 21961, 22007, 22008, 22005
8882, 21475, 21476, 21499, 21498, 21963, 22009, 22010, 22007
8883, 21476, 21477, 21500, 21499, 21965, 22011, 22012, 22009
8884, 21477, 21478, 21501, 21500, 21967, 22013, 22014, 22011
8885, 21478, 21479, 21502, 21501, 21969, 22015, 22016, 22013
8886, 21479, 21480, 21503, 21502, 21971, 22017, 22018, 22015
8887, 21480, 21481, 21504, 21503, 21973, 22019, 22020, 22017
8888, 21481, 1944, 1945, 21504, 21974, 1956, 22021, 22019
8889, 1617, 21482, 1653, 33, 21976, 22022, 1676, 1629
8890, 21482, 21483, 1654, 1653, 21978, 22023, 1677, 22022
8891, 21483, 21484, 1655, 1654, 21980, 22024, 1678, 22023
8892, 21484, 21485, 1656, 1655, 21982, 22025, 1679, 22024
8893, 21485, 21486, 1657, 1656, 21984, 22026, 1680, 22025
8894, 21486, 21487, 1658, 1657, 21986, 22027, 1681, 22026
8895, 21487, 21488, 1659, 1658, 21988, 22028, 1682, 22027
8896, 21488, 21489, 1660, 1659, 21990, 22029, 1683, 22028
8897, 21489, 21490, 1661, 1660, 21992, 22030, 1684, 22029
8898, 21490, 21491, 1662, 1661, 21994, 22031, 1685, 22030
8899, 21491, 21492, 1663, 1662, 21996, 22032, 1686, 22031
8900, 21492, 21493, 1664, 1663, 21998, 22033, 1687, 22032
8901, 21493, 21494, 1665, 1664, 22000, 22034, 1688, 22033
8902, 21494, 21495, 1666, 1665, 22002, 22035, 1689, 22034
8903, 21495, 21496, 1667, 1666, 22004, 22036, 1690, 22035
8904, 21496, 21497, 1668, 1667, 22006, 22037, 1691, 22036
8905, 21497, 21498, 1669, 1668, 22008, 22038, 1692, 22037
8906, 21498, 21499, 1670, 1669, 22010, 22039, 1693, 22038
8907, 21499, 21500, 1671, 1670, 22012, 22040, 1694, 22039
8908, 21500, 21501, 1672, 1671, 22014, 22041, 1695, 22040
8909, 21501, 21502, 1673, 1672, 22016, 22042, 1696, 22041
8910, 21502, 21503, 1674, 1673, 22018, 22043, 1697, 22042
8911, 21503, 21504, 1675, 1674, 22020, 22044, 1698, 22043
8912, 21504, 1945, 37, 1675, 22021, 1957, 1699, 22044
*ELEMENT, type=CPS8, ELSET=Surface45
8913, 36, 1630, 22045, 1841, 1641, 22298, 22299, 1864
8914, 1841, 22045, 22046, 1842, 22299, 22300, 22301, 1865
8915, 1842, 22046, 22047, 1843, 22301, 22302, 22303, 1866
8916, 1843, 22047, 22048, 1844, 22303, 22304, 22305, 1867
8917, 1844, 22048, 22049, 1845, 22305, 22306, 22307, 1868
8918, 1845, 22049, 22050, 1846, 22307, 22308, 22309, 1869
8919, 1846, 22050, 22051, 1847, 22309, 22310, 22311, 1870
8920, 1847, 22051, 22052, 1848, 22311, 22312, 22313, 1871
8921, 1848, 22052, 22053, 1849, 22313, 22314, 22315, 1872
8922, 1849, 22053, 22054, 1850, 22315, 22316, 22317, 1873
8923, 1850, 22054, 22055, 1851, 22317, 22318, 22319, 1874
8924, 1851, 22055, 22056, 1852, 22319, 22320, 22321, 1875
8925, 1852, 22056, 22057, 1853, 22321, 22322, 22323, 1876
8926, 1853, 22057, 22058, 1854, 22323, 22324, 22325, 1877
8927, 1854, 22058, 22059, 1855, 22325, 22326, 22327, 1878
8928, 1855, 22059, 22060, 1856, 22327, 22328, 22329, 1879
8929, 1856, 22060, 22061, 1857, 22329, 22330, 22331, 1880
8930, 1857, 22061, 22062, 1858, 22331, 22332, 22333, 1881
8931, 1858, 22062, 22063, 1859, 22333, 22334, 22335, 1882
8932, 1859, 22063, 22064, 1860, 22335, 22336, 22337, 1883
8933, 1860, 22064, 22065, 1861, 22337, 22338, 22339, 1884
8934, 1861, 22065, 22066, 1862, 22339, 22340, 22341, 1885
8935, 1862, 22066, 22067, 1863, 22341, 22342, 22343, 1886
8936, 1863, 22067, 1958, 40, 22343, 22344, 1969, 1887
8937, 1630, 1631, 22068, 22045, 1642, 22345, 22346, 22298
8938, 22045, 22068, 22069, 22046, 22346, 22347, 22348, 22300
8939, 22046, 22069, 22070, 22047, 22348, 22349, 22350, 22302
8940, 22047, 22070, 22071, 22048, 22350, 22351, 22352, 22304
8941, 22048, 22071, 22072, 22049, 22352, 22353, 22354, 22306
8942, 22049, 22072, 22073, 22050, 22354, 22355, 22356, 22308
8943, 22050, 22073, 22074, 22051, 22356, 22357, 22358, 22310
8944, 22051, 22074, 22075, 22052, 22358, 22359, 22360, 22312
8945, 22052, 22075, 22076, 22053, 22360, 22361, 22362, 22314
8946, 22053, 22076, 22077, 22054, 22362, 22363, 22364, 22316
8947, 22054, 22077, 22078, 22055, 22364, 22365, 22366, 22318
8948, 22055, 22078, 22079, 22056, 22366, 22367, 22368, 22320
8949, 22056, 22079, 22080, 22057, 22368, 22369, 22370, 22322
8950, 22057, 22080, 22081, 22058, 22370, 22371, 22372, 22324
8951, 22058, 22081, 22082, 22059, 22372, 22373, 22374, 22326
8952, 22059, 22082, 22083, 22060, 22374, 22375, 22376, 22328
8953, 22060, 22083, 22084, 22061, 22376, 22377, 22378, 22330
8954, 22061, 22084, 22085, 22062, 22378, 22379, 22380, 22332
8955, 22062, 22085, 22086, 22063, 22380, 22381, 22382, 22334
8956, 22063, 22086, 22087, 22064, 22382, 22383, 22384, 22336
8957, 22064, 22087, 22088, 22065, 22384, 22385, 22386, 22338
8958, 22065, 22088, 22089, 22066, 22386, 22387, 22388, 22340
8959, 22066, 22089, 22090, 22067, 22388, 22389, 22390, 22342
8960, 22067, 22090, 1959, 1958, 22390, 22391, 1970, 22344
8961, 1631, 1632, 22091, 22068, 1643, 22392, 22393, 22345
8962, 22068, 22091, 22092, 22069, 22393, 22394, 22395, 22347
8963, 22069, 22092, 22093, 22070, 22395, 22396, 22397, 22349
8964, 22070, 22093, 22094, 22071, 22397, 22398, 22399, 22351
8965, 22071, 22094, 22095, 22072, 22399, 22400, 22401, 22353
8966, 22072, 22095, 22096, 22073, 22401, 22402, 22403, 22355
8967, 22073, 22096, 22097, 22074, 22403, 22404, 22405, 22357
8968, 22074, 22097, 22098, 22075, 22405, 22406, 22407, 22359
8969, 22075, 22098, 22099, 22076, 22407, 22408, 22409, 22361
8970, 22076, 22099, 22100, 22077, 22409, 22410, 22411, 22363
8971, 22077, 22100, 22101, 22078, 22411, 22412, 22413, 22365
8972, 22078, 22101, 22102, 22079, 22413, 22414, 22415, 22367
8973, 22079, 22102, 22103, 22080, 22415, 22416, 22417, 22369
8974, 22080, 22103, 22104, 22081, 22417, 22418, 22419, 22371
8975, 22081, 22104, 22105, 22082, 22419, 22420, 22421, 22373
8976, 22082, 22105, 22106, 22083, 22421, 22422, 22423, 22375
8977, 22083, 22106, 22107, 22084, 22423, 22424, 22425, 22377
8978, 22084, 22107, 22108, 22085, 22425, 22426, 22427, 22379
8979, 22085, 22108, 22109, 22086, 22427, 22428, 22429, 22381
8980, 22086, 22109, 22110, 22087, 22429, 22430, 22431, 22383
8981, 22087, 22110, 22111, 22088, 22431, 22432, 22433, 22385
8982, 22088, 22111, 22112, 22089, 22433, 22434, 22435, 22387
8983, 22089, 22112, 22113, 22090, 22435, 22436, 22437, 22389
8984, 22090, 22113, 1960, 1959, 22437, 22438, 1971, 22391
8985, 1632, 1633, 22114, 22091, 1644, 22439, 22440, 22392
8986, 22091, 22114, 22115, 22092, 22440, 22441, 22442, 22394
8987, 22092, 22115, 22116, 22093, 22442, 22443, 22444, 22396
8988, 22093, 22116, 22117, 22094, 22444, 22445, 22446, 22398
8989, 22094, 22117, 22118, 22095, 22446, 22447, 22448, 22400
8990, 22095, 22118, 22119, 22096, 22448, 22449, 22450, 22402
8991, 22096, 22119, 22120, 22097, 22450, 22451, 22452, 22404
8992, 22097, 22120, 22121, 22098, 22452, 22453, 22454, 22406
8993, 22098, 22121, 22122, 22099, 22454, 22455, 22456, 22408
8994, 22099, 22122, 22123, 22100, 22456, 22457, 22458, 22410
8995, 22100, 22123, 22124, 22101, 22458, 22459, 22460, 22412
8996, 22101, 22124, 22125, 22102, 22460, 22461, 22462, 22414
8997, 22102, 22125, 22126, 22103, 22462, 22463, 22464, 22416
8998, 22103, 22126, 22127, 22104, 22464, 22465, 22466, 22418
8999, 22104, 22127, 22128, 22105, 22466, 22467, 22468, 22420
9000, 22105, 22128, 22129, 22106, 22468, 22469, 22470, 22422
9001, 22106, 22129, 22130, 22107, 22470, 22471, 22472, 22424
9002, 22107, 22130, 22131, 22108, 22472, 22473, 22474, 22426
9003, 22108, 22131, 22132, 22109, 22474, 22475, 22476, 22428
9004, 22109, 22132, 22133, 22110, 22476, 22477, 22478, 22430
9005, 22110, 22133, 22134, 22111, 22478, 22479, 22480, 22432
9006, 22111, 22134, 22135, 22112, 22480, 22481, 22482, 22434
9007, 22112, 22135, 22136, 22113, 22482, 22483, 22484, 22436
9008, 22113, 22136, 1961, 1960, 22484, 22485, 1972, 22438
9009, 1633, 1634, 22137, 22114, 1645, 22486, 22487, 22439
9010, 22114, 22137, 22138, 22115, 22487, 22488, 22489, 22441
9011, 22115, 22138, 22139, 22116, 22489, 22490, 22491, 22443
9012, 22116, 22139, 22140, 22117, 22491, 22492, 22493, 22445
9013, 22117, 22140, 22141, 22118, 22493, 22494, 22495, 22447
9014, 22118, 22141, 22142, 22119, 22495, 22496, 22497, 22449
9015, 22119, 22142, 22143, 22120, 22497, 22498, 22499, 22451
9016, 22120, 22143, 22144, 22121, 22499, 22500, 22501, 22453
9017, 22121, 22144, 22145, 22122, 22501, 22502, 22503, 22455
9018, 22122, 22145, 22146, 22123, 22503, 22504, 22505, 22457
9019, 22123, 22146, 22147, 22124, 22505, 22506, 22507, 22459
9020, 22124, 22147, 22148, 22125, 22507, 22508, 22509, 22461
9021, 22125, 22148, 22149, 22126, 22509, 22510, 22511, 22463
9022, 22126, 22149, 22150, 22127, 22511, 22512, 22513, 22465
9023, 22127, 22150, 22151, 22128, 22513, 22514, 22515, 22467
9024, 22128, 22151, 22152, 22129, 22515, 22516, 22517, 22469
9025, 22129, 22152, 22153, 22130, 22517, 22518, 22519, 22471
9026, 22130, 22153, 22154, 22131, 22519, 22520, 22521, 22473
9027, 22131, 22154, 22155, 22132, 22521, 22522, 22523, 22475
9028, 22132, 22155, 22156, 22133, 22523, 22524, 22525, 22477
9029, 22133, 22156, 22157, 22134, 22525, 22526, 22527, 22479
9030, 22134, 22157, 22158, 22135, 22527, 22528, 22529, 22481
9031, 22135, 22158, 22159, 22136, 22529, 22530, 22531, 22483
9032, 22136, 22159, 1962, 1961, 22531, 22532, 1973, 22485
9033, 1634, 1635, 22160, 22137, 1646, 22533, 22534, 22486
9034, 22137, 22160, 22161, 22138, 22534, 22535, 22536, 22488
9035, 22138, 22161, 22162, 22139, 22536, 22537, 22538, 22490
9036, 22139, 22162, 22163, 22140, 22538, 22539, 22540, 22492
9037, 22140, 22163, 22164, 22141, 22540, 22541, 22542, 22494
9038, 22141, 22164, 22165, 22142, 22542, 22543, 22544, 22496
9039, 22142, 22165, 22166, 22143, 22544, 22545, 22546, 22498
9040, 22143, 22166, 22167, 22144, 22546, 22547, 22548, 22500
9041, 22144, 22167, 22168, 22145, 22548, 22549, 22550, 22502
9042, 22145, 22168, 22169, 22146, 22550, 22551, 22552, 22504
9043, 22146, 22169, 22170, 22147, 22552, 22553, 22554, 22506
9044, 22147, 22170, 22171, 22148, 22554, 22555, 22556, 22508
9045, 22148, 22171, 22172, 22149, 22556, 22557, 22558, 22510
9046, 22149, 22172, 22173, 22150, 22558, 22559, 22560, 22512
9047, 22150, 22173, 22174, 22151, 22560, 22561, 22562, 22514
9048, 22151, 22174, 22175, 22152, 22562, 22563, 22564, 22516
9049, 22152, 22175, 22176, 22153, 22564, 22565, 22566, 22518
9050, 22153, 22176, 22177, 22154, 22566, 22567, 22568, 22520
9051, 22154, 22177, 22178, 22155, 22568, 22569, 22570, 22522
9052, 22155, 22178, 22179, 22156, 22570, 22571, 22572, 22524
9053, 22156, 22179, 22180, 22157, 22572, 22573, 22574, 22526
9054, 22157, 22180, 22181, 22158, 22574, 22575, 22576, 22528
9055, 22158, 22181, 22182, 22159, 22576, 22577, 22578, 22530
9056, 22159, 22182, 1963, 1962, 22578, 22579, 1974, 22532
9057, 1635, 1636, 22183, 22160, 1647, 22580, 22581, 22533
9058, 22160, 22183, 22184, 22161, 22581, 22582, 22583, 22535
9059, 22161, 22184, 22185, 22162, 22583, 22584, 22585, 22537
9060, 22162, 22185, 22186, 22163, 22585, 22586, 22587, 22539
9061, 22163, 22186, 22187, 22164, 22587, 22588, 22589, 22541
9062, 22164, 22187, 22188, 22165, 22589, 22590, 22591, 22543
9063, 22165, 22188, 22189, 22166, 22591, 22592, 22593, 22545
9064, 22166, 22189, 22190, 22167, 22593, 22594, 22595, 22547
9065, 22167, 22190, 22191, 22168, 22595, 22596, 22597, 22549
9066, 22168, 22191, 22192, 22169, 22597, 22598, 22599, 22551
9067, 22169, 22192, 22193, 22170, 22599, 22600, 22601, 22553
9068, 22170, 22193, 22194, 22171, 22601, 22602, 22603, 22555
9069, 22171, 22194, 22195, 22172, 22603, 22604, 22605, 22557
9070, 22172, 22195, 22196, 22173, 22605, 22606, 22607, 22559
9071, 22173, 22196, 22197, 22174, 22607, 22608, 22609, 22561
9072, 22174, 22197, 22198, 22175, 22609, 22610, 22611, 22563
9073, 22175, 22198, 22199, 22176, 22611, 22612, 22613, 22565
9074, 22176, 22199, 22200, 22177, 22613, 22614, 22615, 22567
9075, 22177, 22200, 22201, 22178, 22615, 22616, 22617, 22569
9076, 22178, 22201, 22202, 22179, 22617, 22618, 22619, 22571
9077, 22179, 22202, 22203, 22180, 22619, 22620, 22621, 22573
9078, 22180, 22203, 22204, 22181, 22621, 22622, 22623, 22575
9079, 22181, 22204, 22205, 22182, 22623, 22624, 22625, 22577
9080, 22182, 22205, 1964, 1963, 22625, 22626, 1975, 22579
9081, 1636, 1637, 22206, 22183, 1648, 22627, 22628, 22580
9082, 22183, 22206, 22207, 22184, 22628, 22629, 22630, 22582
9083, 22184, 22207, 22208, 22185, 22630, 22631, 22632, 22584
9084, 22185, 22208, 22209, 22186, 22632, 22633, 22634, 22586
9085, 22186, 22209, 22210, 22187, 22634, 22635, 22636, 22588
9086, 22187, 22210, 22211, 22188, 22636, 22637, 22638, 22590
9087, 22188, 22211, 22212, 22189, 22638, 22639, 22640, 22592
9088, 22189, 22212, 22213, 22190, 22640, 22641, 22642, 22594
9089, 22190, 22213, 22214, 22191, 22642, 22643, 22644, 22596
9090, 22191, 22214, 22215, 22192, 22644, 22645, 22646, 22598
9091, 22192, 22215, 22216, 22193, 22646, 22647, 22648, 22600
9092, 22193, 22216, 22217, 22194, 22648, 22649, 22650, 22602
9093, 22194, 22217, 22218, 22195, 22650, 22651, 22652, 22604
9094, 22195, 22218, 22219, 22196, 22652, 22653, 22654, 22606
9095, 22196, 22219, 22220, 22197, 22654, 22655, 22656, 22608
9096, 22197, 22220, 22221, 22198, 22656, 22657, 22658, 22610
9097, 22198, 22221, 22222, 22199, 22658, 22659, 22660, 22612
9098, 22199, 22222, 22223, 22200, 22660, 22661, 22662, 22614
9099, 22200, 22223, 22224, 22201, 22662, 22663, 22664, 22616
9100, 22201, 22224, 22225, 22202, 22664, 22665, 22666, 22618
9101, 22202, 22225, 22226, 22203, 22666, 22667, 22668, 22620
9102, 22203, 22226, 22227, 22204, 22668, 22669, 22670, 22622
9103, 22204, 22227, 22228, 22205, 22670, 22671, 22672, 22624
9104, 22205, 22228, 1965, 1964, 22672, 22673, 1976, 22626
9105, 1637, 1638, 22229, 22206, 1649, 22674, 22675, 22627
9106, 22206, 22229, 22230, 22207, 22675, 22676, 22677, 22629
9107, 22207, 22230, 22231, 22208, 22677, 22678, 22679, 22631
9108, 22208, 22231, 22232, 22209, 22679, 22680, 22681, 22633
9109, 22209, 22232, 22233, 22210, 22681, 22682, 22683, 22635
9110, 22210, 22233, 22234, 22211, 22683, 22684, 22685, 22637
9111, 22211, 22234, 22235, 22212, 22685, 22686, 22687, 22639
9112, 22212, 22235, 22236, 22213, 22687, 22688, 22689, 22641
9113, 22213, 22236, 22237, 22214, 22689, 22690, 22691, 22643
9114, 22214, 22237, 22238, 22215, 22691, 22692, 22693, 22645
9115, 22215, 22238, 22239, 22216, 22693, 22694, 22695, 22647
9116, 22216, 22239, 22240, 22217, 22695, 22696, 22697, 22649
9117, 22217, 22240, 22241, 22218, 22697, 22698, 22699, 22651
9118, 22218, 22241, 22242, 22219, 22699, 22700, 22701, 22653
9119, 22219, 22242, 22243, 22220, 22701, 22702, 22703, 22655
9120, 22220, 22243, 22244, 22221, 22703, 22704, 22705, 22657
9121, 22221, 22244, 22245, 22222, 22705, 22706, 22707, 22659
9122, 22222, 22245, 22246, 22223, 22707, 22708, 22709, 22661
9123, 22223, 22246, 22247, 22224, 22709, 22710, 22711, 22663
9124, 22224, 22247, 22248, 22225, 22711, 22712, 22713, 22665
9125, 22225, 22248, 22249, 22226, 22713, 22714, 22715, 22667
9126, 22226, 22249, 22250, 22227, 22715, 22716, 22717, 22669
9127, 22227, 22250, 22251, 22228, 22717, 22718, 22719, 22671
9128, 22228, 22251, 1966, 1965, 22719, 22720, 1977, 22673
9129, 1638, 1639, 22252, 22229, 1650, 22721, 22722, 22674
9130, 22229, 22252, 22253, 22230, 22722, 22723, 22724, 22676
9131, 22230, 22253, 22254, 22231, 22724, 22725, 22726, 22678
9132, 22231, 22254, 22255, 22232, 22726, 22727, 22728, 22680
9133, 22232, 22255, 22256, 22233, 22728, 22729, 22730, 22682
9134, 22233, 22256, 22257, 22234, 22730, 22731, 22732, 22684
9135, 22234, 22257, 22258, 22235, 22732, 22733, 22734, 22686
9136, 22235, 22258, 22259, 22236, 22734, 22735, 22736, 22688
9137, 22236, 22259, 22260, 22237, 22736, 22737, 22738, 22690
9138, 22237, 22260, 22261, 22238, 22738, 22739, 22740, 22692
9139, 22238, 22261, 22262, 22239, 22740, 22741, 22742, 22694
9140, 22239, 22262, 22263, 22240, 22742, 22743, 22744, 22696
9141, 22240, 22263, 22264, 22241, 22744, 22745, 22746, 22698
9142, 22241, 22264, 22265, 22242, 22746, 22747, 22748, 22700
9143, 22242, 22265, 22266, 22243, 22748, 22749, 22750, 22702
9144, 22243, 22266, 22267, 22244, 22750, 22751, 22752, 22704
9145, 22244, 22267, 22268, 22245, 22752, 22753, 22754, 22706
9146, 22245, 22268, 22269, 22246, 22754, 22755, 22756, 22708
9147, 22246, 22269, 22270, 22247, 22756, 22757, 22758, 22710
9148, 22247, 22270, 22271, 22248, 22758, 22759, 22760, 22712
9149, 22248, 22271, 22272, 22249, 22760, 22761, 22762, 22714
9150, 22249, 22272, 22273, 22250, 22762, 22763, 22764, 22716
9151, 22250, 22273, 22274, 22251, 22764, 22765, 22766, 22718
9152, 22251, 22274, 1967, 1966, 22766, 22767, 1978, 22720
9153, 1639, 1640, 22275, 22252, 1651, 22768, 22769, 22721
9154, 22252, 22275, 22276, 22253, 22769, 22770, 22771, 22723
9155, 22253, 22276, 22277, 22254, 22771, 22772, 22773, 22725
9156, 22254, 22277, 22278, 22255, 22773, 22774, 22775, 22727
9157, 22255, 22278, 22279, 22256, 22775, 22776, 22777, 22729
9158, 22256, 22279, 22280, 22257, 22777, 22778, 22779, 22731
9159, 22257, 22280, 22281, 22258, 22779, 22780, 22781, 22733
9160, 22258, 22281, 22282, 22259, 22781, 22782, 22783, 22735
9161, 22259, 22282, 22283, 22260, 22783, 22784, 22785, 22737
9162, 22260, 22283, 22284, 22261, 22785, 22786, 22787, 22739
9163, 22261, 22284, 22285, 22262, 22787, 22788, 22789, 22741
9164, 22262, 22285, 22286, 22263, 22789, 22790, 22791, 22743
9165, 22263, 22286, 22287, 22264, 22791, 22792, 22793, 22745
9166, 22264, 22287, 22288, 22265, 22793, 22794, 22795, 22747
9167, 22265, 22288, 22289, 22266, 22795, 22796, 22797, 22749
9168, 22266, 22289, 22290, 22267, 22797, 22798, 22799, 22751
9169, 22267, 22290, 22291, 22268, 22799, 22800, 22801, 22753
9170, 22268, 22291, 22292, 22269, 22801, 22802, 22803, 22755
9171, 22269, 22292, 22293, 22270, 22803, 22804, 22805, 22757
9172, 22270, 22293, 22294, 22271, 22805, 22806, 22807, 22759
9173, 22271, 22294, 22295, 22272, 22807, 22808, 22809, 22761
9174, 22272, 22295, 22296, 22273, 22809, 22810, 22811, 22763
9175, 22273, 22296, 22297, 22274, 22811, 22812, 22813, 22765
9176, 22274, 22297, 1968, 1967, 22813, 22814, 1979, 22767
9177, 1640, 34, 1700, 22275, 1652, 1723, 22815, 22768
9178, 22275, 1700, 1701, 22276, 22815, 1724, 22816, 22770
9179, 22276, 1701, 1702, 22277, 22816, 1725, 22817, 22772
9180, 22277, 1702, 1703, 22278, 22817, 1726, 22818, 22774
9181, 22278, 1703, 1704, 22279, 22818, 1727, 22819, 22776
9182, 22279, 1704, 1705, 22280, 22819, 1728, 22820, 22778
9183, 22280, 1705, 1706, 22281, 22820, 1729, 22821, 22780
9184, 22281, 1706, 1707, 22282, 22821, 1730, 22822, 22782
9185, 22282, 1707, 1708, 22283, 22822, 1731, 22823, 22784
9186, 22283, 1708, 1709, 22284, 22823, 1732, 22824, 22786
9187, 22284, 1709, 1710, 22285, 22824, 1733, 22825, 22788
9188, 22285, 1710, 1711, 22286, 22825, 1734, 22826, 22790
9189, 22286, 1711, 1712, 22287, 22826, 1735, 22827, 22792
9190, 22287, 1712, 1713, 22288, 22827, 1736, 22828, 22794
9191, 22288, 1713, 1714, 22289, 22828, 1737, 22829, 22796
9192, 22289, 1714, 1715, 22290, 22829, 1738, 22830, 22798
9193, 22290, 1715, 1716, 22291, 22830, 1739, 22831, 22800
9194, 22291, 1716, 1717, 22292, 22831, 1740, 22832, 22802
9195, 22292, 1717, 1718, 22293, 22832, 1741, 22833, 22804
9196, 22293, 1718, 1719, 22294, 22833, 1742, 22834, 22806
9197, 22294, 1719, 1720, 22295, 22834, 1743, 22835, 22808
9198, 22295, 1720, 1721, 22296, 22835, 1744, 22836, 22810
9199, 22296, 1721, 1722, 22297, 22836, 1745, 22837, 22812
9200, 22297, 1722, 38, 1968, 22837, 1746, 1980, 22814
*ELEMENT, type=CPS8, ELSET=Surface46
9201, 39, 1888, 22838, 1935, 1911, 23091, 23092, 1946
9202, 1888, 1889, 22839, 22838, 1912, 23093, 23094, 23091
9203, 1889, 1890, 22840, 22839, 1913, 23095, 23096, 23093
9204, 1890, 1891, 22841, 22840, 1914, 23097, 23098, 23095
9205, 1891, 1892, 22842, 22841, 1915, 23099, 23100, 23097
9206, 1892, 1893, 22843, 22842, 1916, 23101, 23102, 23099
9207, 1893, 1894, 22844, 22843, 1917, 23103, 23104, 23101
9208, 1894, 1895, 22845, 22844, 1918, 23105, 23106, 23103
9209, 1895, 1896, 22846, 22845, 1919, 23107, 23108, 23105
9210, 1896, 1897, 22847, 22846, 1920, 23109, 23110, 23107
9211, 1897, 1898, 22848, 22847, 1921, 23111, 23112, 23109
9212, 1898, 1899, 22849, 22848, 1922, 23113, 23114, 23111
9213, 1899, 1900, 22850, 22849, 1923, 23115, 23116, 23113
9214, 1900, 1901, 22851, 22850, 1924, 23117, 23118, 23115
9215, 1901, 1902, 22852, 22851, 1925, 23119, 23120, 23117
9216, 1902, 1903, 22853, 22852, 1926, 23121, 23122, 23119
9217, 1903, 1904, 22854, 22853, 1927, 23123, 23124, 23121
9218, 1904, 1905, 22855, 22854, 1928, 23125, 23126, 23123
9219, 1905, 1906, 22856, 22855, 1929, 23127, 23128, 23125
9220, 1906, 1907, 22857, 22856, 1930, 23129, 23130, 23127
9221, 1907, 1908, 22858, 22857, 1931, 23131, 23132, 23129
9222, 1908, 1909, 22859, 22858, 1932, 23133, 23134, 23131
9223, 1909, 1910, 22860, 22859, 1933, 23135, 23136, 23133
9224, 1910, 40, 1958, 22860, 1934, 1969, 23137, 23135
9225, 1935, 22838, 22861, 1936, 23092, 23138, 23139, 1947
9226, 22838, 22839, 22862, 22861, 23094, 23140, 23141, 23138
9227, 22839, 22840, 22863, 22862, 23096, 23142, 23143, 23140
9228, 22840, 22841, 22864, 22863, 23098, 23144, 23145, 23142
9229, 22841, 22842, 22865, 22864, 23100, 23146, 23147, 23144
9230, 22842, 22843, 22866, 22865, 23102, 23148, 23149, 23146
9231, 22843, 22844, 22867, 22866, 23104, 23150, 23151, 23148
9232, 22844, 22845, 22868, 22867, 23106, 23152, 23153, 23150
9233, 22845, 22846, 22869, 22868, 23108, 23154, 23155, 23152
9234, 22846, 22847, 22870, 22869, 23110, 23156, 23157, 23154
9235, 22847, 22848, 22871, 22870, 23112, 23158, 23159, 23156
9236, 22848, 22849, 22872, 22871, 23114, 23160, 23161, 23158
9237, 22849, 22850, 22873, 22872, 23116, 23162, 23163, 23160
9238, 22850, 22851, 22874, 22873, 23118, 23164, 23165, 23162
9239, 22851, 22852, 22875, 22874, 23120, 23166, 23167, 23164
9240, 22852, 22853, 22876, 22875, 23122, 23168, 23169, 23166
9241, 22853, 22854, 22877, 22876, 23124, 23170, 23171, 23168
9242, 22854, 22855, 22878, 22877, 23126, 23172, 23173, 23170
9243, 22855, 22856, 22879, 22878, 23128, 23174, 23175, 23172
9244, 22856, 22857, 22880, 22879, 23130, 23176, 23177, 23174
9245, 22857, 22858, 22881, 22880, 23132, 23178, 23179, 23176
9246, 22858, 22859, 22882, 22881, 23134, 23180, 23181, 23178
9247, 22859, 22860, 22883, 22882, 23136, 23182, 23183, 23180
9248, 22860, 1958, 1959, 22883, 23137, 1970, 23184, 23182
9249, 1936, 22861, 22884, 1937, 23139, 23185, 23186, 1948
9250, 22861, 22862, 22885, 22884, 23141, 23187, 23188, 23185
9251, 22862, 22863, 22886, 22885, 23143, 23189, 23190, 23187
9252, 22863, 22864, 22887, 22886, 23145, 23191, 23192, 23189
9253, 22864, 22865, 22888, 22887, 23147, 23193, 23194, 23191
9254, 22865, 22866, 22889, 22888, 23149, 23195, 23196, 23193
9255, 22866, 22867, 22890, 22889, 23151, 23197, 23198, 23195
9256, 22867, 22868, 22891, 22890, 23153, 23199, 23200, 23197
9257, 22868, 22869, 22892, 22891, 23155, 23201, 23202, 23199
9258, 22869, 22870, 22893, 22892, 23157, 23203, 23204, 23201
9259, 22870, 22871, 22894, 22893, 23159, 23205, 23206, 23203
9260, 22871, 22872, 22895, 22894, 23161, 23207, 23208, 23205
9261, 22872, 22873, 22896, 22895, 23163, 23209, 23210, 23207
9262, 22873, 22874, 22897, 22896, 23165, 23211, 23212, 23209
9263, 22874, 22875, 22898, 22897, 23167, 23213, 23214, 23211
9264, 22875, 22876, 22899, 22898, 23169, 23215, 23216, 23213
9265, 22876, 22877, 22900, 22899, 23171, 23217, 23218, 23215
9266, 22877, 22878, 22901, 22900, 23173, 23219, 23220, 23217
9267, 22878, 22879, 22902, 22901, 23175, 23221, 23222, 23219
9268, 22879, 22880, 22903, 22902, 23177, 23223, 23224, 23221
9269, 22880, 22881, 22904, 22903, 23179, 23225, 23226, 23223
9270, 22881, 22882, 22905, 22904, 23181, 23227, 23228, 23225
9271, 22882, 22883, 22906, 22905, 23183, 23229, 23230, 23227
9272, 22883, 1959, 1960, 22906, 23184, 1971, 23231, 23229
9273, 1937, 22884, 22907, 1938, 23186, 23232, 23233, 1949
9274, 22884, 22885, 22908, 22907, 23188, 23234, 23235, 23232
9275, 22885, 22886, 22909, 22908, 23190, 23236, 23237, 23234
9276, 22886, 22887, 22910, 22909, 23192, 23238, 23239, 23236
9277, 22887, 22888, 22911, 22910, 23194, 23240, 23241, 23238
9278, 22888, 22889, 22912, 22911, 23196, 23242, 23243, 23240
9279, 22889, 22890, 22913, 22912, 23198, 23244, 23245, 23242
9280, 22890, 22891, 22914, 22913, 23200, 23246, 23247, 23244
9281, 22891, 22892, 22915, 22914, 23202, 23248, 23249, 23246
9282, 22892, 22893, 22916, 22915, 23204, 23250, 23251, 23248
9283, 22893, 22894, 22917, 22916, 23206, 23252, 23253, 23250
9284, 22894, 22895, 22918, 22917, 23208, 23254, 23255, 23252
9285, 22895, 22896, 22919, 22918, 23210, 23256, 23257, 23254
9286, 22896, 22897, 22920, 22919, 23212, 23258, 23259, 23256
9287, 22897, 22898, 22921, 22920, 23214, 23260, 23261, 23258
9288, 22898, 22899, 22922, 22921, 23216, 23262, 23263, 23260
9289, 22899, 22900, 22923, 22922, 23218, 23264, 23265, 23262
9290, 22900, 22901, 22924, 22923, 23220, 23266, 23267, 23264
9291, 22901, 22902, 22925, 22924, 23222, 23268, 23269, 23266
9292, 22902, 22903, 22926, 22925, 23224, 23270, 23271, 23268
9293, 22903, 22904, 22927, 22926, 23226, 23272, 23273, 23270
9294, 22904, 22905, 22928, 22927, 23228, 23274, 23275, 23272
9295, 22905, 22906, 22929, 22928, 23230, 23276, 23277, 23274
9296, 22906, 1960, 1961, 22929, 23231, 1972, 23278, 23276
9297, 1938, 22907, 22930, 1939, 23233, 23279, 23280, 1950
9298, 22907, 22908, 22931, 22930, 23235, 23281, 23282, 23279
9299, 22908, 22909, 22932, 22931, 23237, 23283, 23284, 23281
9300, 22909, 22910, 22933, 22932, 23239, 23285, 23286, 23283
9301, 22910, 22911, 22934, 22933, 23241, 23287, 23288, 23285
9302, 22911, 22912, 22935, 22934, 23243, 23289, 23290, 23287
9303, 22912, 22913, 22936, 22935, 23245, 23291, 23292, 23289
9304, 22913, 22914, 22937, 22936, 23247, 23293, 23294, 23291
9305, 22914, 22915, 22938, 22937, 23249, 23295, 23296, 23293
9306, 22915, 22916, 22939, 22938, 23251, 23297, 23298, 23295
9307, 22916, 22917, 22940, 22939, 23253, 23299, 23300, 23297
9308, 22917, 22918, 22941, 22940, 23255, 23301, 23302, 23299
9309, 22918, 22919, 22942, 22941, 23257, 23303, 23304, 23301
9310, 22919, 22920, 22943, 22942, 23259, 23305, 23306, 23303
9311, 22920, 22921, 22944, 22943, 23261, 23307, 23308, 23305
9312, 22921, 22922, 22945, 22944, 23263, 23309, 23310, 23307
9313, 22922, 22923, 22946, 22945, 23265, 23311, 23312, 23309
9314, 22923, 22924, 22947, 22946, 23267, 23313, 23314, 23311
9315, 22924, 22925, 22948, 22947, 23269, 23315, 23316, 23313
9316, 22925, 22926, 22949, 22948, 23271, 23317, 23318, 23315
9317, 22926, 22927, 22950, 22949, 23273, 23319, 23320, 23317
9318, 22927, 22928, 22951, 22950, 23275, 23321, 23322, 23319
9319, 22928, 22929, 22952, 22951, 23277, 23323, 23324, 23321
9320, 22929, 1961, 1962, 22952, 23278, 1973, 23325, 23323
9321, 1939, 22930, 22953, 1940, 23280, 23326, 23327, 1951
9322, 22930, 22931, 22954, 22953, 23282, 23328, 23329, 23326
9323, 22931, 22932, 22955, 22954, 23284, 23330, 23331, 23328
9324, 22932, 22933, 22956, 22955, 23286, 23332, 23333, 23330
9325, 22933, 22934, 22957, 22956, 23288, 23334, 23335, 23332
9326, 22934, 22935, 22958, 22957, 23290, 23336, 23337, 23334
9327, 22935, 22936, 22959, 22958, 23292, 23338, 23339, 23336
9328, 22936, 22937, 22960, 22959, 23294, 23340, 23341, 23338
9329, 22937, 22938, 22961, 22960, 23296, 23342, 23343, 23340
9330, 22938, 22939, 22962, 22961, 23298, 23344, 23345, 23342
9331, 22939, 22940, 22963, 22962, 23300, 23346, 23347, 23344
9332, 22940, 22941, 22964, 22963, 23302, 23348, 23349, 23346
9333, 22941, 22942, 22965, 22964, 23304, 23350, 23351, 23348
9334, 22942, 22943, 22966, 22965, 23306, 23352, 23353, 23350
9335, 22943, 22944, 22967, 22966, 23308, 23354, 23355, 23352
9336, 22944, 22945, 22968, 22967, 23310, 23356, 23357, 23354
9337, 22945, 22946, 22969, 22968, 23312, 23358, 23359, 23356
9338, 22946, 22947, 22970, 22969, 23314, 23360, 23361, 23358
9339, 22947, 22948, 22971, 22970, 23316, 23362, 23363, 23360
9340, 22948, 22949, 22972, 22971, 23318, 23364, 23365, 23362
9341, 22949, 22950, 22973, 22972, 23320, 23366, 23367, 23364
9342, 22950, 22951, 22974, 22973, 23322, 23368, 23369, 23366
9343, 22951, 22952, 22975, 22974, 23324, 23370, 23371, 23368
9344, 22952, 1962, 1963, 22975, 23325, 1974, 23372, 23370
9345, 1940, 22953, 22976, 1941, 23327, 23373, 23374, 1952
9346, 22953, 22954, 22977, 22976, 23329, 23375, 23376, 23373
9347, 22954, 22955, 22978, 22977, 23331, 23377, 23378, 23375
9348, 22955, 22956, 22979, 22978, 23333, 23379, 23380, 23377
9349, 22956, 22957, 22980, 22979, 23335, 23381, 23382, 23379
9350, 22957, 22958, 22981, 22980, 23337, 23383, 23384, 23381
9351, 22958, 22959, 22982, 22981, 23339, 23385, 23386, 23383
9352, 22959, 22960, 22983, 22982, 23341, 23387, 23388, 23385
9353, 22960, 22961, 22984, 22983, 23343, 23389, 23390, 23387
9354, 22961, 22962, 22985, 22984, 23345, 23391, 23392, 23389
9355, 22962, 22963, 22986, 22985, 23347, 23393, 23394, 23391
9356, 22963, 22964, 22987, 22986, 23349, 23395, 23396, 23393
9357, 22964, 22965, 22988, 22987, 23351, 23397, 23398, 23395
9358, 22965, 22966, 22989, 22988, 23353, 23399, 23400, 23397
9359, 22966, 22967, 22990, 22989, 23355, 23401, 23402, 23399
9360, 22967, 22968, 22991, 22990, 23357, 23403, 23404, 23401
9361, 22968, 22969, 22992, 22991, 23359, 23405, 23406, 23403
9362, 22969, 22970, 22993, 22992, 23361, 23407, 23408, 23405
9363, 22970, 22971, 22994, 22993, 23363, 23409, 23410, 23407
9364, 22971, 22972, 22995, 22994, 23365, 23411, 23412, 23409
9365, 22972, 22973, 22996, 22995, 23367, 23413, 23414, 23411
9366, 22973, 22974, 22997, 22996, 23369, 23415, 23416, 23413
9367, 22974, 22975, 22998, 22997, 23371, 23417, 23418, 23415
9368, 22975, 1963, 1964, 22998, 23372, 1975, 23419, 23417
9369, 1941, 22976, 22999, 1942, 23374, 23420, 23421, 1953
9370, 22976, 22977, 23000, 22999, 23376, 23422, 23423, 23420
9371, 22977, 22978, 23001, 23000, 23378, 23424, 23425, 23422
9372, 22978, 22979, 23002, 23001, 23380, 23426, 23427, 23424
9373, 22979, 22980, 23003, 23002, 23382, 23428, 23429, 23426
9374, 22980, 22981, 23004, 23003, 23384, 23430, 23431, 23428
9375, 22981, 22982, 23005, 23004, 23386, 23432, 23433, 23430
9376, 22982, 22983, 23006, 23005, 23388, 23434, 23435, 23432
9377, 22983, 22984, 23007, 23006, 23390, 23436, 23437, 23434
9378, 22984, 22985, 23008, 23007, 23392, 23438, 23439, 23436
9379, 22985, 22986, 23009, 23008, 23394, 23440, 23441, 23438
9380, 22986, 22987, 23010, 23009, 23396, 23442, 23443, 23440
9381, 22987, 22988, 23011, 23010, 23398, 23444, 23445, 23442
9382, 22988, 22989, 23012, 23011, 23400, 23446, 23447, 23444
9383, 22989, 22990, 23013, 23012, 23402, 23448, 23449, 23446
9384, 22990, 22991, 23014, 23013, 23404, 23450, 23451, 23448
9385, 22991, 22992, 23015, 23014, 23406, 23452, 23453, 23450
9386, 22992, 22993, 23016, 23015, 23408, 23454, 23455, 23452
9387, 22993, 22994, 23017, 23016, 23410, 23456, 23457, 23454
9388, 22994, 22995, 23018, 23017, 23412, 23458, 23459, 23456
9389, 22995, 22996, 23019, 23018, 23414, 23460, 23461, 23458
9390, 22996, 22997, 23020, 23019, 23416, 23462, 23463, 23460
9391, 22997, 22998, 23021, 23020, 23418, 23464, 23465, 23462
9392, 22998, 1964, 1965, 23021, 23419, 1976, 23466, 23464
9393, 1942, 22999, 23022, 1943, 23421, 23467, 23468, 1954
9394, 22999, 23000, 23023, 23022, 23423, 23469, 23470, 23467
9395, 23000, 23001, 23024, 23023, 23425, 23471, 23472, 23469
9396, 23001, 23002, 23025, 23024, 23427, 23473, 23474, 23471
9397, 23002, 23003, 23026, 23025, 23429, 23475, 23476, 23473
9398, 23003, 23004, 23027, 23026, 23431, 23477, 23478, 23475
9399, 23004, 23005, 23028, 23027, 23433, 23479, 23480, 23477
9400, 23005, 23006, 23029, 23028, 23435, 23481, 23482, 23479
9401, 23006, 23007, 23030, 23029, 23437, 23483, 23484, 23481
9402, 23007, 23008, 23031, 23030, 23439, 23485, 23486, 23483
9403, 23008, 23009, 23032, 23031, 23441, 23487, 23488, 23485
9404, 23009, 23010, 23033, 23032, 23443, 23489, 23490, 23487
9405, 23010, 23011, 23034, 23033, 23445, 23491, 23492, 23489
9406, 23011, 23012, 23035, 23034, 23447, 23493, 23494, 23491
9407, 23012, 23013, 23036, 23035, 23449, 23495, 23496, 23493
9408, 23013, 23014, 23037, 23036, 23451, 23497, 23498, 23495
9409, 23014, 23015, 23038, 23037, 23453, 23499, 23500, 23497
9410, 23015, 23016, 23039, 23038, 23455, 23501, 23502, 23499
9411, 23016, 23017, 23040, 23039, 23457, 23503, 23504, 23501
9412, 23017, 23018, 23041, 23040, 23459, 23505, 23506, 23503
9413, 23018, 23019, 23042, 23041, 23461, 23507, 23508, 23505
9414, 23019, 23020, 23043, 23042, 23463, 23509, 23510, 23507
9415, 23020, 23021, 23044, 23043, 23465, 23511, 23512, 23509
9416, 23021, 1965, 1966, 23044, 23466, 1977, 23513, 23511
9417, 1943, 23022, 23045, 1944, 23468, 23514, 23515, 1955
9418, 23022, 23023, 23046, 23045, 23470, 23516, 23517, 23514
9419, 23023, 23024, 23047, 23046, 23472, 23518, 23519, 23516
9420, 23024, 23025, 23048, 23047, 23474, 23520, 23521, 23518
9421, 23025, 23026, 23049, 23048, 23476, 23522, 23523, 23520
9422, 23026, 23027, 23050, 23049, 23478, 23524, 23525, 23522
9423, 23027, 23028, 23051, 23050, 23480, 23526, 23527, 23524
9424, 23028, 23029, 23052, 23051, 23482, 23528, 23529, 23526
9425, 23029, 23030, 23053, 23052, 23484, 23530, 23531, 23528
9426, 23030, 23031, 23054, 23053, 23486, 23532, 23533, 23530
9427, 23031, 23032, 23055, 23054, 23488, 23534, 23535, 23532
9428, 23032, 23033, 23056, 23055, 23490, 23536, 23537, 23534
9429, 23033, 23034, 23057, 23056, 23492, 23538, 23539, 23536
9430, 23034, 23035, 23058, 23057, 23494, 23540, 23541, 23538
9431, 23035, 23036, 23059, 23058, 23496, 23542, 23543, 23540
9432, 23036, 23037, 23060, 23059, 23498, 23544, 23545, 23542
9433, 23037, 23038, 23061, 23060, 23500, 23546, 23547, 23544
9434, 23038, 23039, 23062, 23061, 23502, 23548, 23549, 23546
9435, 23039, 23040, 23063, 23062, 23504, 23550, 23551, 23548
9436, 23040, 23041, 23064, 23063, 23506, 23552, 23553, 23550
9437, 23041, 23042, 23065, 23064, 23508, 23554, 23555, 23552
9438, 23042, 23043, 23066, 23065, 23510, 23556, 23557, 23554
9439, 23043, 23044, 23067, 23066, 23512, 23558, 23559, 23556
9440, 23044, 1966, 1967, 23067, 23513, 1978, 23560, 23558
9441, 1944, 23045, 23068, 1945, 23515, 23561, 23562, 1956
9442, 23045, 23046, 23069, 23068, 23517, 23563, 23564, 23561
9443, 23046, 23047, 23070, 23069, 23519, 23565, 23566, 23563
9444, 23047, 23048, 23071, 23070, 23521, 23567, 23568, 23565
9445, 23048, 23049, 23072, 23071, 23523, 23569, 23570, 23567
9446, 23049, 23050, 23073, 23072, 23525, 23571, 23572, 23569
9447, 23050, 23051, 23074, 23073, 23527, 23573, 23574, 23571
9448, 23051, 23052, 23075, 23074, 23529, 23575, 23576, 23573
9449, 23052, 23053, 23076, 23075, 23531, 23577, 23578, 23575
9450, 23053, 23054, 23077, 23076, 23533, 23579, 23580, 23577
9451, 23054, 23055, 23078, 23077, 23535, 23581, 23582, 23579
9452, 23055, 23056, 23079, 23078, 23537, 23583, 23584, 23581
9453, 23056, 23057, 23080, 23079, 23539, 23585, 23586, 23583
9454, 23057, 23058, 23081, 23080, 23541, 23587, 23588, 23585
9455, 23058, 23059, 23082, 23081, 23543, 23589, 23590, 23587
9456, 23059, 23060, 23083, 23082, 23545, 23591, 23592, 23589
9457, 23060, 23061, 23084, 23083, 23547, 23593, 23594, 23591
9458, 23061, 23062, 23085, 23084, 23549, 23595, 23596, 23593
9459, 23062, 23063, 23086, 23085, 23551, 23597, 23598, 23595
9460, 23063, 23064, 23087, 23086, 23553, 23599, 23600, 23597
9461, 23064, 23065, 23088, 23087, 23555, 23601, 23602, 23599
9462, 23065, 23066, 23089, 23088, 23557, 23603, 23604, 23601
9463, 23066, 23067, 23090, 23089, 23559, 23605, 23606, 23603
9464, 23067, 1967, 1968, 23090, 23560, 1979, 23607, 23605
9465, 1945, 23068, 1747, 37, 23562, 23608, 1770, 1957
9466, 23068, 23069, 1748, 1747, 23564, 23609, 1771, 23608
9467, 23069, 23070, 1749, 1748, 23566, 23610, 1772, 23609
9468, 23070, 23071, 1750, 1749, 23568, 23611, 1773, 23610
9469, 23071, 23072, 1751, 1750, 23570, 23612, 1774, 23611
9470, 23072, 23073, 1752, 1751, 23572, 23613, 1775, 23612
9471, 23073, 23074, 1753, 1752, 23574, 23614, 1776, 23613
9472, 23074, 23075, 1754, 1753, 23576, 23615, 1777, 23614
9473, 23075, 23076, 1755, 1754, 23578, 23616, 1778, 23615
9474, 23076, 23077, 1756, 1755, 23580, 23617, 1779, 23616
9475, 23077, 23078, 1757, 1756, 23582, 23618, 1780, 23617
9476, 23078, 23079, 1758, 1757, 23584, 23619, 1781, 23618
9477, 23079, 23080, 1759, 1758, 23586, 23620, 1782, 23619
9478, 23080, 23081, 1760, 1759, 23588, 23621, 1783, 23620
9479, 23081, 23082, 1761, 1760, 23590, 23622, 1784, 23621
9480, 23082, 23083, 1762, 1761, 23592, 23623, 1785, 23622
9481, 23083, 23084, 1763, 1762, 23594, 23624, 1786, 23623
9482, 23084, 23085, 1764, 1763, 23596, 23625, 1787, 23624
9483, 23085, 23086, 1765, 1764, 23598, 23626, 1788, 23625
9484, 23086, 23087, 1766, 1765, 23600, 23627, 1789, 23626
9485, 23087, 23088, 1767, 1766, 23602, 23628, 1790, 23627
9486, 23088, 23089, 1768, 1767, 23604, 23629, 1791, 23628
9487, 23089, 23090, 1769, 1768, 23606, 23630, 1792, 23629
9488, 23090, 1968, 38, 1769, 23607, 1980, 1793, 23630
*ELEMENT, type=CPS8, ELSET=Surface47
9489, 37, 41, 1983, 1747, 1981, 2006, 23631, 1770
9490, 1747, 1983, 1984, 1748, 23631, 2007, 23632, 1771
9491, 1748, 1984, 1985, 1749, 23632, 2008, 23633, 1772
9492, 1749, 1985, 1986, 1750, 23633, 2009, 23634, 1773
9493, 1750, 1986, 1987, 1751, 23634, 2010, 23635, 1774
9494, 1751, 1987, 1988, 1752, 23635, 2011, 23636, 1775
9495, 1752, 1988, 1989, 1753, 23636, 2012, 23637, 1776
9496, 1753, 1989, 1990, 1754, 23637, 2013, 23638, 1777
9497, 1754, 1990, 1991, 1755, 23638, 2014, 23639, 1778
9498, 1755, 1991, 1992, 1756, 23639, 2015, 23640, 1779
9499, 1756, 1992, 1993, 1757, 23640, 2016, 23641, 1780
9500, 1757, 1993, 1994, 1758, 23641, 2017, 23642, 1781
9501, 1758, 1994, 1995, 1759, 23642, 2018, 23643, 1782
9502, 1759, 1995, 1996, 1760, 23643, 2019, 23644, 1783
9503, 1760, 1996, 1997, 1761, 23644, 2020, 23645, 1784
9504, 1761, 1997, 1998, 1762, 23645, 2021, 23646, 1785
9505, 1762, 1998, 1999, 1763, 23646, 2022, 23647, 1786
9506, 1763, 1999, 2000, 1764, 23647, 2023, 23648, 1787
9507, 1764, 2000, 2001, 1765, 23648, 2024, 23649, 1788
9508, 1765, 2001, 2002, 1766, 23649, 2025, 23650, 1789
9509, 1766, 2002, 2003, 1767, 23650, 2026, 23651, 1790
9510, 1767, 2003, 2004, 1768, 23651, 2027, 23652, 1791
9511, 1768, 2004, 2005, 1769, 23652, 2028, 23653, 1792
9512, 1769, 2005, 42, 38, 23653, 2029, 1982, 1793
*ELEMENT, type=CPS8, ELSET=Surface48
9513, 39, 1888, 2032, 43, 1911, 23654, 2055, 2030
9514, 1888, 1889, 2033, 2032, 1912, 23655, 2056, 23654
9515, 1889, 1890, 2034, 2033, 1913, 23656, 2057, 23655
9516, 1890, 1891, 2035, 2034, 1914, 23657, 2058, 23656
9517, 1891, 1892, 2036, 2035, 1915, 23658, 2059, 23657
9518, 1892, 1893, 2037, 2036, 1916, 23659, 2060, 23658
9519, 1893, 1894, 2038, 2037, 1917, 23660, 2061, 23659
9520, 1894, 1895, 2039, 2038, 1918, 23661, 2062, 23660
9521, 1895, 1896, 2040, 2039, 1919, 23662, 2063, 23661
9522, 1896, 1897, 2041, 2040, 1920, 23663, 2064, 23662
9523, 1897, 1898, 2042, 2041, 1921, 23664, 2065, 23663
9524, 1898, 1899, 2043, 2042, 1922, 23665, 2066, 23664
9525, 1899, 1900, 2044, 2043, 1923, 23666, 2067, 23665
9526, 1900, 1901, 2045, 2044, 1924, 23667, 2068, 23666
9527, 1901, 1902, 2046, 2045, 1925, 23668, 2069, 23667
9528, 1902, 1903, 2047, 2046, 1926, 23669, 2070, 23668
9529, 1903, 1904, 2048, 2047, 1927, 23670, 2071, 23669
9530, 1904, 1905, 2049, 2048, 1928, 23671, 2072, 23670
9531, 1905, 1906, 2050, 2049, 1929, 23672, 2073, 23671
9532, 1906, 1907, 2051, 2050, 1930, 23673, 2074, 23672
9533, 1907, 1908, 2052, 2051, 1931, 23674, 2075, 23673
9534, 1908, 1909, 2053, 2052, 1932, 23675, 2076, 23674
9535, 1909, 1910, 2054, 2053, 1933, 23676, 2077, 23675
9536, 1910, 40, 44, 2054, 1934, 2031, 2078, 23676
*ELEMENT, type=CPS8, ELSET=Surface49
9537, 39, 43, 2079, 1935, 2030, 2090, 23677, 1946
9538, 1935, 2079, 2080, 1936, 23677, 2091, 23678, 1947
9539, 1936, 2080, 2081, 1937, 23678, 2092, 23679, 1948
9540, 1937, 2081, 2082, 1938, 23679, 2093, 23680, 1949
9541, 1938, 2082, 2083, 1939, 23680, 2094, 23681, 1950
9542, 1939, 2083, 2084, 1940, 23681, 2095, 23682, 1951
9543, 1940, 2084, 2085, 1941, 23682, 2096, 23683, 1952
9544, 1941, 2085, 2086, 1942, 23683, 2097, 23684, 1953
9545, 1942, 2086, 2087, 1943, 23684, 2098, 23685, 1954
9546, 1943, 2087, 2088, 1944, 23685, 2099, 23686, 1955
9547, 1944, 2088, 2089, 1945, 23686, 2100, 23687, 1956
9548, 1945, 2089, 41, 37, 23687, 2101, 1981, 1957
*ELEMENT, type=CPS8, ELSET=Surface50
9549, 40, 1958, 2102, 44, 1969, 23688, 2113, 2031
9550, 1958, 1959, 2103, 2102, 1970, 23689, 2114, 23688
9551, 1959, 1960, 2104, 2103, 1971, 23690, 2115, 23689
9552, 1960, 1961, 2105, 2104, 1972, 23691, 2116, 23690
9553, 1961, 1962, 2106, 2105, 1973, 23692, 2117, 23691
9554, 1962, 1963, 2107, 2106, 1974, 23693, 2118, 23692
9555, 1963, 1964, 2108, 2107, 1975, 23694, 2119, 23693
9556, 1964, 1965, 2109, 2108, 1976, 23695, 2120, 23694
9557, 1965, 1966, 2110, 2109, 1977, 23696, 2121, 23695
9558, 1966, 1967, 2111, 2110, 1978, 23697, 2122, 23696
9559, 1967, 1968, 2112, 2111, 1979, 23698, 2123, 23697
9560, 1968, 38, 42, 2112, 1980, 1982, 2124, 23698
*ELEMENT, type=CPS8, ELSET=Surface51
9561, 43, 2032, 23699, 2079, 2055, 23952, 23953, 2090
9562, 2032, 2033, 23700, 23699, 2056, 23954, 23955, 23952
9563, 2033, 2034, 23701, 23700, 2057, 23956, 23957, 23954
9564, 2034, 2035, 23702, 23701, 2058, 23958, 23959, 23956
9565, 2035, 2036, 23703, 23702, 2059, 23960, 23961, 23958
9566, 2036, 2037, 23704, 23703, 2060, 23962, 23963, 23960
9567, 2037, 2038, 23705, 23704, 2061, 23964, 23965, 23962
9568, 2038, 2039, 23706, 23705, 2062, 23966, 23967, 23964
9569, 2039, 2040, 23707, 23706, 2063, 23968, 23969, 23966
9570, 2040, 2041, 23708, 23707, 2064, 23970, 23971, 23968
9571, 2041, 2042, 23709, 23708, 2065, 23972, 23973, 23970
9572, 2042, 2043, 23710, 23709, 2066, 23974, 23975, 23972
9573, 2043, 2044, 23711, 23710, 2067, 23976, 23977, 23974
9574, 2044, 2045, 23712, 23711, 2068, 23978, 23979, 23976
9575, 2045, 2046, 23713, 23712, 2069, 23980, 23981, 23978
9576, 2046, 2047, 23714, 23713, 2070, 23982, 23983, 23980
9577, 2047, 2048, 23715, 23714, 2071, 23984, 23985, 23982
9578, 2048, 2049, 23716, 23715, 2072, 23986, 23987, 23984
9579, 2049, 2050, 23717, 23716, 2073, 23988, 23989, 23986
9580, 2050, 2051, 23718, 23717, 2074, 23990, 23991, 23988
9581, 2051, 2052, 23719, 23718, 2075, 23992, 23993, 23990
9582, 2052, 2053, 23720, 23719, 2076, 23994, 23995, 23992
9583, 2053, 2054, 23721, 23720, 2077, 23996, 23997, 23994
9584, 2054, 44, 2102, 23721, 2078, 2113, 23998, 23996
9585, 2079, 23699, 23722, 2080, 23953, 23999, 24000, 2091
9586, 23699, 23700, 23723, 23722, 23955, 24001, 24002, 23999
9587, 23700, 23701, 23724, 23723, 23957, 24003, 24004, 24001
9588, 23701, 23702, 23725, 23724, 23959, 24005, 24006, 24003
9589, 23702, 23703, 23726, 23725, 23961, 24007, 24008, 24005
9590, 23703, 23704, 23727, 23726, 23963, 24009, 24010, 24007
9591, 23704, 23705, 23728, 23727, 23965, 24011, 24012, 24009
9592, 23705, 23706, 23729, 23728, 23967, 24013, 24014, 24011
9593, 23706, 23707, 23730, 23729, 23969, 24015, 24016, 24013
9594, 23707, 23708, 23731, 23730, 23971, 24017, 24018, 24015
9595, 23708, 23709, 23732, 23731, 23973, 24019, 24020, 24017
9596, 23709, 23710, 23733, 23732, 23975, 24021, 24022, 24019
9597, 23710, 23711, 23734, 23733, 23977, 24023, 24024, 24021
9598, 23711, 23712, 23735, 23734, 23979, 24025, 24026, 24023
9599, 23712, 23713, 23736, 23735, 23981, 24027, 24028, 24025
9600, 23713, 23714, 23737, 23736, 23983, 24029, 24030, 24027
9601, 23714, 23715, 23738, 23737, 23985, 24031, 24032, 24029
9602, 23715, 23716, 23739, 23738, 23987, 24033, 24034, 24031
9603, 23716, 23717, 23740, 23739, 23989, 24035, 24036, 24033
9604, 23717, 23718, 23741, 23740, 23991, 24037, 24038, 24035
9605, 23718, 23719, 23742, 23741, 23993, 24039, 24040, 24037
9606, 23719, 23720, 23743, 23742, 23995, 24041, 24042, 24039
9607, 23720, 23721, 23744, 23743, 23997, 24043, 24044, 24041
9608, 23721, 2102, 2103, 23744, 23998, 2114, 24045, 24043
9609, 2080, 23722, 23745, 2081, 24000, 24046, 24047, 2092
9610, 23722, 23723, 23746, 23745, 24002, 24048, 24049, 24046
9611, 23723, 23724, 23747, 23746, 24004, 24050, 24051, 24048
9612, 23724, 23725, 23748, 23747, 24006, 24052, 24053, 24050
9613, 23725, 23726, 23749, 23748, 24008, 24054, 24055, 24052
9614, 23726, 23727, 23750, 23749, 24010, 24056, 24057, 24054
9615, 23727, 23728, 23751, 23750, 24012, 24058, 24059, 24056
9616, 23728, 23729, 23752, 23751, 24014, 24060, 24061, 24058
9617, 23729, 23730, 23753, 23752, 24016, 24062, 24063, 24060
9618, 23730, 23731, 23754, 23753, 24018, 24064, 24065, 24062
9619, 23731, 23732, 23755, 23754, 24020, 24066, 24067, 24064
9620, 23732, 23733, 23756, 23755, 24022, 24068, 24069, 24066
9621, 23733, 23734, 23757, 23756, 24024, 24070, 24071, 24068
9622, 23734, 23735, 23758, 23757, 24026, 24072, 24073, 24070
9623, 23735, 23736, 23759, 23758, 24028, 24074, 24075, 24072
9624, 23736, 23737, 23760, 23759, 24030, 24076, 24077, 24074
9625, 23737, 23738, 23761, 23760, 24032, 24078, 24079, 24076
9626, 23738, 23739, 23762, 23761, 24034, 24080, 24081, 24078
9627, 23739, 23740, 23763, 23762, 24036, 24082, 24083, 24080
9628, 23740, 23741, 23764, 23763, 24038, 24084, 24085, 24082
9629, 23741, 23742, 23765, 23764, 24040, 24086, 24087, 24084
9630, 23742, 23743, 23766, 23765, 24042, 24088, 24089, 24086
9631, 23743, 23744, 23767, 23766, 24044, 24090, 24091, 24088
9632, 23744, 2103, 2104, 23767, 24045, 2115, 24092, 24090
9633, 2081, 23745, 23768, 2082, 24047, 24093, 24094, 2093
9634, 23745, 23746, 23769, 23768, 24049, 24095, 24096, 24093
9635, 23746, 23747, 23770, 23769, 24051, 24097, 24098, 24095
9636, 23747, 23748, 23771, 23770, 24053, 24099, 24100, 24097
9637, 23748, 23749, 23772, 23771, 24055, 24101, 24102, 24099
9638, 23749, 23750, 23773, 23772, 24057, 24103, 24104, 24101
9639, 23750, 23751, 23774, 23773, 24059, 24105, 24106, 24103
9640, 23751, 23752, 23775, 23774, 24061, 24107, 24108, 24105
9641, 23752, 23753, 23776, 23775, 24063, 24109, 24110, 24107
9642, 23753, 23754, 23777, 23776, 24065, 24111, 24112, 24109
9643, 23754, 23755, 23778, 23777, 24067, 24113, 24114, 24111
9644, 23755, 23756, 23779, 23778, 24069, 24115, 24116, 24113
9645, 23756, 23757, 23780, 23779, 24071, 24117, 24118, 24115
9646, 23757, 23758, 23781, 23780, 24073, 24119, 24120, 24117
9647, 23758, 23759, 23782, 23781, 24075, 24121, 24122, 24119
9648, 23759, 23760, 23783, 23782, 24077, 24123, 24124, 24121
9649, 23760, 23761, 23784, 23783, 24079, 24125, 24126, 24123
9650, 23761, 23762, 23785, 23784, 24081, 24127, 24128, 24125
9651, 23762, 23763, 23786, 23785, 24083, 24129, 24130, 24127
9652, 23763, 23764, 23787, 23786, 24085, 24131, 24132, 24129
9653, 23764, 23765, 23788, 23787, 24087, 24133, 24134, 24131
9654, 23765, 23766, 23789, 23788, 24089, 24135, 24136, 24133
9655, 23766, 23767, 23790, 23789, 24091, 24137, 24138, 24135
9656, 23767, 2104, 2105, 23790, 24092, 2116, 24139, 24137
9657, 2082, 23768, 23791, 2083, 24094, 24140, 24141, 2094
9658, 23768, 23769, 23792, 23791, 24096, 24142, 24143, 24140
9659, 23769, 23770, 23793, 23792, 24098, 24144, 24145, 24142
9660, 23770, 23771, 23794, 23793, 24100, 24146, 24147, 24144
9661, 23771, 23772, 23795, 23794, 24102, 24148, 24149, 24146
9662, 23772, 23773, 23796, 23795, 24104, 24150, 24151, 24148
9663, 23773, 23774, 23797, 23796, 24106, 24152, 24153, 24150
9664, 23774, 23775, 23798, 23797, 24108, 24154, 24155, 24152
9665, 23775, 23776, 23799, 23798, 24110, 24156, 24157, 24154
9666, 23776, 23777, 23800, 23799, 24112, 24158, 24159, 24156
9667, 23777, 23778, 23801, 23800, 24114, 24160, 24161, 24158
9668, 23778, 23779, 23802, 23801, 24116, 24162, 24163, 24160
9669, 23779, 23780, 23803, 23802, 24118, 24164, 24165, 24162
9670, 23780, 23781, 23804, 23803, 24120, 24166, 24167, 24164
9671, 23781, 23782, 23805, 23804, 24122, 24168, 24169, 24166
9672, 23782, 23783, 23806, 23805, 24124, 24170, 24171, 24168
9673, 23783, 23784, 23807, 23806, 24126, 24172, 24173, 24170
9674, 23784, 23785, 23808, 23807, 24128, 24174, 24175, 24172
9675, 23785, 23786, 23809, 23808, 24130, 24176, 24177, 24174
9676, 23786, 23787, 23810, 23809, 24132, 24178, 24179, 24176
9677, 23787, 23788, 23811, 23810, 24134, 24180, 24181, 24178
9678, 23788, 23789, 23812, 23811, 24136, 24182, 24183, 24180
9679, 23789, 23790, 23813, 23812, 24138, 24184, 24185, 24182
9680, 23790, 2105, 2106, 23813, 24139, 2117, 24186, 24184
9681, 2083, 23791, 23814, 2084, 24141, 24187, 24188, 2095
9682, 23791, 23792, 23815, 23814, 24143, 24189, 24190, 24187
9683, 23792, 23793, 23816, 23815, 24145, 24191, 24192, 24189
9684, 23793, 23794, 23817, 23816, 24147, 24193, 24194, 24191
9685, 23794, 23795, 23818, 23817, 24149, 24195, 24196, 24193
9686, 23795, 23796, 23819, 23818, 24151, 24197, 24198, 24195
9687, 23796, 23797, 23820, 23819, 24153, 24199, 24200, 24197
9688, 23797, 23798, 23821, 23820, 24155, 24201, 24202, 24199
9689, 23798, 23799, 23822, 23821, 24157, 24203, 24204, 24201
9690, 23799, 23800, 23823, 23822, 24159, 24205, 24206, 24203
9691, 23800, 23801, 23824, 23823, 24161, 24207, 24208, 24205
9692, 23801, 23802, 23825, 23824, 24163, 24209, 24210, 24207
9693, 23802, 23803, 23826, 23825, 24165, 24211, 24212, 24209
9694, 23803, 23804, 23827, 23826, 24167, 24213, 24214, 24211
9695, 23804, 23805, 23828, 23827, 24169, 24215, 24216, 24213
9696, 23805, 23806, 23829, 23828, 24171, 24217, 24218, 24215
9697, 23806, 23807, 23830, 23829, 24173, 24219, 24220, 24217
9698, 23807, 23808, 23831, 23830, 24175, 24221, 24222, 24219
9699, 23808, 23809, 23832, 23831, 24177, 24223, 24224, 24221
9700, 23809, 23810, 23833, 23832, 24179, 24225, 24226, 24223
9701, 23810, 23811, 23834, 23833, 24181, 24227, 24228, 24225
9702, 23811, 23812, 23835, 23834, 24183, 24229, 24230, 24227
9703, 23812, 23813, 23836, 23835, 24185, 24231, 24232, 24229
9704, 23813, 2106, 2107, 23836, 24186, 2118, 24233, 24231
9705, 2084, 23814, 23837, 2085, 24188, 24234, 24235, 2096
9706, 23814, 23815, 23838, 23837, 24190, 24236, 24237, 24234
9707, 23815, 23816, 23839, 23838, 24192, 24238, 24239, 24236
9708, 23816, 23817, 23840, 23839, 24194, 24240, 24241, 24238
9709, 23817, 23818, 23841, 23840, 24196, 24242, 24243, 24240
9710, 23818, 23819, 23842, 23841, 24198, 24244, 24245, 24242
9711, 23819, 23820, 23843, 23842, 24200, 24246, 24247, 24244
9712, 23820, 23821, 23844, 23843, 24202, 24248, 24249, 24246
9713, 23821, 23822, 23845, 23844, 24204, 24250, 24251, 24248
9714, 23822, 23823, 23846, 23845, 24206, 24252, 24253, 24250
9715, 23823, 23824, 23847, 23846, 24208, 24254, 24255, 24252
9716, 23824, 23825, 23848, 23847, 24210, 24256, 24257, 24254
9717, 23825, 23826, 23849, 23848, 24212, 24258, 24259, 24256
9718, 23826, 23827, 23850, 23849, 24214, 24260, 24261, 24258
9719, 23827, 23828, 23851, 23850, 24216, 24262, 24263, 24260
9720, 23828, 23829, 23852, 23851, 24218, 24264, 24265, 24262
9721, 23829, 23830, 23853, 23852, 24220, 24266, 24267, 24264
9722, 23830, 23831, 23854, 23853, 24222, 24268, 24269, 24266
9723, 23831, 23832, 23855, 23854, 24224, 24270, 24271, 24268
9724, 23832, 23833, 23856, 23855, 24226, 24272, 24273, 24270
9725, 23833, 23834, 23857, 23856, 24228, 24274, 24275, 24272
9726, 23834, 23835, 23858, 23857, 24230, 24276, 24277, 24274
9727, 23835, 23836, 23859, 23858, 24232, 24278, 24279, 24276
9728, 23836, 2107, 2108, 23859, 24233, 2119, 24280, 24278
9729, 2085, 23837, 23860, 2086, 24235, 24281, 24282, 2097
9730, 23837, 23838, 23861, 23860, 24237, 24283, 24284, 24281
9731, 23838, 23839, 23862, 23861, 24239, 24285, 24286, 24283
9732, 23839, 23840, 23863, 23862, 24241, 24287, 24288, 24285
9733, 23840, 23841, 23864, 23863, 24243, 24289, 24290, 24287
9734, 23841, 23842, 23865, 23864, 24245, 24291, 24292, 24289
9735, 23842, 23843, 23866, 23865, 24247, 24293, 24294, 24291
9736, 23843, 23844, 23867, 23866, 24249, 24295, 24296, 24293
9737, 23844, 23845, 23868, 23867, 24251, 24297, 24298, 24295
9738, 23845, 23846, 23869, 23868, 24253, 24299, 24300, 24297
9739, 23846, 23847, 23870, 23869, 24255, 24301, 24302, 24299
9740, 23847, 23848, 23871, 23870, 24257, 24303, 24304, 24301
9741, 23848, 23849, 23872, 23871, 24259, 24305, 24306, 24303
9742, 23849, 23850, 23873, 23872, 24261, 24307, 24308, 24305
9743, 23850, 23851, 23874, 23873, 24263, 24309, 24310, 24307
9744, 23851, 23852, 23875, 23874, 24265, 24311, 24312, 24309
9745, 23852, 23853, 23876, 23875, 24267, 24313, 24314, 24311
9746, 23853, 23854, 23877, 23876, 24269, 24315, 24316, 24313
9747, 23854, 23855, 23878, 23877, 24271, 24317, 24318, 24315
9748, 23855, 23856, 23879, 23878, 24273, 24319, 24320, 24317
9749, 23856, 23857, 23880, 23879, 24275, 24321, 24322, 24319
9750, 23857, 23858, 23881, 23880, 24277, 24323, 24324, 24321
9751, 23858, 23859, 23882, 23881, 24279, 24325, 24326, 24323
9752, 23859, 2108, 2109, 23882, 24280, 2120, 24327, 24325
9753, 2086, 23860, 23883, 2087, 24282, 24328, 24329, 2098
9754, 23860, 23861, 23884, 23883, 24284, 24330, 24331, 24328
9755, 23861, 23862, 23885, 23884, 24286, 24332, 24333, 24330
9756, 23862, 23863, 23886, 23885, 24288, 24334, 24335, 24332
9757, 23863, 23864, 23887, 23886, 24290, 24336, 24337, 24334
9758, 23864, 23865, 23888, 23887, 24292, 24338, 24339, 24336
9759, 23865, 23866, 23889, 23888, 24294, 24340, 24341, 24338
9760, 23866, 23867, 23890, 23889, 24296, 24342, 24343, 24340
9761, 23867, 23868, 23891, 23890, 24298, 24344, 24345, 24342
9762, 23868, 23869, 23892, 23891, 24300, 24346, 24347, 24344
9763, 23869, 23870, 23893, 23892, 24302, 24348, 24349, 24346
9764, 23870, 23871, 23894, 23893, 24304, 24350, 24351, 24348
9765, 23871, 23872, 23895, 23894, 24306, 24352, 24353, 24350
9766, 23872, 23873, 23896, 23895, 24308, 24354, 24355, 24352
9767, 23873, 23874, 23897, 23896, 24310, 24356, 24357, 24354
9768, 23874, 23875, 23898, 23897, 24312, 24358, 24359, 24356
9769, 23875, 23876, 23899, 23898, 24314, 24360, 24361, 24358
9770, 23876, 23877, 23900, 23899, 24316, 24362, 24363, 24360
9771, 23877, 23878, 23901, 23900, 24318, 24364, 24365, 24362
9772, 23878, 23879, 23902, 23901, 24320, 24366, 24367, 24364
9773, 23879, 23880, 23903, 23902, 24322, 24368, 24369, 24366
9774, 23880, 23881, 23904, 23903, 24324, 24370, 24371, 24368
9775, 23881, 23882, 23905, 23904, 24326, 24372, 24373, 24370
9776, 23882, 2109, 2110, 23905, 24327, 2121, 24374, 24372
9777, 2087, 23883, 23906, 2088, 24329, 24375, 24376, 2099
9778, 23883, 23884, 23907, 23906, 24331, 24377, 24378, 24375
9779, 23884, 23885, 23908, 23907, 24333, 24379, 24380, 24377
9780, 23885, 23886, 23909, 23908, 24335, 24381, 24382, 24379
9781, 23886, 23887, 23910, 23909, 24337, 24383, 24384, 24381
9782, 23887, 23888, 23911, 23910, 24339, 24385, 24386, 24383
9783, 23888, 23889, 23912, 23911, 24341, 24387, 24388, 24385
9784, 23889, 23890, 23913, 23912, 24343, 24389, 24390, 24387
9785, 23890, 23891, 23914, 23913, 24345, 24391, 24392, 24389
9786, 23891, 23892, 23915, 23914, 24347, 24393, 24394, 24391
9787, 23892, 23893, 23916, 23915, 24349, 24395, 24396, 24393
9788, 23893, 23894, 23917, 23916, 24351, 24397, 24398, 24395
9789, 23894, 23895, 23918, 23917, 24353, 24399, 24400, 24397
9790, 23895, 23896, 23919, 23918, 24355, 24401, 24402, 24399
9791, 23896, 23897, 23920, 23919, 24357, 24403, 24404, 24401
9792, 23897, 23898, 23921, 23920, 24359, 24405, 24406, 24403
9793, 23898, 23899, 23922, 23921, 24361, 24407, 24408, 24405
9794, 23899, 23900, 23923, 23922, 24363, 24409, 24410, 24407
9795, 23900, 23901, 23924, 23923, 24365, 24411, 24412, 24409
9796, 23901, 23902, 23925, 23924, 24367, 24413, 24414, 24411
9797, 23902, 23903, 23926, 23925, 24369, 24415, 24416, 24413
9798, 23903, 23904, 23927, 23926, 24371, 24417, 24418, 24415
9799, 23904, 23905, 23928, 23927, 24373, 24419, 24420, 24417
9800, 23905, 2110, 2111, 23928, 24374, 2122, 24421, 24419
9801, 2088, 23906, 23929, 2089, 24376, 24422, 24423, 2100
9802, 23906, 23907, 23930, 23929, 24378, 24424, 24425, 24422
9803, 23907, 23908, 23931, 23930, 24380, 24426, 24427, 24424
9804, 23908, 23909, 23932, 23931, 24382, 24428, 24429, 24426
9805, 23909, 23910, 23933, 23932, 24384, 24430, 24431, 24428
9806, 23910, 23911, 23934, 23933, 24386, 24432, 24433, 24430
9807, 23911, 23912, 23935, 23934, 24388, 24434, 24435, 24432
9808, 23912, 23913, 23936, 23935, 24390, 24436, 24437, 24434
9809, 23913, 23914, 23937, 23936, 24392, 24438, 24439, 24436
9810, 23914, 23915, 23938, 23937, 24394, 24440, 24441, 24438
9811, 23915, 23916, 23939, 23938, 24396, 24442, 24443, 24440
9812, 23916, 23917, 23940, 23939, 24398, 24444, 24445, 24442
9813, 23917, 23918, 23941, 23940, 24400, 24446, 24447, 24444
9814, 23918, 23919, 23942, 23941, 24402, 24448, 24449, 24446
9815, 23919, 23920, 23943, 23942, 24404, 24450, 24451, 24448
9816, 23920, 23921, 23944, 23943, 24406, 24452, 24453, 24450
9817, 23921, 23922, 23945, 23944, 24408, 24454, 24455, 24452
9818, 23922, 23923, 23946, 23945, 24410, 24456, 24457, 24454
9819, 23923, 23924, 23947, 23946, 24412, 24458, 24459, 24456
9820, 23924, 23925, 23948, 23947, 24414, 24460, 24461, 24458
9821, 23925, 23926, 23949, 23948, 24416, 24462, 24463, 24460
9822, 23926, 23927, 23950, 23949, 24418, 24464, 24465, 24462
9823, 23927, 23928, 23951, 23950, 24420, 24466, 24467, 24464
9824, 23928, 2111, 2112, 23951, 24421, 2123, 24468, 24466
9825, 2089, 23929, 1983, 41, 24423, 24469, 2006, 2101
9826, 23929, 23930, 1984, 1983, 24425, 24470, 2007, 24469
9827, 23930, 23931, 1985, 1984, 24427, 24471, 2008, 24470
9828, 23931, 23932, 1986, 1985, 24429, 24472, 2009, 24471
9829, 23932, 23933, 1987, 1986, 24431, 24473, 2010, 24472
9830, 23933, 23934, 1988, 1987, 24433, 24474, 2011, 24473
9831, 23934, 23935, 1989, 1988, 24435, 24475, 2012, 24474
9832, 23935, 23936, 1990, 1989, 24437, 24476, 2013, 24475
9833, 23936, 23937, 1991, 1990, 24439, 24477, 2014, 24476
9834, 23937, 23938, 1992, 1991, 24441, 24478, 2015, 24477
9835, 23938, 23939, 1993, 1992, 24443, 24479, 2016, 24478
9836, 23939, 23940, 1994, 1993, 24445, 24480, 2017, 24479
9837, 23940, 23941, 1995, 1994, 24447, 24481, 2018, 24480
9838, 23941, 23942, 1996, 1995, 24449, 24482, 2019, 24481
9839, 23942, 23943, 1997, 1996, 24451, 24483, 2020, 24482
9840, 23943, 23944, 1998, 1997, 24453, 24484, 2021, 24483
9841, 23944, 23945, 1999, 1998, 24455, 24485, 2022, 24484
9842, 23945, 23946, 2000, 1999, 24457, 24486, 2023, 24485
9843, 23946, 23947, 2001, 2000, 24459, 24487, 2024, 24486
9844, 23947, 23948, 2002, 2001, 24461, 24488, 2025, 24487
9845, 23948, 23949, 2003, 2002, 24463, 24489, 2026, 24488
9846, 23949, 23950, 2004, 2003, 24465, 24490, 2027, 24489
9847, 23950, 23951, 2005, 2004, 24467, 24491, 2028, 24490
9848, 23951, 2112, 42, 2005, 24468, 2124, 2029, 24491
*ELEMENT, type=CPS8, ELSET=Surface52
9849, 41, 2125, 24492, 1983, 2127, 24538, 24539, 2006
9850, 2125, 2126, 24493, 24492, 2128, 24540, 24541, 24538
9851, 2126, 45, 2135, 24493, 2129, 2158, 24542, 24540
9852, 1983, 24492, 24494, 1984, 24539, 24543, 24544, 2007
9853, 24492, 24493, 24495, 24494, 24541, 24545, 24546, 24543
9854, 24493, 2135, 2136, 24495, 24542, 2159, 24547, 24545
9855, 1984, 24494, 24496, 1985, 24544, 24548, 24549, 2008
9856, 24494, 24495, 24497, 24496, 24546, 24550, 24551, 24548
9857, 24495, 2136, 2137, 24497, 24547, 2160, 24552, 24550
9858, 1985, 24496, 24498, 1986, 24549, 24553, 24554, 2009
9859, 24496, 24497, 24499, 24498, 24551, 24555, 24556, 24553
9860, 24497, 2137, 2138, 24499, 24552, 2161, 24557, 24555
9861, 1986, 24498, 24500, 1987, 24554, 24558, 24559, 2010
9862, 24498, 24499, 24501, 24500, 24556, 24560, 24561, 24558
9863, 24499, 2138, 2139, 24501, 24557, 2162, 24562, 24560
9864, 1987, 24500, 24502, 1988, 24559, 24563, 24564, 2011
9865, 24500, 24501, 24503, 24502, 24561, 24565, 24566, 24563
9866, 24501, 2139, 2140, 24503, 24562, 2163, 24567, 24565
9867, 1988, 24502, 24504, 1989, 24564, 24568, 24569, 2012
9868, 24502, 24503, 24505, 24504, 24566, 24570, 24571, 24568
9869, 24503, 2140, 2141, 24505, 24567, 2164, 24572, 24570
9870, 1989, 24504, 24506, 1990, 24569, 24573, 24574, 2013
9871, 24504, 24505, 24507, 24506, 24571, 24575, 24576, 24573
9872, 24505, 2141, 2142, 24507, 24572, 2165, 24577, 24575
9873, 1990, 24506, 24508, 1991, 24574, 24578, 24579, 2014
9874, 24506, 24507, 24509, 24508, 24576, 24580, 24581, 24578
9875, 24507, 2142, 2143, 24509, 24577, 2166, 24582, 24580
9876, 1991, 24508, 24510, 1992, 24579, 24583, 24584, 2015
9877, 24508, 24509, 24511, 24510, 24581, 24585, 24586, 24583
9878, 24509, 2143, 2144, 24511, 24582, 2167, 24587, 24585
9879, 1992, 24510, 24512, 1993, 24584, 24588, 24589, 2016
9880, 24510, 24511, 24513, 24512, 24586, 24590, 24591, 24588
9881, 24511, 2144, 2145, 24513, 24587, 2168, 24592, 24590
9882, 1993, 24512, 24514, 1994, 24589, 24593, 24594, 2017
9883, 24512, 24513, 24515, 24514, 24591, 24595, 24596, 24593
9884, 24513, 2145, 2146, 24515, 24592, 2169, 24597, 24595
9885, 1994, 24514, 24516, 1995, 24594, 24598, 24599, 2018
9886, 24514, 24515, 24517, 24516, 24596, 24600, 24601, 24598
9887, 24515, 2146, 2147, 24517, 24597, 2170, 24602, 24600
9888, 1995, 24516, 24518, 1996, 24599, 24603, 24604, 2019
9889, 24516, 24517, 24519, 24518, 24601, 24605, 24606, 24603
9890, 24517, 2147, 2148, 24519, 24602, 2171, 24607, 24605
9891, 1996, 24518, 24520, 1997, 24604, 24608, 24609, 2020
9892, 24518, 24519, 24521, 24520, 24606, 24610, 24611, 24608
9893, 24519, 2148, 2149, 24521, 24607, 2172, 24612, 24610
9894, 1997, 24520, 24522, 1998, 24609, 24613, 24614, 2021
9895, 24520, 24521, 24523, 24522, 24611, 24615, 24616, 24613
9896, 24521, 2149, 2150, 24523, 24612, 2173, 24617, 24615
9897, 1998, 24522, 24524, 1999, 24614, 24618, 24619, 2022
9898, 24522, 24523, 24525, 24524, 24616, 24620, 24621, 24618
9899, 24523, 2150, 2151, 24525, 24617, 2174, 24622, 24620
9900, 1999, 24524, 24526, 2000, 24619, 24623, 24624, 2023
9901, 24524, 24525, 24527, 24526, 24621, 24625, 24626, 24623
9902, 24525, 2151, 2152, 24527, 24622, 2175, 24627, 24625
9903, 2000, 24526, 24528, 2001, 24624, 24628, 24629, 2024
9904, 24526, 24527, 24529, 24528, 24626, 24630, 24631, 24628
9905, 24527, 2152, 2153, 24529, 24627, 2176, 24632, 24630
9906, 2001, 24528, 24530, 2002, 24629, 24633, 24634, 2025
9907, 24528, 24529, 24531, 24530, 24631, 24635, 24636, 24633
9908, 24529, 2153, 2154, 24531, 24632, 2177, 24637, 24635
9909, 2002, 24530, 24532, 2003, 24634, 24638, 24639, 2026
9910, 24530, 24531, 24533, 24532, 24636, 24640, 24641, 24638
9911, 24531, 2154, 2155, 24533, 24637, 2178, 24642, 24640
9912, 2003, 24532, 24534, 2004, 24639, 24643, 24644, 2027
9913, 24532, 24533, 24535, 24534, 24641, 24645, 24646, 24643
9914, 24533, 2155, 2156, 24535, 24642, 2179, 24647, 24645
9915, 2004, 24534, 24536, 2005, 24644, 24648, 24649, 2028
9916, 24534, 24535, 24537, 24536, 24646, 24650, 24651, 24648
9917, 24535, 2156, 2157, 24537, 24647, 2180, 24652, 24650
9918, 2005, 24536, 2130, 42, 24649, 24653, 2132, 2029
9919, 24536, 24537, 2131, 2130, 24651, 24654, 2133, 24653
9920, 24537, 2157, 46, 2131, 24652, 2181, 2134, 24654
*ELEMENT, type=CPS8, ELSET=Surface53
9921, 43, 2032, 24655, 2182, 2055, 24701, 24702, 2184
9922, 2182, 24655, 24656, 2183, 24702, 24703, 24704, 2185
9923, 2183, 24656, 2192, 47, 24704, 24705, 2215, 2186
9924, 2032, 2033, 24657, 24655, 2056, 24706, 24707, 24701
9925, 24655, 24657, 24658, 24656, 24707, 24708, 24709, 24703
9926, 24656, 24658, 2193, 2192, 24709, 24710, 2216, 24705
