9927, 2033, 2034, 24659, 24657, 2057, 24711, 24712, 24706
9928, 24657, 24659, 24660, 24658, 24712, 24713, 24714, 24708
9929, 24658, 24660, 2194, 2193, 24714, 24715, 2217, 24710
9930, 2034, 2035, 24661, 24659, 2058, 24716, 24717, 24711
9931, 24659, 24661, 24662, 24660, 24717, 24718, 24719, 24713
9932, 24660, 24662, 2195, 2194, 24719, 24720, 2218, 24715
9933, 2035, 2036, 24663, 24661, 2059, 24721, 24722, 24716
9934, 24661, 24663, 24664, 24662, 24722, 24723, 24724, 24718
9935, 24662, 24664, 2196, 2195, 24724, 24725, 2219, 24720
9936, 2036, 2037, 24665, 24663, 2060, 24726, 24727, 24721
9937, 24663, 24665, 24666, 24664, 24727, 24728, 24729, 24723
9938, 24664, 24666, 2197, 2196, 24729, 24730, 2220, 24725
9939, 2037, 2038, 24667, 24665, 2061, 24731, 24732, 24726
9940, 24665, 24667, 24668, 24666, 24732, 24733, 24734, 24728
9941, 24666, 24668, 2198, 2197, 24734, 24735, 2221, 24730
9942, 2038, 2039, 24669, 24667, 2062, 24736, 24737, 24731
9943, 24667, 24669, 24670, 24668, 24737, 24738, 24739, 24733
9944, 24668, 24670, 2199, 2198, 24739, 24740, 2222, 24735
9945, 2039, 2040, 24671, 24669, 2063, 24741, 24742, 24736
9946, 24669, 24671, 24672, 24670, 24742, 24743, 24744, 24738
9947, 24670, 24672, 2200, 2199, 24744, 24745, 2223, 24740
9948, 2040, 2041, 24673, 24671, 2064, 24746, 24747, 24741
9949, 24671, 24673, 24674, 24672, 24747, 24748, 24749, 24743
9950, 24672, 24674, 2201, 2200, 24749, 24750, 2224, 24745
9951, 2041, 2042, 24675, 24673, 2065, 24751, 24752, 24746
9952, 24673, 24675, 24676, 24674, 24752, 24753, 24754, 24748
9953, 24674, 24676, 2202, 2201, 24754, 24755, 2225, 24750
9954, 2042, 2043, 24677, 24675, 2066, 24756, 24757, 24751
9955, 24675, 24677, 24678, 24676, 24757, 24758, 24759, 24753
9956, 24676, 24678, 2203, 2202, 24759, 24760, 2226, 24755
9957, 2043, 2044, 24679, 24677, 2067, 24761, 24762, 24756
9958, 24677, 24679, 24680, 24678, 24762, 24763, 24764, 24758
9959, 24678, 24680, 2204, 2203, 24764, 24765, 2227, 24760
9960, 2044, 2045, 24681, 24679, 2068, 24766, 24767, 24761
9961, 24679, 24681, 24682, 24680, 24767, 24768, 24769, 24763
9962, 24680, 24682, 2205, 2204, 24769, 24770, 2228, 24765
9963, 2045, 2046, 24683, 24681, 2069, 24771, 24772, 24766
9964, 24681, 24683, 24684, 24682, 24772, 24773, 24774, 24768
9965, 24682, 24684, 2206, 2205, 24774, 24775, 2229, 24770
9966, 2046, 2047, 24685, 24683, 2070, 24776, 24777, 24771
9967, 24683, 24685, 24686, 24684, 24777, 24778, 24779, 24773
9968, 24684, 24686, 2207, 2206, 24779, 24780, 2230, 24775
9969, 2047, 2048, 24687, 24685, 2071, 24781, 24782, 24776
9970, 24685, 24687, 24688, 24686, 24782, 24783, 24784, 24778
9971, 24686, 24688, 2208, 2207, 24784, 24785, 2231, 24780
9972, 2048, 2049, 24689, 24687, 2072, 24786, 24787, 24781
9973, 24687, 24689, 24690, 24688, 24787, 24788, 24789, 24783
9974, 24688, 24690, 2209, 2208, 24789, 24790, 2232, 24785
9975, 2049, 2050, 24691, 24689, 2073, 24791, 24792, 24786
9976, 24689, 24691, 24692, 24690, 24792, 24793, 24794, 24788
9977, 24690, 24692, 2210, 2209, 24794, 24795, 2233, 24790
9978, 2050, 2051, 24693, 24691, 2074, 24796, 24797, 24791
9979, 24691, 24693, 24694, 24692, 24797, 24798, 24799, 24793
9980, 24692, 24694, 2211, 2210, 24799, 24800, 2234, 24795
9981, 2051, 2052, 24695, 24693, 2075, 24801, 24802, 24796
9982, 24693, 24695, 24696, 24694, 24802, 24803, 24804, 24798
9983, 24694, 24696, 2212, 2211, 24804, 24805, 2235, 24800
9984, 2052, 2053, 24697, 24695, 2076, 24806, 24807, 24801
9985, 24695, 24697, 24698, 24696, 24807, 24808, 24809, 24803
9986, 24696, 24698, 2213, 2212, 24809, 24810, 2236, 24805
9987, 2053, 2054, 24699, 24697, 2077, 24811, 24812, 24806
9988, 24697, 24699, 24700, 24698, 24812, 24813, 24814, 24808
9989, 24698, 24700, 2214, 2213, 24814, 24815, 2237, 24810
9990, 2054, 44, 2187, 24699, 2078, 2189, 24816, 24811
9991, 24699, 2187, 2188, 24700, 24816, 2190, 24817, 24813
9992, 24700, 2188, 48, 2214, 24817, 2191, 2238, 24815
*ELEMENT, type=CPS8, ELSET=Surface54
9993, 43, 2182, 24818, 2079, 2184, 24840, 24841, 2090
9994, 2182, 2183, 24819, 24818, 2185, 24842, 24843, 24840
9995, 2183, 47, 2239, 24819, 2186, 2250, 24844, 24842
9996, 2079, 24818, 24820, 2080, 24841, 24845, 24846, 2091
9997, 24818, 24819, 24821, 24820, 24843, 24847, 24848, 24845
9998, 24819, 2239, 2240, 24821, 24844, 2251, 24849, 24847
9999, 2080, 24820, 24822, 2081, 24846, 24850, 24851, 2092
10000, 24820, 24821, 24823, 24822, 24848, 24852, 24853, 24850
10001, 24821, 2240, 2241, 24823, 24849, 2252, 24854, 24852
10002, 2081, 24822, 24824, 2082, 24851, 24855, 24856, 2093
10003, 24822, 24823, 24825, 24824, 24853, 24857, 24858, 24855
10004, 24823, 2241, 2242, 24825, 24854, 2253, 24859, 24857
10005, 2082, 24824, 24826, 2083, 24856, 24860, 24861, 2094
10006, 24824, 24825, 24827, 24826, 24858, 24862, 24863, 24860
10007, 24825, 2242, 2243, 24827, 24859, 2254, 24864, 24862
10008, 2083, 24826, 24828, 2084, 24861, 24865, 24866, 2095
10009, 24826, 24827, 24829, 24828, 24863, 24867, 24868, 24865
10010, 24827, 2243, 2244, 24829, 24864, 2255, 24869, 24867
10011, 2084, 24828, 24830, 2085, 24866, 24870, 24871, 2096
10012, 24828, 24829, 24831, 24830, 24868, 24872, 24873, 24870
10013, 24829, 2244, 2245, 24831, 24869, 2256, 24874, 24872
10014, 2085, 24830, 24832, 2086, 24871, 24875, 24876, 2097
10015, 24830, 24831, 24833, 24832, 24873, 24877, 24878, 24875
10016, 24831, 2245, 2246, 24833, 24874, 2257, 24879, 24877
10017, 2086, 24832, 24834, 2087, 24876, 24880, 24881, 2098
10018, 24832, 24833, 24835, 24834, 24878, 24882, 24883, 24880
10019, 24833, 2246, 2247, 24835, 24879, 2258, 24884, 24882
10020, 2087, 24834, 24836, 2088, 24881, 24885, 24886, 2099
10021, 24834, 24835, 24837, 24836, 24883, 24887, 24888, 24885
10022, 24835, 2247, 2248, 24837, 24884, 2259, 24889, 24887
10023, 2088, 24836, 24838, 2089, 24886, 24890, 24891, 2100
10024, 24836, 24837, 24839, 24838, 24888, 24892, 24893, 24890
10025, 24837, 2248, 2249, 24839, 24889, 2260, 24894, 24892
10026, 2089, 24838, 2125, 41, 24891, 24895, 2127, 2101
10027, 24838, 24839, 2126, 2125, 24893, 24896, 2128, 24895
10028, 24839, 2249, 45, 2126, 24894, 2261, 2129, 24896
*ELEMENT, type=CPS8, ELSET=Surface55
10029, 44, 2102, 24897, 2187, 2113, 24919, 24920, 2189
10030, 2187, 24897, 24898, 2188, 24920, 24921, 24922, 2190
10031, 2188, 24898, 2262, 48, 24922, 24923, 2273, 2191
10032, 2102, 2103, 24899, 24897, 2114, 24924, 24925, 24919
10033, 24897, 24899, 24900, 24898, 24925, 24926, 24927, 24921
10034, 24898, 24900, 2263, 2262, 24927, 24928, 2274, 24923
10035, 2103, 2104, 24901, 24899, 2115, 24929, 24930, 24924
10036, 24899, 24901, 24902, 24900, 24930, 24931, 24932, 24926
10037, 24900, 24902, 2264, 2263, 24932, 24933, 2275, 24928
10038, 2104, 2105, 24903, 24901, 2116, 24934, 24935, 24929
10039, 24901, 24903, 24904, 24902, 24935, 24936, 24937, 24931
10040, 24902, 24904, 2265, 2264, 24937, 24938, 2276, 24933
10041, 2105, 2106, 24905, 24903, 2117, 24939, 24940, 24934
10042, 24903, 24905, 24906, 24904, 24940, 24941, 24942, 24936
10043, 24904, 24906, 2266, 2265, 24942, 24943, 2277, 24938
10044, 2106, 2107, 24907, 24905, 2118, 24944, 24945, 24939
10045, 24905, 24907, 24908, 24906, 24945, 24946, 24947, 24941
10046, 24906, 24908, 2267, 2266, 24947, 24948, 2278, 24943
10047, 2107, 2108, 24909, 24907, 2119, 24949, 24950, 24944
10048, 24907, 24909, 24910, 24908, 24950, 24951, 24952, 24946
10049, 24908, 24910, 2268, 2267, 24952, 24953, 2279, 24948
10050, 2108, 2109, 24911, 24909, 2120, 24954, 24955, 24949
10051, 24909, 24911, 24912, 24910, 24955, 24956, 24957, 24951
10052, 24910, 24912, 2269, 2268, 24957, 24958, 2280, 24953
10053, 2109, 2110, 24913, 24911, 2121, 24959, 24960, 24954
10054, 24911, 24913, 24914, 24912, 24960, 24961, 24962, 24956
10055, 24912, 24914, 2270, 2269, 24962, 24963, 2281, 24958
10056, 2110, 2111, 24915, 24913, 2122, 24964, 24965, 24959
10057, 24913, 24915, 24916, 24914, 24965, 24966, 24967, 24961
10058, 24914, 24916, 2271, 2270, 24967, 24968, 2282, 24963
10059, 2111, 2112, 24917, 24915, 2123, 24969, 24970, 24964
10060, 24915, 24917, 24918, 24916, 24970, 24971, 24972, 24966
10061, 24916, 24918, 2272, 2271, 24972, 24973, 2283, 24968
10062, 2112, 42, 2130, 24917, 2124, 2132, 24974, 24969
10063, 24917, 2130, 2131, 24918, 24974, 2133, 24975, 24971
10064, 24918, 2131, 46, 2272, 24975, 2134, 2284, 24973
*ELEMENT, type=CPS8, ELSET=Surface56
10065, 47, 2192, 24976, 2239, 2215, 25229, 25230, 2250
10066, 2192, 2193, 24977, 24976, 2216, 25231, 25232, 25229
10067, 2193, 2194, 24978, 24977, 2217, 25233, 25234, 25231
10068, 2194, 2195, 24979, 24978, 2218, 25235, 25236, 25233
10069, 2195, 2196, 24980, 24979, 2219, 25237, 25238, 25235
10070, 2196, 2197, 24981, 24980, 2220, 25239, 25240, 25237
10071, 2197, 2198, 24982, 24981, 2221, 25241, 25242, 25239
10072, 2198, 2199, 24983, 24982, 2222, 25243, 25244, 25241
10073, 2199, 2200, 24984, 24983, 2223, 25245, 25246, 25243
10074, 2200, 2201, 24985, 24984, 2224, 25247, 25248, 25245
10075, 2201, 2202, 24986, 24985, 2225, 25249, 25250, 25247
10076, 2202, 2203, 24987, 24986, 2226, 25251, 25252, 25249
10077, 2203, 2204, 24988, 24987, 2227, 25253, 25254, 25251
10078, 2204, 2205, 24989, 24988, 2228, 25255, 25256, 25253
10079, 2205, 2206, 24990, 24989, 2229, 25257, 25258, 25255
10080, 2206, 2207, 24991, 24990, 2230, 25259, 25260, 25257
10081, 2207, 2208, 24992, 24991, 2231, 25261, 25262, 25259
10082, 2208, 2209, 24993, 24992, 2232, 25263, 25264, 25261
10083, 2209, 2210, 24994, 24993, 2233, 25265, 25266, 25263
10084, 2210, 2211, 24995, 24994, 2234, 25267, 25268, 25265
10085, 2211, 2212, 24996, 24995, 2235, 25269, 25270, 25267
10086, 2212, 2213, 24997, 24996, 2236, 25271, 25272, 25269
10087, 2213, 2214, 24998, 24997, 2237, 25273, 25274, 25271
10088, 2214, 48, 2262, 24998, 2238, 2273, 25275, 25273
10089, 2239, 24976, 24999, 2240, 25230, 25276, 25277, 2251
10090, 24976, 24977, 25000, 24999, 25232, 25278, 25279, 25276
10091, 24977, 24978, 25001, 25000, 25234, 25280, 25281, 25278
10092, 24978, 24979, 25002, 25001, 25236, 25282, 25283, 25280
10093, 24979, 24980, 25003, 25002, 25238, 25284, 25285, 25282
10094, 24980, 24981, 25004, 25003, 25240, 25286, 25287, 25284
10095, 24981, 24982, 25005, 25004, 25242, 25288, 25289, 25286
10096, 24982, 24983, 25006, 25005, 25244, 25290, 25291, 25288
10097, 24983, 24984, 25007, 25006, 25246, 25292, 25293, 25290
10098, 24984, 24985, 25008, 25007, 25248, 25294, 25295, 25292
10099, 24985, 24986, 25009, 25008, 25250, 25296, 25297, 25294
10100, 24986, 24987, 25010, 25009, 25252, 25298, 25299, 25296
10101, 24987, 24988, 25011, 25010, 25254, 25300, 25301, 25298
10102, 24988, 24989, 25012, 25011, 25256, 25302, 25303, 25300
10103, 24989, 24990, 25013, 25012, 25258, 25304, 25305, 25302
10104, 24990, 24991, 25014, 25013, 25260, 25306, 25307, 25304
10105, 24991, 24992, 25015, 25014, 25262, 25308, 25309, 25306
10106, 24992, 24993, 25016, 25015, 25264, 25310, 25311, 25308
10107, 24993, 24994, 25017, 25016, 25266, 25312, 25313, 25310
10108, 24994, 24995, 25018, 25017, 25268, 25314, 25315, 25312
10109, 24995, 24996, 25019, 25018, 25270, 25316, 25317, 25314
10110, 24996, 24997, 25020, 25019, 25272, 25318, 25319, 25316
10111, 24997, 24998, 25021, 25020, 25274, 25320, 25321, 25318
10112, 24998, 2262, 2263, 25021, 25275, 2274, 25322, 25320
10113, 2240, 24999, 25022, 2241, 25277, 25323, 25324, 2252
10114, 24999, 25000, 25023, 25022, 25279, 25325, 25326, 25323
10115, 25000, 25001, 25024, 25023, 25281, 25327, 25328, 25325
10116, 25001, 25002, 25025, 25024, 25283, 25329, 25330, 25327
10117, 25002, 25003, 25026, 25025, 25285, 25331, 25332, 25329
10118, 25003, 25004, 25027, 25026, 25287, 25333, 25334, 25331
10119, 25004, 25005, 25028, 25027, 25289, 25335, 25336, 25333
10120, 25005, 25006, 25029, 25028, 25291, 25337, 25338, 25335
10121, 25006, 25007, 25030, 25029, 25293, 25339, 25340, 25337
10122, 25007, 25008, 25031, 25030, 25295, 25341, 25342, 25339
10123, 25008, 25009, 25032, 25031, 25297, 25343, 25344, 25341
10124, 25009, 25010, 25033, 25032, 25299, 25345, 25346, 25343
10125, 25010, 25011, 25034, 25033, 25301, 25347, 25348, 25345
10126, 25011, 25012, 25035, 25034, 25303, 25349, 25350, 25347
10127, 25012, 25013, 25036, 25035, 25305, 25351, 25352, 25349
10128, 25013, 25014, 25037, 25036, 25307, 25353, 25354, 25351
10129, 25014, 25015, 25038, 25037, 25309, 25355, 25356, 25353
10130, 25015, 25016, 25039, 25038, 25311, 25357, 25358, 25355
10131, 25016, 25017, 25040, 25039, 25313, 25359, 25360, 25357
10132, 25017, 25018, 25041, 25040, 25315, 25361, 25362, 25359
10133, 25018, 25019, 25042, 25041, 25317, 25363, 25364, 25361
10134, 25019, 25020, 25043, 25042, 25319, 25365, 25366, 25363
10135, 25020, 25021, 25044, 25043, 25321, 25367, 25368, 25365
10136, 25021, 2263, 2264, 25044, 25322, 2275, 25369, 25367
10137, 2241, 25022, 25045, 2242, 25324, 25370, 25371, 2253
10138, 25022, 25023, 25046, 25045, 25326, 25372, 25373, 25370
10139, 25023, 25024, 25047, 25046, 25328, 25374, 25375, 25372
10140, 25024, 25025, 25048, 25047, 25330, 25376, 25377, 25374
10141, 25025, 25026, 25049, 25048, 25332, 25378, 25379, 25376
10142, 25026, 25027, 25050, 25049, 25334, 25380, 25381, 25378
10143, 25027, 25028, 25051, 25050, 25336, 25382, 25383, 25380
10144, 25028, 25029, 25052, 25051, 25338, 25384, 25385, 25382
10145, 25029, 25030, 25053, 25052, 25340, 25386, 25387, 25384
10146, 25030, 25031, 25054, 25053, 25342, 25388, 25389, 25386
10147, 25031, 25032, 25055, 25054, 25344, 25390, 25391, 25388
10148, 25032, 25033, 25056, 25055, 25346, 25392, 25393, 25390
10149, 25033, 25034, 25057, 25056, 25348, 25394, 25395, 25392
10150, 25034, 25035, 25058, 25057, 25350, 25396, 25397, 25394
10151, 25035, 25036, 25059, 25058, 25352, 25398, 25399, 25396
10152, 25036, 25037, 25060, 25059, 25354, 25400, 25401, 25398
10153, 25037, 25038, 25061, 25060, 25356, 25402, 25403, 25400
10154, 25038, 25039, 25062, 25061, 25358, 25404, 25405, 25402
10155, 25039, 25040, 25063, 25062, 25360, 25406, 25407, 25404
10156, 25040, 25041, 25064, 25063, 25362, 25408, 25409, 25406
10157, 25041, 25042, 25065, 25064, 25364, 25410, 25411, 25408
10158, 25042, 25043, 25066, 25065, 25366, 25412, 25413, 25410
10159, 25043, 25044, 25067, 25066, 25368, 25414, 25415, 25412
10160, 25044, 2264, 2265, 25067, 25369, 2276, 25416, 25414
10161, 2242, 25045, 25068, 2243, 25371, 25417, 25418, 2254
10162, 25045, 25046, 25069, 25068, 25373, 25419, 25420, 25417
10163, 25046, 25047, 25070, 25069, 25375, 25421, 25422, 25419
10164, 25047, 25048, 25071, 25070, 25377, 25423, 25424, 25421
10165, 25048, 25049, 25072, 25071, 25379, 25425, 25426, 25423
10166, 25049, 25050, 25073, 25072, 25381, 25427, 25428, 25425
10167, 25050, 25051, 25074, 25073, 25383, 25429, 25430, 25427
10168, 25051, 25052, 25075, 25074, 25385, 25431, 25432, 25429
10169, 25052, 25053, 25076, 25075, 25387, 25433, 25434, 25431
10170, 25053, 25054, 25077, 25076, 25389, 25435, 25436, 25433
10171, 25054, 25055, 25078, 25077, 25391, 25437, 25438, 25435
10172, 25055, 25056, 25079, 25078, 25393, 25439, 25440, 25437
10173, 25056, 25057, 25080, 25079, 25395, 25441, 25442, 25439
10174, 25057, 25058, 25081, 25080, 25397, 25443, 25444, 25441
10175, 25058, 25059, 25082, 25081, 25399, 25445, 25446, 25443
10176, 25059, 25060, 25083, 25082, 25401, 25447, 25448, 25445
10177, 25060, 25061, 25084, 25083, 25403, 25449, 25450, 25447
10178, 25061, 25062, 25085, 25084, 25405, 25451, 25452, 25449
10179, 25062, 25063, 25086, 25085, 25407, 25453, 25454, 25451
10180, 25063, 25064, 25087, 25086, 25409, 25455, 25456, 25453
10181, 25064, 25065, 25088, 25087, 25411, 25457, 25458, 25455
10182, 25065, 25066, 25089, 25088, 25413, 25459, 25460, 25457
10183, 25066, 25067, 25090, 25089, 25415, 25461, 25462, 25459
10184, 25067, 2265, 2266, 25090, 25416, 2277, 25463, 25461
10185, 2243, 25068, 25091, 2244, 25418, 25464, 25465, 2255
10186, 25068, 25069, 25092, 25091, 25420, 25466, 25467, 25464
10187, 25069, 25070, 25093, 25092, 25422, 25468, 25469, 25466
10188, 25070, 25071, 25094, 25093, 25424, 25470, 25471, 25468
10189, 25071, 25072, 25095, 25094, 25426, 25472, 25473, 25470
10190, 25072, 25073, 25096, 25095, 25428, 25474, 25475, 25472
10191, 25073, 25074, 25097, 25096, 25430, 25476, 25477, 25474
10192, 25074, 25075, 25098, 25097, 25432, 25478, 25479, 25476
10193, 25075, 25076, 25099, 25098, 25434, 25480, 25481, 25478
10194, 25076, 25077, 25100, 25099, 25436, 25482, 25483, 25480
10195, 25077, 25078, 25101, 25100, 25438, 25484, 25485, 25482
10196, 25078, 25079, 25102, 25101, 25440, 25486, 25487, 25484
10197, 25079, 25080, 25103, 25102, 25442, 25488, 25489, 25486
10198, 25080, 25081, 25104, 25103, 25444, 25490, 25491, 25488
10199, 25081, 25082, 25105, 25104, 25446, 25492, 25493, 25490
10200, 25082, 25083, 25106, 25105, 25448, 25494, 25495, 25492
10201, 25083, 25084, 25107, 25106, 25450, 25496, 25497, 25494
10202, 25084, 25085, 25108, 25107, 25452, 25498, 25499, 25496
10203, 25085, 25086, 25109, 25108, 25454, 25500, 25501, 25498
10204, 25086, 25087, 25110, 25109, 25456, 25502, 25503, 25500
10205, 25087, 25088, 25111, 25110, 25458, 25504, 25505, 25502
10206, 25088, 25089, 25112, 25111, 25460, 25506, 25507, 25504
10207, 25089, 25090, 25113, 25112, 25462, 25508, 25509, 25506
10208, 25090, 2266, 2267, 25113, 25463, 2278, 25510, 25508
10209, 2244, 25091, 25114, 2245, 25465, 25511, 25512, 2256
10210, 25091, 25092, 25115, 25114, 25467, 25513, 25514, 25511
10211, 25092, 25093, 25116, 25115, 25469, 25515, 25516, 25513
10212, 25093, 25094, 25117, 25116, 25471, 25517, 25518, 25515
10213, 25094, 25095, 25118, 25117, 25473, 25519, 25520, 25517
10214, 25095, 25096, 25119, 25118, 25475, 25521, 25522, 25519
10215, 25096, 25097, 25120, 25119, 25477, 25523, 25524, 25521
10216, 25097, 25098, 25121, 25120, 25479, 25525, 25526, 25523
10217, 25098, 25099, 25122, 25121, 25481, 25527, 25528, 25525
10218, 25099, 25100, 25123, 25122, 25483, 25529, 25530, 25527
10219, 25100, 25101, 25124, 25123, 25485, 25531, 25532, 25529
10220, 25101, 25102, 25125, 25124, 25487, 25533, 25534, 25531
10221, 25102, 25103, 25126, 25125, 25489, 25535, 25536, 25533
10222, 25103, 25104, 25127, 25126, 25491, 25537, 25538, 25535
10223, 25104, 25105, 25128, 25127, 25493, 25539, 25540, 25537
10224, 25105, 25106, 25129, 25128, 25495, 25541, 25542, 25539
10225, 25106, 25107, 25130, 25129, 25497, 25543, 25544, 25541
10226, 25107, 25108, 25131, 25130, 25499, 25545, 25546, 25543
10227, 25108, 25109, 25132, 25131, 25501, 25547, 25548, 25545
10228, 25109, 25110, 25133, 25132, 25503, 25549, 25550, 25547
10229, 25110, 25111, 25134, 25133, 25505, 25551, 25552, 25549
10230, 25111, 25112, 25135, 25134, 25507, 25553, 25554, 25551
10231, 25112, 25113, 25136, 25135, 25509, 25555, 25556, 25553
10232, 25113, 2267, 2268, 25136, 25510, 2279, 25557, 25555
10233, 2245, 25114, 25137, 2246, 25512, 25558, 25559, 2257
10234, 25114, 25115, 25138, 25137, 25514, 25560, 25561, 25558
10235, 25115, 25116, 25139, 25138, 25516, 25562, 25563, 25560
10236, 25116, 25117, 25140, 25139, 25518, 25564, 25565, 25562
10237, 25117, 25118, 25141, 25140, 25520, 25566, 25567, 25564
10238, 25118, 25119, 25142, 25141, 25522, 25568, 25569, 25566
10239, 25119, 25120, 25143, 25142, 25524, 25570, 25571, 25568
10240, 25120, 25121, 25144, 25143, 25526, 25572, 25573, 25570
10241, 25121, 25122, 25145, 25144, 25528, 25574, 25575, 25572
10242, 25122, 25123, 25146, 25145, 25530, 25576, 25577, 25574
10243, 25123, 25124, 25147, 25146, 25532, 25578, 25579, 25576
10244, 25124, 25125, 25148, 25147, 25534, 25580, 25581, 25578
10245, 25125, 25126, 25149, 25148, 25536, 25582, 25583, 25580
10246, 25126, 25127, 25150, 25149, 25538, 25584, 25585, 25582
10247, 25127, 25128, 25151, 25150, 25540, 25586, 25587, 25584
10248, 25128, 25129, 25152, 25151, 25542, 25588, 25589, 25586
10249, 25129, 25130, 25153, 25152, 25544, 25590, 25591, 25588
10250, 25130, 25131, 25154, 25153, 25546, 25592, 25593, 25590
10251, 25131, 25132, 25155, 25154, 25548, 25594, 25595, 25592
10252, 25132, 25133, 25156, 25155, 25550, 25596, 25597, 25594
10253, 25133, 25134, 25157, 25156, 25552, 25598, 25599, 25596
10254, 25134, 25135, 25158, 25157, 25554, 25600, 25601, 25598
10255, 25135, 25136, 25159, 25158, 25556, 25602, 25603, 25600
10256, 25136, 2268, 2269, 25159, 25557, 2280, 25604, 25602
10257, 2246, 25137, 25160, 2247, 25559, 25605, 25606, 2258
10258, 25137, 25138, 25161, 25160, 25561, 25607, 25608, 25605
10259, 25138, 25139, 25162, 25161, 25563, 25609, 25610, 25607
10260, 25139, 25140, 25163, 25162, 25565, 25611, 25612, 25609
10261, 25140, 25141, 25164, 25163, 25567, 25613, 25614, 25611
10262, 25141, 25142, 25165, 25164, 25569, 25615, 25616, 25613
10263, 25142, 25143, 25166, 25165, 25571, 25617, 25618, 25615
10264, 25143, 25144, 25167, 25166, 25573, 25619, 25620, 25617
10265, 25144, 25145, 25168, 25167, 25575, 25621, 25622, 25619
10266, 25145, 25146, 25169, 25168, 25577, 25623, 25624, 25621
10267, 25146, 25147, 25170, 25169, 25579, 25625, 25626, 25623
10268, 25147, 25148, 25171, 25170, 25581, 25627, 25628, 25625
10269, 25148, 25149, 25172, 25171, 25583, 25629, 25630, 25627
10270, 25149, 25150, 25173, 25172, 25585, 25631, 25632, 25629
10271, 25150, 25151, 25174, 25173, 25587, 25633, 25634, 25631
10272, 25151, 25152, 25175, 25174, 25589, 25635, 25636, 25633
10273, 25152, 25153, 25176, 25175, 25591, 25637, 25638, 25635
10274, 25153, 25154, 25177, 25176, 25593, 25639, 25640, 25637
10275, 25154, 25155, 25178, 25177, 25595, 25641, 25642, 25639
10276, 25155, 25156, 25179, 25178, 25597, 25643, 25644, 25641
10277, 25156, 25157, 25180, 25179, 25599, 25645, 25646, 25643
10278, 25157, 25158, 25181, 25180, 25601, 25647, 25648, 25645
10279, 25158, 25159, 25182, 25181, 25603, 25649, 25650, 25647
10280, 25159, 2269, 2270, 25182, 25604, 2281, 25651, 25649
10281, 2247, 25160, 25183, 2248, 25606, 25652, 25653, 2259
10282, 25160, 25161, 25184, 25183, 25608, 25654, 25655, 25652
10283, 25161, 25162, 25185, 25184, 25610, 25656, 25657, 25654
10284, 25162, 25163, 25186, 25185, 25612, 25658, 25659, 25656
10285, 25163, 25164, 25187, 25186, 25614, 25660, 25661, 25658
10286, 25164, 25165, 25188, 25187, 25616, 25662, 25663, 25660
10287, 25165, 25166, 25189, 25188, 25618, 25664, 25665, 25662
10288, 25166, 25167, 25190, 25189, 25620, 25666, 25667, 25664
10289, 25167, 25168, 25191, 25190, 25622, 25668, 25669, 25666
10290, 25168, 25169, 25192, 25191, 25624, 25670, 25671, 25668
10291, 25169, 25170, 25193, 25192, 25626, 25672, 25673, 25670
10292, 25170, 25171, 25194, 25193, 25628, 25674, 25675, 25672
10293, 25171, 25172, 25195, 25194, 25630, 25676, 25677, 25674
10294, 25172, 25173, 25196, 25195, 25632, 25678, 25679, 25676
10295, 25173, 25174, 25197, 25196, 25634, 25680, 25681, 25678
10296, 25174, 25175, 25198, 25197, 25636, 25682, 25683, 25680
10297, 25175, 25176, 25199, 25198, 25638, 25684, 25685, 25682
10298, 25176, 25177, 25200, 25199, 25640, 25686, 25687, 25684
10299, 25177, 25178, 25201, 25200, 25642, 25688, 25689, 25686
10300, 25178, 25179, 25202, 25201, 25644, 25690, 25691, 25688
10301, 25179, 25180, 25203, 25202, 25646, 25692, 25693, 25690
10302, 25180, 25181, 25204, 25203, 25648, 25694, 25695, 25692
10303, 25181, 25182, 25205, 25204, 25650, 25696, 25697, 25694
10304, 25182, 2270, 2271, 25205, 25651, 2282, 25698, 25696
10305, 2248, 25183, 25206, 2249, 25653, 25699, 25700, 2260
10306, 25183, 25184, 25207, 25206, 25655, 25701, 25702, 25699
10307, 25184, 25185, 25208, 25207, 25657, 25703, 25704, 25701
10308, 25185, 25186, 25209, 25208, 25659, 25705, 25706, 25703
10309, 25186, 25187, 25210, 25209, 25661, 25707, 25708, 25705
10310, 25187, 25188, 25211, 25210, 25663, 25709, 25710, 25707
10311, 25188, 25189, 25212, 25211, 25665, 25711, 25712, 25709
10312, 25189, 25190, 25213, 25212, 25667, 25713, 25714, 25711
10313, 25190, 25191, 25214, 25213, 25669, 25715, 25716, 25713
10314, 25191, 25192, 25215, 25214, 25671, 25717, 25718, 25715
10315, 25192, 25193, 25216, 25215, 25673, 25719, 25720, 25717
10316, 25193, 25194, 25217, 25216, 25675, 25721, 25722, 25719
10317, 25194, 25195, 25218, 25217, 25677, 25723, 25724, 25721
10318, 25195, 25196, 25219, 25218, 25679, 25725, 25726, 25723
10319, 25196, 25197, 25220, 25219, 25681, 25727, 25728, 25725
10320, 25197, 25198, 25221, 25220, 25683, 25729, 25730, 25727
10321, 25198, 25199, 25222, 25221, 25685, 25731, 25732, 25729
10322, 25199, 25200, 25223, 25222, 25687, 25733, 25734, 25731
10323, 25200, 25201, 25224, 25223, 25689, 25735, 25736, 25733
10324, 25201, 25202, 25225, 25224, 25691, 25737, 25738, 25735
10325, 25202, 25203, 25226, 25225, 25693, 25739, 25740, 25737
10326, 25203, 25204, 25227, 25226, 25695, 25741, 25742, 25739
10327, 25204, 25205, 25228, 25227, 25697, 25743, 25744, 25741
10328, 25205, 2271, 2272, 25228, 25698, 2283, 25745, 25743
10329, 2249, 25206, 2135, 45, 25700, 25746, 2158, 2261
10330, 25206, 25207, 2136, 2135, 25702, 25747, 2159, 25746
10331, 25207, 25208, 2137, 2136, 25704, 25748, 2160, 25747
10332, 25208, 25209, 2138, 2137, 25706, 25749, 2161, 25748
10333, 25209, 25210, 2139, 2138, 25708, 25750, 2162, 25749
10334, 25210, 25211, 2140, 2139, 25710, 25751, 2163, 25750
10335, 25211, 25212, 2141, 2140, 25712, 25752, 2164, 25751
10336, 25212, 25213, 2142, 2141, 25714, 25753, 2165, 25752
10337, 25213, 25214, 2143, 2142, 25716, 25754, 2166, 25753
10338, 25214, 25215, 2144, 2143, 25718, 25755, 2167, 25754
10339, 25215, 25216, 2145, 2144, 25720, 25756, 2168, 25755
10340, 25216, 25217, 2146, 2145, 25722, 25757, 2169, 25756
10341, 25217, 25218, 2147, 2146, 25724, 25758, 2170, 25757
10342, 25218, 25219, 2148, 2147, 25726, 25759, 2171, 25758
10343, 25219, 25220, 2149, 2148, 25728, 25760, 2172, 25759
10344, 25220, 25221, 2150, 2149, 25730, 25761, 2173, 25760
10345, 25221, 25222, 2151, 2150, 25732, 25762, 2174, 25761
10346, 25222, 25223, 2152, 2151, 25734, 25763, 2175, 25762
10347, 25223, 25224, 2153, 2152, 25736, 25764, 2176, 25763
10348, 25224, 25225, 2154, 2153, 25738, 25765, 2177, 25764
10349, 25225, 25226, 2155, 2154, 25740, 25766, 2178, 25765
10350, 25226, 25227, 2156, 2155, 25742, 25767, 2179, 25766
10351, 25227, 25228, 2157, 2156, 25744, 25768, 2180, 25767
10352, 25228, 2272, 46, 2157, 25745, 2284, 2181, 25768
*ELEMENT, type=CPS8, ELSET=Surface57
10353, 42, 2130, 2287, 49, 2132, 25769, 2289, 2285
10354, 2130, 2131, 2288, 2287, 2133, 25770, 2290, 25769
10355, 2131, 46, 50, 2288, 2134, 2286, 2291, 25770
*ELEMENT, type=CPS8, ELSET=Surface58
10356, 44, 51, 2294, 2187, 2292, 2296, 25771, 2189
10357, 2187, 2294, 2295, 2188, 25771, 2297, 25772, 2190
10358, 2188, 2295, 52, 48, 25772, 2298, 2293, 2191
*ELEMENT, type=CPS8, ELSET=Surface59
10359, 44, 2102, 2299, 51, 2113, 25773, 2310, 2292
10360, 2102, 2103, 2300, 2299, 2114, 25774, 2311, 25773
10361, 2103, 2104, 2301, 2300, 2115, 25775, 2312, 25774
10362, 2104, 2105, 2302, 2301, 2116, 25776, 2313, 25775
10363, 2105, 2106, 2303, 2302, 2117, 25777, 2314, 25776
10364, 2106, 2107, 2304, 2303, 2118, 25778, 2315, 25777
10365, 2107, 2108, 2305, 2304, 2119, 25779, 2316, 25778
10366, 2108, 2109, 2306, 2305, 2120, 25780, 2317, 25779
10367, 2109, 2110, 2307, 2306, 2121, 25781, 2318, 25780
10368, 2110, 2111, 2308, 2307, 2122, 25782, 2319, 25781
10369, 2111, 2112, 2309, 2308, 2123, 25783, 2320, 25782
10370, 2112, 42, 49, 2309, 2124, 2285, 2321, 25783
*ELEMENT, type=CPS8, ELSET=Surface60
10371, 48, 52, 2322, 2262, 2293, 2333, 25784, 2273
10372, 2262, 2322, 2323, 2263, 25784, 2334, 25785, 2274
10373, 2263, 2323, 2324, 2264, 25785, 2335, 25786, 2275
10374, 2264, 2324, 2325, 2265, 25786, 2336, 25787, 2276
10375, 2265, 2325, 2326, 2266, 25787, 2337, 25788, 2277
10376, 2266, 2326, 2327, 2267, 25788, 2338, 25789, 2278
10377, 2267, 2327, 2328, 2268, 25789, 2339, 25790, 2279
10378, 2268, 2328, 2329, 2269, 25790, 2340, 25791, 2280
10379, 2269, 2329, 2330, 2270, 25791, 2341, 25792, 2281
10380, 2270, 2330, 2331, 2271, 25792, 2342, 25793, 2282
10381, 2271, 2331, 2332, 2272, 25793, 2343, 25794, 2283
10382, 2272, 2332, 50, 46, 25794, 2344, 2286, 2284
*ELEMENT, type=CPS8, ELSET=Surface61
10383, 51, 2299, 25795, 2294, 2310, 25817, 25818, 2296
10384, 2294, 25795, 25796, 2295, 25818, 25819, 25820, 2297
10385, 2295, 25796, 2322, 52, 25820, 25821, 2333, 2298
10386, 2299, 2300, 25797, 25795, 2311, 25822, 25823, 25817
10387, 25795, 25797, 25798, 25796, 25823, 25824, 25825, 25819
10388, 25796, 25798, 2323, 2322, 25825, 25826, 2334, 25821
10389, 2300, 2301, 25799, 25797, 2312, 25827, 25828, 25822
10390, 25797, 25799, 25800, 25798, 25828, 25829, 25830, 25824
10391, 25798, 25800, 2324, 2323, 25830, 25831, 2335, 25826
10392, 2301, 2302, 25801, 25799, 2313, 25832, 25833, 25827
10393, 25799, 25801, 25802, 25800, 25833, 25834, 25835, 25829
10394, 25800, 25802, 2325, 2324, 25835, 25836, 2336, 25831
10395, 2302, 2303, 25803, 25801, 2314, 25837, 25838, 25832
10396, 25801, 25803, 25804, 25802, 25838, 25839, 25840, 25834
10397, 25802, 25804, 2326, 2325, 25840, 25841, 2337, 25836
10398, 2303, 2304, 25805, 25803, 2315, 25842, 25843, 25837
10399, 25803, 25805, 25806, 25804, 25843, 25844, 25845, 25839
10400, 25804, 25806, 2327, 2326, 25845, 25846, 2338, 25841
10401, 2304, 2305, 25807, 25805, 2316, 25847, 25848, 25842
10402, 25805, 25807, 25808, 25806, 25848, 25849, 25850, 25844
10403, 25806, 25808, 2328, 2327, 25850, 25851, 2339, 25846
10404, 2305, 2306, 25809, 25807, 2317, 25852, 25853, 25847
10405, 25807, 25809, 25810, 25808, 25853, 25854, 25855, 25849
10406, 25808, 25810, 2329, 2328, 25855, 25856, 2340, 25851
10407, 2306, 2307, 25811, 25809, 2318, 25857, 25858, 25852
10408, 25809, 25811, 25812, 25810, 25858, 25859, 25860, 25854
10409, 25810, 25812, 2330, 2329, 25860, 25861, 2341, 25856
10410, 2307, 2308, 25813, 25811, 2319, 25862, 25863, 25857
10411, 25811, 25813, 25814, 25812, 25863, 25864, 25865, 25859
10412, 25812, 25814, 2331, 2330, 25865, 25866, 2342, 25861
10413, 2308, 2309, 25815, 25813, 2320, 25867, 25868, 25862
10414, 25813, 25815, 25816, 25814, 25868, 25869, 25870, 25864
10415, 25814, 25816, 2332, 2331, 25870, 25871, 2343, 25866
10416, 2309, 49, 2287, 25815, 2321, 2289, 25872, 25867
10417, 25815, 2287, 2288, 25816, 25872, 2290, 25873, 25869
10418, 25816, 2288, 50, 2332, 25873, 2291, 2344, 25871
*ELEMENT, type=CPS8, ELSET=Surface62
10419, 2, 97, 2347, 54, 108, 25874, 2358, 2346
10420, 97, 98, 2348, 2347, 109, 25875, 2359, 25874
10421, 98, 99, 2349, 2348, 110, 25876, 2360, 25875
10422, 99, 100, 2350, 2349, 111, 25877, 2361, 25876
10423, 100, 101, 2351, 2350, 112, 25878, 2362, 25877
10424, 101, 102, 2352, 2351, 113, 25879, 2363, 25878
10425, 102, 103, 2353, 2352, 114, 25880, 2364, 25879
10426, 103, 104, 2354, 2353, 115, 25881, 2365, 25880
10427, 104, 105, 2355, 2354, 116, 25882, 2366, 25881
10428, 105, 106, 2356, 2355, 117, 25883, 2367, 25882
10429, 106, 107, 2357, 2356, 118, 25884, 2368, 25883
10430, 107, 1, 53, 2357, 119, 2345, 2369, 25884
*ELEMENT, type=CPS8, ELSET=Surface63
10431, 1, 120, 2371, 53, 122, 25885, 2373, 2345
10432, 120, 121, 2372, 2371, 123, 25886, 2374, 25885
10433, 121, 3, 55, 2372, 124, 2370, 2375, 25886
*ELEMENT, type=CPS8, ELSET=Surface64
10434, 4, 56, 2377, 125, 2376, 2388, 25887, 136
10435, 125, 2377, 2378, 126, 25887, 2389, 25888, 137
10436, 126, 2378, 2379, 127, 25888, 2390, 25889, 138
10437, 127, 2379, 2380, 128, 25889, 2391, 25890, 139
10438, 128, 2380, 2381, 129, 25890, 2392, 25891, 140
10439, 129, 2381, 2382, 130, 25891, 2393, 25892, 141
10440, 130, 2382, 2383, 131, 25892, 2394, 25893, 142
10441, 131, 2383, 2384, 132, 25893, 2395, 25894, 143
10442, 132, 2384, 2385, 133, 25894, 2396, 25895, 144
10443, 133, 2385, 2386, 134, 25895, 2397, 25896, 145
10444, 134, 2386, 2387, 135, 25896, 2398, 25897, 146
10445, 135, 2387, 55, 3, 25897, 2399, 2370, 147
*ELEMENT, type=CPS8, ELSET=Surface65
10446, 2, 54, 2400, 148, 2346, 2402, 25898, 150
10447, 148, 2400, 2401, 149, 25898, 2403, 25899, 151
10448, 149, 2401, 56, 4, 25899, 2404, 2376, 152
*ELEMENT, type=CPS8, ELSET=Surface66
10449, 54, 2347, 25900, 2400, 2358, 25922, 25923, 2402
10450, 2400, 25900, 25901, 2401, 25923, 25924, 25925, 2403
10451, 2401, 25901, 2377, 56, 25925, 25926, 2388, 2404
10452, 2347, 2348, 25902, 25900, 2359, 25927, 25928, 25922
10453, 25900, 25902, 25903, 25901, 25928, 25929, 25930, 25924
10454, 25901, 25903, 2378, 2377, 25930, 25931, 2389, 25926
10455, 2348, 2349, 25904, 25902, 2360, 25932, 25933, 25927
10456, 25902, 25904, 25905, 25903, 25933, 25934, 25935, 25929
10457, 25903, 25905, 2379, 2378, 25935, 25936, 2390, 25931
10458, 2349, 2350, 25906, 25904, 2361, 25937, 25938, 25932
10459, 25904, 25906, 25907, 25905, 25938, 25939, 25940, 25934
10460, 25905, 25907, 2380, 2379, 25940, 25941, 2391, 25936
10461, 2350, 2351, 25908, 25906, 2362, 25942, 25943, 25937
10462, 25906, 25908, 25909, 25907, 25943, 25944, 25945, 25939
10463, 25907, 25909, 2381, 2380, 25945, 25946, 2392, 25941
10464, 2351, 2352, 25910, 25908, 2363, 25947, 25948, 25942
10465, 25908, 25910, 25911, 25909, 25948, 25949, 25950, 25944
10466, 25909, 25911, 2382, 2381, 25950, 25951, 2393, 25946
10467, 2352, 2353, 25912, 25910, 2364, 25952, 25953, 25947
10468, 25910, 25912, 25913, 25911, 25953, 25954, 25955, 25949
10469, 25911, 25913, 2383, 2382, 25955, 25956, 2394, 25951
10470, 2353, 2354, 25914, 25912, 2365, 25957, 25958, 25952
10471, 25912, 25914, 25915, 25913, 25958, 25959, 25960, 25954
10472, 25913, 25915, 2384, 2383, 25960, 25961, 2395, 25956
10473, 2354, 2355, 25916, 25914, 2366, 25962, 25963, 25957
10474, 25914, 25916, 25917, 25915, 25963, 25964, 25965, 25959
10475, 25915, 25917, 2385, 2384, 25965, 25966, 2396, 25961
10476, 2355, 2356, 25918, 25916, 2367, 25967, 25968, 25962
10477, 25916, 25918, 25919, 25917, 25968, 25969, 25970, 25964
10478, 25917, 25919, 2386, 2385, 25970, 25971, 2397, 25966
10479, 2356, 2357, 25920, 25918, 2368, 25972, 25973, 25967
10480, 25918, 25920, 25921, 25919, 25973, 25974, 25975, 25969
10481, 25919, 25921, 2387, 2386, 25975, 25976, 2398, 25971
10482, 2357, 53, 2371, 25920, 2369, 2373, 25977, 25972
10483, 25920, 2371, 2372, 25921, 25977, 2374, 25978, 25974
10484, 25921, 2372, 55, 2387, 25978, 2375, 2399, 25976
*ELEMENT, type=CPS8, ELSET=Surface77
10485, 11, 57, 2407, 682, 2405, 2430, 25979, 705
10486, 682, 2407, 2408, 683, 25979, 2431, 25980, 706
10487, 683, 2408, 2409, 684, 25980, 2432, 25981, 707
10488, 684, 2409, 2410, 685, 25981, 2433, 25982, 708
10489, 685, 2410, 2411, 686, 25982, 2434, 25983, 709
10490, 686, 2411, 2412, 687, 25983, 2435, 25984, 710
10491, 687, 2412, 2413, 688, 25984, 2436, 25985, 711
10492, 688, 2413, 2414, 689, 25985, 2437, 25986, 712
10493, 689, 2414, 2415, 690, 25986, 2438, 25987, 713
10494, 690, 2415, 2416, 691, 25987, 2439, 25988, 714
10495, 691, 2416, 2417, 692, 25988, 2440, 25989, 715
10496, 692, 2417, 2418, 693, 25989, 2441, 25990, 716
10497, 693, 2418, 2419, 694, 25990, 2442, 25991, 717
10498, 694, 2419, 2420, 695, 25991, 2443, 25992, 718
10499, 695, 2420, 2421, 696, 25992, 2444, 25993, 719
10500, 696, 2421, 2422, 697, 25993, 2445, 25994, 720
10501, 697, 2422, 2423, 698, 25994, 2446, 25995, 721
10502, 698, 2423, 2424, 699, 25995, 2447, 25996, 722
10503, 699, 2424, 2425, 700, 25996, 2448, 25997, 723
10504, 700, 2425, 2426, 701, 25997, 2449, 25998, 724
10505, 701, 2426, 2427, 702, 25998, 2450, 25999, 725
10506, 702, 2427, 2428, 703, 25999, 2451, 26000, 726
10507, 703, 2428, 2429, 704, 26000, 2452, 26001, 727
10508, 704, 2429, 58, 15, 26001, 2453, 2406, 728
*ELEMENT, type=CPS8, ELSET=Surface78
10509, 9, 541, 2456, 59, 564, 26002, 2479, 2454
10510, 541, 542, 2457, 2456, 565, 26003, 2480, 26002
10511, 542, 543, 2458, 2457, 566, 26004, 2481, 26003
10512, 543, 544, 2459, 2458, 567, 26005, 2482, 26004
10513, 544, 545, 2460, 2459, 568, 26006, 2483, 26005
10514, 545, 546, 2461, 2460, 569, 26007, 2484, 26006
10515, 546, 547, 2462, 2461, 570, 26008, 2485, 26007
10516, 547, 548, 2463, 2462, 571, 26009, 2486, 26008
10517, 548, 549, 2464, 2463, 572, 26010, 2487, 26009
10518, 549, 550, 2465, 2464, 573, 26011, 2488, 26010
10519, 550, 551, 2466, 2465, 574, 26012, 2489, 26011
10520, 551, 552, 2467, 2466, 575, 26013, 2490, 26012
10521, 552, 553, 2468, 2467, 576, 26014, 2491, 26013
10522, 553, 554, 2469, 2468, 577, 26015, 2492, 26014
10523, 554, 555, 2470, 2469, 578, 26016, 2493, 26015
10524, 555, 556, 2471, 2470, 579, 26017, 2494, 26016
10525, 556, 557, 2472, 2471, 580, 26018, 2495, 26017
10526, 557, 558, 2473, 2472, 581, 26019, 2496, 26018
10527, 558, 559, 2474, 2473, 582, 26020, 2497, 26019
10528, 559, 560, 2475, 2474, 583, 26021, 2498, 26020
10529, 560, 561, 2476, 2475, 584, 26022, 2499, 26021
10530, 561, 562, 2477, 2476, 585, 26023, 2500, 26022
10531, 562, 563, 2478, 2477, 586, 26024, 2501, 26023
10532, 563, 13, 60, 2478, 587, 2455, 2502, 26024
*ELEMENT, type=CPS8, ELSET=Surface79
10533, 9, 59, 2503, 447, 2454, 2514, 26025, 458
10534, 447, 2503, 2504, 448, 26025, 2515, 26026, 459
10535, 448, 2504, 2505, 449, 26026, 2516, 26027, 460
10536, 449, 2505, 2506, 450, 26027, 2517, 26028, 461
10537, 450, 2506, 2507, 451, 26028, 2518, 26029, 462
10538, 451, 2507, 2508, 452, 26029, 2519, 26030, 463
10539, 452, 2508, 2509, 453, 26030, 2520, 26031, 464
10540, 453, 2509, 2510, 454, 26031, 2521, 26032, 465
10541, 454, 2510, 2511, 455, 26032, 2522, 26033, 466
10542, 455, 2511, 2512, 456, 26033, 2523, 26034, 467
10543, 456, 2512, 2513, 457, 26034, 2524, 26035, 468
10544, 457, 2513, 57, 11, 26035, 2525, 2405, 469
*ELEMENT, type=CPS8, ELSET=Surface80
10545, 13, 729, 2526, 60, 740, 26036, 2537, 2455
10546, 729, 730, 2527, 2526, 741, 26037, 2538, 26036
10547, 730, 731, 2528, 2527, 742, 26038, 2539, 26037
10548, 731, 732, 2529, 2528, 743, 26039, 2540, 26038
10549, 732, 733, 2530, 2529, 744, 26040, 2541, 26039
10550, 733, 734, 2531, 2530, 745, 26041, 2542, 26040
10551, 734, 735, 2532, 2531, 746, 26042, 2543, 26041
10552, 735, 736, 2533, 2532, 747, 26043, 2544, 26042
10553, 736, 737, 2534, 2533, 748, 26044, 2545, 26043
10554, 737, 738, 2535, 2534, 749, 26045, 2546, 26044
10555, 738, 739, 2536, 2535, 750, 26046, 2547, 26045
10556, 739, 15, 58, 2536, 751, 2406, 2548, 26046
*ELEMENT, type=CPS8, ELSET=Surface81
10557, 59, 2456, 26047, 2503, 2479, 26300, 26301, 2514
10558, 2456, 2457, 26048, 26047, 2480, 26302, 26303, 26300
10559, 2457, 2458, 26049, 26048, 2481, 26304, 26305, 26302
10560, 2458, 2459, 26050, 26049, 2482, 26306, 26307, 26304
10561, 2459, 2460, 26051, 26050, 2483, 26308, 26309, 26306
10562, 2460, 2461, 26052, 26051, 2484, 26310, 26311, 26308
10563, 2461, 2462, 26053, 26052, 2485, 26312, 26313, 26310
10564, 2462, 2463, 26054, 26053, 2486, 26314, 26315, 26312
10565, 2463, 2464, 26055, 26054, 2487, 26316, 26317, 26314
10566, 2464, 2465, 26056, 26055, 2488, 26318, 26319, 26316
10567, 2465, 2466, 26057, 26056, 2489, 26320, 26321, 26318
10568, 2466, 2467, 26058, 26057, 2490, 26322, 26323, 26320
10569, 2467, 2468, 26059, 26058, 2491, 26324, 26325, 26322
10570, 2468, 2469, 26060, 26059, 2492, 26326, 26327, 26324
10571, 2469, 2470, 26061, 26060, 2493, 26328, 26329, 26326
10572, 2470, 2471, 26062, 26061, 2494, 26330, 26331, 26328
10573, 2471, 2472, 26063, 26062, 2495, 26332, 26333, 26330
10574, 2472, 2473, 26064, 26063, 2496, 26334, 26335, 26332
10575, 2473, 2474, 26065, 26064, 2497, 26336, 26337, 26334
10576, 2474, 2475, 26066, 26065, 2498, 26338, 26339, 26336
10577, 2475, 2476, 26067, 26066, 2499, 26340, 26341, 26338
10578, 2476, 2477, 26068, 26067, 2500, 26342, 26343, 26340
10579, 2477, 2478, 26069, 26068, 2501, 26344, 26345, 26342
10580, 2478, 60, 2526, 26069, 2502, 2537, 26346, 26344
10581, 2503, 26047, 26070, 2504, 26301, 26347, 26348, 2515
10582, 26047, 26048, 26071, 26070, 26303, 26349, 26350, 26347
10583, 26048, 26049, 26072, 26071, 26305, 26351, 26352, 26349
10584, 26049, 26050, 26073, 26072, 26307, 26353, 26354, 26351
10585, 26050, 26051, 26074, 26073, 26309, 26355, 26356, 26353
10586, 26051, 26052, 26075, 26074, 26311, 26357, 26358, 26355
10587, 26052, 26053, 26076, 26075, 26313, 26359, 26360, 26357
10588, 26053, 26054, 26077, 26076, 26315, 26361, 26362, 26359
10589, 26054, 26055, 26078, 26077, 26317, 26363, 26364, 26361
10590, 26055, 26056, 26079, 26078, 26319, 26365, 26366, 26363
10591, 26056, 26057, 26080, 26079, 26321, 26367, 26368, 26365
10592, 26057, 26058, 26081, 26080, 26323, 26369, 26370, 26367
10593, 26058, 26059, 26082, 26081, 26325, 26371, 26372, 26369
10594, 26059, 26060, 26083, 26082, 26327, 26373, 26374, 26371
10595, 26060, 26061, 26084, 26083, 26329, 26375, 26376, 26373
10596, 26061, 26062, 26085, 26084, 26331, 26377, 26378, 26375
10597, 26062, 26063, 26086, 26085, 26333, 26379, 26380, 26377
10598, 26063, 26064, 26087, 26086, 26335, 26381, 26382, 26379
10599, 26064, 26065, 26088, 26087, 26337, 26383, 26384, 26381
10600, 26065, 26066, 26089, 26088, 26339, 26385, 26386, 26383
10601, 26066, 26067, 26090, 26089, 26341, 26387, 26388, 26385
10602, 26067, 26068, 26091, 26090, 26343, 26389, 26390, 26387
10603, 26068, 26069, 26092, 26091, 26345, 26391, 26392, 26389
10604, 26069, 2526, 2527, 26092, 26346, 2538, 26393, 26391
10605, 2504, 26070, 26093, 2505, 26348, 26394, 26395, 2516
10606, 26070, 26071, 26094, 26093, 26350, 26396, 26397, 26394
10607, 26071, 26072, 26095, 26094, 26352, 26398, 26399, 26396
10608, 26072, 26073, 26096, 26095, 26354, 26400, 26401, 26398
10609, 26073, 26074, 26097, 26096, 26356, 26402, 26403, 26400
10610, 26074, 26075, 26098, 26097, 26358, 26404, 26405, 26402
10611, 26075, 26076, 26099, 26098, 26360, 26406, 26407, 26404
10612, 26076, 26077, 26100, 26099, 26362, 26408, 26409, 26406
10613, 26077, 26078, 26101, 26100, 26364, 26410, 26411, 26408
10614, 26078, 26079, 26102, 26101, 26366, 26412, 26413, 26410
10615, 26079, 26080, 26103, 26102, 26368, 26414, 26415, 26412
10616, 26080, 26081, 26104, 26103, 26370, 26416, 26417, 26414
10617, 26081, 26082, 26105, 26104, 26372, 26418, 26419, 26416
10618, 26082, 26083, 26106, 26105, 26374, 26420, 26421, 26418
10619, 26083, 26084, 26107, 26106, 26376, 26422, 26423, 26420
10620, 26084, 26085, 26108, 26107, 26378, 26424, 26425, 26422
10621, 26085, 26086, 26109, 26108, 26380, 26426, 26427, 26424
10622, 26086, 26087, 26110, 26109, 26382, 26428, 26429, 26426
10623, 26087, 26088, 26111, 26110, 26384, 26430, 26431, 26428
10624, 26088, 26089, 26112, 26111, 26386, 26432, 26433, 26430
10625, 26089, 26090, 26113, 26112, 26388, 26434, 26435, 26432
10626, 26090, 26091, 26114, 26113, 26390, 26436, 26437, 26434
10627, 26091, 26092, 26115, 26114, 26392, 26438, 26439, 26436
10628, 26092, 2527, 2528, 26115, 26393, 2539, 26440, 26438
10629, 2505, 26093, 26116, 2506, 26395, 26441, 26442, 2517
10630, 26093, 26094, 26117, 26116, 26397, 26443, 26444, 26441
10631, 26094, 26095, 26118, 26117, 26399, 26445, 26446, 26443
10632, 26095, 26096, 26119, 26118, 26401, 26447, 26448, 26445
10633, 26096, 26097, 26120, 26119, 26403, 26449, 26450, 26447
10634, 26097, 26098, 26121, 26120, 26405, 26451, 26452, 26449
10635, 26098, 26099, 26122, 26121, 26407, 26453, 26454, 26451
10636, 26099, 26100, 26123, 26122, 26409, 26455, 26456, 26453
10637, 26100, 26101, 26124, 26123, 26411, 26457, 26458, 26455
10638, 26101, 26102, 26125, 26124, 26413, 26459, 26460, 26457
10639, 26102, 26103, 26126, 26125, 26415, 26461, 26462, 26459
10640, 26103, 26104, 26127, 26126, 26417, 26463, 26464, 26461
10641, 26104, 26105, 26128, 26127, 26419, 26465, 26466, 26463
10642, 26105, 26106, 26129, 26128, 26421, 26467, 26468, 26465
10643, 26106, 26107, 26130, 26129, 26423, 26469, 26470, 26467
10644, 26107, 26108, 26131, 26130, 26425, 26471, 26472, 26469
10645, 26108, 26109, 26132, 26131, 26427, 26473, 26474, 26471
10646, 26109, 26110, 26133, 26132, 26429, 26475, 26476, 26473
10647, 26110, 26111, 26134, 26133, 26431, 26477, 26478, 26475
10648, 26111, 26112, 26135, 26134, 26433, 26479, 26480, 26477
10649, 26112, 26113, 26136, 26135, 26435, 26481, 26482, 26479
10650, 26113, 26114, 26137, 26136, 26437, 26483, 26484, 26481
10651, 26114, 26115, 26138, 26137, 26439, 26485, 26486, 26483
10652, 26115, 2528, 2529, 26138, 26440, 2540, 26487, 26485
10653, 2506, 26116, 26139, 2507, 26442, 26488, 26489, 2518
10654, 26116, 26117, 26140, 26139, 26444, 26490, 26491, 26488
10655, 26117, 26118, 26141, 26140, 26446, 26492, 26493, 26490
10656, 26118, 26119, 26142, 26141, 26448, 26494, 26495, 26492
10657, 26119, 26120, 26143, 26142, 26450, 26496, 26497, 26494
10658, 26120, 26121, 26144, 26143, 26452, 26498, 26499, 26496
10659, 26121, 26122, 26145, 26144, 26454, 26500, 26501, 26498
10660, 26122, 26123, 26146, 26145, 26456, 26502, 26503, 26500
10661, 26123, 26124, 26147, 26146, 26458, 26504, 26505, 26502
10662, 26124, 26125, 26148, 26147, 26460, 26506, 26507, 26504
10663, 26125, 26126, 26149, 26148, 26462, 26508, 26509, 26506
10664, 26126, 26127, 26150, 26149, 26464, 26510, 26511, 26508
10665, 26127, 26128, 26151, 26150, 26466, 26512, 26513, 26510
10666, 26128, 26129, 26152, 26151, 26468, 26514, 26515, 26512
10667, 26129, 26130, 26153, 26152, 26470, 26516, 26517, 26514
10668, 26130, 26131, 26154, 26153, 26472, 26518, 26519, 26516
10669, 26131, 26132, 26155, 26154, 26474, 26520, 26521, 26518
10670, 26132, 26133, 26156, 26155, 26476, 26522, 26523, 26520
10671, 26133, 26134, 26157, 26156, 26478, 26524, 26525, 26522
10672, 26134, 26135, 26158, 26157, 26480, 26526, 26527, 26524
10673, 26135, 26136, 26159, 26158, 26482, 26528, 26529, 26526
10674, 26136, 26137, 26160, 26159, 26484, 26530, 26531, 26528
10675, 26137, 26138, 26161, 26160, 26486, 26532, 26533, 26530
10676, 26138, 2529, 2530, 26161, 26487, 2541, 26534, 26532
10677, 2507, 26139, 26162, 2508, 26489, 26535, 26536, 2519
10678, 26139, 26140, 26163, 26162, 26491, 26537, 26538, 26535
10679, 26140, 26141, 26164, 26163, 26493, 26539, 26540, 26537
10680, 26141, 26142, 26165, 26164, 26495, 26541, 26542, 26539
10681, 26142, 26143, 26166, 26165, 26497, 26543, 26544, 26541
10682, 26143, 26144, 26167, 26166, 26499, 26545, 26546, 26543
10683, 26144, 26145, 26168, 26167, 26501, 26547, 26548, 26545
10684, 26145, 26146, 26169, 26168, 26503, 26549, 26550, 26547
10685, 26146, 26147, 26170, 26169, 26505, 26551, 26552, 26549
10686, 26147, 26148, 26171, 26170, 26507, 26553, 26554, 26551
10687, 26148, 26149, 26172, 26171, 26509, 26555, 26556, 26553
10688, 26149, 26150, 26173, 26172, 26511, 26557, 26558, 26555
10689, 26150, 26151, 26174, 26173, 26513, 26559, 26560, 26557
10690, 26151, 26152, 26175, 26174, 26515, 26561, 26562, 26559
10691, 26152, 26153, 26176, 26175, 26517, 26563, 26564, 26561
10692, 26153, 26154, 26177, 26176, 26519, 26565, 26566, 26563
10693, 26154, 26155, 26178, 26177, 26521, 26567, 26568, 26565
10694, 26155, 26156, 26179, 26178, 26523, 26569, 26570, 26567
10695, 26156, 26157, 26180, 26179, 26525, 26571, 26572, 26569
10696, 26157, 26158, 26181, 26180, 26527, 26573, 26574, 26571
10697, 26158, 26159, 26182, 26181, 26529, 26575, 26576, 26573
10698, 26159, 26160, 26183, 26182, 26531, 26577, 26578, 26575
10699, 26160, 26161, 26184, 26183, 26533, 26579, 26580, 26577
10700, 26161, 2530, 2531, 26184, 26534, 2542, 26581, 26579
10701, 2508, 26162, 26185, 2509, 26536, 26582, 26583, 2520
10702, 26162, 26163, 26186, 26185, 26538, 26584, 26585, 26582
10703, 26163, 26164, 26187, 26186, 26540, 26586, 26587, 26584
10704, 26164, 26165, 26188, 26187, 26542, 26588, 26589, 26586
10705, 26165, 26166, 26189, 26188, 26544, 26590, 26591, 26588
10706, 26166, 26167, 26190, 26189, 26546, 26592, 26593, 26590
10707, 26167, 26168, 26191, 26190, 26548, 26594, 26595, 26592
10708, 26168, 26169, 26192, 26191, 26550, 26596, 26597, 26594
10709, 26169, 26170, 26193, 26192, 26552, 26598, 26599, 26596
10710, 26170, 26171, 26194, 26193, 26554, 26600, 26601, 26598
10711, 26171, 26172, 26195, 26194, 26556, 26602, 26603, 26600
10712, 26172, 26173, 26196, 26195, 26558, 26604, 26605, 26602
10713, 26173, 26174, 26197, 26196, 26560, 26606, 26607, 26604
10714, 26174, 26175, 26198, 26197, 26562, 26608, 26609, 26606
10715, 26175, 26176, 26199, 26198, 26564, 26610, 26611, 26608
10716, 26176, 26177, 26200, 26199, 26566, 26612, 26613, 26610
10717, 26177, 26178, 26201, 26200, 26568, 26614, 26615, 26612
10718, 26178, 26179, 26202, 26201, 26570, 26616, 26617, 26614
10719, 26179, 26180, 26203, 26202, 26572, 26618, 26619, 26616
10720, 26180, 26181, 26204, 26203, 26574, 26620, 26621, 26618
10721, 26181, 26182, 26205, 26204, 26576, 26622, 26623, 26620
10722, 26182, 26183, 26206, 26205, 26578, 26624, 26625, 26622
10723, 26183, 26184, 26207, 26206, 26580, 26626, 26627, 26624
10724, 26184, 2531, 2532, 26207, 26581, 2543, 26628, 26626
10725, 2509, 26185, 26208, 2510, 26583, 26629, 26630, 2521
10726, 26185, 26186, 26209, 26208, 26585, 26631, 26632, 26629
10727, 26186, 26187, 26210, 26209, 26587, 26633, 26634, 26631
10728, 26187, 26188, 26211, 26210, 26589, 26635, 26636, 26633
10729, 26188, 26189, 26212, 26211, 26591, 26637, 26638, 26635
10730, 26189, 26190, 26213, 26212, 26593, 26639, 26640, 26637
10731, 26190, 26191, 26214, 26213, 26595, 26641, 26642, 26639
10732, 26191, 26192, 26215, 26214, 26597, 26643, 26644, 26641
10733, 26192, 26193, 26216, 26215, 26599, 26645, 26646, 26643
10734, 26193, 26194, 26217, 26216, 26601, 26647, 26648, 26645
10735, 26194, 26195, 26218, 26217, 26603, 26649, 26650, 26647
10736, 26195, 26196, 26219, 26218, 26605, 26651, 26652, 26649
10737, 26196, 26197, 26220, 26219, 26607, 26653, 26654, 26651
10738, 26197, 26198, 26221, 26220, 26609, 26655, 26656, 26653
10739, 26198, 26199, 26222, 26221, 26611, 26657, 26658, 26655
10740, 26199, 26200, 26223, 26222, 26613, 26659, 26660, 26657
10741, 26200, 26201, 26224, 26223, 26615, 26661, 26662, 26659
10742, 26201, 26202, 26225, 26224, 26617, 26663, 26664, 26661
10743, 26202, 26203, 26226, 26225, 26619, 26665, 26666, 26663
10744, 26203, 26204, 26227, 26226, 26621, 26667, 26668, 26665
10745, 26204, 26205, 26228, 26227, 26623, 26669, 26670, 26667
10746, 26205, 26206, 26229, 26228, 26625, 26671, 26672, 26669
10747, 26206, 26207, 26230, 26229, 26627, 26673, 26674, 26671
10748, 26207, 2532, 2533, 26230, 26628, 2544, 26675, 26673
10749, 2510, 26208, 26231, 2511, 26630, 26676, 26677, 2522
10750, 26208, 26209, 26232, 26231, 26632, 26678, 26679, 26676
10751, 26209, 26210, 26233, 26232, 26634, 26680, 26681, 26678
10752, 26210, 26211, 26234, 26233, 26636, 26682, 26683, 26680
10753, 26211, 26212, 26235, 26234, 26638, 26684, 26685, 26682
10754, 26212, 26213, 26236, 26235, 26640, 26686, 26687, 26684
10755, 26213, 26214, 26237, 26236, 26642, 26688, 26689, 26686
10756, 26214, 26215, 26238, 26237, 26644, 26690, 26691, 26688
10757, 26215, 26216, 26239, 26238, 26646, 26692, 26693, 26690
10758, 26216, 26217, 26240, 26239, 26648, 26694, 26695, 26692
10759, 26217, 26218, 26241, 26240, 26650, 26696, 26697, 26694
10760, 26218, 26219, 26242, 26241, 26652, 26698, 26699, 26696
10761, 26219, 26220, 26243, 26242, 26654, 26700, 26701, 26698
10762, 26220, 26221, 26244, 26243, 26656, 26702, 26703, 26700
10763, 26221, 26222, 26245, 26244, 26658, 26704, 26705, 26702
10764, 26222, 26223, 26246, 26245, 26660, 26706, 26707, 26704
10765, 26223, 26224, 26247, 26246, 26662, 26708, 26709, 26706
10766, 26224, 26225, 26248, 26247, 26664, 26710, 26711, 26708
10767, 26225, 26226, 26249, 26248, 26666, 26712, 26713, 26710
10768, 26226, 26227, 26250, 26249, 26668, 26714, 26715, 26712
10769, 26227, 26228, 26251, 26250, 26670, 26716, 26717, 26714
10770, 26228, 26229, 26252, 26251, 26672, 26718, 26719, 26716
10771, 26229, 26230, 26253, 26252, 26674, 26720, 26721, 26718
10772, 26230, 2533, 2534, 26253, 26675, 2545, 26722, 26720
10773, 2511, 26231, 26254, 2512, 26677, 26723, 26724, 2523
10774, 26231, 26232, 26255, 26254, 26679, 26725, 26726, 26723
10775, 26232, 26233, 26256, 26255, 26681, 26727, 26728, 26725
10776, 26233, 26234, 26257, 26256, 26683, 26729, 26730, 26727
10777, 26234, 26235, 26258, 26257, 26685, 26731, 26732, 26729
10778, 26235, 26236, 26259, 26258, 26687, 26733, 26734, 26731
10779, 26236, 26237, 26260, 26259, 26689, 26735, 26736, 26733
10780, 26237, 26238, 26261, 26260, 26691, 26737, 26738, 26735
10781, 26238, 26239, 26262, 26261, 26693, 26739, 26740, 26737
10782, 26239, 26240, 26263, 26262, 26695, 26741, 26742, 26739
10783, 26240, 26241, 26264, 26263, 26697, 26743, 26744, 26741
10784, 26241, 26242, 26265, 26264, 26699, 26745, 26746, 26743
10785, 26242, 26243, 26266, 26265, 26701, 26747, 26748, 26745
10786, 26243, 26244, 26267, 26266, 26703, 26749, 26750, 26747
10787, 26244, 26245, 26268, 26267, 26705, 26751, 26752, 26749
10788, 26245, 26246, 26269, 26268, 26707, 26753, 26754, 26751
10789, 26246, 26247, 26270, 26269, 26709, 26755, 26756, 26753
10790, 26247, 26248, 26271, 26270, 26711, 26757, 26758, 26755
10791, 26248, 26249, 26272, 26271, 26713, 26759, 26760, 26757
10792, 26249, 26250, 26273, 26272, 26715, 26761, 26762, 26759
10793, 26250, 26251, 26274, 26273, 26717, 26763, 26764, 26761
10794, 26251, 26252, 26275, 26274, 26719, 26765, 26766, 26763
10795, 26252, 26253, 26276, 26275, 26721, 26767, 26768, 26765
10796, 26253, 2534, 2535, 26276, 26722, 2546, 26769, 26767
10797, 2512, 26254, 26277, 2513, 26724, 26770, 26771, 2524
10798, 26254, 26255, 26278, 26277, 26726, 26772, 26773, 26770
10799, 26255, 26256, 26279, 26278, 26728, 26774, 26775, 26772
10800, 26256, 26257, 26280, 26279, 26730, 26776, 26777, 26774
10801, 26257, 26258, 26281, 26280, 26732, 26778, 26779, 26776
10802, 26258, 26259, 26282, 26281, 26734, 26780, 26781, 26778
10803, 26259, 26260, 26283, 26282, 26736, 26782, 26783, 26780
10804, 26260, 26261, 26284, 26283, 26738, 26784, 26785, 26782
10805, 26261, 26262, 26285, 26284, 26740, 26786, 26787, 26784
10806, 26262, 26263, 26286, 26285, 26742, 26788, 26789, 26786
10807, 26263, 26264, 26287, 26286, 26744, 26790, 26791, 26788
10808, 26264, 26265, 26288, 26287, 26746, 26792, 26793, 26790
10809, 26265, 26266, 26289, 26288, 26748, 26794, 26795, 26792
10810, 26266, 26267, 26290, 26289, 26750, 26796, 26797, 26794
10811, 26267, 26268, 26291, 26290, 26752, 26798, 26799, 26796
10812, 26268, 26269, 26292, 26291, 26754, 26800, 26801, 26798
10813, 26269, 26270, 26293, 26292, 26756, 26802, 26803, 26800
10814, 26270, 26271, 26294, 26293, 26758, 26804, 26805, 26802
10815, 26271, 26272, 26295, 26294, 26760, 26806, 26807, 26804
10816, 26272, 26273, 26296, 26295, 26762, 26808, 26809, 26806
10817, 26273, 26274, 26297, 26296, 26764, 26810, 26811, 26808
10818, 26274, 26275, 26298, 26297, 26766, 26812, 26813, 26810
10819, 26275, 26276, 26299, 26298, 26768, 26814, 26815, 26812
10820, 26276, 2535, 2536, 26299, 26769, 2547, 26816, 26814
10821, 2513, 26277, 2407, 57, 26771, 26817, 2430, 2525
10822, 26277, 26278, 2408, 2407, 26773, 26818, 2431, 26817
10823, 26278, 26279, 2409, 2408, 26775, 26819, 2432, 26818
10824, 26279, 26280, 2410, 2409, 26777, 26820, 2433, 26819
10825, 26280, 26281, 2411, 2410, 26779, 26821, 2434, 26820
10826, 26281, 26282, 2412, 2411, 26781, 26822, 2435, 26821
10827, 26282, 26283, 2413, 2412, 26783, 26823, 2436, 26822
10828, 26283, 26284, 2414, 2413, 26785, 26824, 2437, 26823
10829, 26284, 26285, 2415, 2414, 26787, 26825, 2438, 26824
10830, 26285, 26286, 2416, 2415, 26789, 26826, 2439, 26825
10831, 26286, 26287, 2417, 2416, 26791, 26827, 2440, 26826
10832, 26287, 26288, 2418, 2417, 26793, 26828, 2441, 26827
10833, 26288, 26289, 2419, 2418, 26795, 26829, 2442, 26828
10834, 26289, 26290, 2420, 2419, 26797, 26830, 2443, 26829
10835, 26290, 26291, 2421, 2420, 26799, 26831, 2444, 26830
10836, 26291, 26292, 2422, 2421, 26801, 26832, 2445, 26831
10837, 26292, 26293, 2423, 2422, 26803, 26833, 2446, 26832
10838, 26293, 26294, 2424, 2423, 26805, 26834, 2447, 26833
10839, 26294, 26295, 2425, 2424, 26807, 26835, 2448, 26834
10840, 26295, 26296, 2426, 2425, 26809, 26836, 2449, 26835
10841, 26296, 26297, 2427, 2426, 26811, 26837, 2450, 26836
10842, 26297, 26298, 2428, 2427, 26813, 26838, 2451, 26837
10843, 26298, 26299, 2429, 2428, 26815, 26839, 2452, 26838
10844, 26299, 2536, 58, 2429, 26816, 2548, 2453, 26839
*ELEMENT, type=CPS8, ELSET=Surface82
10845, 33, 61, 2551, 1653, 2549, 2574, 26840, 1676
10846, 1653, 2551, 2552, 1654, 26840, 2575, 26841, 1677
10847, 1654, 2552, 2553, 1655, 26841, 2576, 26842, 1678
10848, 1655, 2553, 2554, 1656, 26842, 2577, 26843, 1679
10849, 1656, 2554, 2555, 1657, 26843, 2578, 26844, 1680
10850, 1657, 2555, 2556, 1658, 26844, 2579, 26845, 1681
10851, 1658, 2556, 2557, 1659, 26845, 2580, 26846, 1682
10852, 1659, 2557, 2558, 1660, 26846, 2581, 26847, 1683
10853, 1660, 2558, 2559, 1661, 26847, 2582, 26848, 1684
10854, 1661, 2559, 2560, 1662, 26848, 2583, 26849, 1685
10855, 1662, 2560, 2561, 1663, 26849, 2584, 26850, 1686
10856, 1663, 2561, 2562, 1664, 26850, 2585, 26851, 1687
10857, 1664, 2562, 2563, 1665, 26851, 2586, 26852, 1688
10858, 1665, 2563, 2564, 1666, 26852, 2587, 26853, 1689
10859, 1666, 2564, 2565, 1667, 26853, 2588, 26854, 1690
10860, 1667, 2565, 2566, 1668, 26854, 2589, 26855, 1691
10861, 1668, 2566, 2567, 1669, 26855, 2590, 26856, 1692
10862, 1669, 2567, 2568, 1670, 26856, 2591, 26857, 1693
10863, 1670, 2568, 2569, 1671, 26857, 2592, 26858, 1694
10864, 1671, 2569, 2570, 1672, 26858, 2593, 26859, 1695
10865, 1672, 2570, 2571, 1673, 26859, 2594, 26860, 1696
10866, 1673, 2571, 2572, 1674, 26860, 2595, 26861, 1697
10867, 1674, 2572, 2573, 1675, 26861, 2596, 26862, 1698
10868, 1675, 2573, 62, 37, 26862, 2597, 2550, 1699
*ELEMENT, type=CPS8, ELSET=Surface83
10869, 35, 1794, 2600, 63, 1817, 26863, 2623, 2598
10870, 1794, 1795, 2601, 2600, 1818, 26864, 2624, 26863
10871, 1795, 1796, 2602, 2601, 1819, 26865, 2625, 26864
10872, 1796, 1797, 2603, 2602, 1820, 26866, 2626, 26865
10873, 1797, 1798, 2604, 2603, 1821, 26867, 2627, 26866
10874, 1798, 1799, 2605, 2604, 1822, 26868, 2628, 26867
10875, 1799, 1800, 2606, 2605, 1823, 26869, 2629, 26868
10876, 1800, 1801, 2607, 2606, 1824, 26870, 2630, 26869
10877, 1801, 1802, 2608, 2607, 1825, 26871, 2631, 26870
10878, 1802, 1803, 2609, 2608, 1826, 26872, 2632, 26871
10879, 1803, 1804, 2610, 2609, 1827, 26873, 2633, 26872
10880, 1804, 1805, 2611, 2610, 1828, 26874, 2634, 26873
10881, 1805, 1806, 2612, 2611, 1829, 26875, 2635, 26874
10882, 1806, 1807, 2613, 2612, 1830, 26876, 2636, 26875
10883, 1807, 1808, 2614, 2613, 1831, 26877, 2637, 26876
10884, 1808, 1809, 2615, 2614, 1832, 26878, 2638, 26877
10885, 1809, 1810, 2616, 2615, 1833, 26879, 2639, 26878
10886, 1810, 1811, 2617, 2616, 1834, 26880, 2640, 26879
10887, 1811, 1812, 2618, 2617, 1835, 26881, 2641, 26880
10888, 1812, 1813, 2619, 2618, 1836, 26882, 2642, 26881
10889, 1813, 1814, 2620, 2619, 1837, 26883, 2643, 26882
10890, 1814, 1815, 2621, 2620, 1838, 26884, 2644, 26883
10891, 1815, 1816, 2622, 2621, 1839, 26885, 2645, 26884
10892, 1816, 39, 64, 2622, 1840, 2599, 2646, 26885
*ELEMENT, type=CPS8, ELSET=Surface84
10893, 35, 63, 2647, 1607, 2598, 2658, 26886, 1618
10894, 1607, 2647, 2648, 1608, 26886, 2659, 26887, 1619
10895, 1608, 2648, 2649, 1609, 26887, 2660, 26888, 1620
10896, 1609, 2649, 2650, 1610, 26888, 2661, 26889, 1621
10897, 1610, 2650, 2651, 1611, 26889, 2662, 26890, 1622
10898, 1611, 2651, 2652, 1612, 26890, 2663, 26891, 1623
10899, 1612, 2652, 2653, 1613, 26891, 2664, 26892, 1624
10900, 1613, 2653, 2654, 1614, 26892, 2665, 26893, 1625
10901, 1614, 2654, 2655, 1615, 26893, 2666, 26894, 1626
10902, 1615, 2655, 2656, 1616, 26894, 2667, 26895, 1627
10903, 1616, 2656, 2657, 1617, 26895, 2668, 26896, 1628
10904, 1617, 2657, 61, 33, 26896, 2669, 2549, 1629
*ELEMENT, type=CPS8, ELSET=Surface85
10905, 39, 1935, 2670, 64, 1946, 26897, 2681, 2599
10906, 1935, 1936, 2671, 2670, 1947, 26898, 2682, 26897
10907, 1936, 1937, 2672, 2671, 1948, 26899, 2683, 26898
10908, 1937, 1938, 2673, 2672, 1949, 26900, 2684, 26899
10909, 1938, 1939, 2674, 2673, 1950, 26901, 2685, 26900
10910, 1939, 1940, 2675, 2674, 1951, 26902, 2686, 26901
10911, 1940, 1941, 2676, 2675, 1952, 26903, 2687, 26902
10912, 1941, 1942, 2677, 2676, 1953, 26904, 2688, 26903
10913, 1942, 1943, 2678, 2677, 1954, 26905, 2689, 26904
10914, 1943, 1944, 2679, 2678, 1955, 26906, 2690, 26905
10915, 1944, 1945, 2680, 2679, 1956, 26907, 2691, 26906
10916, 1945, 37, 62, 2680, 1957, 2550, 2692, 26907
*ELEMENT, type=CPS8, ELSET=Surface86
10917, 63, 2600, 26908, 2647, 2623, 27161, 27162, 2658
10918, 2600, 2601, 26909, 26908, 2624, 27163, 27164, 27161
10919, 2601, 2602, 26910, 26909, 2625, 27165, 27166, 27163
10920, 2602, 2603, 26911, 26910, 2626, 27167, 27168, 27165
10921, 2603, 2604, 26912, 26911, 2627, 27169, 27170, 27167
10922, 2604, 2605, 26913, 26912, 2628, 27171, 27172, 27169
10923, 2605, 2606, 26914, 26913, 2629, 27173, 27174, 27171
10924, 2606, 2607, 26915, 26914, 2630, 27175, 27176, 27173
10925, 2607, 2608, 26916, 26915, 2631, 27177, 27178, 27175
10926, 2608, 2609, 26917, 26916, 2632, 27179, 27180, 27177
10927, 2609, 2610, 26918, 26917, 2633, 27181, 27182, 27179
10928, 2610, 2611, 26919, 26918, 2634, 27183, 27184, 27181
10929, 2611, 2612, 26920, 26919, 2635, 27185, 27186, 27183
10930, 2612, 2613, 26921, 26920, 2636, 27187, 27188, 27185
10931, 2613, 2614, 26922, 26921, 2637, 27189, 27190, 27187
10932, 2614, 2615, 26923, 26922, 2638, 27191, 27192, 27189
10933, 2615, 2616, 26924, 26923, 2639, 27193, 27194, 27191
10934, 2616, 2617, 26925, 26924, 2640, 27195, 27196, 27193
10935, 2617, 2618, 26926, 26925, 2641, 27197, 27198, 27195
10936, 2618, 2619, 26927, 26926, 2642, 27199, 27200, 27197
10937, 2619, 2620, 26928, 26927, 2643, 27201, 27202, 27199
10938, 2620, 2621, 26929, 26928, 2644, 27203, 27204, 27201
10939, 2621, 2622, 26930, 26929, 2645, 27205, 27206, 27203
10940, 2622, 64, 2670, 26930, 2646, 2681, 27207, 27205
10941, 2647, 26908, 26931, 2648, 27162, 27208, 27209, 2659
10942, 26908, 26909, 26932, 26931, 27164, 27210, 27211, 27208
10943, 26909, 26910, 26933, 26932, 27166, 27212, 27213, 27210
10944, 26910, 26911, 26934, 26933, 27168, 27214, 27215, 27212
10945, 26911, 26912, 26935, 26934, 27170, 27216, 27217, 27214
10946, 26912, 26913, 26936, 26935, 27172, 27218, 27219, 27216
10947, 26913, 26914, 26937, 26936, 27174, 27220, 27221, 27218
10948, 26914, 26915, 26938, 26937, 27176, 27222, 27223, 27220
10949, 26915, 26916, 26939, 26938, 27178, 27224, 27225, 27222
10950, 26916, 26917, 26940, 26939, 27180, 27226, 27227, 27224
10951, 26917, 26918, 26941, 26940, 27182, 27228, 27229, 27226
10952, 26918, 26919, 26942, 26941, 27184, 27230, 27231, 27228
10953, 26919, 26920, 26943, 26942, 27186, 27232, 27233, 27230
10954, 26920, 26921, 26944, 26943, 27188, 27234, 27235, 27232
10955, 26921, 26922, 26945, 26944, 27190, 27236, 27237, 27234
10956, 26922, 26923, 26946, 26945, 27192, 27238, 27239, 27236
10957, 26923, 26924, 26947, 26946, 27194, 27240, 27241, 27238
10958, 26924, 26925, 26948, 26947, 27196, 27242, 27243, 27240
10959, 26925, 26926, 26949, 26948, 27198, 27244, 27245, 27242
10960, 26926, 26927, 26950, 26949, 27200, 27246, 27247, 27244
10961, 26927, 26928, 26951, 26950, 27202, 27248, 27249, 27246
10962, 26928, 26929, 26952, 26951, 27204, 27250, 27251, 27248
10963, 26929, 26930, 26953, 26952, 27206, 27252, 27253, 27250
10964, 26930, 2670, 2671, 26953, 27207, 2682, 27254, 27252
10965, 2648, 26931, 26954, 2649, 27209, 27255, 27256, 2660
10966, 26931, 26932, 26955, 26954, 27211, 27257, 27258, 27255
10967, 26932, 26933, 26956, 26955, 27213, 27259, 27260, 27257
10968, 26933, 26934, 26957, 26956, 27215, 27261, 27262, 27259
10969, 26934, 26935, 26958, 26957, 27217, 27263, 27264, 27261
10970, 26935, 26936, 26959, 26958, 27219, 27265, 27266, 27263
10971, 26936, 26937, 26960, 26959, 27221, 27267, 27268, 27265
10972, 26937, 26938, 26961, 26960, 27223, 27269, 27270, 27267
10973, 26938, 26939, 26962, 26961, 27225, 27271, 27272, 27269
10974, 26939, 26940, 26963, 26962, 27227, 27273, 27274, 27271
10975, 26940, 26941, 26964, 26963, 27229, 27275, 27276, 27273
10976, 26941, 26942, 26965, 26964, 27231, 27277, 27278, 27275
10977, 26942, 26943, 26966, 26965, 27233, 27279, 27280, 27277
10978, 26943, 26944, 26967, 26966, 27235, 27281, 27282, 27279
10979, 26944, 26945, 26968, 26967, 27237, 27283, 27284, 27281
10980, 26945, 26946, 26969, 26968, 27239, 27285, 27286, 27283
10981, 26946, 26947, 26970, 26969, 27241, 27287, 27288, 27285
10982, 26947, 26948, 26971, 26970, 27243, 27289, 27290, 27287
10983, 26948, 26949, 26972, 26971, 27245, 27291, 27292, 27289
10984, 26949, 26950, 26973, 26972, 27247, 27293, 27294, 27291
10985, 26950, 26951, 26974, 26973, 27249, 27295, 27296, 27293
10986, 26951, 26952, 26975, 26974, 27251, 27297, 27298, 27295
10987, 26952, 26953, 26976, 26975, 27253, 27299, 27300, 27297
10988, 26953, 2671, 2672, 26976, 27254, 2683, 27301, 27299
10989, 2649, 26954, 26977, 2650, 27256, 27302, 27303, 2661
10990, 26954, 26955, 26978, 26977, 27258, 27304, 27305, 27302
10991, 26955, 26956, 26979, 26978, 27260, 27306, 27307, 27304
10992, 26956, 26957, 26980, 26979, 27262, 27308, 27309, 27306
10993, 26957, 26958, 26981, 26980, 27264, 27310, 27311, 27308
10994, 26958, 26959, 26982, 26981, 27266, 27312, 27313, 27310
10995, 26959, 26960, 26983, 26982, 27268, 27314, 27315, 27312
10996, 26960, 26961, 26984, 26983, 27270, 27316, 27317, 27314
10997, 26961, 26962, 26985, 26984, 27272, 27318, 27319, 27316
10998, 26962, 26963, 26986, 26985, 27274, 27320, 27321, 27318
10999, 26963, 26964, 26987, 26986, 27276, 27322, 27323, 27320
11000, 26964, 26965, 26988, 26987, 27278, 27324, 27325, 27322
11001, 26965, 26966, 26989, 26988, 27280, 27326, 27327, 27324
11002, 26966, 26967, 26990, 26989, 27282, 27328, 27329, 27326
11003, 26967, 26968, 26991, 26990, 27284, 27330, 27331, 27328
11004, 26968, 26969, 26992, 26991, 27286, 27332, 27333, 27330
11005, 26969, 26970, 26993, 26992, 27288, 27334, 27335, 27332
11006, 26970, 26971, 26994, 26993, 27290, 27336, 27337, 27334
11007, 26971, 26972, 26995, 26994, 27292, 27338, 27339, 27336
11008, 26972, 26973, 26996, 26995, 27294, 27340, 27341, 27338
11009, 26973, 26974, 26997, 26996, 27296, 27342, 27343, 27340
11010, 26974, 26975, 26998, 26997, 27298, 27344, 27345, 27342
11011, 26975, 26976, 26999, 26998, 27300, 27346, 27347, 27344
11012, 26976, 2672, 2673, 26999, 27301, 2684, 27348, 27346
11013, 2650, 26977, 27000, 2651, 27303, 27349, 27350, 2662
11014, 26977, 26978, 27001, 27000, 27305, 27351, 27352, 27349
11015, 26978, 26979, 27002, 27001, 27307, 27353, 27354, 27351
11016, 26979, 26980, 27003, 27002, 27309, 27355, 27356, 27353
11017, 26980, 26981, 27004, 27003, 27311, 27357, 27358, 27355
11018, 26981, 26982, 27005, 27004, 27313, 27359, 27360, 27357
11019, 26982, 26983, 27006, 27005, 27315, 27361, 27362, 27359
11020, 26983, 26984, 27007, 27006, 27317, 27363, 27364, 27361
11021, 26984, 26985, 27008, 27007, 27319, 27365, 27366, 27363
11022, 26985, 26986, 27009, 27008, 27321, 27367, 27368, 27365
11023, 26986, 26987, 27010, 27009, 27323, 27369, 27370, 27367
11024, 26987, 26988, 27011, 27010, 27325, 27371, 27372, 27369
11025, 26988, 26989, 27012, 27011, 27327, 27373, 27374, 27371
11026, 26989, 26990, 27013, 27012, 27329, 27375, 27376, 27373
11027, 26990, 26991, 27014, 27013, 27331, 27377, 27378, 27375
11028, 26991, 26992, 27015, 27014, 27333, 27379, 27380, 27377
11029, 26992, 26993, 27016, 27015, 27335, 27381, 27382, 27379
11030, 26993, 26994, 27017, 27016, 27337, 27383, 27384, 27381
11031, 26994, 26995, 27018, 27017, 27339, 27385, 27386, 27383
11032, 26995, 26996, 27019, 27018, 27341, 27387, 27388, 27385
11033, 26996, 26997, 27020, 27019, 27343, 27389, 27390, 27387
11034, 26997, 26998, 27021, 27020, 27345, 27391, 27392, 27389
11035, 26998, 26999, 27022, 27021, 27347, 27393, 27394, 27391
11036, 26999, 2673, 2674, 27022, 27348, 2685, 27395, 27393
11037, 2651, 27000, 27023, 2652, 27350, 27396, 27397, 2663
11038, 27000, 27001, 27024, 27023, 27352, 27398, 27399, 27396
11039, 27001, 27002, 27025, 27024, 27354, 27400, 27401, 27398
11040, 27002, 27003, 27026, 27025, 27356, 27402, 27403, 27400
11041, 27003, 27004, 27027, 27026, 27358, 27404, 27405, 27402
11042, 27004, 27005, 27028, 27027, 27360, 27406, 27407, 27404
11043, 27005, 27006, 27029, 27028, 27362, 27408, 27409, 27406
11044, 27006, 27007, 27030, 27029, 27364, 27410, 27411, 27408
11045, 27007, 27008, 27031, 27030, 27366, 27412, 27413, 27410
11046, 27008, 27009, 27032, 27031, 27368, 27414, 27415, 27412
11047, 27009, 27010, 27033, 27032, 27370, 27416, 27417, 27414
11048, 27010, 27011, 27034, 27033, 27372, 27418, 27419, 27416
11049, 27011, 27012, 27035, 27034, 27374, 27420, 27421, 27418
11050, 27012, 27013, 27036, 27035, 27376, 27422, 27423, 27420
11051, 27013, 27014, 27037, 27036, 27378, 27424, 27425, 27422
11052, 27014, 27015, 27038, 27037, 27380, 27426, 27427, 27424
11053, 27015, 27016, 27039, 27038, 27382, 27428, 27429, 27426
11054, 27016, 27017, 27040, 27039, 27384, 27430, 27431, 27428
11055, 27017, 27018, 27041, 27040, 27386, 27432, 27433, 27430
11056, 27018, 27019, 27042, 27041, 27388, 27434, 27435, 27432
11057, 27019, 27020, 27043, 27042, 27390, 27436, 27437, 27434
11058, 27020, 27021, 27044, 27043, 27392, 27438, 27439, 27436
11059, 27021, 27022, 27045, 27044, 27394, 27440, 27441, 27438
11060, 27022, 2674, 2675, 27045, 27395, 2686, 27442, 27440
11061, 2652, 27023, 27046, 2653, 27397, 27443, 27444, 2664
11062, 27023, 27024, 27047, 27046, 27399, 27445, 27446, 27443
11063, 27024, 27025, 27048, 27047, 27401, 27447, 27448, 27445
11064, 27025, 27026, 27049, 27048, 27403, 27449, 27450, 27447
11065, 27026, 27027, 27050, 27049, 27405, 27451, 27452, 27449
11066, 27027, 27028, 27051, 27050, 27407, 27453, 27454, 27451
11067, 27028, 27029, 27052, 27051, 27409, 27455, 27456, 27453
11068, 27029, 27030, 27053, 27052, 27411, 27457, 27458, 27455
11069, 27030, 27031, 27054, 27053, 27413, 27459, 27460, 27457
11070, 27031, 27032, 27055, 27054, 27415, 27461, 27462, 27459
11071, 27032, 27033, 27056, 27055, 27417, 27463, 27464, 27461
11072, 27033, 27034, 27057, 27056, 27419, 27465, 27466, 27463
11073, 27034, 27035, 27058, 27057, 27421, 27467, 27468, 27465
11074, 27035, 27036, 27059, 27058, 27423, 27469, 27470, 27467
11075, 27036, 27037, 27060, 27059, 27425, 27471, 27472, 27469
11076, 27037, 27038, 27061, 27060, 27427, 27473, 27474, 27471
11077, 27038, 27039, 27062, 27061, 27429, 27475, 27476, 27473
11078, 27039, 27040, 27063, 27062, 27431, 27477, 27478, 27475
11079, 27040, 27041, 27064, 27063, 27433, 27479, 27480, 27477
11080, 27041, 27042, 27065, 27064, 27435, 27481, 27482, 27479
11081, 27042, 27043, 27066, 27065, 27437, 27483, 27484, 27481
11082, 27043, 27044, 27067, 27066, 27439, 27485, 27486, 27483
11083, 27044, 27045, 27068, 27067, 27441, 27487, 27488, 27485
11084, 27045, 2675, 2676, 27068, 27442, 2687, 27489, 27487
11085, 2653, 27046, 27069, 2654, 27444, 27490, 27491, 2665
11086, 27046, 27047, 27070, 27069, 27446, 27492, 27493, 27490
11087, 27047, 27048, 27071, 27070, 27448, 27494, 27495, 27492
11088, 27048, 27049, 27072, 27071, 27450, 27496, 27497, 27494
11089, 27049, 27050, 27073, 27072, 27452, 27498, 27499, 27496
11090, 27050, 27051, 27074, 27073, 27454, 27500, 27501, 27498
11091, 27051, 27052, 27075, 27074, 27456, 27502, 27503, 27500
11092, 27052, 27053, 27076, 27075, 27458, 27504, 27505, 27502
11093, 27053, 27054, 27077, 27076, 27460, 27506, 27507, 27504
11094, 27054, 27055, 27078, 27077, 27462, 27508, 27509, 27506
11095, 27055, 27056, 27079, 27078, 27464, 27510, 27511, 27508
11096, 27056, 27057, 27080, 27079, 27466, 27512, 27513, 27510
11097, 27057, 27058, 27081, 27080, 27468, 27514, 27515, 27512
11098, 27058, 27059, 27082, 27081, 27470, 27516, 27517, 27514
11099, 27059, 27060, 27083, 27082, 27472, 27518, 27519, 27516
11100, 27060, 27061, 27084, 27083, 27474, 27520, 27521, 27518
11101, 27061, 27062, 27085, 27084, 27476, 27522, 27523, 27520
11102, 27062, 27063, 27086, 27085, 27478, 27524, 27525, 27522
11103, 27063, 27064, 27087, 27086, 27480, 27526, 27527, 27524
11104, 27064, 27065, 27088, 27087, 27482, 27528, 27529, 27526
11105, 27065, 27066, 27089, 27088, 27484, 27530, 27531, 27528
11106, 27066, 27067, 27090, 27089, 27486, 27532, 27533, 27530
11107, 27067, 27068, 27091, 27090, 27488, 27534, 27535, 27532
11108, 27068, 2676, 2677, 27091, 27489, 2688, 27536, 27534
11109, 2654, 27069, 27092, 2655, 27491, 27537, 27538, 2666
11110, 27069, 27070, 27093, 27092, 27493, 27539, 27540, 27537
11111, 27070, 27071, 27094, 27093, 27495, 27541, 27542, 27539
11112, 27071, 27072, 27095, 27094, 27497, 27543, 27544, 27541
11113, 27072, 27073, 27096, 27095, 27499, 27545, 27546, 27543
11114, 27073, 27074, 27097, 27096, 27501, 27547, 27548, 27545
11115, 27074, 27075, 27098, 27097, 27503, 27549, 27550, 27547
11116, 27075, 27076, 27099, 27098, 27505, 27551, 27552, 27549
11117, 27076, 27077, 27100, 27099, 27507, 27553, 27554, 27551
11118, 27077, 27078, 27101, 27100, 27509, 27555, 27556, 27553
11119, 27078, 27079, 27102, 27101, 27511, 27557, 27558, 27555
11120, 27079, 27080, 27103, 27102, 27513, 27559, 27560, 27557
11121, 27080, 27081, 27104, 27103, 27515, 27561, 27562, 27559
11122, 27081, 27082, 27105, 27104, 27517, 27563, 27564, 27561
11123, 27082, 27083, 27106, 27105, 27519, 27565, 27566, 27563
11124, 27083, 27084, 27107, 27106, 27521, 27567, 27568, 27565
11125, 27084, 27085, 27108, 27107, 27523, 27569, 27570, 27567
11126, 27085, 27086, 27109, 27108, 27525, 27571, 27572, 27569
11127, 27086, 27087, 27110, 27109, 27527, 27573, 27574, 27571
11128, 27087, 27088, 27111, 27110, 27529, 27575, 27576, 27573
11129, 27088, 27089, 27112, 27111, 27531, 27577, 27578, 27575
11130, 27089, 27090, 27113, 27112, 27533, 27579, 27580, 27577
11131, 27090, 27091, 27114, 27113, 27535, 27581, 27582, 27579
11132, 27091, 2677, 2678, 27114, 27536, 2689, 27583, 27581
11133, 2655, 27092, 27115, 2656, 27538, 27584, 27585, 2667
11134, 27092, 27093, 27116, 27115, 27540, 27586, 27587, 27584
11135, 27093, 27094, 27117, 27116, 27542, 27588, 27589, 27586
11136, 27094, 27095, 27118, 27117, 27544, 27590, 27591, 27588
11137, 27095, 27096, 27119, 27118, 27546, 27592, 27593, 27590
11138, 27096, 27097, 27120, 27119, 27548, 27594, 27595, 27592
11139, 27097, 27098, 27121, 27120, 27550, 27596, 27597, 27594
11140, 27098, 27099, 27122, 27121, 27552, 27598, 27599, 27596
11141, 27099, 27100, 27123, 27122, 27554, 27600, 27601, 27598
11142, 27100, 27101, 27124, 27123, 27556, 27602, 27603, 27600
11143, 27101, 27102, 27125, 27124, 27558, 27604, 27605, 27602
11144, 27102, 27103, 27126, 27125, 27560, 27606, 27607, 27604
11145, 27103, 27104, 27127, 27126, 27562, 27608, 27609, 27606
11146, 27104, 27105, 27128, 27127, 27564, 27610, 27611, 27608
11147, 27105, 27106, 27129, 27128, 27566, 27612, 27613, 27610
11148, 27106, 27107, 27130, 27129, 27568, 27614, 27615, 27612
11149, 27107, 27108, 27131, 27130, 27570, 27616, 27617, 27614
11150, 27108, 27109, 27132, 27131, 27572, 27618, 27619, 27616
11151, 27109, 27110, 27133, 27132, 27574, 27620, 27621, 27618
11152, 27110, 27111, 27134, 27133, 27576, 27622, 27623, 27620
11153, 27111, 27112, 27135, 27134, 27578, 27624, 27625, 27622
11154, 27112, 27113, 27136, 27135, 27580, 27626, 27627, 27624
11155, 27113, 27114, 27137, 27136, 27582, 27628, 27629, 27626
11156, 27114, 2678, 2679, 27137, 27583, 2690, 27630, 27628
11157, 2656, 27115, 27138, 2657, 27585, 27631, 27632, 2668
11158, 27115, 27116, 27139, 27138, 27587, 27633, 27634, 27631
11159, 27116, 27117, 27140, 27139, 27589, 27635, 27636, 27633
11160, 27117, 27118, 27141, 27140, 27591, 27637, 27638, 27635
11161, 27118, 27119, 27142, 27141, 27593, 27639, 27640, 27637
11162, 27119, 27120, 27143, 27142, 27595, 27641, 27642, 27639
11163, 27120, 27121, 27144, 27143, 27597, 27643, 27644, 27641
11164, 27121, 27122, 27145, 27144, 27599, 27645, 27646, 27643
11165, 27122, 27123, 27146, 27145, 27601, 27647, 27648, 27645
11166, 27123, 27124, 27147, 27146, 27603, 27649, 27650, 27647
11167, 27124, 27125, 27148, 27147, 27605, 27651, 27652, 27649
11168, 27125, 27126, 27149, 27148, 27607, 27653, 27654, 27651
11169, 27126, 27127, 27150, 27149, 27609, 27655, 27656, 27653
11170, 27127, 27128, 27151, 27150, 27611, 27657, 27658, 27655
11171, 27128, 27129, 27152, 27151, 27613, 27659, 27660, 27657
11172, 27129, 27130, 27153, 27152, 27615, 27661, 27662, 27659
11173, 27130, 27131, 27154, 27153, 27617, 27663, 27664, 27661
11174, 27131, 27132, 27155, 27154, 27619, 27665, 27666, 27663
11175, 27132, 27133, 27156, 27155, 27621, 27667, 27668, 27665
11176, 27133, 27134, 27157, 27156, 27623, 27669, 27670, 27667
11177, 27134, 27135, 27158, 27157, 27625, 27671, 27672, 27669
11178, 27135, 27136, 27159, 27158, 27627, 27673, 27674, 27671
11179, 27136, 27137, 27160, 27159, 27629, 27675, 27676, 27673
11180, 27137, 2679, 2680, 27160, 27630, 2691, 27677, 27675
11181, 2657, 27138, 2551, 61, 27632, 27678, 2574, 2669
11182, 27138, 27139, 2552, 2551, 27634, 27679, 2575, 27678
11183, 27139, 27140, 2553, 2552, 27636, 27680, 2576, 27679
11184, 27140, 27141, 2554, 2553, 27638, 27681, 2577, 27680
11185, 27141, 27142, 2555, 2554, 27640, 27682, 2578, 27681
11186, 27142, 27143, 2556, 2555, 27642, 27683, 2579, 27682
11187, 27143, 27144, 2557, 2556, 27644, 27684, 2580, 27683
11188, 27144, 27145, 2558, 2557, 27646, 27685, 2581, 27684
11189, 27145, 27146, 2559, 2558, 27648, 27686, 2582, 27685
11190, 27146, 27147, 2560, 2559, 27650, 27687, 2583, 27686
11191, 27147, 27148, 2561, 2560, 27652, 27688, 2584, 27687
11192, 27148, 27149, 2562, 2561, 27654, 27689, 2585, 27688
11193, 27149, 27150, 2563, 2562, 27656, 27690, 2586, 27689
11194, 27150, 27151, 2564, 2563, 27658, 27691, 2587, 27690
11195, 27151, 27152, 2565, 2564, 27660, 27692, 2588, 27691
11196, 27152, 27153, 2566, 2565, 27662, 27693, 2589, 27692
11197, 27153, 27154, 2567, 2566, 27664, 27694, 2590, 27693
11198, 27154, 27155, 2568, 2567, 27666, 27695, 2591, 27694
11199, 27155, 27156, 2569, 2568, 27668, 27696, 2592, 27695
11200, 27156, 27157, 2570, 2569, 27670, 27697, 2593, 27696
11201, 27157, 27158, 2571, 2570, 27672, 27698, 2594, 27697
11202, 27158, 27159, 2572, 2571, 27674, 27699, 2595, 27698
11203, 27159, 27160, 2573, 2572, 27676, 27700, 2596, 27699
11204, 27160, 2680, 62, 2573, 27677, 2692, 2597, 27700
*ELEMENT, type=CPS8, ELSET=Surface87
11205, 9, 65, 2695, 541, 2693, 2718, 27701, 564
11206, 541, 2695, 2696, 542, 27701, 2719, 27702, 565
11207, 542, 2696, 2697, 543, 27702, 2720, 27703, 566
11208, 543, 2697, 2698, 544, 27703, 2721, 27704, 567
11209, 544, 2698, 2699, 545, 27704, 2722, 27705, 568
11210, 545, 2699, 2700, 546, 27705, 2723, 27706, 569
11211, 546, 2700, 2701, 547, 27706, 2724, 27707, 570
11212, 547, 2701, 2702, 548, 27707, 2725, 27708, 571
11213, 548, 2702, 2703, 549, 27708, 2726, 27709, 572
11214, 549, 2703, 2704, 550, 27709, 2727, 27710, 573
11215, 550, 2704, 2705, 551, 27710, 2728, 27711, 574
11216, 551, 2705, 2706, 552, 27711, 2729, 27712, 575
11217, 552, 2706, 2707, 553, 27712, 2730, 27713, 576
11218, 553, 2707, 2708, 554, 27713, 2731, 27714, 577
11219, 554, 2708, 2709, 555, 27714, 2732, 27715, 578
11220, 555, 2709, 2710, 556, 27715, 2733, 27716, 579
11221, 556, 2710, 2711, 557, 27716, 2734, 27717, 580
11222, 557, 2711, 2712, 558, 27717, 2735, 27718, 581
11223, 558, 2712, 2713, 559, 27718, 2736, 27719, 582
11224, 559, 2713, 2714, 560, 27719, 2737, 27720, 583
11225, 560, 2714, 2715, 561, 27720, 2738, 27721, 584
11226, 561, 2715, 2716, 562, 27721, 2739, 27722, 585
11227, 562, 2716, 2717, 563, 27722, 2740, 27723, 586
11228, 563, 2717, 66, 13, 27723, 2741, 2694, 587
*ELEMENT, type=CPS8, ELSET=Surface88
11229, 10, 588, 2744, 67, 611, 27724, 2767, 2742
11230, 588, 589, 2745, 2744, 612, 27725, 2768, 27724
11231, 589, 590, 2746, 2745, 613, 27726, 2769, 27725
11232, 590, 591, 2747, 2746, 614, 27727, 2770, 27726
11233, 591, 592, 2748, 2747, 615, 27728, 2771, 27727
11234, 592, 593, 2749, 2748, 616, 27729, 2772, 27728
11235, 593, 594, 2750, 2749, 617, 27730, 2773, 27729
11236, 594, 595, 2751, 2750, 618, 27731, 2774, 27730
11237, 595, 596, 2752, 2751, 619, 27732, 2775, 27731
11238, 596, 597, 2753, 2752, 620, 27733, 2776, 27732
11239, 597, 598, 2754, 2753, 621, 27734, 2777, 27733
11240, 598, 599, 2755, 2754, 622, 27735, 2778, 27734
11241, 599, 600, 2756, 2755, 623, 27736, 2779, 27735
11242, 600, 601, 2757, 2756, 624, 27737, 2780, 27736
11243, 601, 602, 2758, 2757, 625, 27738, 2781, 27737
11244, 602, 603, 2759, 2758, 626, 27739, 2782, 27738
11245, 603, 604, 2760, 2759, 627, 27740, 2783, 27739
11246, 604, 605, 2761, 2760, 628, 27741, 2784, 27740
11247, 605, 606, 2762, 2761, 629, 27742, 2785, 27741
11248, 606, 607, 2763, 2762, 630, 27743, 2786, 27742
11249, 607, 608, 2764, 2763, 631, 27744, 2787, 27743
11250, 608, 609, 2765, 2764, 632, 27745, 2788, 27744
11251, 609, 610, 2766, 2765, 633, 27746, 2789, 27745
11252, 610, 14, 68, 2766, 634, 2743, 2790, 27746
*ELEMENT, type=CPS8, ELSET=Surface89
11253, 10, 67, 2791, 399, 2742, 2814, 27747, 422
11254, 399, 2791, 2792, 400, 27747, 2815, 27748, 423
11255, 400, 2792, 2793, 401, 27748, 2816, 27749, 424
11256, 401, 2793, 2794, 402, 27749, 2817, 27750, 425
11257, 402, 2794, 2795, 403, 27750, 2818, 27751, 426
11258, 403, 2795, 2796, 404, 27751, 2819, 27752, 427
11259, 404, 2796, 2797, 405, 27752, 2820, 27753, 428
11260, 405, 2797, 2798, 406, 27753, 2821, 27754, 429
11261, 406, 2798, 2799, 407, 27754, 2822, 27755, 430
11262, 407, 2799, 2800, 408, 27755, 2823, 27756, 431
11263, 408, 2800, 2801, 409, 27756, 2824, 27757, 432
11264, 409, 2801, 2802, 410, 27757, 2825, 27758, 433
11265, 410, 2802, 2803, 411, 27758, 2826, 27759, 434
11266, 411, 2803, 2804, 412, 27759, 2827, 27760, 435
11267, 412, 2804, 2805, 413, 27760, 2828, 27761, 436
11268, 413, 2805, 2806, 414, 27761, 2829, 27762, 437
11269, 414, 2806, 2807, 415, 27762, 2830, 27763, 438
11270, 415, 2807, 2808, 416, 27763, 2831, 27764, 439
11271, 416, 2808, 2809, 417, 27764, 2832, 27765, 440
11272, 417, 2809, 2810, 418, 27765, 2833, 27766, 441
11273, 418, 2810, 2811, 419, 27766, 2834, 27767, 442
11274, 419, 2811, 2812, 420, 27767, 2835, 27768, 443
11275, 420, 2812, 2813, 421, 27768, 2836, 27769, 444
11276, 421, 2813, 65, 9, 27769, 2837, 2693, 445
*ELEMENT, type=CPS8, ELSET=Surface90
11277, 14, 635, 2838, 68, 658, 27770, 2861, 2743
11278, 635, 636, 2839, 2838, 659, 27771, 2862, 27770
11279, 636, 637, 2840, 2839, 660, 27772, 2863, 27771
11280, 637, 638, 2841, 2840, 661, 27773, 2864, 27772
11281, 638, 639, 2842, 2841, 662, 27774, 2865, 27773
11282, 639, 640, 2843, 2842, 663, 27775, 2866, 27774
11283, 640, 641, 2844, 2843, 664, 27776, 2867, 27775
11284, 641, 642, 2845, 2844, 665, 27777, 2868, 27776
11285, 642, 643, 2846, 2845, 666, 27778, 2869, 27777
11286, 643, 644, 2847, 2846, 667, 27779, 2870, 27778
11287, 644, 645, 2848, 2847, 668, 27780, 2871, 27779
11288, 645, 646, 2849, 2848, 669, 27781, 2872, 27780
11289, 646, 647, 2850, 2849, 670, 27782, 2873, 27781
11290, 647, 648, 2851, 2850, 671, 27783, 2874, 27782
11291, 648, 649, 2852, 2851, 672, 27784, 2875, 27783
11292, 649, 650, 2853, 2852, 673, 27785, 2876, 27784
11293, 650, 651, 2854, 2853, 674, 27786, 2877, 27785
11294, 651, 652, 2855, 2854, 675, 27787, 2878, 27786
11295, 652, 653, 2856, 2855, 676, 27788, 2879, 27787
11296, 653, 654, 2857, 2856, 677, 27789, 2880, 27788
11297, 654, 655, 2858, 2857, 678, 27790, 2881, 27789
11298, 655, 656, 2859, 2858, 679, 27791, 2882, 27790
11299, 656, 657, 2860, 2859, 680, 27792, 2883, 27791
11300, 657, 13, 66, 2860, 681, 2694, 2884, 27792
*ELEMENT, type=CPS8, ELSET=Surface91
11301, 67, 2744, 27793, 2791, 2767, 28322, 28323, 2814
11302, 2744, 2745, 27794, 27793, 2768, 28324, 28325, 28322
11303, 2745, 2746, 27795, 27794, 2769, 28326, 28327, 28324
11304, 2746, 2747, 27796, 27795, 2770, 28328, 28329, 28326
11305, 2747, 2748, 27797, 27796, 2771, 28330, 28331, 28328
11306, 2748, 2749, 27798, 27797, 2772, 28332, 28333, 28330
11307, 2749, 2750, 27799, 27798, 2773, 28334, 28335, 28332
11308, 2750, 2751, 27800, 27799, 2774, 28336, 28337, 28334
11309, 2751, 2752, 27801, 27800, 2775, 28338, 28339, 28336
11310, 2752, 2753, 27802, 27801, 2776, 28340, 28341, 28338
11311, 2753, 2754, 27803, 27802, 2777, 28342, 28343, 28340
11312, 2754, 2755, 27804, 27803, 2778, 28344, 28345, 28342
11313, 2755, 2756, 27805, 27804, 2779, 28346, 28347, 28344
11314, 2756, 2757, 27806, 27805, 2780, 28348, 28349, 28346
11315, 2757, 2758, 27807, 27806, 2781, 28350, 28351, 28348
11316, 2758, 2759, 27808, 27807, 2782, 28352, 28353, 28350
11317, 2759, 2760, 27809, 27808, 2783, 28354, 28355, 28352
11318, 2760, 2761, 27810, 27809, 2784, 28356, 28357, 28354
11319, 2761, 2762, 27811, 27810, 2785, 28358, 28359, 28356
11320, 2762, 2763, 27812, 27811, 2786, 28360, 28361, 28358
11321, 2763, 2764, 27813, 27812, 2787, 28362, 28363, 28360
11322, 2764, 2765, 27814, 27813, 2788, 28364, 28365, 28362
11323, 2765, 2766, 27815, 27814, 2789, 28366, 28367, 28364
11324, 2766, 68, 2838, 27815, 2790, 2861, 28368, 28366
11325, 2791, 27793, 27816, 2792, 28323, 28369, 28370, 2815
11326, 27793, 27794, 27817, 27816, 28325, 28371, 28372, 28369
11327, 27794, 27795, 27818, 27817, 28327, 28373, 28374, 28371
11328, 27795, 27796, 27819, 27818, 28329, 28375, 28376, 28373
11329, 27796, 27797, 27820, 27819, 28331, 28377, 28378, 28375
11330, 27797, 27798, 27821, 27820, 28333, 28379, 28380, 28377
11331, 27798, 27799, 27822, 27821, 28335, 28381, 28382, 28379
11332, 27799, 27800, 27823, 27822, 28337, 28383, 28384, 28381
11333, 27800, 27801, 27824, 27823, 28339, 28385, 28386, 28383
11334, 27801, 27802, 27825, 27824, 28341, 28387, 28388, 28385
11335, 27802, 27803, 27826, 27825, 28343, 28389, 28390, 28387
11336, 27803, 27804, 27827, 27826, 28345, 28391, 28392, 28389
11337, 27804, 27805, 27828, 27827, 28347, 28393, 28394, 28391
11338, 27805, 27806, 27829, 27828, 28349, 28395, 28396, 28393
11339, 27806, 27807, 27830, 27829, 28351, 28397, 28398, 28395
11340, 27807, 27808, 27831, 27830, 28353, 28399, 28400, 28397
11341, 27808, 27809, 27832, 27831, 28355, 28401, 28402, 28399
11342, 27809, 27810, 27833, 27832, 28357, 28403, 28404, 28401
11343, 27810, 27811, 27834, 27833, 28359, 28405, 28406, 28403
11344, 27811, 27812, 27835, 27834, 28361, 28407, 28408, 28405
11345, 27812, 27813, 27836, 27835, 28363, 28409, 28410, 28407
11346, 27813, 27814, 27837, 27836, 28365, 28411, 28412, 28409
11347, 27814, 27815, 27838, 27837, 28367, 28413, 28414, 28411
11348, 27815, 2838, 2839, 27838, 28368, 2862, 28415, 28413
11349, 2792, 27816, 27839, 2793, 28370, 28416, 28417, 2816
11350, 27816, 27817, 27840, 27839, 28372, 28418, 28419, 28416
11351, 27817, 27818, 27841, 27840, 28374, 28420, 28421, 28418
11352, 27818, 27819, 27842, 27841, 28376, 28422, 28423, 28420
11353, 27819, 27820, 27843, 27842, 28378, 28424, 28425, 28422
11354, 27820, 27821, 27844, 27843, 28380, 28426, 28427, 28424
11355, 27821, 27822, 27845, 27844, 28382, 28428, 28429, 28426
11356, 27822, 27823, 27846, 27845, 28384, 28430, 28431, 28428
11357, 27823, 27824, 27847, 27846, 28386, 28432, 28433, 28430
11358, 27824, 27825, 27848, 27847, 28388, 28434, 28435, 28432
11359, 27825, 27826, 27849, 27848, 28390, 28436, 28437, 28434
11360, 27826, 27827, 27850, 27849, 28392, 28438, 28439, 28436
11361, 27827, 27828, 27851, 27850, 28394, 28440, 28441, 28438
11362, 27828, 27829, 27852, 27851, 28396, 28442, 28443, 28440
11363, 27829, 27830, 27853, 27852, 28398, 28444, 28445, 28442
11364, 27830, 27831, 27854, 27853, 28400, 28446, 28447, 28444
11365, 27831, 27832, 27855, 27854, 28402, 28448, 28449, 28446
11366, 27832, 27833, 27856, 27855, 28404, 28450, 28451, 28448
11367, 27833, 27834, 27857, 27856, 28406, 28452, 28453, 28450
11368, 27834, 27835, 27858, 27857, 28408, 28454, 28455, 28452
11369, 27835, 27836, 27859, 27858, 28410, 28456, 28457, 28454
11370, 27836, 27837, 27860, 27859, 28412, 28458, 28459, 28456
11371, 27837, 27838, 27861, 27860, 28414, 28460, 28461, 28458
11372, 27838, 2839, 2840, 27861, 28415, 2863, 28462, 28460
11373, 2793, 27839, 27862, 2794, 28417, 28463, 28464, 2817
11374, 27839, 27840, 27863, 27862, 28419, 28465, 28466, 28463
11375, 27840, 27841, 27864, 27863, 28421, 28467, 28468, 28465
11376, 27841, 27842, 27865, 27864, 28423, 28469, 28470, 28467
11377, 27842, 27843, 27866, 27865, 28425, 28471, 28472, 28469
11378, 27843, 27844, 27867, 27866, 28427, 28473, 28474, 28471
11379, 27844, 27845, 27868, 27867, 28429, 28475, 28476, 28473
11380, 27845, 27846, 27869, 27868, 28431, 28477, 28478, 28475
11381, 27846, 27847, 27870, 27869, 28433, 28479, 28480, 28477
11382, 27847, 27848, 27871, 27870, 28435, 28481, 28482, 28479
11383, 27848, 27849, 27872, 27871, 28437, 28483, 28484, 28481
11384, 27849, 27850, 27873, 27872, 28439, 28485, 28486, 28483
11385, 27850, 27851, 27874, 27873, 28441, 28487, 28488, 28485
11386, 27851, 27852, 27875, 27874, 28443, 28489, 28490, 28487
11387, 27852, 27853, 27876, 27875, 28445, 28491, 28492, 28489
11388, 27853, 27854, 27877, 27876, 28447, 28493, 28494, 28491
11389, 27854, 27855, 27878, 27877, 28449, 28495, 28496, 28493
11390, 27855, 27856, 27879, 27878, 28451, 28497, 28498, 28495
11391, 27856, 27857, 27880, 27879, 28453, 28499, 28500, 28497
11392, 27857, 27858, 27881, 27880, 28455, 28501, 28502, 28499
11393, 27858, 27859, 27882, 27881, 28457, 28503, 28504, 28501
11394, 27859, 27860, 27883, 27882, 28459, 28505, 28506, 28503
11395, 27860, 27861, 27884, 27883, 28461, 28507, 28508, 28505
11396, 27861, 2840, 2841, 27884, 28462, 2864, 28509, 28507
11397, 2794, 27862, 27885, 2795, 28464, 28510, 28511, 2818
11398, 27862, 27863, 27886, 27885, 28466, 28512, 28513, 28510
11399, 27863, 27864, 27887, 27886, 28468, 28514, 28515, 28512
11400, 27864, 27865, 27888, 27887, 28470, 28516, 28517, 28514
11401, 27865, 27866, 27889, 27888, 28472, 28518, 28519, 28516
11402, 27866, 27867, 27890, 27889, 28474, 28520, 28521, 28518
11403, 27867, 27868, 27891, 27890, 28476, 28522, 28523, 28520
11404, 27868, 27869, 27892, 27891, 28478, 28524, 28525, 28522
11405, 27869, 27870, 27893, 27892, 28480, 28526, 28527, 28524
11406, 27870, 27871, 27894, 27893, 28482, 28528, 28529, 28526
11407, 27871, 27872, 27895, 27894, 28484, 28530, 28531, 28528
11408, 27872, 27873, 27896, 27895, 28486, 28532, 28533, 28530
11409, 27873, 27874, 27897, 27896, 28488, 28534, 28535, 28532
11410, 27874, 27875, 27898, 27897, 28490, 28536, 28537, 28534
11411, 27875, 27876, 27899, 27898, 28492, 28538, 28539, 28536
11412, 27876, 27877, 27900, 27899, 28494, 28540, 28541, 28538
11413, 27877, 27878, 27901, 27900, 28496, 28542, 28543, 28540
11414, 27878, 27879, 27902, 27901, 28498, 28544, 28545, 28542
11415, 27879, 27880, 27903, 27902, 28500, 28546, 28547, 28544
11416, 27880, 27881, 27904, 27903, 28502, 28548, 28549, 28546
11417, 27881, 27882, 27905, 27904, 28504, 28550, 28551, 28548
11418, 27882, 27883, 27906, 27905, 28506, 28552, 28553, 28550
11419, 27883, 27884, 27907, 27906, 28508, 28554, 28555, 28552
11420, 27884, 2841, 2842, 27907, 28509, 2865, 28556, 28554
11421, 2795, 27885, 27908, 2796, 28511, 28557, 28558, 2819
11422, 27885, 27886, 27909, 27908, 28513, 28559, 28560, 28557
11423, 27886, 27887, 27910, 27909, 28515, 28561, 28562, 28559
11424, 27887, 27888, 27911, 27910, 28517, 28563, 28564, 28561
11425, 27888, 27889, 27912, 27911, 28519, 28565, 28566, 28563
11426, 27889, 27890, 27913, 27912, 28521, 28567, 28568, 28565
11427, 27890, 27891, 27914, 27913, 28523, 28569, 28570, 28567
11428, 27891, 27892, 27915, 27914, 28525, 28571, 28572, 28569
11429, 27892, 27893, 27916, 27915, 28527, 28573, 28574, 28571
11430, 27893, 27894, 27917, 27916, 28529, 28575, 28576, 28573
11431, 27894, 27895, 27918, 27917, 28531, 28577, 28578, 28575
11432, 27895, 27896, 27919, 27918, 28533, 28579, 28580, 28577
11433, 27896, 27897, 27920, 27919, 28535, 28581, 28582, 28579
11434, 27897, 27898, 27921, 27920, 28537, 28583, 28584, 28581
11435, 27898, 27899, 27922, 27921, 28539, 28585, 28586, 28583
11436, 27899, 27900, 27923, 27922, 28541, 28587, 28588, 28585
11437, 27900, 27901, 27924, 27923, 28543, 28589, 28590, 28587
11438, 27901, 27902, 27925, 27924, 28545, 28591, 28592, 28589
11439, 27902, 27903, 27926, 27925, 28547, 28593, 28594, 28591
11440, 27903, 27904, 27927, 27926, 28549, 28595, 28596, 28593
11441, 27904, 27905, 27928, 27927, 28551, 28597, 28598, 28595
11442, 27905, 27906, 27929, 27928, 28553, 28599, 28600, 28597
11443, 27906, 27907, 27930, 27929, 28555, 28601, 28602, 28599
11444, 27907, 2842, 2843, 27930, 28556, 2866, 28603, 28601
11445, 2796, 27908, 27931, 2797, 28558, 28604, 28605, 2820
11446, 27908, 27909, 27932, 27931, 28560, 28606, 28607, 28604
11447, 27909, 27910, 27933, 27932, 28562, 28608, 28609, 28606
11448, 27910, 27911, 27934, 27933, 28564, 28610, 28611, 28608
11449, 27911, 27912, 27935, 27934, 28566, 28612, 28613, 28610
11450, 27912, 27913, 27936, 27935, 28568, 28614, 28615, 28612
11451, 27913, 27914, 27937, 27936, 28570, 28616, 28617, 28614
11452, 27914, 27915, 27938, 27937, 28572, 28618, 28619, 28616
11453, 27915, 27916, 27939, 27938, 28574, 28620, 28621, 28618
11454, 27916, 27917, 27940, 27939, 28576, 28622, 28623, 28620
11455, 27917, 27918, 27941, 27940, 28578, 28624, 28625, 28622
11456, 27918, 27919, 27942, 27941, 28580, 28626, 28627, 28624
11457, 27919, 27920, 27943, 27942, 28582, 28628, 28629, 28626
11458, 27920, 27921, 27944, 27943, 28584, 28630, 28631, 28628
11459, 27921, 27922, 27945, 27944, 28586, 28632, 28633, 28630
11460, 27922, 27923, 27946, 27945, 28588, 28634, 28635, 28632
11461, 27923, 27924, 27947, 27946, 28590, 28636, 28637, 28634
11462, 27924, 27925, 27948, 27947, 28592, 28638, 28639, 28636
11463, 27925, 27926, 27949, 27948, 28594, 28640, 28641, 28638
11464, 27926, 27927, 27950, 27949, 28596, 28642, 28643, 28640
11465, 27927, 27928, 27951, 27950, 28598, 28644, 28645, 28642
11466, 27928, 27929, 27952, 27951, 28600, 28646, 28647, 28644
11467, 27929, 27930, 27953, 27952, 28602, 28648, 28649, 28646
11468, 27930, 2843, 2844, 27953, 28603, 2867, 28650, 28648
11469, 2797, 27931, 27954, 2798, 28605, 28651, 28652, 2821
11470, 27931, 27932, 27955, 27954, 28607, 28653, 28654, 28651
11471, 27932, 27933, 27956, 27955, 28609, 28655, 28656, 28653
11472, 27933, 27934, 27957, 27956, 28611, 28657, 28658, 28655
11473, 27934, 27935, 27958, 27957, 28613, 28659, 28660, 28657
11474, 27935, 27936, 27959, 27958, 28615, 28661, 28662, 28659
11475, 27936, 27937, 27960, 27959, 28617, 28663, 28664, 28661
11476, 27937, 27938, 27961, 27960, 28619, 28665, 28666, 28663
11477, 27938, 27939, 27962, 27961, 28621, 28667, 28668, 28665
11478, 27939, 27940, 27963, 27962, 28623, 28669, 28670, 28667
11479, 27940, 27941, 27964, 27963, 28625, 28671, 28672, 28669
11480, 27941, 27942, 27965, 27964, 28627, 28673, 28674, 28671
11481, 27942, 27943, 27966, 27965, 28629, 28675, 28676, 28673
11482, 27943, 27944, 27967, 27966, 28631, 28677, 28678, 28675
11483, 27944, 27945, 27968, 27967, 28633, 28679, 28680, 28677
11484, 27945, 27946, 27969, 27968, 28635, 28681, 28682, 28679
11485, 27946, 27947, 27970, 27969, 28637, 28683, 28684, 28681
11486, 27947, 27948, 27971, 27970, 28639, 28685, 28686, 28683
11487, 27948, 27949, 27972, 27971, 28641, 28687, 28688, 28685
11488, 27949, 27950, 27973, 27972, 28643, 28689, 28690, 28687
11489, 27950, 27951, 27974, 27973, 28645, 28691, 28692, 28689
11490, 27951, 27952, 27975, 27974, 28647, 28693, 28694, 28691
11491, 27952, 27953, 27976, 27975, 28649, 28695, 28696, 28693
11492, 27953, 2844, 2845, 27976, 28650, 2868, 28697, 28695
11493, 2798, 27954, 27977, 2799, 28652, 28698, 28699, 2822
11494, 27954, 27955, 27978, 27977, 28654, 28700, 28701, 28698
11495, 27955, 27956, 27979, 27978, 28656, 28702, 28703, 28700
11496, 27956, 27957, 27980, 27979, 28658, 28704, 28705, 28702
11497, 27957, 27958, 27981, 27980, 28660, 28706, 28707, 28704
11498, 27958, 27959, 27982, 27981, 28662, 28708, 28709, 28706
11499, 27959, 27960, 27983, 27982, 28664, 28710, 28711, 28708
11500, 27960, 27961, 27984, 27983, 28666, 28712, 28713, 28710
11501, 27961, 27962, 27985, 27984, 28668, 28714, 28715, 28712
11502, 27962, 27963, 27986, 27985, 28670, 28716, 28717, 28714
11503, 27963, 27964, 27987, 27986, 28672, 28718, 28719, 28716
11504, 27964, 27965, 27988, 27987, 28674, 28720, 28721, 28718
11505, 27965, 27966, 27989, 27988, 28676, 28722, 28723, 28720
11506, 27966, 27967, 27990, 27989, 28678, 28724, 28725, 28722
11507, 27967, 27968, 27991, 27990, 28680, 28726, 28727, 28724
11508, 27968, 27969, 27992, 27991, 28682, 28728, 28729, 28726
11509, 27969, 27970, 27993, 27992, 28684, 28730, 28731, 28728
11510, 27970, 27971, 27994, 27993, 28686, 28732, 28733, 28730
11511, 27971, 27972, 27995, 27994, 28688, 28734, 28735, 28732
11512, 27972, 27973, 27996, 27995, 28690, 28736, 28737, 28734
11513, 27973, 27974, 27997, 27996, 28692, 28738, 28739, 28736
11514, 27974, 27975, 27998, 27997, 28694, 28740, 28741, 28738
11515, 27975, 27976, 27999, 27998, 28696, 28742, 28743, 28740
11516, 27976, 2845, 2846, 27999, 28697, 2869, 28744, 28742
11517, 2799, 27977, 28000, 2800, 28699, 28745, 28746, 2823
11518, 27977, 27978, 28001, 28000, 28701, 28747, 28748, 28745
11519, 27978, 27979, 28002, 28001, 28703, 28749, 28750, 28747
11520, 27979, 27980, 28003, 28002, 28705, 28751, 28752, 28749
11521, 27980, 27981, 28004, 28003, 28707, 28753, 28754, 28751
11522, 27981, 27982, 28005, 28004, 28709, 28755, 28756, 28753
11523, 27982, 27983, 28006, 28005, 28711, 28757, 28758, 28755
11524, 27983, 27984, 28007, 28006, 28713, 28759, 28760, 28757
11525, 27984, 27985, 28008, 28007, 28715, 28761, 28762, 28759
11526, 27985, 27986, 28009, 28008, 28717, 28763, 28764, 28761
11527, 27986, 27987, 28010, 28009, 28719, 28765, 28766, 28763
11528, 27987, 27988, 28011, 28010, 28721, 28767, 28768, 28765
11529, 27988, 27989, 28012, 28011, 28723, 28769, 28770, 28767
11530, 27989, 27990, 28013, 28012, 28725, 28771, 28772, 28769
11531, 27990, 27991, 28014, 28013, 28727, 28773, 28774, 28771
11532, 27991, 27992, 28015, 28014, 28729, 28775, 28776, 28773
11533, 27992, 27993, 28016, 28015, 28731, 28777, 28778, 28775
11534, 27993, 27994, 28017, 28016, 28733, 28779, 28780, 28777
11535, 27994, 27995, 28018, 28017, 28735, 28781, 28782, 28779
11536, 27995, 27996, 28019, 28018, 28737, 28783, 28784, 28781
11537, 27996, 27997, 28020, 28019, 28739, 28785, 28786, 28783
11538, 27997, 27998, 28021, 28020, 28741, 28787, 28788, 28785
11539, 27998, 27999, 28022, 28021, 28743, 28789, 28790, 28787
11540, 27999, 2846, 2847, 28022, 28744, 2870, 28791, 28789
11541, 2800, 28000, 28023, 2801, 28746, 28792, 28793, 2824
11542, 28000, 28001, 28024, 28023, 28748, 28794, 28795, 28792
11543, 28001, 28002, 28025, 28024, 28750, 28796, 28797, 28794
11544, 28002, 28003, 28026, 28025, 28752, 28798, 28799, 28796
11545, 28003, 28004, 28027, 28026, 28754, 28800, 28801, 28798
11546, 28004, 28005, 28028, 28027, 28756, 28802, 28803, 28800
11547, 28005, 28006, 28029, 28028, 28758, 28804, 28805, 28802
11548, 28006, 28007, 28030, 28029, 28760, 28806, 28807, 28804
11549, 28007, 28008, 28031, 28030, 28762, 28808, 28809, 28806
11550, 28008, 28009, 28032, 28031, 28764, 28810, 28811, 28808
11551, 28009, 28010, 28033, 28032, 28766, 28812, 28813, 28810
11552, 28010, 28011, 28034, 28033, 28768, 28814, 28815, 28812
11553, 28011, 28012, 28035, 28034, 28770, 28816, 28817, 28814
11554, 28012, 28013, 28036, 28035, 28772, 28818, 28819, 28816
11555, 28013, 28014, 28037, 28036, 28774, 28820, 28821, 28818
11556, 28014, 28015, 28038, 28037, 28776, 28822, 28823, 28820
11557, 28015, 28016, 28039, 28038, 28778, 28824, 28825, 28822
11558, 28016, 28017, 28040, 28039, 28780, 28826, 28827, 28824
11559, 28017, 28018, 28041, 28040, 28782, 28828, 28829, 28826
11560, 28018, 28019, 28042, 28041, 28784, 28830, 28831, 28828
11561, 28019, 28020, 28043, 28042, 28786, 28832, 28833, 28830
11562, 28020, 28021, 28044, 28043, 28788, 28834, 28835, 28832
11563, 28021, 28022, 28045, 28044, 28790, 28836, 28837, 28834
11564, 28022, 2847, 2848, 28045, 28791, 2871, 28838, 28836
11565, 2801, 28023, 28046, 2802, 28793, 28839, 28840, 2825
11566, 28023, 28024, 28047, 28046, 28795, 28841, 28842, 28839
11567, 28024, 28025, 28048, 28047, 28797, 28843, 28844, 28841
11568, 28025, 28026, 28049, 28048, 28799, 28845, 28846, 28843
11569, 28026, 28027, 28050, 28049, 28801, 28847, 28848, 28845
11570, 28027, 28028, 28051, 28050, 28803, 28849, 28850, 28847
11571, 28028, 28029, 28052, 28051, 28805, 28851, 28852, 28849
11572, 28029, 28030, 28053, 28052, 28807, 28853, 28854, 28851
11573, 28030, 28031, 28054, 28053, 28809, 28855, 28856, 28853
11574, 28031, 28032, 28055, 28054, 28811, 28857, 28858, 28855
11575, 28032, 28033, 28056, 28055, 28813, 28859, 28860, 28857
11576, 28033, 28034, 28057, 28056, 28815, 28861, 28862, 28859
11577, 28034, 28035, 28058, 28057, 28817, 28863, 28864, 28861
11578, 28035, 28036, 28059, 28058, 28819, 28865, 28866, 28863
11579, 28036, 28037, 28060, 28059, 28821, 28867, 28868, 28865
11580, 28037, 28038, 28061, 28060, 28823, 28869, 28870, 28867
11581, 28038, 28039, 28062, 28061, 28825, 28871, 28872, 28869
11582, 28039, 28040, 28063, 28062, 28827, 28873, 28874, 28871
11583, 28040, 28041, 28064, 28063, 28829, 28875, 28876, 28873
11584, 28041, 28042, 28065, 28064, 28831, 28877, 28878, 28875
11585, 28042, 28043, 28066, 28065, 28833, 28879, 28880, 28877
11586, 28043, 28044, 28067, 28066, 28835, 28881, 28882, 28879
