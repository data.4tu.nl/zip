3079, 6183, 6184, 6195, 6194, 6502, 6524, 6525, 6522
3080, 6184, 6185, 6196, 6195, 6504, 6526, 6527, 6524
3081, 6185, 6186, 6197, 6196, 6506, 6528, 6529, 6526
3082, 6186, 6187, 6198, 6197, 6508, 6530, 6531, 6528
3083, 6187, 6188, 6199, 6198, 6510, 6532, 6533, 6530
3084, 6188, 6189, 6200, 6199, 6512, 6534, 6535, 6532
3085, 6189, 6190, 6201, 6200, 6514, 6536, 6537, 6534
3086, 6190, 476, 477, 6201, 6515, 500, 6538, 6536
3087, 405, 6191, 6202, 406, 6517, 6539, 6540, 429
3088, 6191, 6192, 6203, 6202, 6519, 6541, 6542, 6539
3089, 6192, 6193, 6204, 6203, 6521, 6543, 6544, 6541
3090, 6193, 6194, 6205, 6204, 6523, 6545, 6546, 6543
3091, 6194, 6195, 6206, 6205, 6525, 6547, 6548, 6545
3092, 6195, 6196, 6207, 6206, 6527, 6549, 6550, 6547
3093, 6196, 6197, 6208, 6207, 6529, 6551, 6552, 6549
3094, 6197, 6198, 6209, 6208, 6531, 6553, 6554, 6551
3095, 6198, 6199, 6210, 6209, 6533, 6555, 6556, 6553
3096, 6199, 6200, 6211, 6210, 6535, 6557, 6558, 6555
3097, 6200, 6201, 6212, 6211, 6537, 6559, 6560, 6557
3098, 6201, 477, 478, 6212, 6538, 501, 6561, 6559
3099, 406, 6202, 6213, 407, 6540, 6562, 6563, 430
3100, 6202, 6203, 6214, 6213, 6542, 6564, 6565, 6562
3101, 6203, 6204, 6215, 6214, 6544, 6566, 6567, 6564
3102, 6204, 6205, 6216, 6215, 6546, 6568, 6569, 6566
3103, 6205, 6206, 6217, 6216, 6548, 6570, 6571, 6568
3104, 6206, 6207, 6218, 6217, 6550, 6572, 6573, 6570
3105, 6207, 6208, 6219, 6218, 6552, 6574, 6575, 6572
3106, 6208, 6209, 6220, 6219, 6554, 6576, 6577, 6574
3107, 6209, 6210, 6221, 6220, 6556, 6578, 6579, 6576
3108, 6210, 6211, 6222, 6221, 6558, 6580, 6581, 6578
3109, 6211, 6212, 6223, 6222, 6560, 6582, 6583, 6580
3110, 6212, 478, 479, 6223, 6561, 502, 6584, 6582
3111, 407, 6213, 6224, 408, 6563, 6585, 6586, 431
3112, 6213, 6214, 6225, 6224, 6565, 6587, 6588, 6585
3113, 6214, 6215, 6226, 6225, 6567, 6589, 6590, 6587
3114, 6215, 6216, 6227, 6226, 6569, 6591, 6592, 6589
3115, 6216, 6217, 6228, 6227, 6571, 6593, 6594, 6591
3116, 6217, 6218, 6229, 6228, 6573, 6595, 6596, 6593
3117, 6218, 6219, 6230, 6229, 6575, 6597, 6598, 6595
3118, 6219, 6220, 6231, 6230, 6577, 6599, 6600, 6597
3119, 6220, 6221, 6232, 6231, 6579, 6601, 6602, 6599
3120, 6221, 6222, 6233, 6232, 6581, 6603, 6604, 6601
3121, 6222, 6223, 6234, 6233, 6583, 6605, 6606, 6603
3122, 6223, 479, 480, 6234, 6584, 503, 6607, 6605
3123, 408, 6224, 6235, 409, 6586, 6608, 6609, 432
3124, 6224, 6225, 6236, 6235, 6588, 6610, 6611, 6608
3125, 6225, 6226, 6237, 6236, 6590, 6612, 6613, 6610
3126, 6226, 6227, 6238, 6237, 6592, 6614, 6615, 6612
3127, 6227, 6228, 6239, 6238, 6594, 6616, 6617, 6614
3128, 6228, 6229, 6240, 6239, 6596, 6618, 6619, 6616
3129, 6229, 6230, 6241, 6240, 6598, 6620, 6621, 6618
3130, 6230, 6231, 6242, 6241, 6600, 6622, 6623, 6620
3131, 6231, 6232, 6243, 6242, 6602, 6624, 6625, 6622
3132, 6232, 6233, 6244, 6243, 6604, 6626, 6627, 6624
3133, 6233, 6234, 6245, 6244, 6606, 6628, 6629, 6626
3134, 6234, 480, 481, 6245, 6607, 504, 6630, 6628
3135, 409, 6235, 6246, 410, 6609, 6631, 6632, 433
3136, 6235, 6236, 6247, 6246, 6611, 6633, 6634, 6631
3137, 6236, 6237, 6248, 6247, 6613, 6635, 6636, 6633
3138, 6237, 6238, 6249, 6248, 6615, 6637, 6638, 6635
3139, 6238, 6239, 6250, 6249, 6617, 6639, 6640, 6637
3140, 6239, 6240, 6251, 6250, 6619, 6641, 6642, 6639
3141, 6240, 6241, 6252, 6251, 6621, 6643, 6644, 6641
3142, 6241, 6242, 6253, 6252, 6623, 6645, 6646, 6643
3143, 6242, 6243, 6254, 6253, 6625, 6647, 6648, 6645
3144, 6243, 6244, 6255, 6254, 6627, 6649, 6650, 6647
3145, 6244, 6245, 6256, 6255, 6629, 6651, 6652, 6649
3146, 6245, 481, 482, 6256, 6630, 505, 6653, 6651
3147, 410, 6246, 6257, 411, 6632, 6654, 6655, 434
3148, 6246, 6247, 6258, 6257, 6634, 6656, 6657, 6654
3149, 6247, 6248, 6259, 6258, 6636, 6658, 6659, 6656
3150, 6248, 6249, 6260, 6259, 6638, 6660, 6661, 6658
3151, 6249, 6250, 6261, 6260, 6640, 6662, 6663, 6660
3152, 6250, 6251, 6262, 6261, 6642, 6664, 6665, 6662
3153, 6251, 6252, 6263, 6262, 6644, 6666, 6667, 6664
3154, 6252, 6253, 6264, 6263, 6646, 6668, 6669, 6666
3155, 6253, 6254, 6265, 6264, 6648, 6670, 6671, 6668
3156, 6254, 6255, 6266, 6265, 6650, 6672, 6673, 6670
3157, 6255, 6256, 6267, 6266, 6652, 6674, 6675, 6672
3158, 6256, 482, 483, 6267, 6653, 506, 6676, 6674
3159, 411, 6257, 6268, 412, 6655, 6677, 6678, 435
3160, 6257, 6258, 6269, 6268, 6657, 6679, 6680, 6677
3161, 6258, 6259, 6270, 6269, 6659, 6681, 6682, 6679
3162, 6259, 6260, 6271, 6270, 6661, 6683, 6684, 6681
3163, 6260, 6261, 6272, 6271, 6663, 6685, 6686, 6683
3164, 6261, 6262, 6273, 6272, 6665, 6687, 6688, 6685
3165, 6262, 6263, 6274, 6273, 6667, 6689, 6690, 6687
3166, 6263, 6264, 6275, 6274, 6669, 6691, 6692, 6689
3167, 6264, 6265, 6276, 6275, 6671, 6693, 6694, 6691
3168, 6265, 6266, 6277, 6276, 6673, 6695, 6696, 6693
3169, 6266, 6267, 6278, 6277, 6675, 6697, 6698, 6695
3170, 6267, 483, 484, 6278, 6676, 507, 6699, 6697
3171, 412, 6268, 6279, 413, 6678, 6700, 6701, 436
3172, 6268, 6269, 6280, 6279, 6680, 6702, 6703, 6700
3173, 6269, 6270, 6281, 6280, 6682, 6704, 6705, 6702
3174, 6270, 6271, 6282, 6281, 6684, 6706, 6707, 6704
3175, 6271, 6272, 6283, 6282, 6686, 6708, 6709, 6706
3176, 6272, 6273, 6284, 6283, 6688, 6710, 6711, 6708
3177, 6273, 6274, 6285, 6284, 6690, 6712, 6713, 6710
3178, 6274, 6275, 6286, 6285, 6692, 6714, 6715, 6712
3179, 6275, 6276, 6287, 6286, 6694, 6716, 6717, 6714
3180, 6276, 6277, 6288, 6287, 6696, 6718, 6719, 6716
3181, 6277, 6278, 6289, 6288, 6698, 6720, 6721, 6718
3182, 6278, 484, 485, 6289, 6699, 508, 6722, 6720
3183, 413, 6279, 6290, 414, 6701, 6723, 6724, 437
3184, 6279, 6280, 6291, 6290, 6703, 6725, 6726, 6723
3185, 6280, 6281, 6292, 6291, 6705, 6727, 6728, 6725
3186, 6281, 6282, 6293, 6292, 6707, 6729, 6730, 6727
3187, 6282, 6283, 6294, 6293, 6709, 6731, 6732, 6729
3188, 6283, 6284, 6295, 6294, 6711, 6733, 6734, 6731
3189, 6284, 6285, 6296, 6295, 6713, 6735, 6736, 6733
3190, 6285, 6286, 6297, 6296, 6715, 6737, 6738, 6735
3191, 6286, 6287, 6298, 6297, 6717, 6739, 6740, 6737
3192, 6287, 6288, 6299, 6298, 6719, 6741, 6742, 6739
3193, 6288, 6289, 6300, 6299, 6721, 6743, 6744, 6741
3194, 6289, 485, 486, 6300, 6722, 509, 6745, 6743
3195, 414, 6290, 6301, 415, 6724, 6746, 6747, 438
3196, 6290, 6291, 6302, 6301, 6726, 6748, 6749, 6746
3197, 6291, 6292, 6303, 6302, 6728, 6750, 6751, 6748
3198, 6292, 6293, 6304, 6303, 6730, 6752, 6753, 6750
3199, 6293, 6294, 6305, 6304, 6732, 6754, 6755, 6752
3200, 6294, 6295, 6306, 6305, 6734, 6756, 6757, 6754
3201, 6295, 6296, 6307, 6306, 6736, 6758, 6759, 6756
3202, 6296, 6297, 6308, 6307, 6738, 6760, 6761, 6758
3203, 6297, 6298, 6309, 6308, 6740, 6762, 6763, 6760
3204, 6298, 6299, 6310, 6309, 6742, 6764, 6765, 6762
3205, 6299, 6300, 6311, 6310, 6744, 6766, 6767, 6764
3206, 6300, 486, 487, 6311, 6745, 510, 6768, 6766
3207, 415, 6301, 6312, 416, 6747, 6769, 6770, 439
3208, 6301, 6302, 6313, 6312, 6749, 6771, 6772, 6769
3209, 6302, 6303, 6314, 6313, 6751, 6773, 6774, 6771
3210, 6303, 6304, 6315, 6314, 6753, 6775, 6776, 6773
3211, 6304, 6305, 6316, 6315, 6755, 6777, 6778, 6775
3212, 6305, 6306, 6317, 6316, 6757, 6779, 6780, 6777
3213, 6306, 6307, 6318, 6317, 6759, 6781, 6782, 6779
3214, 6307, 6308, 6319, 6318, 6761, 6783, 6784, 6781
3215, 6308, 6309, 6320, 6319, 6763, 6785, 6786, 6783
3216, 6309, 6310, 6321, 6320, 6765, 6787, 6788, 6785
3217, 6310, 6311, 6322, 6321, 6767, 6789, 6790, 6787
3218, 6311, 487, 488, 6322, 6768, 511, 6791, 6789
3219, 416, 6312, 6323, 417, 6770, 6792, 6793, 440
3220, 6312, 6313, 6324, 6323, 6772, 6794, 6795, 6792
3221, 6313, 6314, 6325, 6324, 6774, 6796, 6797, 6794
3222, 6314, 6315, 6326, 6325, 6776, 6798, 6799, 6796
3223, 6315, 6316, 6327, 6326, 6778, 6800, 6801, 6798
3224, 6316, 6317, 6328, 6327, 6780, 6802, 6803, 6800
3225, 6317, 6318, 6329, 6328, 6782, 6804, 6805, 6802
3226, 6318, 6319, 6330, 6329, 6784, 6806, 6807, 6804
3227, 6319, 6320, 6331, 6330, 6786, 6808, 6809, 6806
3228, 6320, 6321, 6332, 6331, 6788, 6810, 6811, 6808
3229, 6321, 6322, 6333, 6332, 6790, 6812, 6813, 6810
3230, 6322, 488, 489, 6333, 6791, 512, 6814, 6812
3231, 417, 6323, 6334, 418, 6793, 6815, 6816, 441
3232, 6323, 6324, 6335, 6334, 6795, 6817, 6818, 6815
3233, 6324, 6325, 6336, 6335, 6797, 6819, 6820, 6817
3234, 6325, 6326, 6337, 6336, 6799, 6821, 6822, 6819
3235, 6326, 6327, 6338, 6337, 6801, 6823, 6824, 6821
3236, 6327, 6328, 6339, 6338, 6803, 6825, 6826, 6823
3237, 6328, 6329, 6340, 6339, 6805, 6827, 6828, 6825
3238, 6329, 6330, 6341, 6340, 6807, 6829, 6830, 6827
3239, 6330, 6331, 6342, 6341, 6809, 6831, 6832, 6829
3240, 6331, 6332, 6343, 6342, 6811, 6833, 6834, 6831
3241, 6332, 6333, 6344, 6343, 6813, 6835, 6836, 6833
3242, 6333, 489, 490, 6344, 6814, 513, 6837, 6835
3243, 418, 6334, 6345, 419, 6816, 6838, 6839, 442
3244, 6334, 6335, 6346, 6345, 6818, 6840, 6841, 6838
3245, 6335, 6336, 6347, 6346, 6820, 6842, 6843, 6840
3246, 6336, 6337, 6348, 6347, 6822, 6844, 6845, 6842
3247, 6337, 6338, 6349, 6348, 6824, 6846, 6847, 6844
3248, 6338, 6339, 6350, 6349, 6826, 6848, 6849, 6846
3249, 6339, 6340, 6351, 6350, 6828, 6850, 6851, 6848
3250, 6340, 6341, 6352, 6351, 6830, 6852, 6853, 6850
3251, 6341, 6342, 6353, 6352, 6832, 6854, 6855, 6852
3252, 6342, 6343, 6354, 6353, 6834, 6856, 6857, 6854
3253, 6343, 6344, 6355, 6354, 6836, 6858, 6859, 6856
3254, 6344, 490, 491, 6355, 6837, 514, 6860, 6858
3255, 419, 6345, 6356, 420, 6839, 6861, 6862, 443
3256, 6345, 6346, 6357, 6356, 6841, 6863, 6864, 6861
3257, 6346, 6347, 6358, 6357, 6843, 6865, 6866, 6863
3258, 6347, 6348, 6359, 6358, 6845, 6867, 6868, 6865
3259, 6348, 6349, 6360, 6359, 6847, 6869, 6870, 6867
3260, 6349, 6350, 6361, 6360, 6849, 6871, 6872, 6869
3261, 6350, 6351, 6362, 6361, 6851, 6873, 6874, 6871
3262, 6351, 6352, 6363, 6362, 6853, 6875, 6876, 6873
3263, 6352, 6353, 6364, 6363, 6855, 6877, 6878, 6875
3264, 6353, 6354, 6365, 6364, 6857, 6879, 6880, 6877
3265, 6354, 6355, 6366, 6365, 6859, 6881, 6882, 6879
3266, 6355, 491, 492, 6366, 6860, 515, 6883, 6881
3267, 420, 6356, 6367, 421, 6862, 6884, 6885, 444
3268, 6356, 6357, 6368, 6367, 6864, 6886, 6887, 6884
3269, 6357, 6358, 6369, 6368, 6866, 6888, 6889, 6886
3270, 6358, 6359, 6370, 6369, 6868, 6890, 6891, 6888
3271, 6359, 6360, 6371, 6370, 6870, 6892, 6893, 6890
3272, 6360, 6361, 6372, 6371, 6872, 6894, 6895, 6892
3273, 6361, 6362, 6373, 6372, 6874, 6896, 6897, 6894
3274, 6362, 6363, 6374, 6373, 6876, 6898, 6899, 6896
3275, 6363, 6364, 6375, 6374, 6878, 6900, 6901, 6898
3276, 6364, 6365, 6376, 6375, 6880, 6902, 6903, 6900
3277, 6365, 6366, 6377, 6376, 6882, 6904, 6905, 6902
3278, 6366, 492, 493, 6377, 6883, 516, 6906, 6904
3279, 421, 6367, 447, 9, 6885, 6907, 458, 445
3280, 6367, 6368, 448, 447, 6887, 6908, 459, 6907
3281, 6368, 6369, 449, 448, 6889, 6909, 460, 6908
3282, 6369, 6370, 450, 449, 6891, 6910, 461, 6909
3283, 6370, 6371, 451, 450, 6893, 6911, 462, 6910
3284, 6371, 6372, 452, 451, 6895, 6912, 463, 6911
3285, 6372, 6373, 453, 452, 6897, 6913, 464, 6912
3286, 6373, 6374, 454, 453, 6899, 6914, 465, 6913
3287, 6374, 6375, 455, 454, 6901, 6915, 466, 6914
3288, 6375, 6376, 456, 455, 6903, 6916, 467, 6915
3289, 6376, 6377, 457, 456, 6905, 6917, 468, 6916
3290, 6377, 493, 11, 457, 6906, 517, 469, 6917
*ELEMENT, type=CPS8, ELSET=Surface12
3291, 10, 588, 6918, 399, 611, 7447, 7448, 422
3292, 588, 589, 6919, 6918, 612, 7449, 7450, 7447
3293, 589, 590, 6920, 6919, 613, 7451, 7452, 7449
3294, 590, 591, 6921, 6920, 614, 7453, 7454, 7451
3295, 591, 592, 6922, 6921, 615, 7455, 7456, 7453
3296, 592, 593, 6923, 6922, 616, 7457, 7458, 7455
3297, 593, 594, 6924, 6923, 617, 7459, 7460, 7457
3298, 594, 595, 6925, 6924, 618, 7461, 7462, 7459
3299, 595, 596, 6926, 6925, 619, 7463, 7464, 7461
3300, 596, 597, 6927, 6926, 620, 7465, 7466, 7463
3301, 597, 598, 6928, 6927, 621, 7467, 7468, 7465
3302, 598, 599, 6929, 6928, 622, 7469, 7470, 7467
3303, 599, 600, 6930, 6929, 623, 7471, 7472, 7469
3304, 600, 601, 6931, 6930, 624, 7473, 7474, 7471
3305, 601, 602, 6932, 6931, 625, 7475, 7476, 7473
3306, 602, 603, 6933, 6932, 626, 7477, 7478, 7475
3307, 603, 604, 6934, 6933, 627, 7479, 7480, 7477
3308, 604, 605, 6935, 6934, 628, 7481, 7482, 7479
3309, 605, 606, 6936, 6935, 629, 7483, 7484, 7481
3310, 606, 607, 6937, 6936, 630, 7485, 7486, 7483
3311, 607, 608, 6938, 6937, 631, 7487, 7488, 7485
3312, 608, 609, 6939, 6938, 632, 7489, 7490, 7487
3313, 609, 610, 6940, 6939, 633, 7491, 7492, 7489
3314, 610, 14, 635, 6940, 634, 658, 7493, 7491
3315, 399, 6918, 6941, 400, 7448, 7494, 7495, 423
3316, 6918, 6919, 6942, 6941, 7450, 7496, 7497, 7494
3317, 6919, 6920, 6943, 6942, 7452, 7498, 7499, 7496
3318, 6920, 6921, 6944, 6943, 7454, 7500, 7501, 7498
3319, 6921, 6922, 6945, 6944, 7456, 7502, 7503, 7500
3320, 6922, 6923, 6946, 6945, 7458, 7504, 7505, 7502
3321, 6923, 6924, 6947, 6946, 7460, 7506, 7507, 7504
3322, 6924, 6925, 6948, 6947, 7462, 7508, 7509, 7506
3323, 6925, 6926, 6949, 6948, 7464, 7510, 7511, 7508
3324, 6926, 6927, 6950, 6949, 7466, 7512, 7513, 7510
3325, 6927, 6928, 6951, 6950, 7468, 7514, 7515, 7512
3326, 6928, 6929, 6952, 6951, 7470, 7516, 7517, 7514
3327, 6929, 6930, 6953, 6952, 7472, 7518, 7519, 7516
3328, 6930, 6931, 6954, 6953, 7474, 7520, 7521, 7518
3329, 6931, 6932, 6955, 6954, 7476, 7522, 7523, 7520
3330, 6932, 6933, 6956, 6955, 7478, 7524, 7525, 7522
3331, 6933, 6934, 6957, 6956, 7480, 7526, 7527, 7524
3332, 6934, 6935, 6958, 6957, 7482, 7528, 7529, 7526
3333, 6935, 6936, 6959, 6958, 7484, 7530, 7531, 7528
3334, 6936, 6937, 6960, 6959, 7486, 7532, 7533, 7530
3335, 6937, 6938, 6961, 6960, 7488, 7534, 7535, 7532
3336, 6938, 6939, 6962, 6961, 7490, 7536, 7537, 7534
3337, 6939, 6940, 6963, 6962, 7492, 7538, 7539, 7536
3338, 6940, 635, 636, 6963, 7493, 659, 7540, 7538
3339, 400, 6941, 6964, 401, 7495, 7541, 7542, 424
3340, 6941, 6942, 6965, 6964, 7497, 7543, 7544, 7541
3341, 6942, 6943, 6966, 6965, 7499, 7545, 7546, 7543
3342, 6943, 6944, 6967, 6966, 7501, 7547, 7548, 7545
3343, 6944, 6945, 6968, 6967, 7503, 7549, 7550, 7547
3344, 6945, 6946, 6969, 6968, 7505, 7551, 7552, 7549
3345, 6946, 6947, 6970, 6969, 7507, 7553, 7554, 7551
3346, 6947, 6948, 6971, 6970, 7509, 7555, 7556, 7553
3347, 6948, 6949, 6972, 6971, 7511, 7557, 7558, 7555
3348, 6949, 6950, 6973, 6972, 7513, 7559, 7560, 7557
3349, 6950, 6951, 6974, 6973, 7515, 7561, 7562, 7559
3350, 6951, 6952, 6975, 6974, 7517, 7563, 7564, 7561
3351, 6952, 6953, 6976, 6975, 7519, 7565, 7566, 7563
3352, 6953, 6954, 6977, 6976, 7521, 7567, 7568, 7565
3353, 6954, 6955, 6978, 6977, 7523, 7569, 7570, 7567
3354, 6955, 6956, 6979, 6978, 7525, 7571, 7572, 7569
3355, 6956, 6957, 6980, 6979, 7527, 7573, 7574, 7571
3356, 6957, 6958, 6981, 6980, 7529, 7575, 7576, 7573
3357, 6958, 6959, 6982, 6981, 7531, 7577, 7578, 7575
3358, 6959, 6960, 6983, 6982, 7533, 7579, 7580, 7577
3359, 6960, 6961, 6984, 6983, 7535, 7581, 7582, 7579
3360, 6961, 6962, 6985, 6984, 7537, 7583, 7584, 7581
3361, 6962, 6963, 6986, 6985, 7539, 7585, 7586, 7583
3362, 6963, 636, 637, 6986, 7540, 660, 7587, 7585
3363, 401, 6964, 6987, 402, 7542, 7588, 7589, 425
3364, 6964, 6965, 6988, 6987, 7544, 7590, 7591, 7588
3365, 6965, 6966, 6989, 6988, 7546, 7592, 7593, 7590
3366, 6966, 6967, 6990, 6989, 7548, 7594, 7595, 7592
3367, 6967, 6968, 6991, 6990, 7550, 7596, 7597, 7594
3368, 6968, 6969, 6992, 6991, 7552, 7598, 7599, 7596
3369, 6969, 6970, 6993, 6992, 7554, 7600, 7601, 7598
3370, 6970, 6971, 6994, 6993, 7556, 7602, 7603, 7600
3371, 6971, 6972, 6995, 6994, 7558, 7604, 7605, 7602
3372, 6972, 6973, 6996, 6995, 7560, 7606, 7607, 7604
3373, 6973, 6974, 6997, 6996, 7562, 7608, 7609, 7606
3374, 6974, 6975, 6998, 6997, 7564, 7610, 7611, 7608
3375, 6975, 6976, 6999, 6998, 7566, 7612, 7613, 7610
3376, 6976, 6977, 7000, 6999, 7568, 7614, 7615, 7612
3377, 6977, 6978, 7001, 7000, 7570, 7616, 7617, 7614
3378, 6978, 6979, 7002, 7001, 7572, 7618, 7619, 7616
3379, 6979, 6980, 7003, 7002, 7574, 7620, 7621, 7618
3380, 6980, 6981, 7004, 7003, 7576, 7622, 7623, 7620
3381, 6981, 6982, 7005, 7004, 7578, 7624, 7625, 7622
3382, 6982, 6983, 7006, 7005, 7580, 7626, 7627, 7624
3383, 6983, 6984, 7007, 7006, 7582, 7628, 7629, 7626
3384, 6984, 6985, 7008, 7007, 7584, 7630, 7631, 7628
3385, 6985, 6986, 7009, 7008, 7586, 7632, 7633, 7630
3386, 6986, 637, 638, 7009, 7587, 661, 7634, 7632
3387, 402, 6987, 7010, 403, 7589, 7635, 7636, 426
3388, 6987, 6988, 7011, 7010, 7591, 7637, 7638, 7635
3389, 6988, 6989, 7012, 7011, 7593, 7639, 7640, 7637
3390, 6989, 6990, 7013, 7012, 7595, 7641, 7642, 7639
3391, 6990, 6991, 7014, 7013, 7597, 7643, 7644, 7641
3392, 6991, 6992, 7015, 7014, 7599, 7645, 7646, 7643
3393, 6992, 6993, 7016, 7015, 7601, 7647, 7648, 7645
3394, 6993, 6994, 7017, 7016, 7603, 7649, 7650, 7647
3395, 6994, 6995, 7018, 7017, 7605, 7651, 7652, 7649
3396, 6995, 6996, 7019, 7018, 7607, 7653, 7654, 7651
3397, 6996, 6997, 7020, 7019, 7609, 7655, 7656, 7653
3398, 6997, 6998, 7021, 7020, 7611, 7657, 7658, 7655
3399, 6998, 6999, 7022, 7021, 7613, 7659, 7660, 7657
3400, 6999, 7000, 7023, 7022, 7615, 7661, 7662, 7659
3401, 7000, 7001, 7024, 7023, 7617, 7663, 7664, 7661
3402, 7001, 7002, 7025, 7024, 7619, 7665, 7666, 7663
3403, 7002, 7003, 7026, 7025, 7621, 7667, 7668, 7665
3404, 7003, 7004, 7027, 7026, 7623, 7669, 7670, 7667
3405, 7004, 7005, 7028, 7027, 7625, 7671, 7672, 7669
3406, 7005, 7006, 7029, 7028, 7627, 7673, 7674, 7671
3407, 7006, 7007, 7030, 7029, 7629, 7675, 7676, 7673
3408, 7007, 7008, 7031, 7030, 7631, 7677, 7678, 7675
3409, 7008, 7009, 7032, 7031, 7633, 7679, 7680, 7677
3410, 7009, 638, 639, 7032, 7634, 662, 7681, 7679
3411, 403, 7010, 7033, 404, 7636, 7682, 7683, 427
3412, 7010, 7011, 7034, 7033, 7638, 7684, 7685, 7682
3413, 7011, 7012, 7035, 7034, 7640, 7686, 7687, 7684
3414, 7012, 7013, 7036, 7035, 7642, 7688, 7689, 7686
3415, 7013, 7014, 7037, 7036, 7644, 7690, 7691, 7688
3416, 7014, 7015, 7038, 7037, 7646, 7692, 7693, 7690
3417, 7015, 7016, 7039, 7038, 7648, 7694, 7695, 7692
3418, 7016, 7017, 7040, 7039, 7650, 7696, 7697, 7694
3419, 7017, 7018, 7041, 7040, 7652, 7698, 7699, 7696
3420, 7018, 7019, 7042, 7041, 7654, 7700, 7701, 7698
3421, 7019, 7020, 7043, 7042, 7656, 7702, 7703, 7700
3422, 7020, 7021, 7044, 7043, 7658, 7704, 7705, 7702
3423, 7021, 7022, 7045, 7044, 7660, 7706, 7707, 7704
3424, 7022, 7023, 7046, 7045, 7662, 7708, 7709, 7706
3425, 7023, 7024, 7047, 7046, 7664, 7710, 7711, 7708
3426, 7024, 7025, 7048, 7047, 7666, 7712, 7713, 7710
3427, 7025, 7026, 7049, 7048, 7668, 7714, 7715, 7712
3428, 7026, 7027, 7050, 7049, 7670, 7716, 7717, 7714
3429, 7027, 7028, 7051, 7050, 7672, 7718, 7719, 7716
3430, 7028, 7029, 7052, 7051, 7674, 7720, 7721, 7718
3431, 7029, 7030, 7053, 7052, 7676, 7722, 7723, 7720
3432, 7030, 7031, 7054, 7053, 7678, 7724, 7725, 7722
3433, 7031, 7032, 7055, 7054, 7680, 7726, 7727, 7724
3434, 7032, 639, 640, 7055, 7681, 663, 7728, 7726
3435, 404, 7033, 7056, 405, 7683, 7729, 7730, 428
3436, 7033, 7034, 7057, 7056, 7685, 7731, 7732, 7729
3437, 7034, 7035, 7058, 7057, 7687, 7733, 7734, 7731
3438, 7035, 7036, 7059, 7058, 7689, 7735, 7736, 7733
3439, 7036, 7037, 7060, 7059, 7691, 7737, 7738, 7735
3440, 7037, 7038, 7061, 7060, 7693, 7739, 7740, 7737
3441, 7038, 7039, 7062, 7061, 7695, 7741, 7742, 7739
3442, 7039, 7040, 7063, 7062, 7697, 7743, 7744, 7741
3443, 7040, 7041, 7064, 7063, 7699, 7745, 7746, 7743
3444, 7041, 7042, 7065, 7064, 7701, 7747, 7748, 7745
3445, 7042, 7043, 7066, 7065, 7703, 7749, 7750, 7747
3446, 7043, 7044, 7067, 7066, 7705, 7751, 7752, 7749
3447, 7044, 7045, 7068, 7067, 7707, 7753, 7754, 7751
3448, 7045, 7046, 7069, 7068, 7709, 7755, 7756, 7753
3449, 7046, 7047, 7070, 7069, 7711, 7757, 7758, 7755
3450, 7047, 7048, 7071, 7070, 7713, 7759, 7760, 7757
3451, 7048, 7049, 7072, 7071, 7715, 7761, 7762, 7759
3452, 7049, 7050, 7073, 7072, 7717, 7763, 7764, 7761
3453, 7050, 7051, 7074, 7073, 7719, 7765, 7766, 7763
3454, 7051, 7052, 7075, 7074, 7721, 7767, 7768, 7765
3455, 7052, 7053, 7076, 7075, 7723, 7769, 7770, 7767
3456, 7053, 7054, 7077, 7076, 7725, 7771, 7772, 7769
3457, 7054, 7055, 7078, 7077, 7727, 7773, 7774, 7771
3458, 7055, 640, 641, 7078, 7728, 664, 7775, 7773
3459, 405, 7056, 7079, 406, 7730, 7776, 7777, 429
3460, 7056, 7057, 7080, 7079, 7732, 7778, 7779, 7776
3461, 7057, 7058, 7081, 7080, 7734, 7780, 7781, 7778
3462, 7058, 7059, 7082, 7081, 7736, 7782, 7783, 7780
3463, 7059, 7060, 7083, 7082, 7738, 7784, 7785, 7782
3464, 7060, 7061, 7084, 7083, 7740, 7786, 7787, 7784
3465, 7061, 7062, 7085, 7084, 7742, 7788, 7789, 7786
3466, 7062, 7063, 7086, 7085, 7744, 7790, 7791, 7788
3467, 7063, 7064, 7087, 7086, 7746, 7792, 7793, 7790
3468, 7064, 7065, 7088, 7087, 7748, 7794, 7795, 7792
3469, 7065, 7066, 7089, 7088, 7750, 7796, 7797, 7794
3470, 7066, 7067, 7090, 7089, 7752, 7798, 7799, 7796
3471, 7067, 7068, 7091, 7090, 7754, 7800, 7801, 7798
3472, 7068, 7069, 7092, 7091, 7756, 7802, 7803, 7800
3473, 7069, 7070, 7093, 7092, 7758, 7804, 7805, 7802
3474, 7070, 7071, 7094, 7093, 7760, 7806, 7807, 7804
3475, 7071, 7072, 7095, 7094, 7762, 7808, 7809, 7806
3476, 7072, 7073, 7096, 7095, 7764, 7810, 7811, 7808
3477, 7073, 7074, 7097, 7096, 7766, 7812, 7813, 7810
3478, 7074, 7075, 7098, 7097, 7768, 7814, 7815, 7812
3479, 7075, 7076, 7099, 7098, 7770, 7816, 7817, 7814
3480, 7076, 7077, 7100, 7099, 7772, 7818, 7819, 7816
3481, 7077, 7078, 7101, 7100, 7774, 7820, 7821, 7818
3482, 7078, 641, 642, 7101, 7775, 665, 7822, 7820
3483, 406, 7079, 7102, 407, 7777, 7823, 7824, 430
3484, 7079, 7080, 7103, 7102, 7779, 7825, 7826, 7823
3485, 7080, 7081, 7104, 7103, 7781, 7827, 7828, 7825
3486, 7081, 7082, 7105, 7104, 7783, 7829, 7830, 7827
3487, 7082, 7083, 7106, 7105, 7785, 7831, 7832, 7829
3488, 7083, 7084, 7107, 7106, 7787, 7833, 7834, 7831
3489, 7084, 7085, 7108, 7107, 7789, 7835, 7836, 7833
3490, 7085, 7086, 7109, 7108, 7791, 7837, 7838, 7835
3491, 7086, 7087, 7110, 7109, 7793, 7839, 7840, 7837
3492, 7087, 7088, 7111, 7110, 7795, 7841, 7842, 7839
3493, 7088, 7089, 7112, 7111, 7797, 7843, 7844, 7841
3494, 7089, 7090, 7113, 7112, 7799, 7845, 7846, 7843
3495, 7090, 7091, 7114, 7113, 7801, 7847, 7848, 7845
3496, 7091, 7092, 7115, 7114, 7803, 7849, 7850, 7847
3497, 7092, 7093, 7116, 7115, 7805, 7851, 7852, 7849
3498, 7093, 7094, 7117, 7116, 7807, 7853, 7854, 7851
3499, 7094, 7095, 7118, 7117, 7809, 7855, 7856, 7853
3500, 7095, 7096, 7119, 7118, 7811, 7857, 7858, 7855
3501, 7096, 7097, 7120, 7119, 7813, 7859, 7860, 7857
3502, 7097, 7098, 7121, 7120, 7815, 7861, 7862, 7859
3503, 7098, 7099, 7122, 7121, 7817, 7863, 7864, 7861
3504, 7099, 7100, 7123, 7122, 7819, 7865, 7866, 7863
3505, 7100, 7101, 7124, 7123, 7821, 7867, 7868, 7865
3506, 7101, 642, 643, 7124, 7822, 666, 7869, 7867
3507, 407, 7102, 7125, 408, 7824, 7870, 7871, 431
3508, 7102, 7103, 7126, 7125, 7826, 7872, 7873, 7870
3509, 7103, 7104, 7127, 7126, 7828, 7874, 7875, 7872
3510, 7104, 7105, 7128, 7127, 7830, 7876, 7877, 7874
3511, 7105, 7106, 7129, 7128, 7832, 7878, 7879, 7876
3512, 7106, 7107, 7130, 7129, 7834, 7880, 7881, 7878
3513, 7107, 7108, 7131, 7130, 7836, 7882, 7883, 7880
3514, 7108, 7109, 7132, 7131, 7838, 7884, 7885, 7882
3515, 7109, 7110, 7133, 7132, 7840, 7886, 7887, 7884
3516, 7110, 7111, 7134, 7133, 7842, 7888, 7889, 7886
3517, 7111, 7112, 7135, 7134, 7844, 7890, 7891, 7888
3518, 7112, 7113, 7136, 7135, 7846, 7892, 7893, 7890
3519, 7113, 7114, 7137, 7136, 7848, 7894, 7895, 7892
3520, 7114, 7115, 7138, 7137, 7850, 7896, 7897, 7894
3521, 7115, 7116, 7139, 7138, 7852, 7898, 7899, 7896
3522, 7116, 7117, 7140, 7139, 7854, 7900, 7901, 7898
3523, 7117, 7118, 7141, 7140, 7856, 7902, 7903, 7900
3524, 7118, 7119, 7142, 7141, 7858, 7904, 7905, 7902
3525, 7119, 7120, 7143, 7142, 7860, 7906, 7907, 7904
3526, 7120, 7121, 7144, 7143, 7862, 7908, 7909, 7906
3527, 7121, 7122, 7145, 7144, 7864, 7910, 7911, 7908
3528, 7122, 7123, 7146, 7145, 7866, 7912, 7913, 7910
3529, 7123, 7124, 7147, 7146, 7868, 7914, 7915, 7912
3530, 7124, 643, 644, 7147, 7869, 667, 7916, 7914
3531, 408, 7125, 7148, 409, 7871, 7917, 7918, 432
3532, 7125, 7126, 7149, 7148, 7873, 7919, 7920, 7917
3533, 7126, 7127, 7150, 7149, 7875, 7921, 7922, 7919
3534, 7127, 7128, 7151, 7150, 7877, 7923, 7924, 7921
3535, 7128, 7129, 7152, 7151, 7879, 7925, 7926, 7923
3536, 7129, 7130, 7153, 7152, 7881, 7927, 7928, 7925
3537, 7130, 7131, 7154, 7153, 7883, 7929, 7930, 7927
3538, 7131, 7132, 7155, 7154, 7885, 7931, 7932, 7929
3539, 7132, 7133, 7156, 7155, 7887, 7933, 7934, 7931
3540, 7133, 7134, 7157, 7156, 7889, 7935, 7936, 7933
3541, 7134, 7135, 7158, 7157, 7891, 7937, 7938, 7935
3542, 7135, 7136, 7159, 7158, 7893, 7939, 7940, 7937
3543, 7136, 7137, 7160, 7159, 7895, 7941, 7942, 7939
3544, 7137, 7138, 7161, 7160, 7897, 7943, 7944, 7941
3545, 7138, 7139, 7162, 7161, 7899, 7945, 7946, 7943
3546, 7139, 7140, 7163, 7162, 7901, 7947, 7948, 7945
3547, 7140, 7141, 7164, 7163, 7903, 7949, 7950, 7947
3548, 7141, 7142, 7165, 7164, 7905, 7951, 7952, 7949
3549, 7142, 7143, 7166, 7165, 7907, 7953, 7954, 7951
3550, 7143, 7144, 7167, 7166, 7909, 7955, 7956, 7953
3551, 7144, 7145, 7168, 7167, 7911, 7957, 7958, 7955
3552, 7145, 7146, 7169, 7168, 7913, 7959, 7960, 7957
3553, 7146, 7147, 7170, 7169, 7915, 7961, 7962, 7959
3554, 7147, 644, 645, 7170, 7916, 668, 7963, 7961
3555, 409, 7148, 7171, 410, 7918, 7964, 7965, 433
3556, 7148, 7149, 7172, 7171, 7920, 7966, 7967, 7964
3557, 7149, 7150, 7173, 7172, 7922, 7968, 7969, 7966
3558, 7150, 7151, 7174, 7173, 7924, 7970, 7971, 7968
3559, 7151, 7152, 7175, 7174, 7926, 7972, 7973, 7970
3560, 7152, 7153, 7176, 7175, 7928, 7974, 7975, 7972
3561, 7153, 7154, 7177, 7176, 7930, 7976, 7977, 7974
3562, 7154, 7155, 7178, 7177, 7932, 7978, 7979, 7976
3563, 7155, 7156, 7179, 7178, 7934, 7980, 7981, 7978
3564, 7156, 7157, 7180, 7179, 7936, 7982, 7983, 7980
3565, 7157, 7158, 7181, 7180, 7938, 7984, 7985, 7982
3566, 7158, 7159, 7182, 7181, 7940, 7986, 7987, 7984
3567, 7159, 7160, 7183, 7182, 7942, 7988, 7989, 7986
3568, 7160, 7161, 7184, 7183, 7944, 7990, 7991, 7988
3569, 7161, 7162, 7185, 7184, 7946, 7992, 7993, 7990
3570, 7162, 7163, 7186, 7185, 7948, 7994, 7995, 7992
3571, 7163, 7164, 7187, 7186, 7950, 7996, 7997, 7994
3572, 7164, 7165, 7188, 7187, 7952, 7998, 7999, 7996
3573, 7165, 7166, 7189, 7188, 7954, 8000, 8001, 7998
3574, 7166, 7167, 7190, 7189, 7956, 8002, 8003, 8000
3575, 7167, 7168, 7191, 7190, 7958, 8004, 8005, 8002
3576, 7168, 7169, 7192, 7191, 7960, 8006, 8007, 8004
3577, 7169, 7170, 7193, 7192, 7962, 8008, 8009, 8006
3578, 7170, 645, 646, 7193, 7963, 669, 8010, 8008
3579, 410, 7171, 7194, 411, 7965, 8011, 8012, 434
3580, 7171, 7172, 7195, 7194, 7967, 8013, 8014, 8011
3581, 7172, 7173, 7196, 7195, 7969, 8015, 8016, 8013
3582, 7173, 7174, 7197, 7196, 7971, 8017, 8018, 8015
3583, 7174, 7175, 7198, 7197, 7973, 8019, 8020, 8017
3584, 7175, 7176, 7199, 7198, 7975, 8021, 8022, 8019
3585, 7176, 7177, 7200, 7199, 7977, 8023, 8024, 8021
3586, 7177, 7178, 7201, 7200, 7979, 8025, 8026, 8023
3587, 7178, 7179, 7202, 7201, 7981, 8027, 8028, 8025
3588, 7179, 7180, 7203, 7202, 7983, 8029, 8030, 8027
3589, 7180, 7181, 7204, 7203, 7985, 8031, 8032, 8029
3590, 7181, 7182, 7205, 7204, 7987, 8033, 8034, 8031
3591, 7182, 7183, 7206, 7205, 7989, 8035, 8036, 8033
3592, 7183, 7184, 7207, 7206, 7991, 8037, 8038, 8035
3593, 7184, 7185, 7208, 7207, 7993, 8039, 8040, 8037
3594, 7185, 7186, 7209, 7208, 7995, 8041, 8042, 8039
3595, 7186, 7187, 7210, 7209, 7997, 8043, 8044, 8041
3596, 7187, 7188, 7211, 7210, 7999, 8045, 8046, 8043
3597, 7188, 7189, 7212, 7211, 8001, 8047, 8048, 8045
3598, 7189, 7190, 7213, 7212, 8003, 8049, 8050, 8047
3599, 7190, 7191, 7214, 7213, 8005, 8051, 8052, 8049
3600, 7191, 7192, 7215, 7214, 8007, 8053, 8054, 8051
3601, 7192, 7193, 7216, 7215, 8009, 8055, 8056, 8053
3602, 7193, 646, 647, 7216, 8010, 670, 8057, 8055
3603, 411, 7194, 7217, 412, 8012, 8058, 8059, 435
3604, 7194, 7195, 7218, 7217, 8014, 8060, 8061, 8058
3605, 7195, 7196, 7219, 7218, 8016, 8062, 8063, 8060
3606, 7196, 7197, 7220, 7219, 8018, 8064, 8065, 8062
3607, 7197, 7198, 7221, 7220, 8020, 8066, 8067, 8064
3608, 7198, 7199, 7222, 7221, 8022, 8068, 8069, 8066
3609, 7199, 7200, 7223, 7222, 8024, 8070, 8071, 8068
3610, 7200, 7201, 7224, 7223, 8026, 8072, 8073, 8070
3611, 7201, 7202, 7225, 7224, 8028, 8074, 8075, 8072
3612, 7202, 7203, 7226, 7225, 8030, 8076, 8077, 8074
3613, 7203, 7204, 7227, 7226, 8032, 8078, 8079, 8076
3614, 7204, 7205, 7228, 7227, 8034, 8080, 8081, 8078
3615, 7205, 7206, 7229, 7228, 8036, 8082, 8083, 8080
3616, 7206, 7207, 7230, 7229, 8038, 8084, 8085, 8082
3617, 7207, 7208, 7231, 7230, 8040, 8086, 8087, 8084
3618, 7208, 7209, 7232, 7231, 8042, 8088, 8089, 8086
3619, 7209, 7210, 7233, 7232, 8044, 8090, 8091, 8088
3620, 7210, 7211, 7234, 7233, 8046, 8092, 8093, 8090
3621, 7211, 7212, 7235, 7234, 8048, 8094, 8095, 8092
3622, 7212, 7213, 7236, 7235, 8050, 8096, 8097, 8094
3623, 7213, 7214, 7237, 7236, 8052, 8098, 8099, 8096
3624, 7214, 7215, 7238, 7237, 8054, 8100, 8101, 8098
3625, 7215, 7216, 7239, 7238, 8056, 8102, 8103, 8100
3626, 7216, 647, 648, 7239, 8057, 671, 8104, 8102
3627, 412, 7217, 7240, 413, 8059, 8105, 8106, 436
3628, 7217, 7218, 7241, 7240, 8061, 8107, 8108, 8105
3629, 7218, 7219, 7242, 7241, 8063, 8109, 8110, 8107
3630, 7219, 7220, 7243, 7242, 8065, 8111, 8112, 8109
3631, 7220, 7221, 7244, 7243, 8067, 8113, 8114, 8111
3632, 7221, 7222, 7245, 7244, 8069, 8115, 8116, 8113
3633, 7222, 7223, 7246, 7245, 8071, 8117, 8118, 8115
3634, 7223, 7224, 7247, 7246, 8073, 8119, 8120, 8117
3635, 7224, 7225, 7248, 7247, 8075, 8121, 8122, 8119
3636, 7225, 7226, 7249, 7248, 8077, 8123, 8124, 8121
3637, 7226, 7227, 7250, 7249, 8079, 8125, 8126, 8123
3638, 7227, 7228, 7251, 7250, 8081, 8127, 8128, 8125
3639, 7228, 7229, 7252, 7251, 8083, 8129, 8130, 8127
3640, 7229, 7230, 7253, 7252, 8085, 8131, 8132, 8129
3641, 7230, 7231, 7254, 7253, 8087, 8133, 8134, 8131
3642, 7231, 7232, 7255, 7254, 8089, 8135, 8136, 8133
3643, 7232, 7233, 7256, 7255, 8091, 8137, 8138, 8135
3644, 7233, 7234, 7257, 7256, 8093, 8139, 8140, 8137
3645, 7234, 7235, 7258, 7257, 8095, 8141, 8142, 8139
3646, 7235, 7236, 7259, 7258, 8097, 8143, 8144, 8141
3647, 7236, 7237, 7260, 7259, 8099, 8145, 8146, 8143
3648, 7237, 7238, 7261, 7260, 8101, 8147, 8148, 8145
3649, 7238, 7239, 7262, 7261, 8103, 8149, 8150, 8147
3650, 7239, 648, 649, 7262, 8104, 672, 8151, 8149
3651, 413, 7240, 7263, 414, 8106, 8152, 8153, 437
3652, 7240, 7241, 7264, 7263, 8108, 8154, 8155, 8152
3653, 7241, 7242, 7265, 7264, 8110, 8156, 8157, 8154
3654, 7242, 7243, 7266, 7265, 8112, 8158, 8159, 8156
3655, 7243, 7244, 7267, 7266, 8114, 8160, 8161, 8158
3656, 7244, 7245, 7268, 7267, 8116, 8162, 8163, 8160
3657, 7245, 7246, 7269, 7268, 8118, 8164, 8165, 8162
3658, 7246, 7247, 7270, 7269, 8120, 8166, 8167, 8164
3659, 7247, 7248, 7271, 7270, 8122, 8168, 8169, 8166
3660, 7248, 7249, 7272, 7271, 8124, 8170, 8171, 8168
3661, 7249, 7250, 7273, 7272, 8126, 8172, 8173, 8170
3662, 7250, 7251, 7274, 7273, 8128, 8174, 8175, 8172
3663, 7251, 7252, 7275, 7274, 8130, 8176, 8177, 8174
3664, 7252, 7253, 7276, 7275, 8132, 8178, 8179, 8176
3665, 7253, 7254, 7277, 7276, 8134, 8180, 8181, 8178
3666, 7254, 7255, 7278, 7277, 8136, 8182, 8183, 8180
3667, 7255, 7256, 7279, 7278, 8138, 8184, 8185, 8182
3668, 7256, 7257, 7280, 7279, 8140, 8186, 8187, 8184
3669, 7257, 7258, 7281, 7280, 8142, 8188, 8189, 8186
3670, 7258, 7259, 7282, 7281, 8144, 8190, 8191, 8188
3671, 7259, 7260, 7283, 7282, 8146, 8192, 8193, 8190
3672, 7260, 7261, 7284, 7283, 8148, 8194, 8195, 8192
3673, 7261, 7262, 7285, 7284, 8150, 8196, 8197, 8194
3674, 7262, 649, 650, 7285, 8151, 673, 8198, 8196
3675, 414, 7263, 7286, 415, 8153, 8199, 8200, 438
3676, 7263, 7264, 7287, 7286, 8155, 8201, 8202, 8199
3677, 7264, 7265, 7288, 7287, 8157, 8203, 8204, 8201
3678, 7265, 7266, 7289, 7288, 8159, 8205, 8206, 8203
3679, 7266, 7267, 7290, 7289, 8161, 8207, 8208, 8205
3680, 7267, 7268, 7291, 7290, 8163, 8209, 8210, 8207
3681, 7268, 7269, 7292, 7291, 8165, 8211, 8212, 8209
3682, 7269, 7270, 7293, 7292, 8167, 8213, 8214, 8211
3683, 7270, 7271, 7294, 7293, 8169, 8215, 8216, 8213
3684, 7271, 7272, 7295, 7294, 8171, 8217, 8218, 8215
3685, 7272, 7273, 7296, 7295, 8173, 8219, 8220, 8217
3686, 7273, 7274, 7297, 7296, 8175, 8221, 8222, 8219
3687, 7274, 7275, 7298, 7297, 8177, 8223, 8224, 8221
3688, 7275, 7276, 7299, 7298, 8179, 8225, 8226, 8223
3689, 7276, 7277, 7300, 7299, 8181, 8227, 8228, 8225
3690, 7277, 7278, 7301, 7300, 8183, 8229, 8230, 8227
3691, 7278, 7279, 7302, 7301, 8185, 8231, 8232, 8229
3692, 7279, 7280, 7303, 7302, 8187, 8233, 8234, 8231
3693, 7280, 7281, 7304, 7303, 8189, 8235, 8236, 8233
3694, 7281, 7282, 7305, 7304, 8191, 8237, 8238, 8235
3695, 7282, 7283, 7306, 7305, 8193, 8239, 8240, 8237
3696, 7283, 7284, 7307, 7306, 8195, 8241, 8242, 8239
3697, 7284, 7285, 7308, 7307, 8197, 8243, 8244, 8241
3698, 7285, 650, 651, 7308, 8198, 674, 8245, 8243
3699, 415, 7286, 7309, 416, 8200, 8246, 8247, 439
3700, 7286, 7287, 7310, 7309, 8202, 8248, 8249, 8246
3701, 7287, 7288, 7311, 7310, 8204, 8250, 8251, 8248
3702, 7288, 7289, 7312, 7311, 8206, 8252, 8253, 8250
3703, 7289, 7290, 7313, 7312, 8208, 8254, 8255, 8252
3704, 7290, 7291, 7314, 7313, 8210, 8256, 8257, 8254
3705, 7291, 7292, 7315, 7314, 8212, 8258, 8259, 8256
3706, 7292, 7293, 7316, 7315, 8214, 8260, 8261, 8258
3707, 7293, 7294, 7317, 7316, 8216, 8262, 8263, 8260
3708, 7294, 7295, 7318, 7317, 8218, 8264, 8265, 8262
3709, 7295, 7296, 7319, 7318, 8220, 8266, 8267, 8264
3710, 7296, 7297, 7320, 7319, 8222, 8268, 8269, 8266
3711, 7297, 7298, 7321, 7320, 8224, 8270, 8271, 8268
3712, 7298, 7299, 7322, 7321, 8226, 8272, 8273, 8270
3713, 7299, 7300, 7323, 7322, 8228, 8274, 8275, 8272
3714, 7300, 7301, 7324, 7323, 8230, 8276, 8277, 8274
3715, 7301, 7302, 7325, 7324, 8232, 8278, 8279, 8276
3716, 7302, 7303, 7326, 7325, 8234, 8280, 8281, 8278
3717, 7303, 7304, 7327, 7326, 8236, 8282, 8283, 8280
3718, 7304, 7305, 7328, 7327, 8238, 8284, 8285, 8282
3719, 7305, 7306, 7329, 7328, 8240, 8286, 8287, 8284
3720, 7306, 7307, 7330, 7329, 8242, 8288, 8289, 8286
3721, 7307, 7308, 7331, 7330, 8244, 8290, 8291, 8288
3722, 7308, 651, 652, 7331, 8245, 675, 8292, 8290
3723, 416, 7309, 7332, 417, 8247, 8293, 8294, 440
3724, 7309, 7310, 7333, 7332, 8249, 8295, 8296, 8293
3725, 7310, 7311, 7334, 7333, 8251, 8297, 8298, 8295
3726, 7311, 7312, 7335, 7334, 8253, 8299, 8300, 8297
3727, 7312, 7313, 7336, 7335, 8255, 8301, 8302, 8299
3728, 7313, 7314, 7337, 7336, 8257, 8303, 8304, 8301
3729, 7314, 7315, 7338, 7337, 8259, 8305, 8306, 8303
3730, 7315, 7316, 7339, 7338, 8261, 8307, 8308, 8305
3731, 7316, 7317, 7340, 7339, 8263, 8309, 8310, 8307
3732, 7317, 7318, 7341, 7340, 8265, 8311, 8312, 8309
3733, 7318, 7319, 7342, 7341, 8267, 8313, 8314, 8311
3734, 7319, 7320, 7343, 7342, 8269, 8315, 8316, 8313
3735, 7320, 7321, 7344, 7343, 8271, 8317, 8318, 8315
3736, 7321, 7322, 7345, 7344, 8273, 8319, 8320, 8317
3737, 7322, 7323, 7346, 7345, 8275, 8321, 8322, 8319
3738, 7323, 7324, 7347, 7346, 8277, 8323, 8324, 8321
3739, 7324, 7325, 7348, 7347, 8279, 8325, 8326, 8323
3740, 7325, 7326, 7349, 7348, 8281, 8327, 8328, 8325
3741, 7326, 7327, 7350, 7349, 8283, 8329, 8330, 8327
3742, 7327, 7328, 7351, 7350, 8285, 8331, 8332, 8329
3743, 7328, 7329, 7352, 7351, 8287, 8333, 8334, 8331
3744, 7329, 7330, 7353, 7352, 8289, 8335, 8336, 8333
3745, 7330, 7331, 7354, 7353, 8291, 8337, 8338, 8335
3746, 7331, 652, 653, 7354, 8292, 676, 8339, 8337
3747, 417, 7332, 7355, 418, 8294, 8340, 8341, 441
3748, 7332, 7333, 7356, 7355, 8296, 8342, 8343, 8340
3749, 7333, 7334, 7357, 7356, 8298, 8344, 8345, 8342
3750, 7334, 7335, 7358, 7357, 8300, 8346, 8347, 8344
3751, 7335, 7336, 7359, 7358, 8302, 8348, 8349, 8346
3752, 7336, 7337, 7360, 7359, 8304, 8350, 8351, 8348
3753, 7337, 7338, 7361, 7360, 8306, 8352, 8353, 8350
3754, 7338, 7339, 7362, 7361, 8308, 8354, 8355, 8352
3755, 7339, 7340, 7363, 7362, 8310, 8356, 8357, 8354
3756, 7340, 7341, 7364, 7363, 8312, 8358, 8359, 8356
3757, 7341, 7342, 7365, 7364, 8314, 8360, 8361, 8358
3758, 7342, 7343, 7366, 7365, 8316, 8362, 8363, 8360
3759, 7343, 7344, 7367, 7366, 8318, 8364, 8365, 8362
3760, 7344, 7345, 7368, 7367, 8320, 8366, 8367, 8364
3761, 7345, 7346, 7369, 7368, 8322, 8368, 8369, 8366
3762, 7346, 7347, 7370, 7369, 8324, 8370, 8371, 8368
3763, 7347, 7348, 7371, 7370, 8326, 8372, 8373, 8370
3764, 7348, 7349, 7372, 7371, 8328, 8374, 8375, 8372
3765, 7349, 7350, 7373, 7372, 8330, 8376, 8377, 8374
3766, 7350, 7351, 7374, 7373, 8332, 8378, 8379, 8376
3767, 7351, 7352, 7375, 7374, 8334, 8380, 8381, 8378
3768, 7352, 7353, 7376, 7375, 8336, 8382, 8383, 8380
3769, 7353, 7354, 7377, 7376, 8338, 8384, 8385, 8382
3770, 7354, 653, 654, 7377, 8339, 677, 8386, 8384
3771, 418, 7355, 7378, 419, 8341, 8387, 8388, 442
3772, 7355, 7356, 7379, 7378, 8343, 8389, 8390, 8387
3773, 7356, 7357, 7380, 7379, 8345, 8391, 8392, 8389
3774, 7357, 7358, 7381, 7380, 8347, 8393, 8394, 8391
3775, 7358, 7359, 7382, 7381, 8349, 8395, 8396, 8393
3776, 7359, 7360, 7383, 7382, 8351, 8397, 8398, 8395
3777, 7360, 7361, 7384, 7383, 8353, 8399, 8400, 8397
3778, 7361, 7362, 7385, 7384, 8355, 8401, 8402, 8399
3779, 7362, 7363, 7386, 7385, 8357, 8403, 8404, 8401
3780, 7363, 7364, 7387, 7386, 8359, 8405, 8406, 8403
3781, 7364, 7365, 7388, 7387, 8361, 8407, 8408, 8405
3782, 7365, 7366, 7389, 7388, 8363, 8409, 8410, 8407
3783, 7366, 7367, 7390, 7389, 8365, 8411, 8412, 8409
3784, 7367, 7368, 7391, 7390, 8367, 8413, 8414, 8411
3785, 7368, 7369, 7392, 7391, 8369, 8415, 8416, 8413
3786, 7369, 7370, 7393, 7392, 8371, 8417, 8418, 8415
3787, 7370, 7371, 7394, 7393, 8373, 8419, 8420, 8417
3788, 7371, 7372, 7395, 7394, 8375, 8421, 8422, 8419
3789, 7372, 7373, 7396, 7395, 8377, 8423, 8424, 8421
3790, 7373, 7374, 7397, 7396, 8379, 8425, 8426, 8423
3791, 7374, 7375, 7398, 7397, 8381, 8427, 8428, 8425
3792, 7375, 7376, 7399, 7398, 8383, 8429, 8430, 8427
3793, 7376, 7377, 7400, 7399, 8385, 8431, 8432, 8429
3794, 7377, 654, 655, 7400, 8386, 678, 8433, 8431
3795, 419, 7378, 7401, 420, 8388, 8434, 8435, 443
3796, 7378, 7379, 7402, 7401, 8390, 8436, 8437, 8434
3797, 7379, 7380, 7403, 7402, 8392, 8438, 8439, 8436
3798, 7380, 7381, 7404, 7403, 8394, 8440, 8441, 8438
3799, 7381, 7382, 7405, 7404, 8396, 8442, 8443, 8440
3800, 7382, 7383, 7406, 7405, 8398, 8444, 8445, 8442
3801, 7383, 7384, 7407, 7406, 8400, 8446, 8447, 8444
3802, 7384, 7385, 7408, 7407, 8402, 8448, 8449, 8446
3803, 7385, 7386, 7409, 7408, 8404, 8450, 8451, 8448
3804, 7386, 7387, 7410, 7409, 8406, 8452, 8453, 8450
3805, 7387, 7388, 7411, 7410, 8408, 8454, 8455, 8452
3806, 7388, 7389, 7412, 7411, 8410, 8456, 8457, 8454
3807, 7389, 7390, 7413, 7412, 8412, 8458, 8459, 8456
3808, 7390, 7391, 7414, 7413, 8414, 8460, 8461, 8458
3809, 7391, 7392, 7415, 7414, 8416, 8462, 8463, 8460
3810, 7392, 7393, 7416, 7415, 8418, 8464, 8465, 8462
3811, 7393, 7394, 7417, 7416, 8420, 8466, 8467, 8464
3812, 7394, 7395, 7418, 7417, 8422, 8468, 8469, 8466
3813, 7395, 7396, 7419, 7418, 8424, 8470, 8471, 8468
3814, 7396, 7397, 7420, 7419, 8426, 8472, 8473, 8470
3815, 7397, 7398, 7421, 7420, 8428, 8474, 8475, 8472
3816, 7398, 7399, 7422, 7421, 8430, 8476, 8477, 8474
3817, 7399, 7400, 7423, 7422, 8432, 8478, 8479, 8476
3818, 7400, 655, 656, 7423, 8433, 679, 8480, 8478
3819, 420, 7401, 7424, 421, 8435, 8481, 8482, 444
3820, 7401, 7402, 7425, 7424, 8437, 8483, 8484, 8481
3821, 7402, 7403, 7426, 7425, 8439, 8485, 8486, 8483
3822, 7403, 7404, 7427, 7426, 8441, 8487, 8488, 8485
3823, 7404, 7405, 7428, 7427, 8443, 8489, 8490, 8487
3824, 7405, 7406, 7429, 7428, 8445, 8491, 8492, 8489
3825, 7406, 7407, 7430, 7429, 8447, 8493, 8494, 8491
3826, 7407, 7408, 7431, 7430, 8449, 8495, 8496, 8493
3827, 7408, 7409, 7432, 7431, 8451, 8497, 8498, 8495
3828, 7409, 7410, 7433, 7432, 8453, 8499, 8500, 8497
3829, 7410, 7411, 7434, 7433, 8455, 8501, 8502, 8499
3830, 7411, 7412, 7435, 7434, 8457, 8503, 8504, 8501
3831, 7412, 7413, 7436, 7435, 8459, 8505, 8506, 8503
3832, 7413, 7414, 7437, 7436, 8461, 8507, 8508, 8505
3833, 7414, 7415, 7438, 7437, 8463, 8509, 8510, 8507
3834, 7415, 7416, 7439, 7438, 8465, 8511, 8512, 8509
3835, 7416, 7417, 7440, 7439, 8467, 8513, 8514, 8511
3836, 7417, 7418, 7441, 7440, 8469, 8515, 8516, 8513
3837, 7418, 7419, 7442, 7441, 8471, 8517, 8518, 8515
3838, 7419, 7420, 7443, 7442, 8473, 8519, 8520, 8517
3839, 7420, 7421, 7444, 7443, 8475, 8521, 8522, 8519
3840, 7421, 7422, 7445, 7444, 8477, 8523, 8524, 8521
3841, 7422, 7423, 7446, 7445, 8479, 8525, 8526, 8523
3842, 7423, 656, 657, 7446, 8480, 680, 8527, 8525
3843, 421, 7424, 541, 9, 8482, 8528, 564, 445
3844, 7424, 7425, 542, 541, 8484, 8529, 565, 8528
3845, 7425, 7426, 543, 542, 8486, 8530, 566, 8529
3846, 7426, 7427, 544, 543, 8488, 8531, 567, 8530
3847, 7427, 7428, 545, 544, 8490, 8532, 568, 8531
3848, 7428, 7429, 546, 545, 8492, 8533, 569, 8532
3849, 7429, 7430, 547, 546, 8494, 8534, 570, 8533
3850, 7430, 7431, 548, 547, 8496, 8535, 571, 8534
3851, 7431, 7432, 549, 548, 8498, 8536, 572, 8535
3852, 7432, 7433, 550, 549, 8500, 8537, 573, 8536
3853, 7433, 7434, 551, 550, 8502, 8538, 574, 8537
3854, 7434, 7435, 552, 551, 8504, 8539, 575, 8538
3855, 7435, 7436, 553, 552, 8506, 8540, 576, 8539
3856, 7436, 7437, 554, 553, 8508, 8541, 577, 8540
3857, 7437, 7438, 555, 554, 8510, 8542, 578, 8541
3858, 7438, 7439, 556, 555, 8512, 8543, 579, 8542
3859, 7439, 7440, 557, 556, 8514, 8544, 580, 8543
3860, 7440, 7441, 558, 557, 8516, 8545, 581, 8544
3861, 7441, 7442, 559, 558, 8518, 8546, 582, 8545
3862, 7442, 7443, 560, 559, 8520, 8547, 583, 8546
3863, 7443, 7444, 561, 560, 8522, 8548, 584, 8547
3864, 7444, 7445, 562, 561, 8524, 8549, 585, 8548
3865, 7445, 7446, 563, 562, 8526, 8550, 586, 8549
3866, 7446, 657, 13, 563, 8527, 681, 587, 8550
*ELEMENT, type=CPS8, ELSET=Surface13
3867, 9, 541, 8551, 447, 564, 8804, 8805, 458
3868, 541, 542, 8552, 8551, 565, 8806, 8807, 8804
3869, 542, 543, 8553, 8552, 566, 8808, 8809, 8806
3870, 543, 544, 8554, 8553, 567, 8810, 8811, 8808
3871, 544, 545, 8555, 8554, 568, 8812, 8813, 8810
3872, 545, 546, 8556, 8555, 569, 8814, 8815, 8812
3873, 546, 547, 8557, 8556, 570, 8816, 8817, 8814
3874, 547, 548, 8558, 8557, 571, 8818, 8819, 8816
3875, 548, 549, 8559, 8558, 572, 8820, 8821, 8818
3876, 549, 550, 8560, 8559, 573, 8822, 8823, 8820
3877, 550, 551, 8561, 8560, 574, 8824, 8825, 8822
3878, 551, 552, 8562, 8561, 575, 8826, 8827, 8824
3879, 552, 553, 8563, 8562, 576, 8828, 8829, 8826
3880, 553, 554, 8564, 8563, 577, 8830, 8831, 8828
3881, 554, 555, 8565, 8564, 578, 8832, 8833, 8830
3882, 555, 556, 8566, 8565, 579, 8834, 8835, 8832
3883, 556, 557, 8567, 8566, 580, 8836, 8837, 8834
3884, 557, 558, 8568, 8567, 581, 8838, 8839, 8836
3885, 558, 559, 8569, 8568, 582, 8840, 8841, 8838
3886, 559, 560, 8570, 8569, 583, 8842, 8843, 8840
3887, 560, 561, 8571, 8570, 584, 8844, 8845, 8842
3888, 561, 562, 8572, 8571, 585, 8846, 8847, 8844
3889, 562, 563, 8573, 8572, 586, 8848, 8849, 8846
3890, 563, 13, 729, 8573, 587, 740, 8850, 8848
3891, 447, 8551, 8574, 448, 8805, 8851, 8852, 459
3892, 8551, 8552, 8575, 8574, 8807, 8853, 8854, 8851
3893, 8552, 8553, 8576, 8575, 8809, 8855, 8856, 8853
3894, 8553, 8554, 8577, 8576, 8811, 8857, 8858, 8855
3895, 8554, 8555, 8578, 8577, 8813, 8859, 8860, 8857
3896, 8555, 8556, 8579, 8578, 8815, 8861, 8862, 8859
3897, 8556, 8557, 8580, 8579, 8817, 8863, 8864, 8861
3898, 8557, 8558, 8581, 8580, 8819, 8865, 8866, 8863
3899, 8558, 8559, 8582, 8581, 8821, 8867, 8868, 8865
3900, 8559, 8560, 8583, 8582, 8823, 8869, 8870, 8867
3901, 8560, 8561, 8584, 8583, 8825, 8871, 8872, 8869
3902, 8561, 8562, 8585, 8584, 8827, 8873, 8874, 8871
3903, 8562, 8563, 8586, 8585, 8829, 8875, 8876, 8873
3904, 8563, 8564, 8587, 8586, 8831, 8877, 8878, 8875
3905, 8564, 8565, 8588, 8587, 8833, 8879, 8880, 8877
3906, 8565, 8566, 8589, 8588, 8835, 8881, 8882, 8879
3907, 8566, 8567, 8590, 8589, 8837, 8883, 8884, 8881
3908, 8567, 8568, 8591, 8590, 8839, 8885, 8886, 8883
3909, 8568, 8569, 8592, 8591, 8841, 8887, 8888, 8885
3910, 8569, 8570, 8593, 8592, 8843, 8889, 8890, 8887
3911, 8570, 8571, 8594, 8593, 8845, 8891, 8892, 8889
3912, 8571, 8572, 8595, 8594, 8847, 8893, 8894, 8891
3913, 8572, 8573, 8596, 8595, 8849, 8895, 8896, 8893
3914, 8573, 729, 730, 8596, 8850, 741, 8897, 8895
3915, 448, 8574, 8597, 449, 8852, 8898, 8899, 460
3916, 8574, 8575, 8598, 8597, 8854, 8900, 8901, 8898
3917, 8575, 8576, 8599, 8598, 8856, 8902, 8903, 8900
3918, 8576, 8577, 8600, 8599, 8858, 8904, 8905, 8902
3919, 8577, 8578, 8601, 8600, 8860, 8906, 8907, 8904
3920, 8578, 8579, 8602, 8601, 8862, 8908, 8909, 8906
3921, 8579, 8580, 8603, 8602, 8864, 8910, 8911, 8908
3922, 8580, 8581, 8604, 8603, 8866, 8912, 8913, 8910
3923, 8581, 8582, 8605, 8604, 8868, 8914, 8915, 8912
3924, 8582, 8583, 8606, 8605, 8870, 8916, 8917, 8914
3925, 8583, 8584, 8607, 8606, 8872, 8918, 8919, 8916
3926, 8584, 8585, 8608, 8607, 8874, 8920, 8921, 8918
3927, 8585, 8586, 8609, 8608, 8876, 8922, 8923, 8920
3928, 8586, 8587, 8610, 8609, 8878, 8924, 8925, 8922
3929, 8587, 8588, 8611, 8610, 8880, 8926, 8927, 8924
3930, 8588, 8589, 8612, 8611, 8882, 8928, 8929, 8926
3931, 8589, 8590, 8613, 8612, 8884, 8930, 8931, 8928
3932, 8590, 8591, 8614, 8613, 8886, 8932, 8933, 8930
3933, 8591, 8592, 8615, 8614, 8888, 8934, 8935, 8932
3934, 8592, 8593, 8616, 8615, 8890, 8936, 8937, 8934
3935, 8593, 8594, 8617, 8616, 8892, 8938, 8939, 8936
3936, 8594, 8595, 8618, 8617, 8894, 8940, 8941, 8938
3937, 8595, 8596, 8619, 8618, 8896, 8942, 8943, 8940
3938, 8596, 730, 731, 8619, 8897, 742, 8944, 8942
3939, 449, 8597, 8620, 450, 8899, 8945, 8946, 461
3940, 8597, 8598, 8621, 8620, 8901, 8947, 8948, 8945
3941, 8598, 8599, 8622, 8621, 8903, 8949, 8950, 8947
3942, 8599, 8600, 8623, 8622, 8905, 8951, 8952, 8949
3943, 8600, 8601, 8624, 8623, 8907, 8953, 8954, 8951
3944, 8601, 8602, 8625, 8624, 8909, 8955, 8956, 8953
3945, 8602, 8603, 8626, 8625, 8911, 8957, 8958, 8955
3946, 8603, 8604, 8627, 8626, 8913, 8959, 8960, 8957
3947, 8604, 8605, 8628, 8627, 8915, 8961, 8962, 8959
3948, 8605, 8606, 8629, 8628, 8917, 8963, 8964, 8961
3949, 8606, 8607, 8630, 8629, 8919, 8965, 8966, 8963
3950, 8607, 8608, 8631, 8630, 8921, 8967, 8968, 8965
3951, 8608, 8609, 8632, 8631, 8923, 8969, 8970, 8967
3952, 8609, 8610, 8633, 8632, 8925, 8971, 8972, 8969
3953, 8610, 8611, 8634, 8633, 8927, 8973, 8974, 8971
3954, 8611, 8612, 8635, 8634, 8929, 8975, 8976, 8973
3955, 8612, 8613, 8636, 8635, 8931, 8977, 8978, 8975
3956, 8613, 8614, 8637, 8636, 8933, 8979, 8980, 8977
3957, 8614, 8615, 8638, 8637, 8935, 8981, 8982, 8979
3958, 8615, 8616, 8639, 8638, 8937, 8983, 8984, 8981
3959, 8616, 8617, 8640, 8639, 8939, 8985, 8986, 8983
3960, 8617, 8618, 8641, 8640, 8941, 8987, 8988, 8985
3961, 8618, 8619, 8642, 8641, 8943, 8989, 8990, 8987
3962, 8619, 731, 732, 8642, 8944, 743, 8991, 8989
3963, 450, 8620, 8643, 451, 8946, 8992, 8993, 462
3964, 8620, 8621, 8644, 8643, 8948, 8994, 8995, 8992
3965, 8621, 8622, 8645, 8644, 8950, 8996, 8997, 8994
3966, 8622, 8623, 8646, 8645, 8952, 8998, 8999, 8996
3967, 8623, 8624, 8647, 8646, 8954, 9000, 9001, 8998
3968, 8624, 8625, 8648, 8647, 8956, 9002, 9003, 9000
3969, 8625, 8626, 8649, 8648, 8958, 9004, 9005, 9002
3970, 8626, 8627, 8650, 8649, 8960, 9006, 9007, 9004
3971, 8627, 8628, 8651, 8650, 8962, 9008, 9009, 9006
3972, 8628, 8629, 8652, 8651, 8964, 9010, 9011, 9008
3973, 8629, 8630, 8653, 8652, 8966, 9012, 9013, 9010
3974, 8630, 8631, 8654, 8653, 8968, 9014, 9015, 9012
3975, 8631, 8632, 8655, 8654, 8970, 9016, 9017, 9014
3976, 8632, 8633, 8656, 8655, 8972, 9018, 9019, 9016
3977, 8633, 8634, 8657, 8656, 8974, 9020, 9021, 9018
3978, 8634, 8635, 8658, 8657, 8976, 9022, 9023, 9020
3979, 8635, 8636, 8659, 8658, 8978, 9024, 9025, 9022
3980, 8636, 8637, 8660, 8659, 8980, 9026, 9027, 9024
3981, 8637, 8638, 8661, 8660, 8982, 9028, 9029, 9026
3982, 8638, 8639, 8662, 8661, 8984, 9030, 9031, 9028
3983, 8639, 8640, 8663, 8662, 8986, 9032, 9033, 9030
3984, 8640, 8641, 8664, 8663, 8988, 9034, 9035, 9032
3985, 8641, 8642, 8665, 8664, 8990, 9036, 9037, 9034
3986, 8642, 732, 733, 8665, 8991, 744, 9038, 9036
3987, 451, 8643, 8666, 452, 8993, 9039, 9040, 463
3988, 8643, 8644, 8667, 8666, 8995, 9041, 9042, 9039
3989, 8644, 8645, 8668, 8667, 8997, 9043, 9044, 9041
3990, 8645, 8646, 8669, 8668, 8999, 9045, 9046, 9043
3991, 8646, 8647, 8670, 8669, 9001, 9047, 9048, 9045
3992, 8647, 8648, 8671, 8670, 9003, 9049, 9050, 9047
3993, 8648, 8649, 8672, 8671, 9005, 9051, 9052, 9049
3994, 8649, 8650, 8673, 8672, 9007, 9053, 9054, 9051
3995, 8650, 8651, 8674, 8673, 9009, 9055, 9056, 9053
3996, 8651, 8652, 8675, 8674, 9011, 9057, 9058, 9055
3997, 8652, 8653, 8676, 8675, 9013, 9059, 9060, 9057
3998, 8653, 8654, 8677, 8676, 9015, 9061, 9062, 9059
3999, 8654, 8655, 8678, 8677, 9017, 9063, 9064, 9061
4000, 8655, 8656, 8679, 8678, 9019, 9065, 9066, 9063
4001, 8656, 8657, 8680, 8679, 9021, 9067, 9068, 9065
4002, 8657, 8658, 8681, 8680, 9023, 9069, 9070, 9067
4003, 8658, 8659, 8682, 8681, 9025, 9071, 9072, 9069
4004, 8659, 8660, 8683, 8682, 9027, 9073, 9074, 9071
4005, 8660, 8661, 8684, 8683, 9029, 9075, 9076, 9073
4006, 8661, 8662, 8685, 8684, 9031, 9077, 9078, 9075
4007, 8662, 8663, 8686, 8685, 9033, 9079, 9080, 9077
4008, 8663, 8664, 8687, 8686, 9035, 9081, 9082, 9079
4009, 8664, 8665, 8688, 8687, 9037, 9083, 9084, 9081
4010, 8665, 733, 734, 8688, 9038, 745, 9085, 9083
4011, 452, 8666, 8689, 453, 9040, 9086, 9087, 464
4012, 8666, 8667, 8690, 8689, 9042, 9088, 9089, 9086
4013, 8667, 8668, 8691, 8690, 9044, 9090, 9091, 9088
4014, 8668, 8669, 8692, 8691, 9046, 9092, 9093, 9090
4015, 8669, 8670, 8693, 8692, 9048, 9094, 9095, 9092
4016, 8670, 8671, 8694, 8693, 9050, 9096, 9097, 9094
4017, 8671, 8672, 8695, 8694, 9052, 9098, 9099, 9096
4018, 8672, 8673, 8696, 8695, 9054, 9100, 9101, 9098
4019, 8673, 8674, 8697, 8696, 9056, 9102, 9103, 9100
4020, 8674, 8675, 8698, 8697, 9058, 9104, 9105, 9102
4021, 8675, 8676, 8699, 8698, 9060, 9106, 9107, 9104
4022, 8676, 8677, 8700, 8699, 9062, 9108, 9109, 9106
4023, 8677, 8678, 8701, 8700, 9064, 9110, 9111, 9108
4024, 8678, 8679, 8702, 8701, 9066, 9112, 9113, 9110
4025, 8679, 8680, 8703, 8702, 9068, 9114, 9115, 9112
4026, 8680, 8681, 8704, 8703, 9070, 9116, 9117, 9114
4027, 8681, 8682, 8705, 8704, 9072, 9118, 9119, 9116
4028, 8682, 8683, 8706, 8705, 9074, 9120, 9121, 9118
4029, 8683, 8684, 8707, 8706, 9076, 9122, 9123, 9120
4030, 8684, 8685, 8708, 8707, 9078, 9124, 9125, 9122
4031, 8685, 8686, 8709, 8708, 9080, 9126, 9127, 9124
4032, 8686, 8687, 8710, 8709, 9082, 9128, 9129, 9126
4033, 8687, 8688, 8711, 8710, 9084, 9130, 9131, 9128
4034, 8688, 734, 735, 8711, 9085, 746, 9132, 9130
4035, 453, 8689, 8712, 454, 9087, 9133, 9134, 465
4036, 8689, 8690, 8713, 8712, 9089, 9135, 9136, 9133
4037, 8690, 8691, 8714, 8713, 9091, 9137, 9138, 9135
4038, 8691, 8692, 8715, 8714, 9093, 9139, 9140, 9137
4039, 8692, 8693, 8716, 8715, 9095, 9141, 9142, 9139
4040, 8693, 8694, 8717, 8716, 9097, 9143, 9144, 9141
4041, 8694, 8695, 8718, 8717, 9099, 9145, 9146, 9143
4042, 8695, 8696, 8719, 8718, 9101, 9147, 9148, 9145
4043, 8696, 8697, 8720, 8719, 9103, 9149, 9150, 9147
4044, 8697, 8698, 8721, 8720, 9105, 9151, 9152, 9149
4045, 8698, 8699, 8722, 8721, 9107, 9153, 9154, 9151
4046, 8699, 8700, 8723, 8722, 9109, 9155, 9156, 9153
4047, 8700, 8701, 8724, 8723, 9111, 9157, 9158, 9155
4048, 8701, 8702, 8725, 8724, 9113, 9159, 9160, 9157
4049, 8702, 8703, 8726, 8725, 9115, 9161, 9162, 9159
4050, 8703, 8704, 8727, 8726, 9117, 9163, 9164, 9161
4051, 8704, 8705, 8728, 8727, 9119, 9165, 9166, 9163
4052, 8705, 8706, 8729, 8728, 9121, 9167, 9168, 9165
4053, 8706, 8707, 8730, 8729, 9123, 9169, 9170, 9167
4054, 8707, 8708, 8731, 8730, 9125, 9171, 9172, 9169
4055, 8708, 8709, 8732, 8731, 9127, 9173, 9174, 9171
4056, 8709, 8710, 8733, 8732, 9129, 9175, 9176, 9173
4057, 8710, 8711, 8734, 8733, 9131, 9177, 9178, 9175
4058, 8711, 735, 736, 8734, 9132, 747, 9179, 9177
4059, 454, 8712, 8735, 455, 9134, 9180, 9181, 466
4060, 8712, 8713, 8736, 8735, 9136, 9182, 9183, 9180
4061, 8713, 8714, 8737, 8736, 9138, 9184, 9185, 9182
4062, 8714, 8715, 8738, 8737, 9140, 9186, 9187, 9184
4063, 8715, 8716, 8739, 8738, 9142, 9188, 9189, 9186
4064, 8716, 8717, 8740, 8739, 9144, 9190, 9191, 9188
4065, 8717, 8718, 8741, 8740, 9146, 9192, 9193, 9190
4066, 8718, 8719, 8742, 8741, 9148, 9194, 9195, 9192
4067, 8719, 8720, 8743, 8742, 9150, 9196, 9197, 9194
4068, 8720, 8721, 8744, 8743, 9152, 9198, 9199, 9196
4069, 8721, 8722, 8745, 8744, 9154, 9200, 9201, 9198
4070, 8722, 8723, 8746, 8745, 9156, 9202, 9203, 9200
4071, 8723, 8724, 8747, 8746, 9158, 9204, 9205, 9202
4072, 8724, 8725, 8748, 8747, 9160, 9206, 9207, 9204
4073, 8725, 8726, 8749, 8748, 9162, 9208, 9209, 9206
4074, 8726, 8727, 8750, 8749, 9164, 9210, 9211, 9208
4075, 8727, 8728, 8751, 8750, 9166, 9212, 9213, 9210
4076, 8728, 8729, 8752, 8751, 9168, 9214, 9215, 9212
4077, 8729, 8730, 8753, 8752, 9170, 9216, 9217, 9214
4078, 8730, 8731, 8754, 8753, 9172, 9218, 9219, 9216
4079, 8731, 8732, 8755, 8754, 9174, 9220, 9221, 9218
4080, 8732, 8733, 8756, 8755, 9176, 9222, 9223, 9220
4081, 8733, 8734, 8757, 8756, 9178, 9224, 9225, 9222
4082, 8734, 736, 737, 8757, 9179, 748, 9226, 9224
4083, 455, 8735, 8758, 456, 9181, 9227, 9228, 467
4084, 8735, 8736, 8759, 8758, 9183, 9229, 9230, 9227
4085, 8736, 8737, 8760, 8759, 9185, 9231, 9232, 9229
4086, 8737, 8738, 8761, 8760, 9187, 9233, 9234, 9231
4087, 8738, 8739, 8762, 8761, 9189, 9235, 9236, 9233
4088, 8739, 8740, 8763, 8762, 9191, 9237, 9238, 9235
4089, 8740, 8741, 8764, 8763, 9193, 9239, 9240, 9237
4090, 8741, 8742, 8765, 8764, 9195, 9241, 9242, 9239
4091, 8742, 8743, 8766, 8765, 9197, 9243, 9244, 9241
4092, 8743, 8744, 8767, 8766, 9199, 9245, 9246, 9243
4093, 8744, 8745, 8768, 8767, 9201, 9247, 9248, 9245
4094, 8745, 8746, 8769, 8768, 9203, 9249, 9250, 9247
4095, 8746, 8747, 8770, 8769, 9205, 9251, 9252, 9249
4096, 8747, 8748, 8771, 8770, 9207, 9253, 9254, 9251
4097, 8748, 8749, 8772, 8771, 9209, 9255, 9256, 9253
4098, 8749, 8750, 8773, 8772, 9211, 9257, 9258, 9255
4099, 8750, 8751, 8774, 8773, 9213, 9259, 9260, 9257
4100, 8751, 8752, 8775, 8774, 9215, 9261, 9262, 9259
4101, 8752, 8753, 8776, 8775, 9217, 9263, 9264, 9261
4102, 8753, 8754, 8777, 8776, 9219, 9265, 9266, 9263
4103, 8754, 8755, 8778, 8777, 9221, 9267, 9268, 9265
4104, 8755, 8756, 8779, 8778, 9223, 9269, 9270, 9267
4105, 8756, 8757, 8780, 8779, 9225, 9271, 9272, 9269
4106, 8757, 737, 738, 8780, 9226, 749, 9273, 9271
4107, 456, 8758, 8781, 457, 9228, 9274, 9275, 468
4108, 8758, 8759, 8782, 8781, 9230, 9276, 9277, 9274
4109, 8759, 8760, 8783, 8782, 9232, 9278, 9279, 9276
4110, 8760, 8761, 8784, 8783, 9234, 9280, 9281, 9278
4111, 8761, 8762, 8785, 8784, 9236, 9282, 9283, 9280
4112, 8762, 8763, 8786, 8785, 9238, 9284, 9285, 9282
4113, 8763, 8764, 8787, 8786, 9240, 9286, 9287, 9284
4114, 8764, 8765, 8788, 8787, 9242, 9288, 9289, 9286
4115, 8765, 8766, 8789, 8788, 9244, 9290, 9291, 9288
4116, 8766, 8767, 8790, 8789, 9246, 9292, 9293, 9290
4117, 8767, 8768, 8791, 8790, 9248, 9294, 9295, 9292
4118, 8768, 8769, 8792, 8791, 9250, 9296, 9297, 9294
4119, 8769, 8770, 8793, 8792, 9252, 9298, 9299, 9296
4120, 8770, 8771, 8794, 8793, 9254, 9300, 9301, 9298
4121, 8771, 8772, 8795, 8794, 9256, 9302, 9303, 9300
4122, 8772, 8773, 8796, 8795, 9258, 9304, 9305, 9302
4123, 8773, 8774, 8797, 8796, 9260, 9306, 9307, 9304
4124, 8774, 8775, 8798, 8797, 9262, 9308, 9309, 9306
4125, 8775, 8776, 8799, 8798, 9264, 9310, 9311, 9308
4126, 8776, 8777, 8800, 8799, 9266, 9312, 9313, 9310
4127, 8777, 8778, 8801, 8800, 9268, 9314, 9315, 9312
4128, 8778, 8779, 8802, 8801, 9270, 9316, 9317, 9314
4129, 8779, 8780, 8803, 8802, 9272, 9318, 9319, 9316
4130, 8780, 738, 739, 8803, 9273, 750, 9320, 9318
4131, 457, 8781, 682, 11, 9275, 9321, 705, 469
4132, 8781, 8782, 683, 682, 9277, 9322, 706, 9321
4133, 8782, 8783, 684, 683, 9279, 9323, 707, 9322
4134, 8783, 8784, 685, 684, 9281, 9324, 708, 9323
4135, 8784, 8785, 686, 685, 9283, 9325, 709, 9324
4136, 8785, 8786, 687, 686, 9285, 9326, 710, 9325
4137, 8786, 8787, 688, 687, 9287, 9327, 711, 9326
4138, 8787, 8788, 689, 688, 9289, 9328, 712, 9327
4139, 8788, 8789, 690, 689, 9291, 9329, 713, 9328
4140, 8789, 8790, 691, 690, 9293, 9330, 714, 9329
4141, 8790, 8791, 692, 691, 9295, 9331, 715, 9330
4142, 8791, 8792, 693, 692, 9297, 9332, 716, 9331
4143, 8792, 8793, 694, 693, 9299, 9333, 717, 9332
4144, 8793, 8794, 695, 694, 9301, 9334, 718, 9333
4145, 8794, 8795, 696, 695, 9303, 9335, 719, 9334
4146, 8795, 8796, 697, 696, 9305, 9336, 720, 9335
4147, 8796, 8797, 698, 697, 9307, 9337, 721, 9336
4148, 8797, 8798, 699, 698, 9309, 9338, 722, 9337
4149, 8798, 8799, 700, 699, 9311, 9339, 723, 9338
4150, 8799, 8800, 701, 700, 9313, 9340, 724, 9339
4151, 8800, 8801, 702, 701, 9315, 9341, 725, 9340
4152, 8801, 8802, 703, 702, 9317, 9342, 726, 9341
4153, 8802, 8803, 704, 703, 9319, 9343, 727, 9342
4154, 8803, 739, 15, 704, 9320, 751, 728, 9343
*ELEMENT, type=CPS8, ELSET=Surface14
4155, 12, 471, 9344, 752, 494, 9873, 9874, 775
4156, 752, 9344, 9345, 753, 9874, 9875, 9876, 776
4157, 753, 9345, 9346, 754, 9876, 9877, 9878, 777
4158, 754, 9346, 9347, 755, 9878, 9879, 9880, 778
4159, 755, 9347, 9348, 756, 9880, 9881, 9882, 779
4160, 756, 9348, 9349, 757, 9882, 9883, 9884, 780
4161, 757, 9349, 9350, 758, 9884, 9885, 9886, 781
4162, 758, 9350, 9351, 759, 9886, 9887, 9888, 782
4163, 759, 9351, 9352, 760, 9888, 9889, 9890, 783
4164, 760, 9352, 9353, 761, 9890, 9891, 9892, 784
4165, 761, 9353, 9354, 762, 9892, 9893, 9894, 785
4166, 762, 9354, 9355, 763, 9894, 9895, 9896, 786
4167, 763, 9355, 9356, 764, 9896, 9897, 9898, 787
4168, 764, 9356, 9357, 765, 9898, 9899, 9900, 788
4169, 765, 9357, 9358, 766, 9900, 9901, 9902, 789
4170, 766, 9358, 9359, 767, 9902, 9903, 9904, 790
4171, 767, 9359, 9360, 768, 9904, 9905, 9906, 791
4172, 768, 9360, 9361, 769, 9906, 9907, 9908, 792
4173, 769, 9361, 9362, 770, 9908, 9909, 9910, 793
4174, 770, 9362, 9363, 771, 9910, 9911, 9912, 794
4175, 771, 9363, 9364, 772, 9912, 9913, 9914, 795
4176, 772, 9364, 9365, 773, 9914, 9915, 9916, 796
4177, 773, 9365, 9366, 774, 9916, 9917, 9918, 797
4178, 774, 9366, 799, 16, 9918, 9919, 822, 798
4179, 471, 472, 9367, 9344, 495, 9920, 9921, 9873
4180, 9344, 9367, 9368, 9345, 9921, 9922, 9923, 9875
4181, 9345, 9368, 9369, 9346, 9923, 9924, 9925, 9877
4182, 9346, 9369, 9370, 9347, 9925, 9926, 9927, 9879
4183, 9347, 9370, 9371, 9348, 9927, 9928, 9929, 9881
4184, 9348, 9371, 9372, 9349, 9929, 9930, 9931, 9883
4185, 9349, 9372, 9373, 9350, 9931, 9932, 9933, 9885
4186, 9350, 9373, 9374, 9351, 9933, 9934, 9935, 9887
4187, 9351, 9374, 9375, 9352, 9935, 9936, 9937, 9889
4188, 9352, 9375, 9376, 9353, 9937, 9938, 9939, 9891
4189, 9353, 9376, 9377, 9354, 9939, 9940, 9941, 9893
4190, 9354, 9377, 9378, 9355, 9941, 9942, 9943, 9895
4191, 9355, 9378, 9379, 9356, 9943, 9944, 9945, 9897
4192, 9356, 9379, 9380, 9357, 9945, 9946, 9947, 9899
4193, 9357, 9380, 9381, 9358, 9947, 9948, 9949, 9901
4194, 9358, 9381, 9382, 9359, 9949, 9950, 9951, 9903
4195, 9359, 9382, 9383, 9360, 9951, 9952, 9953, 9905
4196, 9360, 9383, 9384, 9361, 9953, 9954, 9955, 9907
4197, 9361, 9384, 9385, 9362, 9955, 9956, 9957, 9909
4198, 9362, 9385, 9386, 9363, 9957, 9958, 9959, 9911
4199, 9363, 9386, 9387, 9364, 9959, 9960, 9961, 9913
4200, 9364, 9387, 9388, 9365, 9961, 9962, 9963, 9915
4201, 9365, 9388, 9389, 9366, 9963, 9964, 9965, 9917
4202, 9366, 9389, 800, 799, 9965, 9966, 823, 9919
4203, 472, 473, 9390, 9367, 496, 9967, 9968, 9920
4204, 9367, 9390, 9391, 9368, 9968, 9969, 9970, 9922
4205, 9368, 9391, 9392, 9369, 9970, 9971, 9972, 9924
4206, 9369, 9392, 9393, 9370, 9972, 9973, 9974, 9926
4207, 9370, 9393, 9394, 9371, 9974, 9975, 9976, 9928
4208, 9371, 9394, 9395, 9372, 9976, 9977, 9978, 9930
4209, 9372, 9395, 9396, 9373, 9978, 9979, 9980, 9932
4210, 9373, 9396, 9397, 9374, 9980, 9981, 9982, 9934
4211, 9374, 9397, 9398, 9375, 9982, 9983, 9984, 9936
4212, 9375, 9398, 9399, 9376, 9984, 9985, 9986, 9938
4213, 9376, 9399, 9400, 9377, 9986, 9987, 9988, 9940
4214, 9377, 9400, 9401, 9378, 9988, 9989, 9990, 9942
4215, 9378, 9401, 9402, 9379, 9990, 9991, 9992, 9944
4216, 9379, 9402, 9403, 9380, 9992, 9993, 9994, 9946
4217, 9380, 9403, 9404, 9381, 9994, 9995, 9996, 9948
4218, 9381, 9404, 9405, 9382, 9996, 9997, 9998, 9950
4219, 9382, 9405, 9406, 9383, 9998, 9999, 10000, 9952
4220, 9383, 9406, 9407, 9384, 10000, 10001, 10002, 9954
4221, 9384, 9407, 9408, 9385, 10002, 10003, 10004, 9956
4222, 9385, 9408, 9409, 9386, 10004, 10005, 10006, 9958
4223, 9386, 9409, 9410, 9387, 10006, 10007, 10008, 9960
4224, 9387, 9410, 9411, 9388, 10008, 10009, 10010, 9962
4225, 9388, 9411, 9412, 9389, 10010, 10011, 10012, 9964
4226, 9389, 9412, 801, 800, 10012, 10013, 824, 9966
4227, 473, 474, 9413, 9390, 497, 10014, 10015, 9967
4228, 9390, 9413, 9414, 9391, 10015, 10016, 10017, 9969
4229, 9391, 9414, 9415, 9392, 10017, 10018, 10019, 9971
4230, 9392, 9415, 9416, 9393, 10019, 10020, 10021, 9973
4231, 9393, 9416, 9417, 9394, 10021, 10022, 10023, 9975
4232, 9394, 9417, 9418, 9395, 10023, 10024, 10025, 9977
4233, 9395, 9418, 9419, 9396, 10025, 10026, 10027, 9979
4234, 9396, 9419, 9420, 9397, 10027, 10028, 10029, 9981
4235, 9397, 9420, 9421, 9398, 10029, 10030, 10031, 9983
4236, 9398, 9421, 9422, 9399, 10031, 10032, 10033, 9985
4237, 9399, 9422, 9423, 9400, 10033, 10034, 10035, 9987
4238, 9400, 9423, 9424, 9401, 10035, 10036, 10037, 9989
4239, 9401, 9424, 9425, 9402, 10037, 10038, 10039, 9991
4240, 9402, 9425, 9426, 9403, 10039, 10040, 10041, 9993
4241, 9403, 9426, 9427, 9404, 10041, 10042, 10043, 9995
4242, 9404, 9427, 9428, 9405, 10043, 10044, 10045, 9997
4243, 9405, 9428, 9429, 9406, 10045, 10046, 10047, 9999
4244, 9406, 9429, 9430, 9407, 10047, 10048, 10049, 10001
4245, 9407, 9430, 9431, 9408, 10049, 10050, 10051, 10003
4246, 9408, 9431, 9432, 9409, 10051, 10052, 10053, 10005
4247, 9409, 9432, 9433, 9410, 10053, 10054, 10055, 10007
4248, 9410, 9433, 9434, 9411, 10055, 10056, 10057, 10009
4249, 9411, 9434, 9435, 9412, 10057, 10058, 10059, 10011
4250, 9412, 9435, 802, 801, 10059, 10060, 825, 10013
4251, 474, 475, 9436, 9413, 498, 10061, 10062, 10014
4252, 9413, 9436, 9437, 9414, 10062, 10063, 10064, 10016
4253, 9414, 9437, 9438, 9415, 10064, 10065, 10066, 10018
4254, 9415, 9438, 9439, 9416, 10066, 10067, 10068, 10020
4255, 9416, 9439, 9440, 9417, 10068, 10069, 10070, 10022
4256, 9417, 9440, 9441, 9418, 10070, 10071, 10072, 10024
4257, 9418, 9441, 9442, 9419, 10072, 10073, 10074, 10026
4258, 9419, 9442, 9443, 9420, 10074, 10075, 10076, 10028
4259, 9420, 9443, 9444, 9421, 10076, 10077, 10078, 10030
4260, 9421, 9444, 9445, 9422, 10078, 10079, 10080, 10032
4261, 9422, 9445, 9446, 9423, 10080, 10081, 10082, 10034
4262, 9423, 9446, 9447, 9424, 10082, 10083, 10084, 10036
4263, 9424, 9447, 9448, 9425, 10084, 10085, 10086, 10038
4264, 9425, 9448, 9449, 9426, 10086, 10087, 10088, 10040
4265, 9426, 9449, 9450, 9427, 10088, 10089, 10090, 10042
4266, 9427, 9450, 9451, 9428, 10090, 10091, 10092, 10044
4267, 9428, 9451, 9452, 9429, 10092, 10093, 10094, 10046
4268, 9429, 9452, 9453, 9430, 10094, 10095, 10096, 10048
4269, 9430, 9453, 9454, 9431, 10096, 10097, 10098, 10050
4270, 9431, 9454, 9455, 9432, 10098, 10099, 10100, 10052
4271, 9432, 9455, 9456, 9433, 10100, 10101, 10102, 10054
4272, 9433, 9456, 9457, 9434, 10102, 10103, 10104, 10056
4273, 9434, 9457, 9458, 9435, 10104, 10105, 10106, 10058
4274, 9435, 9458, 803, 802, 10106, 10107, 826, 10060
4275, 475, 476, 9459, 9436, 499, 10108, 10109, 10061
4276, 9436, 9459, 9460, 9437, 10109, 10110, 10111, 10063
4277, 9437, 9460, 9461, 9438, 10111, 10112, 10113, 10065
4278, 9438, 9461, 9462, 9439, 10113, 10114, 10115, 10067
4279, 9439, 9462, 9463, 9440, 10115, 10116, 10117, 10069
4280, 9440, 9463, 9464, 9441, 10117, 10118, 10119, 10071
4281, 9441, 9464, 9465, 9442, 10119, 10120, 10121, 10073
4282, 9442, 9465, 9466, 9443, 10121, 10122, 10123, 10075
4283, 9443, 9466, 9467, 9444, 10123, 10124, 10125, 10077
4284, 9444, 9467, 9468, 9445, 10125, 10126, 10127, 10079
4285, 9445, 9468, 9469, 9446, 10127, 10128, 10129, 10081
4286, 9446, 9469, 9470, 9447, 10129, 10130, 10131, 10083
4287, 9447, 9470, 9471, 9448, 10131, 10132, 10133, 10085
4288, 9448, 9471, 9472, 9449, 10133, 10134, 10135, 10087
4289, 9449, 9472, 9473, 9450, 10135, 10136, 10137, 10089
4290, 9450, 9473, 9474, 9451, 10137, 10138, 10139, 10091
4291, 9451, 9474, 9475, 9452, 10139, 10140, 10141, 10093
4292, 9452, 9475, 9476, 9453, 10141, 10142, 10143, 10095
4293, 9453, 9476, 9477, 9454, 10143, 10144, 10145, 10097
4294, 9454, 9477, 9478, 9455, 10145, 10146, 10147, 10099
4295, 9455, 9478, 9479, 9456, 10147, 10148, 10149, 10101
4296, 9456, 9479, 9480, 9457, 10149, 10150, 10151, 10103
4297, 9457, 9480, 9481, 9458, 10151, 10152, 10153, 10105
4298, 9458, 9481, 804, 803, 10153, 10154, 827, 10107
4299, 476, 477, 9482, 9459, 500, 10155, 10156, 10108
4300, 9459, 9482, 9483, 9460, 10156, 10157, 10158, 10110
4301, 9460, 9483, 9484, 9461, 10158, 10159, 10160, 10112
4302, 9461, 9484, 9485, 9462, 10160, 10161, 10162, 10114
4303, 9462, 9485, 9486, 9463, 10162, 10163, 10164, 10116
4304, 9463, 9486, 9487, 9464, 10164, 10165, 10166, 10118
4305, 9464, 9487, 9488, 9465, 10166, 10167, 10168, 10120
4306, 9465, 9488, 9489, 9466, 10168, 10169, 10170, 10122
4307, 9466, 9489, 9490, 9467, 10170, 10171, 10172, 10124
4308, 9467, 9490, 9491, 9468, 10172, 10173, 10174, 10126
4309, 9468, 9491, 9492, 9469, 10174, 10175, 10176, 10128
4310, 9469, 9492, 9493, 9470, 10176, 10177, 10178, 10130
4311, 9470, 9493, 9494, 9471, 10178, 10179, 10180, 10132
4312, 9471, 9494, 9495, 9472, 10180, 10181, 10182, 10134
4313, 9472, 9495, 9496, 9473, 10182, 10183, 10184, 10136
4314, 9473, 9496, 9497, 9474, 10184, 10185, 10186, 10138
4315, 9474, 9497, 9498, 9475, 10186, 10187, 10188, 10140
4316, 9475, 9498, 9499, 9476, 10188, 10189, 10190, 10142
4317, 9476, 9499, 9500, 9477, 10190, 10191, 10192, 10144
4318, 9477, 9500, 9501, 9478, 10192, 10193, 10194, 10146
4319, 9478, 9501, 9502, 9479, 10194, 10195, 10196, 10148
4320, 9479, 9502, 9503, 9480, 10196, 10197, 10198, 10150
4321, 9480, 9503, 9504, 9481, 10198, 10199, 10200, 10152
4322, 9481, 9504, 805, 804, 10200, 10201, 828, 10154
4323, 477, 478, 9505, 9482, 501, 10202, 10203, 10155
4324, 9482, 9505, 9506, 9483, 10203, 10204, 10205, 10157
4325, 9483, 9506, 9507, 9484, 10205, 10206, 10207, 10159
4326, 9484, 9507, 9508, 9485, 10207, 10208, 10209, 10161
4327, 9485, 9508, 9509, 9486, 10209, 10210, 10211, 10163
4328, 9486, 9509, 9510, 9487, 10211, 10212, 10213, 10165
4329, 9487, 9510, 9511, 9488, 10213, 10214, 10215, 10167
4330, 9488, 9511, 9512, 9489, 10215, 10216, 10217, 10169
4331, 9489, 9512, 9513, 9490, 10217, 10218, 10219, 10171
4332, 9490, 9513, 9514, 9491, 10219, 10220, 10221, 10173
4333, 9491, 9514, 9515, 9492, 10221, 10222, 10223, 10175
4334, 9492, 9515, 9516, 9493, 10223, 10224, 10225, 10177
4335, 9493, 9516, 9517, 9494, 10225, 10226, 10227, 10179
4336, 9494, 9517, 9518, 9495, 10227, 10228, 10229, 10181
4337, 9495, 9518, 9519, 9496, 10229, 10230, 10231, 10183
4338, 9496, 9519, 9520, 9497, 10231, 10232, 10233, 10185
4339, 9497, 9520, 9521, 9498, 10233, 10234, 10235, 10187
4340, 9498, 9521, 9522, 9499, 10235, 10236, 10237, 10189
4341, 9499, 9522, 9523, 9500, 10237, 10238, 10239, 10191
4342, 9500, 9523, 9524, 9501, 10239, 10240, 10241, 10193
4343, 9501, 9524, 9525, 9502, 10241, 10242, 10243, 10195
4344, 9502, 9525, 9526, 9503, 10243, 10244, 10245, 10197
4345, 9503, 9526, 9527, 9504, 10245, 10246, 10247, 10199
4346, 9504, 9527, 806, 805, 10247, 10248, 829, 10201
4347, 478, 479, 9528, 9505, 502, 10249, 10250, 10202
4348, 9505, 9528, 9529, 9506, 10250, 10251, 10252, 10204
4349, 9506, 9529, 9530, 9507, 10252, 10253, 10254, 10206
4350, 9507, 9530, 9531, 9508, 10254, 10255, 10256, 10208
4351, 9508, 9531, 9532, 9509, 10256, 10257, 10258, 10210
4352, 9509, 9532, 9533, 9510, 10258, 10259, 10260, 10212
4353, 9510, 9533, 9534, 9511, 10260, 10261, 10262, 10214
4354, 9511, 9534, 9535, 9512, 10262, 10263, 10264, 10216
4355, 9512, 9535, 9536, 9513, 10264, 10265, 10266, 10218
4356, 9513, 9536, 9537, 9514, 10266, 10267, 10268, 10220
4357, 9514, 9537, 9538, 9515, 10268, 10269, 10270, 10222
4358, 9515, 9538, 9539, 9516, 10270, 10271, 10272, 10224
4359, 9516, 9539, 9540, 9517, 10272, 10273, 10274, 10226
4360, 9517, 9540, 9541, 9518, 10274, 10275, 10276, 10228
4361, 9518, 9541, 9542, 9519, 10276, 10277, 10278, 10230
4362, 9519, 9542, 9543, 9520, 10278, 10279, 10280, 10232
4363, 9520, 9543, 9544, 9521, 10280, 10281, 10282, 10234
4364, 9521, 9544, 9545, 9522, 10282, 10283, 10284, 10236
4365, 9522, 9545, 9546, 9523, 10284, 10285, 10286, 10238
4366, 9523, 9546, 9547, 9524, 10286, 10287, 10288, 10240
4367, 9524, 9547, 9548, 9525, 10288, 10289, 10290, 10242
4368, 9525, 9548, 9549, 9526, 10290, 10291, 10292, 10244
4369, 9526, 9549, 9550, 9527, 10292, 10293, 10294, 10246
4370, 9527, 9550, 807, 806, 10294, 10295, 830, 10248
4371, 479, 480, 9551, 9528, 503, 10296, 10297, 10249
4372, 9528, 9551, 9552, 9529, 10297, 10298, 10299, 10251
4373, 9529, 9552, 9553, 9530, 10299, 10300, 10301, 10253
4374, 9530, 9553, 9554, 9531, 10301, 10302, 10303, 10255
4375, 9531, 9554, 9555, 9532, 10303, 10304, 10305, 10257
4376, 9532, 9555, 9556, 9533, 10305, 10306, 10307, 10259
4377, 9533, 9556, 9557, 9534, 10307, 10308, 10309, 10261
4378, 9534, 9557, 9558, 9535, 10309, 10310, 10311, 10263
4379, 9535, 9558, 9559, 9536, 10311, 10312, 10313, 10265
4380, 9536, 9559, 9560, 9537, 10313, 10314, 10315, 10267
4381, 9537, 9560, 9561, 9538, 10315, 10316, 10317, 10269
4382, 9538, 9561, 9562, 9539, 10317, 10318, 10319, 10271
4383, 9539, 9562, 9563, 9540, 10319, 10320, 10321, 10273
4384, 9540, 9563, 9564, 9541, 10321, 10322, 10323, 10275
4385, 9541, 9564, 9565, 9542, 10323, 10324, 10325, 10277
4386, 9542, 9565, 9566, 9543, 10325, 10326, 10327, 10279
4387, 9543, 9566, 9567, 9544, 10327, 10328, 10329, 10281
4388, 9544, 9567, 9568, 9545, 10329, 10330, 10331, 10283
4389, 9545, 9568, 9569, 9546, 10331, 10332, 10333, 10285
4390, 9546, 9569, 9570, 9547, 10333, 10334, 10335, 10287
4391, 9547, 9570, 9571, 9548, 10335, 10336, 10337, 10289
4392, 9548, 9571, 9572, 9549, 10337, 10338, 10339, 10291
4393, 9549, 9572, 9573, 9550, 10339, 10340, 10341, 10293
4394, 9550, 9573, 808, 807, 10341, 10342, 831, 10295
4395, 480, 481, 9574, 9551, 504, 10343, 10344, 10296
4396, 9551, 9574, 9575, 9552, 10344, 10345, 10346, 10298
4397, 9552, 9575, 9576, 9553, 10346, 10347, 10348, 10300
4398, 9553, 9576, 9577, 9554, 10348, 10349, 10350, 10302
4399, 9554, 9577, 9578, 9555, 10350, 10351, 10352, 10304
4400, 9555, 9578, 9579, 9556, 10352, 10353, 10354, 10306
4401, 9556, 9579, 9580, 9557, 10354, 10355, 10356, 10308
4402, 9557, 9580, 9581, 9558, 10356, 10357, 10358, 10310
4403, 9558, 9581, 9582, 9559, 10358, 10359, 10360, 10312
4404, 9559, 9582, 9583, 9560, 10360, 10361, 10362, 10314
4405, 9560, 9583, 9584, 9561, 10362, 10363, 10364, 10316
4406, 9561, 9584, 9585, 9562, 10364, 10365, 10366, 10318
4407, 9562, 9585, 9586, 9563, 10366, 10367, 10368, 10320
4408, 9563, 9586, 9587, 9564, 10368, 10369, 10370, 10322
4409, 9564, 9587, 9588, 9565, 10370, 10371, 10372, 10324
4410, 9565, 9588, 9589, 9566, 10372, 10373, 10374, 10326
4411, 9566, 9589, 9590, 9567, 10374, 10375, 10376, 10328
4412, 9567, 9590, 9591, 9568, 10376, 10377, 10378, 10330
4413, 9568, 9591, 9592, 9569, 10378, 10379, 10380, 10332
4414, 9569, 9592, 9593, 9570, 10380, 10381, 10382, 10334
4415, 9570, 9593, 9594, 9571, 10382, 10383, 10384, 10336
4416, 9571, 9594, 9595, 9572, 10384, 10385, 10386, 10338
4417, 9572, 9595, 9596, 9573, 10386, 10387, 10388, 10340
4418, 9573, 9596, 809, 808, 10388, 10389, 832, 10342
4419, 481, 482, 9597, 9574, 505, 10390, 10391, 10343
4420, 9574, 9597, 9598, 9575, 10391, 10392, 10393, 10345
4421, 9575, 9598, 9599, 9576, 10393, 10394, 10395, 10347
4422, 9576, 9599, 9600, 9577, 10395, 10396, 10397, 10349
4423, 9577, 9600, 9601, 9578, 10397, 10398, 10399, 10351
4424, 9578, 9601, 9602, 9579, 10399, 10400, 10401, 10353
4425, 9579, 9602, 9603, 9580, 10401, 10402, 10403, 10355
4426, 9580, 9603, 9604, 9581, 10403, 10404, 10405, 10357
4427, 9581, 9604, 9605, 9582, 10405, 10406, 10407, 10359
4428, 9582, 9605, 9606, 9583, 10407, 10408, 10409, 10361
4429, 9583, 9606, 9607, 9584, 10409, 10410, 10411, 10363
4430, 9584, 9607, 9608, 9585, 10411, 10412, 10413, 10365
4431, 9585, 9608, 9609, 9586, 10413, 10414, 10415, 10367
4432, 9586, 9609, 9610, 9587, 10415, 10416, 10417, 10369
4433, 9587, 9610, 9611, 9588, 10417, 10418, 10419, 10371
4434, 9588, 9611, 9612, 9589, 10419, 10420, 10421, 10373
4435, 9589, 9612, 9613, 9590, 10421, 10422, 10423, 10375
4436, 9590, 9613, 9614, 9591, 10423, 10424, 10425, 10377
4437, 9591, 9614, 9615, 9592, 10425, 10426, 10427, 10379
4438, 9592, 9615, 9616, 9593, 10427, 10428, 10429, 10381
4439, 9593, 9616, 9617, 9594, 10429, 10430, 10431, 10383
4440, 9594, 9617, 9618, 9595, 10431, 10432, 10433, 10385
4441, 9595, 9618, 9619, 9596, 10433, 10434, 10435, 10387
4442, 9596, 9619, 810, 809, 10435, 10436, 833, 10389
4443, 482, 483, 9620, 9597, 506, 10437, 10438, 10390
4444, 9597, 9620, 9621, 9598, 10438, 10439, 10440, 10392
4445, 9598, 9621, 9622, 9599, 10440, 10441, 10442, 10394
4446, 9599, 9622, 9623, 9600, 10442, 10443, 10444, 10396
4447, 9600, 9623, 9624, 9601, 10444, 10445, 10446, 10398
4448, 9601, 9624, 9625, 9602, 10446, 10447, 10448, 10400
4449, 9602, 9625, 9626, 9603, 10448, 10449, 10450, 10402
4450, 9603, 9626, 9627, 9604, 10450, 10451, 10452, 10404
4451, 9604, 9627, 9628, 9605, 10452, 10453, 10454, 10406
4452, 9605, 9628, 9629, 9606, 10454, 10455, 10456, 10408
4453, 9606, 9629, 9630, 9607, 10456, 10457, 10458, 10410
4454, 9607, 9630, 9631, 9608, 10458, 10459, 10460, 10412
4455, 9608, 9631, 9632, 9609, 10460, 10461, 10462, 10414
4456, 9609, 9632, 9633, 9610, 10462, 10463, 10464, 10416
4457, 9610, 9633, 9634, 9611, 10464, 10465, 10466, 10418
4458, 9611, 9634, 9635, 9612, 10466, 10467, 10468, 10420
4459, 9612, 9635, 9636, 9613, 10468, 10469, 10470, 10422
4460, 9613, 9636, 9637, 9614, 10470, 10471, 10472, 10424
4461, 9614, 9637, 9638, 9615, 10472, 10473, 10474, 10426
4462, 9615, 9638, 9639, 9616, 10474, 10475, 10476, 10428
4463, 9616, 9639, 9640, 9617, 10476, 10477, 10478, 10430
4464, 9617, 9640, 9641, 9618, 10478, 10479, 10480, 10432
4465, 9618, 9641, 9642, 9619, 10480, 10481, 10482, 10434
4466, 9619, 9642, 811, 810, 10482, 10483, 834, 10436
4467, 483, 484, 9643, 9620, 507, 10484, 10485, 10437
4468, 9620, 9643, 9644, 9621, 10485, 10486, 10487, 10439
4469, 9621, 9644, 9645, 9622, 10487, 10488, 10489, 10441
4470, 9622, 9645, 9646, 9623, 10489, 10490, 10491, 10443
4471, 9623, 9646, 9647, 9624, 10491, 10492, 10493, 10445
4472, 9624, 9647, 9648, 9625, 10493, 10494, 10495, 10447
4473, 9625, 9648, 9649, 9626, 10495, 10496, 10497, 10449
4474, 9626, 9649, 9650, 9627, 10497, 10498, 10499, 10451
4475, 9627, 9650, 9651, 9628, 10499, 10500, 10501, 10453
4476, 9628, 9651, 9652, 9629, 10501, 10502, 10503, 10455
4477, 9629, 9652, 9653, 9630, 10503, 10504, 10505, 10457
4478, 9630, 9653, 9654, 9631, 10505, 10506, 10507, 10459
4479, 9631, 9654, 9655, 9632, 10507, 10508, 10509, 10461
4480, 9632, 9655, 9656, 9633, 10509, 10510, 10511, 10463
4481, 9633, 9656, 9657, 9634, 10511, 10512, 10513, 10465
4482, 9634, 9657, 9658, 9635, 10513, 10514, 10515, 10467
4483, 9635, 9658, 9659, 9636, 10515, 10516, 10517, 10469
4484, 9636, 9659, 9660, 9637, 10517, 10518, 10519, 10471
4485, 9637, 9660, 9661, 9638, 10519, 10520, 10521, 10473
4486, 9638, 9661, 9662, 9639, 10521, 10522, 10523, 10475
4487, 9639, 9662, 9663, 9640, 10523, 10524, 10525, 10477
4488, 9640, 9663, 9664, 9641, 10525, 10526, 10527, 10479
4489, 9641, 9664, 9665, 9642, 10527, 10528, 10529, 10481
4490, 9642, 9665, 812, 811, 10529, 10530, 835, 10483
4491, 484, 485, 9666, 9643, 508, 10531, 10532, 10484
4492, 9643, 9666, 9667, 9644, 10532, 10533, 10534, 10486
4493, 9644, 9667, 9668, 9645, 10534, 10535, 10536, 10488
4494, 9645, 9668, 9669, 9646, 10536, 10537, 10538, 10490
4495, 9646, 9669, 9670, 9647, 10538, 10539, 10540, 10492
4496, 9647, 9670, 9671, 9648, 10540, 10541, 10542, 10494
4497, 9648, 9671, 9672, 9649, 10542, 10543, 10544, 10496
4498, 9649, 9672, 9673, 9650, 10544, 10545, 10546, 10498
4499, 9650, 9673, 9674, 9651, 10546, 10547, 10548, 10500
4500, 9651, 9674, 9675, 9652, 10548, 10549, 10550, 10502
4501, 9652, 9675, 9676, 9653, 10550, 10551, 10552, 10504
4502, 9653, 9676, 9677, 9654, 10552, 10553, 10554, 10506
4503, 9654, 9677, 9678, 9655, 10554, 10555, 10556, 10508
4504, 9655, 9678, 9679, 9656, 10556, 10557, 10558, 10510
4505, 9656, 9679, 9680, 9657, 10558, 10559, 10560, 10512
4506, 9657, 9680, 9681, 9658, 10560, 10561, 10562, 10514
4507, 9658, 9681, 9682, 9659, 10562, 10563, 10564, 10516
4508, 9659, 9682, 9683, 9660, 10564, 10565, 10566, 10518
4509, 9660, 9683, 9684, 9661, 10566, 10567, 10568, 10520
4510, 9661, 9684, 9685, 9662, 10568, 10569, 10570, 10522
4511, 9662, 9685, 9686, 9663, 10570, 10571, 10572, 10524
4512, 9663, 9686, 9687, 9664, 10572, 10573, 10574, 10526
4513, 9664, 9687, 9688, 9665, 10574, 10575, 10576, 10528
4514, 9665, 9688, 813, 812, 10576, 10577, 836, 10530
4515, 485, 486, 9689, 9666, 509, 10578, 10579, 10531
4516, 9666, 9689, 9690, 9667, 10579, 10580, 10581, 10533
4517, 9667, 9690, 9691, 9668, 10581, 10582, 10583, 10535
4518, 9668, 9691, 9692, 9669, 10583, 10584, 10585, 10537
4519, 9669, 9692, 9693, 9670, 10585, 10586, 10587, 10539
4520, 9670, 9693, 9694, 9671, 10587, 10588, 10589, 10541
4521, 9671, 9694, 9695, 9672, 10589, 10590, 10591, 10543
4522, 9672, 9695, 9696, 9673, 10591, 10592, 10593, 10545
4523, 9673, 9696, 9697, 9674, 10593, 10594, 10595, 10547
4524, 9674, 9697, 9698, 9675, 10595, 10596, 10597, 10549
4525, 9675, 9698, 9699, 9676, 10597, 10598, 10599, 10551
4526, 9676, 9699, 9700, 9677, 10599, 10600, 10601, 10553
4527, 9677, 9700, 9701, 9678, 10601, 10602, 10603, 10555
4528, 9678, 9701, 9702, 9679, 10603, 10604, 10605, 10557
4529, 9679, 9702, 9703, 9680, 10605, 10606, 10607, 10559
4530, 9680, 9703, 9704, 9681, 10607, 10608, 10609, 10561
4531, 9681, 9704, 9705, 9682, 10609, 10610, 10611, 10563
4532, 9682, 9705, 9706, 9683, 10611, 10612, 10613, 10565
4533, 9683, 9706, 9707, 9684, 10613, 10614, 10615, 10567
4534, 9684, 9707, 9708, 9685, 10615, 10616, 10617, 10569
4535, 9685, 9708, 9709, 9686, 10617, 10618, 10619, 10571
4536, 9686, 9709, 9710, 9687, 10619, 10620, 10621, 10573
4537, 9687, 9710, 9711, 9688, 10621, 10622, 10623, 10575
4538, 9688, 9711, 814, 813, 10623, 10624, 837, 10577
4539, 486, 487, 9712, 9689, 510, 10625, 10626, 10578
4540, 9689, 9712, 9713, 9690, 10626, 10627, 10628, 10580
4541, 9690, 9713, 9714, 9691, 10628, 10629, 10630, 10582
4542, 9691, 9714, 9715, 9692, 10630, 10631, 10632, 10584
4543, 9692, 9715, 9716, 9693, 10632, 10633, 10634, 10586
4544, 9693, 9716, 9717, 9694, 10634, 10635, 10636, 10588
4545, 9694, 9717, 9718, 9695, 10636, 10637, 10638, 10590
4546, 9695, 9718, 9719, 9696, 10638, 10639, 10640, 10592
4547, 9696, 9719, 9720, 9697, 10640, 10641, 10642, 10594
4548, 9697, 9720, 9721, 9698, 10642, 10643, 10644, 10596
4549, 9698, 9721, 9722, 9699, 10644, 10645, 10646, 10598
4550, 9699, 9722, 9723, 9700, 10646, 10647, 10648, 10600
4551, 9700, 9723, 9724, 9701, 10648, 10649, 10650, 10602
4552, 9701, 9724, 9725, 9702, 10650, 10651, 10652, 10604
4553, 9702, 9725, 9726, 9703, 10652, 10653, 10654, 10606
4554, 9703, 9726, 9727, 9704, 10654, 10655, 10656, 10608
4555, 9704, 9727, 9728, 9705, 10656, 10657, 10658, 10610
4556, 9705, 9728, 9729, 9706, 10658, 10659, 10660, 10612
4557, 9706, 9729, 9730, 9707, 10660, 10661, 10662, 10614
4558, 9707, 9730, 9731, 9708, 10662, 10663, 10664, 10616
4559, 9708, 9731, 9732, 9709, 10664, 10665, 10666, 10618
4560, 9709, 9732, 9733, 9710, 10666, 10667, 10668, 10620
4561, 9710, 9733, 9734, 9711, 10668, 10669, 10670, 10622
4562, 9711, 9734, 815, 814, 10670, 10671, 838, 10624
4563, 487, 488, 9735, 9712, 511, 10672, 10673, 10625
4564, 9712, 9735, 9736, 9713, 10673, 10674, 10675, 10627
4565, 9713, 9736, 9737, 9714, 10675, 10676, 10677, 10629
4566, 9714, 9737, 9738, 9715, 10677, 10678, 10679, 10631
4567, 9715, 9738, 9739, 9716, 10679, 10680, 10681, 10633
4568, 9716, 9739, 9740, 9717, 10681, 10682, 10683, 10635
4569, 9717, 9740, 9741, 9718, 10683, 10684, 10685, 10637
4570, 9718, 9741, 9742, 9719, 10685, 10686, 10687, 10639
4571, 9719, 9742, 9743, 9720, 10687, 10688, 10689, 10641
4572, 9720, 9743, 9744, 9721, 10689, 10690, 10691, 10643
4573, 9721, 9744, 9745, 9722, 10691, 10692, 10693, 10645
4574, 9722, 9745, 9746, 9723, 10693, 10694, 10695, 10647
4575, 9723, 9746, 9747, 9724, 10695, 10696, 10697, 10649
4576, 9724, 9747, 9748, 9725, 10697, 10698, 10699, 10651
4577, 9725, 9748, 9749, 9726, 10699, 10700, 10701, 10653
4578, 9726, 9749, 9750, 9727, 10701, 10702, 10703, 10655
4579, 9727, 9750, 9751, 9728, 10703, 10704, 10705, 10657
4580, 9728, 9751, 9752, 9729, 10705, 10706, 10707, 10659
4581, 9729, 9752, 9753, 9730, 10707, 10708, 10709, 10661
4582, 9730, 9753, 9754, 9731, 10709, 10710, 10711, 10663
4583, 9731, 9754, 9755, 9732, 10711, 10712, 10713, 10665
4584, 9732, 9755, 9756, 9733, 10713, 10714, 10715, 10667
4585, 9733, 9756, 9757, 9734, 10715, 10716, 10717, 10669
4586, 9734, 9757, 816, 815, 10717, 10718, 839, 10671
4587, 488, 489, 9758, 9735, 512, 10719, 10720, 10672
4588, 9735, 9758, 9759, 9736, 10720, 10721, 10722, 10674
4589, 9736, 9759, 9760, 9737, 10722, 10723, 10724, 10676
4590, 9737, 9760, 9761, 9738, 10724, 10725, 10726, 10678
4591, 9738, 9761, 9762, 9739, 10726, 10727, 10728, 10680
4592, 9739, 9762, 9763, 9740, 10728, 10729, 10730, 10682
4593, 9740, 9763, 9764, 9741, 10730, 10731, 10732, 10684
4594, 9741, 9764, 9765, 9742, 10732, 10733, 10734, 10686
4595, 9742, 9765, 9766, 9743, 10734, 10735, 10736, 10688
4596, 9743, 9766, 9767, 9744, 10736, 10737, 10738, 10690
4597, 9744, 9767, 9768, 9745, 10738, 10739, 10740, 10692
4598, 9745, 9768, 9769, 9746, 10740, 10741, 10742, 10694
4599, 9746, 9769, 9770, 9747, 10742, 10743, 10744, 10696
4600, 9747, 9770, 9771, 9748, 10744, 10745, 10746, 10698
4601, 9748, 9771, 9772, 9749, 10746, 10747, 10748, 10700
4602, 9749, 9772, 9773, 9750, 10748, 10749, 10750, 10702
4603, 9750, 9773, 9774, 9751, 10750, 10751, 10752, 10704
4604, 9751, 9774, 9775, 9752, 10752, 10753, 10754, 10706
4605, 9752, 9775, 9776, 9753, 10754, 10755, 10756, 10708
4606, 9753, 9776, 9777, 9754, 10756, 10757, 10758, 10710
4607, 9754, 9777, 9778, 9755, 10758, 10759, 10760, 10712
4608, 9755, 9778, 9779, 9756, 10760, 10761, 10762, 10714
4609, 9756, 9779, 9780, 9757, 10762, 10763, 10764, 10716
4610, 9757, 9780, 817, 816, 10764, 10765, 840, 10718
4611, 489, 490, 9781, 9758, 513, 10766, 10767, 10719
4612, 9758, 9781, 9782, 9759, 10767, 10768, 10769, 10721
4613, 9759, 9782, 9783, 9760, 10769, 10770, 10771, 10723
4614, 9760, 9783, 9784, 9761, 10771, 10772, 10773, 10725
4615, 9761, 9784, 9785, 9762, 10773, 10774, 10775, 10727
4616, 9762, 9785, 9786, 9763, 10775, 10776, 10777, 10729
4617, 9763, 9786, 9787, 9764, 10777, 10778, 10779, 10731
4618, 9764, 9787, 9788, 9765, 10779, 10780, 10781, 10733
4619, 9765, 9788, 9789, 9766, 10781, 10782, 10783, 10735
4620, 9766, 9789, 9790, 9767, 10783, 10784, 10785, 10737
4621, 9767, 9790, 9791, 9768, 10785, 10786, 10787, 10739
4622, 9768, 9791, 9792, 9769, 10787, 10788, 10789, 10741
4623, 9769, 9792, 9793, 9770, 10789, 10790, 10791, 10743
4624, 9770, 9793, 9794, 9771, 10791, 10792, 10793, 10745
4625, 9771, 9794, 9795, 9772, 10793, 10794, 10795, 10747
4626, 9772, 9795, 9796, 9773, 10795, 10796, 10797, 10749
4627, 9773, 9796, 9797, 9774, 10797, 10798, 10799, 10751
4628, 9774, 9797, 9798, 9775, 10799, 10800, 10801, 10753
4629, 9775, 9798, 9799, 9776, 10801, 10802, 10803, 10755
4630, 9776, 9799, 9800, 9777, 10803, 10804, 10805, 10757
4631, 9777, 9800, 9801, 9778, 10805, 10806, 10807, 10759
4632, 9778, 9801, 9802, 9779, 10807, 10808, 10809, 10761
4633, 9779, 9802, 9803, 9780, 10809, 10810, 10811, 10763
4634, 9780, 9803, 818, 817, 10811, 10812, 841, 10765
4635, 490, 491, 9804, 9781, 514, 10813, 10814, 10766
4636, 9781, 9804, 9805, 9782, 10814, 10815, 10816, 10768
4637, 9782, 9805, 9806, 9783, 10816, 10817, 10818, 10770
4638, 9783, 9806, 9807, 9784, 10818, 10819, 10820, 10772
4639, 9784, 9807, 9808, 9785, 10820, 10821, 10822, 10774
4640, 9785, 9808, 9809, 9786, 10822, 10823, 10824, 10776
4641, 9786, 9809, 9810, 9787, 10824, 10825, 10826, 10778
4642, 9787, 9810, 9811, 9788, 10826, 10827, 10828, 10780
4643, 9788, 9811, 9812, 9789, 10828, 10829, 10830, 10782
4644, 9789, 9812, 9813, 9790, 10830, 10831, 10832, 10784
4645, 9790, 9813, 9814, 9791, 10832, 10833, 10834, 10786
4646, 9791, 9814, 9815, 9792, 10834, 10835, 10836, 10788
4647, 9792, 9815, 9816, 9793, 10836, 10837, 10838, 10790
4648, 9793, 9816, 9817, 9794, 10838, 10839, 10840, 10792
4649, 9794, 9817, 9818, 9795, 10840, 10841, 10842, 10794
4650, 9795, 9818, 9819, 9796, 10842, 10843, 10844, 10796
4651, 9796, 9819, 9820, 9797, 10844, 10845, 10846, 10798
4652, 9797, 9820, 9821, 9798, 10846, 10847, 10848, 10800
4653, 9798, 9821, 9822, 9799, 10848, 10849, 10850, 10802
4654, 9799, 9822, 9823, 9800, 10850, 10851, 10852, 10804
4655, 9800, 9823, 9824, 9801, 10852, 10853, 10854, 10806
4656, 9801, 9824, 9825, 9802, 10854, 10855, 10856, 10808
4657, 9802, 9825, 9826, 9803, 10856, 10857, 10858, 10810
4658, 9803, 9826, 819, 818, 10858, 10859, 842, 10812
4659, 491, 492, 9827, 9804, 515, 10860, 10861, 10813
4660, 9804, 9827, 9828, 9805, 10861, 10862, 10863, 10815
4661, 9805, 9828, 9829, 9806, 10863, 10864, 10865, 10817
4662, 9806, 9829, 9830, 9807, 10865, 10866, 10867, 10819
4663, 9807, 9830, 9831, 9808, 10867, 10868, 10869, 10821
4664, 9808, 9831, 9832, 9809, 10869, 10870, 10871, 10823
4665, 9809, 9832, 9833, 9810, 10871, 10872, 10873, 10825
4666, 9810, 9833, 9834, 9811, 10873, 10874, 10875, 10827
4667, 9811, 9834, 9835, 9812, 10875, 10876, 10877, 10829
4668, 9812, 9835, 9836, 9813, 10877, 10878, 10879, 10831
4669, 9813, 9836, 9837, 9814, 10879, 10880, 10881, 10833
4670, 9814, 9837, 9838, 9815, 10881, 10882, 10883, 10835
4671, 9815, 9838, 9839, 9816, 10883, 10884, 10885, 10837
4672, 9816, 9839, 9840, 9817, 10885, 10886, 10887, 10839
4673, 9817, 9840, 9841, 9818, 10887, 10888, 10889, 10841
4674, 9818, 9841, 9842, 9819, 10889, 10890, 10891, 10843
4675, 9819, 9842, 9843, 9820, 10891, 10892, 10893, 10845
4676, 9820, 9843, 9844, 9821, 10893, 10894, 10895, 10847
4677, 9821, 9844, 9845, 9822, 10895, 10896, 10897, 10849
4678, 9822, 9845, 9846, 9823, 10897, 10898, 10899, 10851
4679, 9823, 9846, 9847, 9824, 10899, 10900, 10901, 10853
4680, 9824, 9847, 9848, 9825, 10901, 10902, 10903, 10855
4681, 9825, 9848, 9849, 9826, 10903, 10904, 10905, 10857
4682, 9826, 9849, 820, 819, 10905, 10906, 843, 10859
4683, 492, 493, 9850, 9827, 516, 10907, 10908, 10860
4684, 9827, 9850, 9851, 9828, 10908, 10909, 10910, 10862
4685, 9828, 9851, 9852, 9829, 10910, 10911, 10912, 10864
4686, 9829, 9852, 9853, 9830, 10912, 10913, 10914, 10866
4687, 9830, 9853, 9854, 9831, 10914, 10915, 10916, 10868
4688, 9831, 9854, 9855, 9832, 10916, 10917, 10918, 10870
4689, 9832, 9855, 9856, 9833, 10918, 10919, 10920, 10872
4690, 9833, 9856, 9857, 9834, 10920, 10921, 10922, 10874
4691, 9834, 9857, 9858, 9835, 10922, 10923, 10924, 10876
4692, 9835, 9858, 9859, 9836, 10924, 10925, 10926, 10878
4693, 9836, 9859, 9860, 9837, 10926, 10927, 10928, 10880
4694, 9837, 9860, 9861, 9838, 10928, 10929, 10930, 10882
4695, 9838, 9861, 9862, 9839, 10930, 10931, 10932, 10884
4696, 9839, 9862, 9863, 9840, 10932, 10933, 10934, 10886
4697, 9840, 9863, 9864, 9841, 10934, 10935, 10936, 10888
4698, 9841, 9864, 9865, 9842, 10936, 10937, 10938, 10890
4699, 9842, 9865, 9866, 9843, 10938, 10939, 10940, 10892
4700, 9843, 9866, 9867, 9844, 10940, 10941, 10942, 10894
4701, 9844, 9867, 9868, 9845, 10942, 10943, 10944, 10896
4702, 9845, 9868, 9869, 9846, 10944, 10945, 10946, 10898
4703, 9846, 9869, 9870, 9847, 10946, 10947, 10948, 10900
4704, 9847, 9870, 9871, 9848, 10948, 10949, 10950, 10902
4705, 9848, 9871, 9872, 9849, 10950, 10951, 10952, 10904
4706, 9849, 9872, 821, 820, 10952, 10953, 844, 10906
4707, 493, 11, 682, 9850, 517, 705, 10954, 10907
4708, 9850, 682, 683, 9851, 10954, 706, 10955, 10909
4709, 9851, 683, 684, 9852, 10955, 707, 10956, 10911
4710, 9852, 684, 685, 9853, 10956, 708, 10957, 10913
4711, 9853, 685, 686, 9854, 10957, 709, 10958, 10915
4712, 9854, 686, 687, 9855, 10958, 710, 10959, 10917
4713, 9855, 687, 688, 9856, 10959, 711, 10960, 10919
4714, 9856, 688, 689, 9857, 10960, 712, 10961, 10921
4715, 9857, 689, 690, 9858, 10961, 713, 10962, 10923
4716, 9858, 690, 691, 9859, 10962, 714, 10963, 10925
4717, 9859, 691, 692, 9860, 10963, 715, 10964, 10927
4718, 9860, 692, 693, 9861, 10964, 716, 10965, 10929
4719, 9861, 693, 694, 9862, 10965, 717, 10966, 10931
4720, 9862, 694, 695, 9863, 10966, 718, 10967, 10933
4721, 9863, 695, 696, 9864, 10967, 719, 10968, 10935
4722, 9864, 696, 697, 9865, 10968, 720, 10969, 10937
4723, 9865, 697, 698, 9866, 10969, 721, 10970, 10939
4724, 9866, 698, 699, 9867, 10970, 722, 10971, 10941
4725, 9867, 699, 700, 9868, 10971, 723, 10972, 10943
4726, 9868, 700, 701, 9869, 10972, 724, 10973, 10945
4727, 9869, 701, 702, 9870, 10973, 725, 10974, 10947
4728, 9870, 702, 703, 9871, 10974, 726, 10975, 10949
4729, 9871, 703, 704, 9872, 10975, 727, 10976, 10951
4730, 9872, 704, 15, 821, 10976, 728, 845, 10953
*ELEMENT, type=CPS8, ELSET=Surface15
4731, 10, 518, 10977, 588, 529, 11230, 11231, 611
4732, 588, 10977, 10978, 589, 11231, 11232, 11233, 612
4733, 589, 10978, 10979, 590, 11233, 11234, 11235, 613
4734, 590, 10979, 10980, 591, 11235, 11236, 11237, 614
4735, 591, 10980, 10981, 592, 11237, 11238, 11239, 615
4736, 592, 10981, 10982, 593, 11239, 11240, 11241, 616
4737, 593, 10982, 10983, 594, 11241, 11242, 11243, 617
4738, 594, 10983, 10984, 595, 11243, 11244, 11245, 618
4739, 595, 10984, 10985, 596, 11245, 11246, 11247, 619
4740, 596, 10985, 10986, 597, 11247, 11248, 11249, 620
4741, 597, 10986, 10987, 598, 11249, 11250, 11251, 621
4742, 598, 10987, 10988, 599, 11251, 11252, 11253, 622
4743, 599, 10988, 10989, 600, 11253, 11254, 11255, 623
4744, 600, 10989, 10990, 601, 11255, 11256, 11257, 624
4745, 601, 10990, 10991, 602, 11257, 11258, 11259, 625
4746, 602, 10991, 10992, 603, 11259, 11260, 11261, 626
4747, 603, 10992, 10993, 604, 11261, 11262, 11263, 627
4748, 604, 10993, 10994, 605, 11263, 11264, 11265, 628
4749, 605, 10994, 10995, 606, 11265, 11266, 11267, 629
4750, 606, 10995, 10996, 607, 11267, 11268, 11269, 630
4751, 607, 10996, 10997, 608, 11269, 11270, 11271, 631
4752, 608, 10997, 10998, 609, 11271, 11272, 11273, 632
4753, 609, 10998, 10999, 610, 11273, 11274, 11275, 633
4754, 610, 10999, 846, 14, 11275, 11276, 857, 634
4755, 518, 519, 11000, 10977, 530, 11277, 11278, 11230
4756, 10977, 11000, 11001, 10978, 11278, 11279, 11280, 11232
4757, 10978, 11001, 11002, 10979, 11280, 11281, 11282, 11234
4758, 10979, 11002, 11003, 10980, 11282, 11283, 11284, 11236
4759, 10980, 11003, 11004, 10981, 11284, 11285, 11286, 11238
4760, 10981, 11004, 11005, 10982, 11286, 11287, 11288, 11240
4761, 10982, 11005, 11006, 10983, 11288, 11289, 11290, 11242
4762, 10983, 11006, 11007, 10984, 11290, 11291, 11292, 11244
4763, 10984, 11007, 11008, 10985, 11292, 11293, 11294, 11246
4764, 10985, 11008, 11009, 10986, 11294, 11295, 11296, 11248
4765, 10986, 11009, 11010, 10987, 11296, 11297, 11298, 11250
4766, 10987, 11010, 11011, 10988, 11298, 11299, 11300, 11252
4767, 10988, 11011, 11012, 10989, 11300, 11301, 11302, 11254
4768, 10989, 11012, 11013, 10990, 11302, 11303, 11304, 11256
4769, 10990, 11013, 11014, 10991, 11304, 11305, 11306, 11258
4770, 10991, 11014, 11015, 10992, 11306, 11307, 11308, 11260
4771, 10992, 11015, 11016, 10993, 11308, 11309, 11310, 11262
4772, 10993, 11016, 11017, 10994, 11310, 11311, 11312, 11264
4773, 10994, 11017, 11018, 10995, 11312, 11313, 11314, 11266
4774, 10995, 11018, 11019, 10996, 11314, 11315, 11316, 11268
4775, 10996, 11019, 11020, 10997, 11316, 11317, 11318, 11270
4776, 10997, 11020, 11021, 10998, 11318, 11319, 11320, 11272
4777, 10998, 11021, 11022, 10999, 11320, 11321, 11322, 11274
4778, 10999, 11022, 847, 846, 11322, 11323, 858, 11276
4779, 519, 520, 11023, 11000, 531, 11324, 11325, 11277
4780, 11000, 11023, 11024, 11001, 11325, 11326, 11327, 11279
4781, 11001, 11024, 11025, 11002, 11327, 11328, 11329, 11281
4782, 11002, 11025, 11026, 11003, 11329, 11330, 11331, 11283
4783, 11003, 11026, 11027, 11004, 11331, 11332, 11333, 11285
4784, 11004, 11027, 11028, 11005, 11333, 11334, 11335, 11287
4785, 11005, 11028, 11029, 11006, 11335, 11336, 11337, 11289
4786, 11006, 11029, 11030, 11007, 11337, 11338, 11339, 11291
4787, 11007, 11030, 11031, 11008, 11339, 11340, 11341, 11293
4788, 11008, 11031, 11032, 11009, 11341, 11342, 11343, 11295
4789, 11009, 11032, 11033, 11010, 11343, 11344, 11345, 11297
4790, 11010, 11033, 11034, 11011, 11345, 11346, 11347, 11299
4791, 11011, 11034, 11035, 11012, 11347, 11348, 11349, 11301
4792, 11012, 11035, 11036, 11013, 11349, 11350, 11351, 11303
4793, 11013, 11036, 11037, 11014, 11351, 11352, 11353, 11305
4794, 11014, 11037, 11038, 11015, 11353, 11354, 11355, 11307
4795, 11015, 11038, 11039, 11016, 11355, 11356, 11357, 11309
4796, 11016, 11039, 11040, 11017, 11357, 11358, 11359, 11311
4797, 11017, 11040, 11041, 11018, 11359, 11360, 11361, 11313
4798, 11018, 11041, 11042, 11019, 11361, 11362, 11363, 11315
4799, 11019, 11042, 11043, 11020, 11363, 11364, 11365, 11317
4800, 11020, 11043, 11044, 11021, 11365, 11366, 11367, 11319
4801, 11021, 11044, 11045, 11022, 11367, 11368, 11369, 11321
4802, 11022, 11045, 848, 847, 11369, 11370, 859, 11323
4803, 520, 521, 11046, 11023, 532, 11371, 11372, 11324
4804, 11023, 11046, 11047, 11024, 11372, 11373, 11374, 11326
4805, 11024, 11047, 11048, 11025, 11374, 11375, 11376, 11328
4806, 11025, 11048, 11049, 11026, 11376, 11377, 11378, 11330
4807, 11026, 11049, 11050, 11027, 11378, 11379, 11380, 11332
4808, 11027, 11050, 11051, 11028, 11380, 11381, 11382, 11334
4809, 11028, 11051, 11052, 11029, 11382, 11383, 11384, 11336
4810, 11029, 11052, 11053, 11030, 11384, 11385, 11386, 11338
4811, 11030, 11053, 11054, 11031, 11386, 11387, 11388, 11340
4812, 11031, 11054, 11055, 11032, 11388, 11389, 11390, 11342
4813, 11032, 11055, 11056, 11033, 11390, 11391, 11392, 11344
4814, 11033, 11056, 11057, 11034, 11392, 11393, 11394, 11346
4815, 11034, 11057, 11058, 11035, 11394, 11395, 11396, 11348
4816, 11035, 11058, 11059, 11036, 11396, 11397, 11398, 11350
4817, 11036, 11059, 11060, 11037, 11398, 11399, 11400, 11352
4818, 11037, 11060, 11061, 11038, 11400, 11401, 11402, 11354
4819, 11038, 11061, 11062, 11039, 11402, 11403, 11404, 11356
4820, 11039, 11062, 11063, 11040, 11404, 11405, 11406, 11358
4821, 11040, 11063, 11064, 11041, 11406, 11407, 11408, 11360
4822, 11041, 11064, 11065, 11042, 11408, 11409, 11410, 11362
4823, 11042, 11065, 11066, 11043, 11410, 11411, 11412, 11364
4824, 11043, 11066, 11067, 11044, 11412, 11413, 11414, 11366
4825, 11044, 11067, 11068, 11045, 11414, 11415, 11416, 11368
4826, 11045, 11068, 849, 848, 11416, 11417, 860, 11370
4827, 521, 522, 11069, 11046, 533, 11418, 11419, 11371
4828, 11046, 11069, 11070, 11047, 11419, 11420, 11421, 11373
4829, 11047, 11070, 11071, 11048, 11421, 11422, 11423, 11375
4830, 11048, 11071, 11072, 11049, 11423, 11424, 11425, 11377
4831, 11049, 11072, 11073, 11050, 11425, 11426, 11427, 11379
4832, 11050, 11073, 11074, 11051, 11427, 11428, 11429, 11381
4833, 11051, 11074, 11075, 11052, 11429, 11430, 11431, 11383
4834, 11052, 11075, 11076, 11053, 11431, 11432, 11433, 11385
4835, 11053, 11076, 11077, 11054, 11433, 11434, 11435, 11387
4836, 11054, 11077, 11078, 11055, 11435, 11436, 11437, 11389
4837, 11055, 11078, 11079, 11056, 11437, 11438, 11439, 11391
4838, 11056, 11079, 11080, 11057, 11439, 11440, 11441, 11393
4839, 11057, 11080, 11081, 11058, 11441, 11442, 11443, 11395
4840, 11058, 11081, 11082, 11059, 11443, 11444, 11445, 11397
4841, 11059, 11082, 11083, 11060, 11445, 11446, 11447, 11399
4842, 11060, 11083, 11084, 11061, 11447, 11448, 11449, 11401
4843, 11061, 11084, 11085, 11062, 11449, 11450, 11451, 11403
4844, 11062, 11085, 11086, 11063, 11451, 11452, 11453, 11405
4845, 11063, 11086, 11087, 11064, 11453, 11454, 11455, 11407
4846, 11064, 11087, 11088, 11065, 11455, 11456, 11457, 11409
4847, 11065, 11088, 11089, 11066, 11457, 11458, 11459, 11411
4848, 11066, 11089, 11090, 11067, 11459, 11460, 11461, 11413
4849, 11067, 11090, 11091, 11068, 11461, 11462, 11463, 11415
4850, 11068, 11091, 850, 849, 11463, 11464, 861, 11417
4851, 522, 523, 11092, 11069, 534, 11465, 11466, 11418
4852, 11069, 11092, 11093, 11070, 11466, 11467, 11468, 11420
4853, 11070, 11093, 11094, 11071, 11468, 11469, 11470, 11422
4854, 11071, 11094, 11095, 11072, 11470, 11471, 11472, 11424
4855, 11072, 11095, 11096, 11073, 11472, 11473, 11474, 11426
4856, 11073, 11096, 11097, 11074, 11474, 11475, 11476, 11428
4857, 11074, 11097, 11098, 11075, 11476, 11477, 11478, 11430
4858, 11075, 11098, 11099, 11076, 11478, 11479, 11480, 11432
4859, 11076, 11099, 11100, 11077, 11480, 11481, 11482, 11434
4860, 11077, 11100, 11101, 11078, 11482, 11483, 11484, 11436
4861, 11078, 11101, 11102, 11079, 11484, 11485, 11486, 11438
4862, 11079, 11102, 11103, 11080, 11486, 11487, 11488, 11440
4863, 11080, 11103, 11104, 11081, 11488, 11489, 11490, 11442
4864, 11081, 11104, 11105, 11082, 11490, 11491, 11492, 11444
4865, 11082, 11105, 11106, 11083, 11492, 11493, 11494, 11446
4866, 11083, 11106, 11107, 11084, 11494, 11495, 11496, 11448
4867, 11084, 11107, 11108, 11085, 11496, 11497, 11498, 11450
4868, 11085, 11108, 11109, 11086, 11498, 11499, 11500, 11452
4869, 11086, 11109, 11110, 11087, 11500, 11501, 11502, 11454
4870, 11087, 11110, 11111, 11088, 11502, 11503, 11504, 11456
4871, 11088, 11111, 11112, 11089, 11504, 11505, 11506, 11458
4872, 11089, 11112, 11113, 11090, 11506, 11507, 11508, 11460
4873, 11090, 11113, 11114, 11091, 11508, 11509, 11510, 11462
4874, 11091, 11114, 851, 850, 11510, 11511, 862, 11464
4875, 523, 524, 11115, 11092, 535, 11512, 11513, 11465
4876, 11092, 11115, 11116, 11093, 11513, 11514, 11515, 11467
4877, 11093, 11116, 11117, 11094, 11515, 11516, 11517, 11469
4878, 11094, 11117, 11118, 11095, 11517, 11518, 11519, 11471
4879, 11095, 11118, 11119, 11096, 11519, 11520, 11521, 11473
4880, 11096, 11119, 11120, 11097, 11521, 11522, 11523, 11475
4881, 11097, 11120, 11121, 11098, 11523, 11524, 11525, 11477
4882, 11098, 11121, 11122, 11099, 11525, 11526, 11527, 11479
4883, 11099, 11122, 11123, 11100, 11527, 11528, 11529, 11481
4884, 11100, 11123, 11124, 11101, 11529, 11530, 11531, 11483
4885, 11101, 11124, 11125, 11102, 11531, 11532, 11533, 11485
4886, 11102, 11125, 11126, 11103, 11533, 11534, 11535, 11487
4887, 11103, 11126, 11127, 11104, 11535, 11536, 11537, 11489
4888, 11104, 11127, 11128, 11105, 11537, 11538, 11539, 11491
4889, 11105, 11128, 11129, 11106, 11539, 11540, 11541, 11493
4890, 11106, 11129, 11130, 11107, 11541, 11542, 11543, 11495
4891, 11107, 11130, 11131, 11108, 11543, 11544, 11545, 11497
4892, 11108, 11131, 11132, 11109, 11545, 11546, 11547, 11499
4893, 11109, 11132, 11133, 11110, 11547, 11548, 11549, 11501
4894, 11110, 11133, 11134, 11111, 11549, 11550, 11551, 11503
4895, 11111, 11134, 11135, 11112, 11551, 11552, 11553, 11505
4896, 11112, 11135, 11136, 11113, 11553, 11554, 11555, 11507
4897, 11113, 11136, 11137, 11114, 11555, 11556, 11557, 11509
4898, 11114, 11137, 852, 851, 11557, 11558, 863, 11511
4899, 524, 525, 11138, 11115, 536, 11559, 11560, 11512
4900, 11115, 11138, 11139, 11116, 11560, 11561, 11562, 11514
4901, 11116, 11139, 11140, 11117, 11562, 11563, 11564, 11516
4902, 11117, 11140, 11141, 11118, 11564, 11565, 11566, 11518
4903, 11118, 11141, 11142, 11119, 11566, 11567, 11568, 11520
4904, 11119, 11142, 11143, 11120, 11568, 11569, 11570, 11522
4905, 11120, 11143, 11144, 11121, 11570, 11571, 11572, 11524
4906, 11121, 11144, 11145, 11122, 11572, 11573, 11574, 11526
4907, 11122, 11145, 11146, 11123, 11574, 11575, 11576, 11528
4908, 11123, 11146, 11147, 11124, 11576, 11577, 11578, 11530
4909, 11124, 11147, 11148, 11125, 11578, 11579, 11580, 11532
4910, 11125, 11148, 11149, 11126, 11580, 11581, 11582, 11534
4911, 11126, 11149, 11150, 11127, 11582, 11583, 11584, 11536
4912, 11127, 11150, 11151, 11128, 11584, 11585, 11586, 11538
4913, 11128, 11151, 11152, 11129, 11586, 11587, 11588, 11540
4914, 11129, 11152, 11153, 11130, 11588, 11589, 11590, 11542
4915, 11130, 11153, 11154, 11131, 11590, 11591, 11592, 11544
4916, 11131, 11154, 11155, 11132, 11592, 11593, 11594, 11546
4917, 11132, 11155, 11156, 11133, 11594, 11595, 11596, 11548
4918, 11133, 11156, 11157, 11134, 11596, 11597, 11598, 11550
