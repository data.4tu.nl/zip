115923, 1.825, -0.06, 0.16666666666667
115924, 1.825, -0.08, 0.14583333333333
115925, 1.8041666666667, -0.08, 0.16666666666667
115926, 1.825, -0.1, 0.16666666666667
115927, 1.825, -0.12, 0.14583333333333
115928, 1.8041666666667, -0.12, 0.16666666666667
115929, 1.825, -0.14, 0.16666666666667
115930, 1.825, -0.16, 0.14583333333333
115931, 1.8041666666667, -0.16, 0.16666666666667
115932, 1.825, -0.18, 0.16666666666667
115933, 1.8666666666667, -0.02, 0.16666666666667
115934, 1.8666666666667, -0.04, 0.14583333333333
115935, 1.8458333333333, -0.04, 0.16666666666667
115936, 1.8666666666667, -0.06, 0.16666666666667
115937, 1.8666666666667, -0.08, 0.14583333333333
115938, 1.8458333333333, -0.08, 0.16666666666667
115939, 1.8666666666667, -0.1, 0.16666666666667
115940, 1.8666666666667, -0.12, 0.14583333333333
115941, 1.8458333333333, -0.12, 0.16666666666667
115942, 1.8666666666667, -0.14, 0.16666666666667
115943, 1.8666666666667, -0.16, 0.14583333333333
115944, 1.8458333333333, -0.16, 0.16666666666667
115945, 1.8666666666667, -0.18, 0.16666666666667
115946, 1.9083333333333, -0.02, 0.16666666666667
115947, 1.9083333333333, -0.04, 0.14583333333333
115948, 1.8875, -0.04, 0.16666666666667
115949, 1.9083333333333, -0.06, 0.16666666666667
115950, 1.9083333333333, -0.08, 0.14583333333333
115951, 1.8875, -0.08, 0.16666666666667
115952, 1.9083333333333, -0.1, 0.16666666666667
115953, 1.9083333333333, -0.12, 0.14583333333333
115954, 1.8875, -0.12, 0.16666666666667
115955, 1.9083333333333, -0.14, 0.16666666666667
115956, 1.9083333333333, -0.16, 0.14583333333333
115957, 1.8875, -0.16, 0.16666666666667
115958, 1.9083333333333, -0.18, 0.16666666666667
115959, 1.95, -0.02, 0.16666666666667
115960, 1.95, -0.04, 0.14583333333333
115961, 1.9291666666667, -0.04, 0.16666666666667
115962, 1.95, -0.06, 0.16666666666667
115963, 1.95, -0.08, 0.14583333333333
115964, 1.9291666666667, -0.08, 0.16666666666667
115965, 1.95, -0.1, 0.16666666666667
115966, 1.95, -0.12, 0.14583333333333
115967, 1.9291666666667, -0.12, 0.16666666666667
115968, 1.95, -0.14, 0.16666666666667
115969, 1.95, -0.16, 0.14583333333333
115970, 1.9291666666667, -0.16, 0.16666666666667
115971, 1.95, -0.18, 0.16666666666667
115972, 1.9916666666667, -0.02, 0.16666666666667
115973, 1.9916666666667, -0.04, 0.14583333333333
115974, 1.9708333333333, -0.04, 0.16666666666667
115975, 1.9916666666667, -0.06, 0.16666666666667
115976, 1.9916666666667, -0.08, 0.14583333333333
115977, 1.9708333333333, -0.08, 0.16666666666667
115978, 1.9916666666667, -0.1, 0.16666666666667
115979, 1.9916666666667, -0.12, 0.14583333333333
115980, 1.9708333333333, -0.12, 0.16666666666667
115981, 1.9916666666667, -0.14, 0.16666666666667
115982, 1.9916666666667, -0.16, 0.14583333333333
115983, 1.9708333333333, -0.16, 0.16666666666667
115984, 1.9916666666667, -0.18, 0.16666666666667
115985, 2.0333333333333, -0.02, 0.16666666666667
115986, 2.0333333333333, -0.04, 0.14583333333333
115987, 2.0125, -0.04, 0.16666666666667
115988, 2.0333333333333, -0.06, 0.16666666666667
115989, 2.0333333333333, -0.08, 0.14583333333333
115990, 2.0125, -0.08, 0.16666666666667
115991, 2.0333333333333, -0.1, 0.16666666666667
115992, 2.0333333333333, -0.12, 0.14583333333333
115993, 2.0125, -0.12, 0.16666666666667
115994, 2.0333333333333, -0.14, 0.16666666666667
115995, 2.0333333333333, -0.16, 0.14583333333333
115996, 2.0125, -0.16, 0.16666666666667
115997, 2.0333333333333, -0.18, 0.16666666666667
115998, 2.075, -0.02, 0.16666666666667
115999, 2.075, -0.04, 0.14583333333333
116000, 2.0541666666667, -0.04, 0.16666666666667
116001, 2.075, -0.06, 0.16666666666667
116002, 2.075, -0.08, 0.14583333333333
116003, 2.0541666666667, -0.08, 0.16666666666667
116004, 2.075, -0.1, 0.16666666666667
116005, 2.075, -0.12, 0.14583333333333
116006, 2.0541666666667, -0.12, 0.16666666666667
116007, 2.075, -0.14, 0.16666666666667
116008, 2.075, -0.16, 0.14583333333333
116009, 2.0541666666667, -0.16, 0.16666666666667
116010, 2.075, -0.18, 0.16666666666667
116011, 2.1166666666667, -0.02, 0.16666666666667
116012, 2.1166666666667, -0.04, 0.14583333333333
116013, 2.0958333333333, -0.04, 0.16666666666667
116014, 2.1166666666667, -0.06, 0.16666666666667
116015, 2.1166666666667, -0.08, 0.14583333333333
116016, 2.0958333333333, -0.08, 0.16666666666667
116017, 2.1166666666667, -0.1, 0.16666666666667
116018, 2.1166666666667, -0.12, 0.14583333333333
116019, 2.0958333333333, -0.12, 0.16666666666667
116020, 2.1166666666667, -0.14, 0.16666666666667
116021, 2.1166666666667, -0.16, 0.14583333333333
116022, 2.0958333333333, -0.16, 0.16666666666667
116023, 2.1166666666667, -0.18, 0.16666666666667
116024, 2.1583333333333, -0.02, 0.16666666666667
116025, 2.1583333333333, -0.04, 0.14583333333333
116026, 2.1375, -0.04, 0.16666666666667
116027, 2.1583333333333, -0.06, 0.16666666666667
116028, 2.1583333333333, -0.08, 0.14583333333333
116029, 2.1375, -0.08, 0.16666666666667
116030, 2.1583333333333, -0.1, 0.16666666666667
116031, 2.1583333333333, -0.12, 0.14583333333333
116032, 2.1375, -0.12, 0.16666666666667
116033, 2.1583333333333, -0.14, 0.16666666666667
116034, 2.1583333333333, -0.16, 0.14583333333333
116035, 2.1375, -0.16, 0.16666666666667
116036, 2.1583333333333, -0.18, 0.16666666666667
116037, 2.1791666666667, -0.04, 0.16666666666667
116038, 2.1791666666667, -0.08, 0.16666666666667
116039, 2.1791666666667, -0.12, 0.16666666666667
116040, 2.1791666666667, -0.16, 0.16666666666667
116041, 1.2416666666667, -0.02, 0.20833333333333
116042, 1.2416666666667, -0.04, 0.1875
116043, 1.2208333333333, -0.04, 0.20833333333333
116044, 1.2416666666667, -0.06, 0.20833333333333
116045, 1.2416666666667, -0.08, 0.1875
116046, 1.2208333333333, -0.08, 0.20833333333333
116047, 1.2416666666667, -0.1, 0.20833333333333
116048, 1.2416666666667, -0.12, 0.1875
116049, 1.2208333333333, -0.12, 0.20833333333333
116050, 1.2416666666667, -0.14, 0.20833333333333
116051, 1.2416666666667, -0.16, 0.1875
116052, 1.2208333333333, -0.16, 0.20833333333333
116053, 1.2416666666667, -0.18, 0.20833333333333
116054, 1.2833333333333, -0.02, 0.20833333333333
116055, 1.2833333333333, -0.04, 0.1875
116056, 1.2625, -0.04, 0.20833333333333
116057, 1.2833333333333, -0.06, 0.20833333333333
116058, 1.2833333333333, -0.08, 0.1875
116059, 1.2625, -0.08, 0.20833333333333
116060, 1.2833333333333, -0.1, 0.20833333333333
116061, 1.2833333333333, -0.12, 0.1875
116062, 1.2625, -0.12, 0.20833333333333
116063, 1.2833333333333, -0.14, 0.20833333333333
116064, 1.2833333333333, -0.16, 0.1875
116065, 1.2625, -0.16, 0.20833333333333
116066, 1.2833333333333, -0.18, 0.20833333333333
116067, 1.325, -0.02, 0.20833333333333
116068, 1.325, -0.04, 0.1875
116069, 1.3041666666667, -0.04, 0.20833333333333
116070, 1.325, -0.06, 0.20833333333333
116071, 1.325, -0.08, 0.1875
116072, 1.3041666666667, -0.08, 0.20833333333333
116073, 1.325, -0.1, 0.20833333333333
116074, 1.325, -0.12, 0.1875
116075, 1.3041666666667, -0.12, 0.20833333333333
116076, 1.325, -0.14, 0.20833333333333
116077, 1.325, -0.16, 0.1875
116078, 1.3041666666667, -0.16, 0.20833333333333
116079, 1.325, -0.18, 0.20833333333333
116080, 1.3666666666667, -0.02, 0.20833333333333
116081, 1.3666666666667, -0.04, 0.1875
116082, 1.3458333333333, -0.04, 0.20833333333333
116083, 1.3666666666667, -0.06, 0.20833333333333
116084, 1.3666666666667, -0.08, 0.1875
116085, 1.3458333333333, -0.08, 0.20833333333333
116086, 1.3666666666667, -0.1, 0.20833333333333
116087, 1.3666666666667, -0.12, 0.1875
116088, 1.3458333333333, -0.12, 0.20833333333333
116089, 1.3666666666667, -0.14, 0.20833333333333
116090, 1.3666666666667, -0.16, 0.1875
116091, 1.3458333333333, -0.16, 0.20833333333333
116092, 1.3666666666667, -0.18, 0.20833333333333
116093, 1.4083333333333, -0.02, 0.20833333333333
116094, 1.4083333333333, -0.04, 0.1875
116095, 1.3875, -0.04, 0.20833333333333
116096, 1.4083333333333, -0.06, 0.20833333333333
116097, 1.4083333333333, -0.08, 0.1875
116098, 1.3875, -0.08, 0.20833333333333
116099, 1.4083333333333, -0.1, 0.20833333333333
116100, 1.4083333333333, -0.12, 0.1875
116101, 1.3875, -0.12, 0.20833333333333
116102, 1.4083333333333, -0.14, 0.20833333333333
116103, 1.4083333333333, -0.16, 0.1875
116104, 1.3875, -0.16, 0.20833333333333
116105, 1.4083333333333, -0.18, 0.20833333333333
116106, 1.45, -0.02, 0.20833333333333
116107, 1.45, -0.04, 0.1875
116108, 1.4291666666667, -0.04, 0.20833333333333
116109, 1.45, -0.06, 0.20833333333333
116110, 1.45, -0.08, 0.1875
116111, 1.4291666666667, -0.08, 0.20833333333333
116112, 1.45, -0.1, 0.20833333333333
116113, 1.45, -0.12, 0.1875
116114, 1.4291666666667, -0.12, 0.20833333333333
116115, 1.45, -0.14, 0.20833333333333
116116, 1.45, -0.16, 0.1875
116117, 1.4291666666667, -0.16, 0.20833333333333
116118, 1.45, -0.18, 0.20833333333333
116119, 1.4916666666667, -0.02, 0.20833333333333
116120, 1.4916666666667, -0.04, 0.1875
116121, 1.4708333333333, -0.04, 0.20833333333333
116122, 1.4916666666667, -0.06, 0.20833333333333
116123, 1.4916666666667, -0.08, 0.1875
116124, 1.4708333333333, -0.08, 0.20833333333333
116125, 1.4916666666667, -0.1, 0.20833333333333
116126, 1.4916666666667, -0.12, 0.1875
116127, 1.4708333333333, -0.12, 0.20833333333333
116128, 1.4916666666667, -0.14, 0.20833333333333
116129, 1.4916666666667, -0.16, 0.1875
116130, 1.4708333333333, -0.16, 0.20833333333333
116131, 1.4916666666667, -0.18, 0.20833333333333
116132, 1.5333333333333, -0.02, 0.20833333333333
116133, 1.5333333333333, -0.04, 0.1875
116134, 1.5125, -0.04, 0.20833333333333
116135, 1.5333333333333, -0.06, 0.20833333333333
116136, 1.5333333333333, -0.08, 0.1875
116137, 1.5125, -0.08, 0.20833333333333
116138, 1.5333333333333, -0.1, 0.20833333333333
116139, 1.5333333333333, -0.12, 0.1875
116140, 1.5125, -0.12, 0.20833333333333
116141, 1.5333333333333, -0.14, 0.20833333333333
116142, 1.5333333333333, -0.16, 0.1875
116143, 1.5125, -0.16, 0.20833333333333
116144, 1.5333333333333, -0.18, 0.20833333333333
116145, 1.575, -0.02, 0.20833333333333
116146, 1.575, -0.04, 0.1875
116147, 1.5541666666667, -0.04, 0.20833333333333
116148, 1.575, -0.06, 0.20833333333333
116149, 1.575, -0.08, 0.1875
116150, 1.5541666666667, -0.08, 0.20833333333333
116151, 1.575, -0.1, 0.20833333333333
116152, 1.575, -0.12, 0.1875
116153, 1.5541666666667, -0.12, 0.20833333333333
116154, 1.575, -0.14, 0.20833333333333
116155, 1.575, -0.16, 0.1875
116156, 1.5541666666667, -0.16, 0.20833333333333
116157, 1.575, -0.18, 0.20833333333333
116158, 1.6166666666667, -0.02, 0.20833333333333
116159, 1.6166666666667, -0.04, 0.1875
116160, 1.5958333333333, -0.04, 0.20833333333333
116161, 1.6166666666667, -0.06, 0.20833333333333
116162, 1.6166666666667, -0.08, 0.1875
116163, 1.5958333333333, -0.08, 0.20833333333333
116164, 1.6166666666667, -0.1, 0.20833333333333
116165, 1.6166666666667, -0.12, 0.1875
116166, 1.5958333333333, -0.12, 0.20833333333333
116167, 1.6166666666667, -0.14, 0.20833333333333
116168, 1.6166666666667, -0.16, 0.1875
116169, 1.5958333333333, -0.16, 0.20833333333333
116170, 1.6166666666667, -0.18, 0.20833333333333
116171, 1.6583333333333, -0.02, 0.20833333333333
116172, 1.6583333333333, -0.04, 0.1875
116173, 1.6375, -0.04, 0.20833333333333
116174, 1.6583333333333, -0.06, 0.20833333333333
116175, 1.6583333333333, -0.08, 0.1875
116176, 1.6375, -0.08, 0.20833333333333
116177, 1.6583333333333, -0.1, 0.20833333333333
116178, 1.6583333333333, -0.12, 0.1875
116179, 1.6375, -0.12, 0.20833333333333
116180, 1.6583333333333, -0.14, 0.20833333333333
116181, 1.6583333333333, -0.16, 0.1875
116182, 1.6375, -0.16, 0.20833333333333
116183, 1.6583333333333, -0.18, 0.20833333333333
116184, 1.7, -0.02, 0.20833333333333
116185, 1.7, -0.04, 0.1875
116186, 1.6791666666667, -0.04, 0.20833333333333
116187, 1.7, -0.06, 0.20833333333333
116188, 1.7, -0.08, 0.1875
116189, 1.6791666666667, -0.08, 0.20833333333333
116190, 1.7, -0.1, 0.20833333333333
116191, 1.7, -0.12, 0.1875
116192, 1.6791666666667, -0.12, 0.20833333333333
116193, 1.7, -0.14, 0.20833333333333
116194, 1.7, -0.16, 0.1875
116195, 1.6791666666667, -0.16, 0.20833333333333
116196, 1.7, -0.18, 0.20833333333333
116197, 1.7416666666667, -0.02, 0.20833333333333
116198, 1.7416666666667, -0.04, 0.1875
116199, 1.7208333333333, -0.04, 0.20833333333333
116200, 1.7416666666667, -0.06, 0.20833333333333
116201, 1.7416666666667, -0.08, 0.1875
116202, 1.7208333333333, -0.08, 0.20833333333333
116203, 1.7416666666667, -0.1, 0.20833333333333
116204, 1.7416666666667, -0.12, 0.1875
116205, 1.7208333333333, -0.12, 0.20833333333333
116206, 1.7416666666667, -0.14, 0.20833333333333
116207, 1.7416666666667, -0.16, 0.1875
116208, 1.7208333333333, -0.16, 0.20833333333333
116209, 1.7416666666667, -0.18, 0.20833333333333
116210, 1.7833333333333, -0.02, 0.20833333333333
116211, 1.7833333333333, -0.04, 0.1875
116212, 1.7625, -0.04, 0.20833333333333
116213, 1.7833333333333, -0.06, 0.20833333333333
116214, 1.7833333333333, -0.08, 0.1875
116215, 1.7625, -0.08, 0.20833333333333
116216, 1.7833333333333, -0.1, 0.20833333333333
116217, 1.7833333333333, -0.12, 0.1875
116218, 1.7625, -0.12, 0.20833333333333
116219, 1.7833333333333, -0.14, 0.20833333333333
116220, 1.7833333333333, -0.16, 0.1875
116221, 1.7625, -0.16, 0.20833333333333
116222, 1.7833333333333, -0.18, 0.20833333333333
116223, 1.825, -0.02, 0.20833333333333
116224, 1.825, -0.04, 0.1875
116225, 1.8041666666667, -0.04, 0.20833333333333
116226, 1.825, -0.06, 0.20833333333333
116227, 1.825, -0.08, 0.1875
116228, 1.8041666666667, -0.08, 0.20833333333333
116229, 1.825, -0.1, 0.20833333333333
116230, 1.825, -0.12, 0.1875
116231, 1.8041666666667, -0.12, 0.20833333333333
116232, 1.825, -0.14, 0.20833333333333
116233, 1.825, -0.16, 0.1875
116234, 1.8041666666667, -0.16, 0.20833333333333
116235, 1.825, -0.18, 0.20833333333333
116236, 1.8666666666667, -0.02, 0.20833333333333
116237, 1.8666666666667, -0.04, 0.1875
116238, 1.8458333333333, -0.04, 0.20833333333333
116239, 1.8666666666667, -0.06, 0.20833333333333
116240, 1.8666666666667, -0.08, 0.1875
116241, 1.8458333333333, -0.08, 0.20833333333333
116242, 1.8666666666667, -0.1, 0.20833333333333
116243, 1.8666666666667, -0.12, 0.1875
116244, 1.8458333333333, -0.12, 0.20833333333333
116245, 1.8666666666667, -0.14, 0.20833333333333
116246, 1.8666666666667, -0.16, 0.1875
116247, 1.8458333333333, -0.16, 0.20833333333333
116248, 1.8666666666667, -0.18, 0.20833333333333
116249, 1.9083333333333, -0.02, 0.20833333333333
116250, 1.9083333333333, -0.04, 0.1875
116251, 1.8875, -0.04, 0.20833333333333
116252, 1.9083333333333, -0.06, 0.20833333333333
116253, 1.9083333333333, -0.08, 0.1875
116254, 1.8875, -0.08, 0.20833333333333
116255, 1.9083333333333, -0.1, 0.20833333333333
116256, 1.9083333333333, -0.12, 0.1875
116257, 1.8875, -0.12, 0.20833333333333
116258, 1.9083333333333, -0.14, 0.20833333333333
116259, 1.9083333333333, -0.16, 0.1875
116260, 1.8875, -0.16, 0.20833333333333
116261, 1.9083333333333, -0.18, 0.20833333333333
116262, 1.95, -0.02, 0.20833333333333
116263, 1.95, -0.04, 0.1875
116264, 1.9291666666667, -0.04, 0.20833333333333
116265, 1.95, -0.06, 0.20833333333333
116266, 1.95, -0.08, 0.1875
116267, 1.9291666666667, -0.08, 0.20833333333333
116268, 1.95, -0.1, 0.20833333333333
116269, 1.95, -0.12, 0.1875
116270, 1.9291666666667, -0.12, 0.20833333333333
116271, 1.95, -0.14, 0.20833333333333
116272, 1.95, -0.16, 0.1875
116273, 1.9291666666667, -0.16, 0.20833333333333
116274, 1.95, -0.18, 0.20833333333333
116275, 1.9916666666667, -0.02, 0.20833333333333
116276, 1.9916666666667, -0.04, 0.1875
116277, 1.9708333333333, -0.04, 0.20833333333333
116278, 1.9916666666667, -0.06, 0.20833333333333
116279, 1.9916666666667, -0.08, 0.1875
116280, 1.9708333333333, -0.08, 0.20833333333333
116281, 1.9916666666667, -0.1, 0.20833333333333
116282, 1.9916666666667, -0.12, 0.1875
116283, 1.9708333333333, -0.12, 0.20833333333333
116284, 1.9916666666667, -0.14, 0.20833333333333
116285, 1.9916666666667, -0.16, 0.1875
116286, 1.9708333333333, -0.16, 0.20833333333333
116287, 1.9916666666667, -0.18, 0.20833333333333
116288, 2.0333333333333, -0.02, 0.20833333333333
116289, 2.0333333333333, -0.04, 0.1875
116290, 2.0125, -0.04, 0.20833333333333
116291, 2.0333333333333, -0.06, 0.20833333333333
116292, 2.0333333333333, -0.08, 0.1875
116293, 2.0125, -0.08, 0.20833333333333
116294, 2.0333333333333, -0.1, 0.20833333333333
116295, 2.0333333333333, -0.12, 0.1875
116296, 2.0125, -0.12, 0.20833333333333
116297, 2.0333333333333, -0.14, 0.20833333333333
116298, 2.0333333333333, -0.16, 0.1875
116299, 2.0125, -0.16, 0.20833333333333
116300, 2.0333333333333, -0.18, 0.20833333333333
116301, 2.075, -0.02, 0.20833333333333
116302, 2.075, -0.04, 0.1875
116303, 2.0541666666667, -0.04, 0.20833333333333
116304, 2.075, -0.06, 0.20833333333333
116305, 2.075, -0.08, 0.1875
116306, 2.0541666666667, -0.08, 0.20833333333333
116307, 2.075, -0.1, 0.20833333333333
116308, 2.075, -0.12, 0.1875
116309, 2.0541666666667, -0.12, 0.20833333333333
116310, 2.075, -0.14, 0.20833333333333
116311, 2.075, -0.16, 0.1875
116312, 2.0541666666667, -0.16, 0.20833333333333
116313, 2.075, -0.18, 0.20833333333333
116314, 2.1166666666667, -0.02, 0.20833333333333
116315, 2.1166666666667, -0.04, 0.1875
116316, 2.0958333333333, -0.04, 0.20833333333333
116317, 2.1166666666667, -0.06, 0.20833333333333
116318, 2.1166666666667, -0.08, 0.1875
116319, 2.0958333333333, -0.08, 0.20833333333333
116320, 2.1166666666667, -0.1, 0.20833333333333
116321, 2.1166666666667, -0.12, 0.1875
116322, 2.0958333333333, -0.12, 0.20833333333333
116323, 2.1166666666667, -0.14, 0.20833333333333
116324, 2.1166666666667, -0.16, 0.1875
116325, 2.0958333333333, -0.16, 0.20833333333333
116326, 2.1166666666667, -0.18, 0.20833333333333
116327, 2.1583333333333, -0.02, 0.20833333333333
116328, 2.1583333333333, -0.04, 0.1875
116329, 2.1375, -0.04, 0.20833333333333
116330, 2.1583333333333, -0.06, 0.20833333333333
116331, 2.1583333333333, -0.08, 0.1875
116332, 2.1375, -0.08, 0.20833333333333
116333, 2.1583333333333, -0.1, 0.20833333333333
116334, 2.1583333333333, -0.12, 0.1875
116335, 2.1375, -0.12, 0.20833333333333
116336, 2.1583333333333, -0.14, 0.20833333333333
116337, 2.1583333333333, -0.16, 0.1875
116338, 2.1375, -0.16, 0.20833333333333
116339, 2.1583333333333, -0.18, 0.20833333333333
116340, 2.1791666666667, -0.04, 0.20833333333333
116341, 2.1791666666667, -0.08, 0.20833333333333
116342, 2.1791666666667, -0.12, 0.20833333333333
116343, 2.1791666666667, -0.16, 0.20833333333333
116344, 1.2416666666667, -0.02, 0.25
116345, 1.2416666666667, -0.04, 0.22916666666667
116346, 1.2208333333333, -0.04, 0.25
116347, 1.2416666666667, -0.06, 0.25
116348, 1.2416666666667, -0.08, 0.22916666666667
116349, 1.2208333333333, -0.08, 0.25
116350, 1.2416666666667, -0.1, 0.25
116351, 1.2416666666667, -0.12, 0.22916666666667
116352, 1.2208333333333, -0.12, 0.25
116353, 1.2416666666667, -0.14, 0.25
116354, 1.2416666666667, -0.16, 0.22916666666667
116355, 1.2208333333333, -0.16, 0.25
116356, 1.2416666666667, -0.18, 0.25
116357, 1.2833333333333, -0.02, 0.25
116358, 1.2833333333333, -0.04, 0.22916666666667
116359, 1.2625, -0.04, 0.25
116360, 1.2833333333333, -0.06, 0.25
116361, 1.2833333333333, -0.08, 0.22916666666667
116362, 1.2625, -0.08, 0.25
116363, 1.2833333333333, -0.1, 0.25
116364, 1.2833333333333, -0.12, 0.22916666666667
116365, 1.2625, -0.12, 0.25
116366, 1.2833333333333, -0.14, 0.25
116367, 1.2833333333333, -0.16, 0.22916666666667
116368, 1.2625, -0.16, 0.25
116369, 1.2833333333333, -0.18, 0.25
116370, 1.325, -0.02, 0.25
116371, 1.325, -0.04, 0.22916666666667
116372, 1.3041666666667, -0.04, 0.25
116373, 1.325, -0.06, 0.25
116374, 1.325, -0.08, 0.22916666666667
116375, 1.3041666666667, -0.08, 0.25
116376, 1.325, -0.1, 0.25
116377, 1.325, -0.12, 0.22916666666667
116378, 1.3041666666667, -0.12, 0.25
116379, 1.325, -0.14, 0.25
116380, 1.325, -0.16, 0.22916666666667
116381, 1.3041666666667, -0.16, 0.25
116382, 1.325, -0.18, 0.25
116383, 1.3666666666667, -0.02, 0.25
116384, 1.3666666666667, -0.04, 0.22916666666667
116385, 1.3458333333333, -0.04, 0.25
116386, 1.3666666666667, -0.06, 0.25
116387, 1.3666666666667, -0.08, 0.22916666666667
116388, 1.3458333333333, -0.08, 0.25
116389, 1.3666666666667, -0.1, 0.25
116390, 1.3666666666667, -0.12, 0.22916666666667
116391, 1.3458333333333, -0.12, 0.25
116392, 1.3666666666667, -0.14, 0.25
116393, 1.3666666666667, -0.16, 0.22916666666667
116394, 1.3458333333333, -0.16, 0.25
116395, 1.3666666666667, -0.18, 0.25
116396, 1.4083333333333, -0.02, 0.25
116397, 1.4083333333333, -0.04, 0.22916666666667
116398, 1.3875, -0.04, 0.25
116399, 1.4083333333333, -0.06, 0.25
116400, 1.4083333333333, -0.08, 0.22916666666667
116401, 1.3875, -0.08, 0.25
116402, 1.4083333333333, -0.1, 0.25
116403, 1.4083333333333, -0.12, 0.22916666666667
116404, 1.3875, -0.12, 0.25
116405, 1.4083333333333, -0.14, 0.25
116406, 1.4083333333333, -0.16, 0.22916666666667
116407, 1.3875, -0.16, 0.25
116408, 1.4083333333333, -0.18, 0.25
116409, 1.45, -0.02, 0.25
116410, 1.45, -0.04, 0.22916666666667
116411, 1.4291666666667, -0.04, 0.25
116412, 1.45, -0.06, 0.25
116413, 1.45, -0.08, 0.22916666666667
116414, 1.4291666666667, -0.08, 0.25
116415, 1.45, -0.1, 0.25
116416, 1.45, -0.12, 0.22916666666667
116417, 1.4291666666667, -0.12, 0.25
116418, 1.45, -0.14, 0.25
116419, 1.45, -0.16, 0.22916666666667
116420, 1.4291666666667, -0.16, 0.25
116421, 1.45, -0.18, 0.25
116422, 1.4916666666667, -0.02, 0.25
116423, 1.4916666666667, -0.04, 0.22916666666667
116424, 1.4708333333333, -0.04, 0.25
116425, 1.4916666666667, -0.06, 0.25
116426, 1.4916666666667, -0.08, 0.22916666666667
116427, 1.4708333333333, -0.08, 0.25
116428, 1.4916666666667, -0.1, 0.25
116429, 1.4916666666667, -0.12, 0.22916666666667
116430, 1.4708333333333, -0.12, 0.25
116431, 1.4916666666667, -0.14, 0.25
116432, 1.4916666666667, -0.16, 0.22916666666667
116433, 1.4708333333333, -0.16, 0.25
116434, 1.4916666666667, -0.18, 0.25
116435, 1.5333333333333, -0.02, 0.25
116436, 1.5333333333333, -0.04, 0.22916666666667
116437, 1.5125, -0.04, 0.25
116438, 1.5333333333333, -0.06, 0.25
116439, 1.5333333333333, -0.08, 0.22916666666667
116440, 1.5125, -0.08, 0.25
116441, 1.5333333333333, -0.1, 0.25
116442, 1.5333333333333, -0.12, 0.22916666666667
116443, 1.5125, -0.12, 0.25
116444, 1.5333333333333, -0.14, 0.25
116445, 1.5333333333333, -0.16, 0.22916666666667
116446, 1.5125, -0.16, 0.25
116447, 1.5333333333333, -0.18, 0.25
116448, 1.575, -0.02, 0.25
116449, 1.575, -0.04, 0.22916666666667
116450, 1.5541666666667, -0.04, 0.25
116451, 1.575, -0.06, 0.25
116452, 1.575, -0.08, 0.22916666666667
116453, 1.5541666666667, -0.08, 0.25
116454, 1.575, -0.1, 0.25
116455, 1.575, -0.12, 0.22916666666667
116456, 1.5541666666667, -0.12, 0.25
116457, 1.575, -0.14, 0.25
116458, 1.575, -0.16, 0.22916666666667
116459, 1.5541666666667, -0.16, 0.25
116460, 1.575, -0.18, 0.25
116461, 1.6166666666667, -0.02, 0.25
116462, 1.6166666666667, -0.04, 0.22916666666667
116463, 1.5958333333333, -0.04, 0.25
116464, 1.6166666666667, -0.06, 0.25
116465, 1.6166666666667, -0.08, 0.22916666666667
116466, 1.5958333333333, -0.08, 0.25
116467, 1.6166666666667, -0.1, 0.25
116468, 1.6166666666667, -0.12, 0.22916666666667
116469, 1.5958333333333, -0.12, 0.25
116470, 1.6166666666667, -0.14, 0.25
116471, 1.6166666666667, -0.16, 0.22916666666667
116472, 1.5958333333333, -0.16, 0.25
116473, 1.6166666666667, -0.18, 0.25
116474, 1.6583333333333, -0.02, 0.25
116475, 1.6583333333333, -0.04, 0.22916666666667
116476, 1.6375, -0.04, 0.25
116477, 1.6583333333333, -0.06, 0.25
116478, 1.6583333333333, -0.08, 0.22916666666667
116479, 1.6375, -0.08, 0.25
116480, 1.6583333333333, -0.1, 0.25
116481, 1.6583333333333, -0.12, 0.22916666666667
116482, 1.6375, -0.12, 0.25
116483, 1.6583333333333, -0.14, 0.25
116484, 1.6583333333333, -0.16, 0.22916666666667
116485, 1.6375, -0.16, 0.25
116486, 1.6583333333333, -0.18, 0.25
116487, 1.7, -0.02, 0.25
116488, 1.7, -0.04, 0.22916666666667
116489, 1.6791666666667, -0.04, 0.25
116490, 1.7, -0.06, 0.25
116491, 1.7, -0.08, 0.22916666666667
116492, 1.6791666666667, -0.08, 0.25
116493, 1.7, -0.1, 0.25
116494, 1.7, -0.12, 0.22916666666667
116495, 1.6791666666667, -0.12, 0.25
116496, 1.7, -0.14, 0.25
116497, 1.7, -0.16, 0.22916666666667
116498, 1.6791666666667, -0.16, 0.25
116499, 1.7, -0.18, 0.25
116500, 1.7416666666667, -0.02, 0.25
116501, 1.7416666666667, -0.04, 0.22916666666667
116502, 1.7208333333333, -0.04, 0.25
116503, 1.7416666666667, -0.06, 0.25
116504, 1.7416666666667, -0.08, 0.22916666666667
116505, 1.7208333333333, -0.08, 0.25
116506, 1.7416666666667, -0.1, 0.25
116507, 1.7416666666667, -0.12, 0.22916666666667
116508, 1.7208333333333, -0.12, 0.25
116509, 1.7416666666667, -0.14, 0.25
116510, 1.7416666666667, -0.16, 0.22916666666667
116511, 1.7208333333333, -0.16, 0.25
116512, 1.7416666666667, -0.18, 0.25
116513, 1.7833333333333, -0.02, 0.25
116514, 1.7833333333333, -0.04, 0.22916666666667
116515, 1.7625, -0.04, 0.25
116516, 1.7833333333333, -0.06, 0.25
116517, 1.7833333333333, -0.08, 0.22916666666667
116518, 1.7625, -0.08, 0.25
116519, 1.7833333333333, -0.1, 0.25
116520, 1.7833333333333, -0.12, 0.22916666666667
116521, 1.7625, -0.12, 0.25
116522, 1.7833333333333, -0.14, 0.25
116523, 1.7833333333333, -0.16, 0.22916666666667
116524, 1.7625, -0.16, 0.25
116525, 1.7833333333333, -0.18, 0.25
116526, 1.825, -0.02, 0.25
116527, 1.825, -0.04, 0.22916666666667
116528, 1.8041666666667, -0.04, 0.25
116529, 1.825, -0.06, 0.25
116530, 1.825, -0.08, 0.22916666666667
116531, 1.8041666666667, -0.08, 0.25
116532, 1.825, -0.1, 0.25
116533, 1.825, -0.12, 0.22916666666667
116534, 1.8041666666667, -0.12, 0.25
116535, 1.825, -0.14, 0.25
116536, 1.825, -0.16, 0.22916666666667
116537, 1.8041666666667, -0.16, 0.25
116538, 1.825, -0.18, 0.25
116539, 1.8666666666667, -0.02, 0.25
116540, 1.8666666666667, -0.04, 0.22916666666667
116541, 1.8458333333333, -0.04, 0.25
116542, 1.8666666666667, -0.06, 0.25
116543, 1.8666666666667, -0.08, 0.22916666666667
116544, 1.8458333333333, -0.08, 0.25
116545, 1.8666666666667, -0.1, 0.25
116546, 1.8666666666667, -0.12, 0.22916666666667
116547, 1.8458333333333, -0.12, 0.25
116548, 1.8666666666667, -0.14, 0.25
116549, 1.8666666666667, -0.16, 0.22916666666667
116550, 1.8458333333333, -0.16, 0.25
116551, 1.8666666666667, -0.18, 0.25
116552, 1.9083333333333, -0.02, 0.25
116553, 1.9083333333333, -0.04, 0.22916666666667
116554, 1.8875, -0.04, 0.25
116555, 1.9083333333333, -0.06, 0.25
116556, 1.9083333333333, -0.08, 0.22916666666667
116557, 1.8875, -0.08, 0.25
116558, 1.9083333333333, -0.1, 0.25
116559, 1.9083333333333, -0.12, 0.22916666666667
116560, 1.8875, -0.12, 0.25
116561, 1.9083333333333, -0.14, 0.25
116562, 1.9083333333333, -0.16, 0.22916666666667
116563, 1.8875, -0.16, 0.25
116564, 1.9083333333333, -0.18, 0.25
116565, 1.95, -0.02, 0.25
116566, 1.95, -0.04, 0.22916666666667
116567, 1.9291666666667, -0.04, 0.25
116568, 1.95, -0.06, 0.25
116569, 1.95, -0.08, 0.22916666666667
116570, 1.9291666666667, -0.08, 0.25
116571, 1.95, -0.1, 0.25
116572, 1.95, -0.12, 0.22916666666667
116573, 1.9291666666667, -0.12, 0.25
116574, 1.95, -0.14, 0.25
116575, 1.95, -0.16, 0.22916666666667
116576, 1.9291666666667, -0.16, 0.25
116577, 1.95, -0.18, 0.25
116578, 1.9916666666667, -0.02, 0.25
116579, 1.9916666666667, -0.04, 0.22916666666667
116580, 1.9708333333333, -0.04, 0.25
116581, 1.9916666666667, -0.06, 0.25
116582, 1.9916666666667, -0.08, 0.22916666666667
116583, 1.9708333333333, -0.08, 0.25
116584, 1.9916666666667, -0.1, 0.25
116585, 1.9916666666667, -0.12, 0.22916666666667
116586, 1.9708333333333, -0.12, 0.25
116587, 1.9916666666667, -0.14, 0.25
116588, 1.9916666666667, -0.16, 0.22916666666667
116589, 1.9708333333333, -0.16, 0.25
116590, 1.9916666666667, -0.18, 0.25
116591, 2.0333333333333, -0.02, 0.25
116592, 2.0333333333333, -0.04, 0.22916666666667
116593, 2.0125, -0.04, 0.25
116594, 2.0333333333333, -0.06, 0.25
116595, 2.0333333333333, -0.08, 0.22916666666667
116596, 2.0125, -0.08, 0.25
116597, 2.0333333333333, -0.1, 0.25
116598, 2.0333333333333, -0.12, 0.22916666666667
116599, 2.0125, -0.12, 0.25
116600, 2.0333333333333, -0.14, 0.25
116601, 2.0333333333333, -0.16, 0.22916666666667
116602, 2.0125, -0.16, 0.25
116603, 2.0333333333333, -0.18, 0.25
116604, 2.075, -0.02, 0.25
116605, 2.075, -0.04, 0.22916666666667
116606, 2.0541666666667, -0.04, 0.25
116607, 2.075, -0.06, 0.25
116608, 2.075, -0.08, 0.22916666666667
116609, 2.0541666666667, -0.08, 0.25
116610, 2.075, -0.1, 0.25
116611, 2.075, -0.12, 0.22916666666667
116612, 2.0541666666667, -0.12, 0.25
116613, 2.075, -0.14, 0.25
116614, 2.075, -0.16, 0.22916666666667
116615, 2.0541666666667, -0.16, 0.25
116616, 2.075, -0.18, 0.25
116617, 2.1166666666667, -0.02, 0.25
116618, 2.1166666666667, -0.04, 0.22916666666667
116619, 2.0958333333333, -0.04, 0.25
116620, 2.1166666666667, -0.06, 0.25
116621, 2.1166666666667, -0.08, 0.22916666666667
116622, 2.0958333333333, -0.08, 0.25
116623, 2.1166666666667, -0.1, 0.25
116624, 2.1166666666667, -0.12, 0.22916666666667
116625, 2.0958333333333, -0.12, 0.25
116626, 2.1166666666667, -0.14, 0.25
116627, 2.1166666666667, -0.16, 0.22916666666667
116628, 2.0958333333333, -0.16, 0.25
116629, 2.1166666666667, -0.18, 0.25
116630, 2.1583333333333, -0.02, 0.25
116631, 2.1583333333333, -0.04, 0.22916666666667
116632, 2.1375, -0.04, 0.25
116633, 2.1583333333333, -0.06, 0.25
116634, 2.1583333333333, -0.08, 0.22916666666667
116635, 2.1375, -0.08, 0.25
116636, 2.1583333333333, -0.1, 0.25
116637, 2.1583333333333, -0.12, 0.22916666666667
116638, 2.1375, -0.12, 0.25
116639, 2.1583333333333, -0.14, 0.25
116640, 2.1583333333333, -0.16, 0.22916666666667
116641, 2.1375, -0.16, 0.25
116642, 2.1583333333333, -0.18, 0.25
116643, 2.1791666666667, -0.04, 0.25
116644, 2.1791666666667, -0.08, 0.25
116645, 2.1791666666667, -0.12, 0.25
116646, 2.1791666666667, -0.16, 0.25
116647, 1.2416666666667, -0.02, 0.29166666666667
116648, 1.2416666666667, -0.04, 0.27083333333333
116649, 1.2208333333333, -0.04, 0.29166666666667
116650, 1.2416666666667, -0.06, 0.29166666666667
116651, 1.2416666666667, -0.08, 0.27083333333333
116652, 1.2208333333333, -0.08, 0.29166666666667
116653, 1.2416666666667, -0.1, 0.29166666666667
116654, 1.2416666666667, -0.12, 0.27083333333333
116655, 1.2208333333333, -0.12, 0.29166666666667
116656, 1.2416666666667, -0.14, 0.29166666666667
116657, 1.2416666666667, -0.16, 0.27083333333333
116658, 1.2208333333333, -0.16, 0.29166666666667
116659, 1.2416666666667, -0.18, 0.29166666666667
116660, 1.2833333333333, -0.02, 0.29166666666667
116661, 1.2833333333333, -0.04, 0.27083333333333
116662, 1.2625, -0.04, 0.29166666666667
116663, 1.2833333333333, -0.06, 0.29166666666667
116664, 1.2833333333333, -0.08, 0.27083333333333
116665, 1.2625, -0.08, 0.29166666666667
116666, 1.2833333333333, -0.1, 0.29166666666667
116667, 1.2833333333333, -0.12, 0.27083333333333
116668, 1.2625, -0.12, 0.29166666666667
116669, 1.2833333333333, -0.14, 0.29166666666667
116670, 1.2833333333333, -0.16, 0.27083333333333
116671, 1.2625, -0.16, 0.29166666666667
116672, 1.2833333333333, -0.18, 0.29166666666667
116673, 1.325, -0.02, 0.29166666666667
116674, 1.325, -0.04, 0.27083333333333
116675, 1.3041666666667, -0.04, 0.29166666666667
116676, 1.325, -0.06, 0.29166666666667
116677, 1.325, -0.08, 0.27083333333333
116678, 1.3041666666667, -0.08, 0.29166666666667
116679, 1.325, -0.1, 0.29166666666667
116680, 1.325, -0.12, 0.27083333333333
116681, 1.3041666666667, -0.12, 0.29166666666667
116682, 1.325, -0.14, 0.29166666666667
116683, 1.325, -0.16, 0.27083333333333
116684, 1.3041666666667, -0.16, 0.29166666666667
116685, 1.325, -0.18, 0.29166666666667
116686, 1.3666666666667, -0.02, 0.29166666666667
116687, 1.3666666666667, -0.04, 0.27083333333333
116688, 1.3458333333333, -0.04, 0.29166666666667
116689, 1.3666666666667, -0.06, 0.29166666666667
116690, 1.3666666666667, -0.08, 0.27083333333333
116691, 1.3458333333333, -0.08, 0.29166666666667
116692, 1.3666666666667, -0.1, 0.29166666666667
116693, 1.3666666666667, -0.12, 0.27083333333333
116694, 1.3458333333333, -0.12, 0.29166666666667
116695, 1.3666666666667, -0.14, 0.29166666666667
116696, 1.3666666666667, -0.16, 0.27083333333333
116697, 1.3458333333333, -0.16, 0.29166666666667
116698, 1.3666666666667, -0.18, 0.29166666666667
116699, 1.4083333333333, -0.02, 0.29166666666667
116700, 1.4083333333333, -0.04, 0.27083333333333
116701, 1.3875, -0.04, 0.29166666666667
116702, 1.4083333333333, -0.06, 0.29166666666667
116703, 1.4083333333333, -0.08, 0.27083333333333
116704, 1.3875, -0.08, 0.29166666666667
116705, 1.4083333333333, -0.1, 0.29166666666667
116706, 1.4083333333333, -0.12, 0.27083333333333
116707, 1.3875, -0.12, 0.29166666666667
116708, 1.4083333333333, -0.14, 0.29166666666667
116709, 1.4083333333333, -0.16, 0.27083333333333
116710, 1.3875, -0.16, 0.29166666666667
116711, 1.4083333333333, -0.18, 0.29166666666667
116712, 1.45, -0.02, 0.29166666666667
116713, 1.45, -0.04, 0.27083333333333
116714, 1.4291666666667, -0.04, 0.29166666666667
116715, 1.45, -0.06, 0.29166666666667
116716, 1.45, -0.08, 0.27083333333333
116717, 1.4291666666667, -0.08, 0.29166666666667
116718, 1.45, -0.1, 0.29166666666667
116719, 1.45, -0.12, 0.27083333333333
116720, 1.4291666666667, -0.12, 0.29166666666667
116721, 1.45, -0.14, 0.29166666666667
116722, 1.45, -0.16, 0.27083333333333
116723, 1.4291666666667, -0.16, 0.29166666666667
116724, 1.45, -0.18, 0.29166666666667
116725, 1.4916666666667, -0.02, 0.29166666666667
116726, 1.4916666666667, -0.04, 0.27083333333333
116727, 1.4708333333333, -0.04, 0.29166666666667
116728, 1.4916666666667, -0.06, 0.29166666666667
116729, 1.4916666666667, -0.08, 0.27083333333333
116730, 1.4708333333333, -0.08, 0.29166666666667
116731, 1.4916666666667, -0.1, 0.29166666666667
116732, 1.4916666666667, -0.12, 0.27083333333333
116733, 1.4708333333333, -0.12, 0.29166666666667
116734, 1.4916666666667, -0.14, 0.29166666666667
116735, 1.4916666666667, -0.16, 0.27083333333333
116736, 1.4708333333333, -0.16, 0.29166666666667
116737, 1.4916666666667, -0.18, 0.29166666666667
116738, 1.5333333333333, -0.02, 0.29166666666667
116739, 1.5333333333333, -0.04, 0.27083333333333
116740, 1.5125, -0.04, 0.29166666666667
116741, 1.5333333333333, -0.06, 0.29166666666667
116742, 1.5333333333333, -0.08, 0.27083333333333
116743, 1.5125, -0.08, 0.29166666666667
116744, 1.5333333333333, -0.1, 0.29166666666667
116745, 1.5333333333333, -0.12, 0.27083333333333
116746, 1.5125, -0.12, 0.29166666666667
116747, 1.5333333333333, -0.14, 0.29166666666667
116748, 1.5333333333333, -0.16, 0.27083333333333
116749, 1.5125, -0.16, 0.29166666666667
116750, 1.5333333333333, -0.18, 0.29166666666667
116751, 1.575, -0.02, 0.29166666666667
116752, 1.575, -0.04, 0.27083333333333
116753, 1.5541666666667, -0.04, 0.29166666666667
116754, 1.575, -0.06, 0.29166666666667
116755, 1.575, -0.08, 0.27083333333333
116756, 1.5541666666667, -0.08, 0.29166666666667
116757, 1.575, -0.1, 0.29166666666667
116758, 1.575, -0.12, 0.27083333333333
116759, 1.5541666666667, -0.12, 0.29166666666667
116760, 1.575, -0.14, 0.29166666666667
116761, 1.575, -0.16, 0.27083333333333
116762, 1.5541666666667, -0.16, 0.29166666666667
116763, 1.575, -0.18, 0.29166666666667
116764, 1.6166666666667, -0.02, 0.29166666666667
116765, 1.6166666666667, -0.04, 0.27083333333333
116766, 1.5958333333333, -0.04, 0.29166666666667
116767, 1.6166666666667, -0.06, 0.29166666666667
116768, 1.6166666666667, -0.08, 0.27083333333333
116769, 1.5958333333333, -0.08, 0.29166666666667
116770, 1.6166666666667, -0.1, 0.29166666666667
116771, 1.6166666666667, -0.12, 0.27083333333333
116772, 1.5958333333333, -0.12, 0.29166666666667
116773, 1.6166666666667, -0.14, 0.29166666666667
116774, 1.6166666666667, -0.16, 0.27083333333333
116775, 1.5958333333333, -0.16, 0.29166666666667
116776, 1.6166666666667, -0.18, 0.29166666666667
116777, 1.6583333333333, -0.02, 0.29166666666667
116778, 1.6583333333333, -0.04, 0.27083333333333
116779, 1.6375, -0.04, 0.29166666666667
116780, 1.6583333333333, -0.06, 0.29166666666667
116781, 1.6583333333333, -0.08, 0.27083333333333
116782, 1.6375, -0.08, 0.29166666666667
116783, 1.6583333333333, -0.1, 0.29166666666667
116784, 1.6583333333333, -0.12, 0.27083333333333
116785, 1.6375, -0.12, 0.29166666666667
116786, 1.6583333333333, -0.14, 0.29166666666667
116787, 1.6583333333333, -0.16, 0.27083333333333
116788, 1.6375, -0.16, 0.29166666666667
116789, 1.6583333333333, -0.18, 0.29166666666667
116790, 1.7, -0.02, 0.29166666666667
116791, 1.7, -0.04, 0.27083333333333
116792, 1.6791666666667, -0.04, 0.29166666666667
116793, 1.7, -0.06, 0.29166666666667
116794, 1.7, -0.08, 0.27083333333333
116795, 1.6791666666667, -0.08, 0.29166666666667
116796, 1.7, -0.1, 0.29166666666667
116797, 1.7, -0.12, 0.27083333333333
116798, 1.6791666666667, -0.12, 0.29166666666667
116799, 1.7, -0.14, 0.29166666666667
116800, 1.7, -0.16, 0.27083333333333
116801, 1.6791666666667, -0.16, 0.29166666666667
116802, 1.7, -0.18, 0.29166666666667
116803, 1.7416666666667, -0.02, 0.29166666666667
116804, 1.7416666666667, -0.04, 0.27083333333333
116805, 1.7208333333333, -0.04, 0.29166666666667
116806, 1.7416666666667, -0.06, 0.29166666666667
116807, 1.7416666666667, -0.08, 0.27083333333333
116808, 1.7208333333333, -0.08, 0.29166666666667
116809, 1.7416666666667, -0.1, 0.29166666666667
116810, 1.7416666666667, -0.12, 0.27083333333333
116811, 1.7208333333333, -0.12, 0.29166666666667
116812, 1.7416666666667, -0.14, 0.29166666666667
116813, 1.7416666666667, -0.16, 0.27083333333333
116814, 1.7208333333333, -0.16, 0.29166666666667
116815, 1.7416666666667, -0.18, 0.29166666666667
116816, 1.7833333333333, -0.02, 0.29166666666667
116817, 1.7833333333333, -0.04, 0.27083333333333
116818, 1.7625, -0.04, 0.29166666666667
116819, 1.7833333333333, -0.06, 0.29166666666667
116820, 1.7833333333333, -0.08, 0.27083333333333
116821, 1.7625, -0.08, 0.29166666666667
116822, 1.7833333333333, -0.1, 0.29166666666667
116823, 1.7833333333333, -0.12, 0.27083333333333
116824, 1.7625, -0.12, 0.29166666666667
116825, 1.7833333333333, -0.14, 0.29166666666667
116826, 1.7833333333333, -0.16, 0.27083333333333
116827, 1.7625, -0.16, 0.29166666666667
116828, 1.7833333333333, -0.18, 0.29166666666667
116829, 1.825, -0.02, 0.29166666666667
116830, 1.825, -0.04, 0.27083333333333
116831, 1.8041666666667, -0.04, 0.29166666666667
116832, 1.825, -0.06, 0.29166666666667
116833, 1.825, -0.08, 0.27083333333333
116834, 1.8041666666667, -0.08, 0.29166666666667
116835, 1.825, -0.1, 0.29166666666667
116836, 1.825, -0.12, 0.27083333333333
116837, 1.8041666666667, -0.12, 0.29166666666667
116838, 1.825, -0.14, 0.29166666666667
116839, 1.825, -0.16, 0.27083333333333
116840, 1.8041666666667, -0.16, 0.29166666666667
116841, 1.825, -0.18, 0.29166666666667
116842, 1.8666666666667, -0.02, 0.29166666666667
116843, 1.8666666666667, -0.04, 0.27083333333333
116844, 1.8458333333333, -0.04, 0.29166666666667
116845, 1.8666666666667, -0.06, 0.29166666666667
116846, 1.8666666666667, -0.08, 0.27083333333333
116847, 1.8458333333333, -0.08, 0.29166666666667
116848, 1.8666666666667, -0.1, 0.29166666666667
116849, 1.8666666666667, -0.12, 0.27083333333333
116850, 1.8458333333333, -0.12, 0.29166666666667
116851, 1.8666666666667, -0.14, 0.29166666666667
116852, 1.8666666666667, -0.16, 0.27083333333333
116853, 1.8458333333333, -0.16, 0.29166666666667
116854, 1.8666666666667, -0.18, 0.29166666666667
116855, 1.9083333333333, -0.02, 0.29166666666667
116856, 1.9083333333333, -0.04, 0.27083333333333
116857, 1.8875, -0.04, 0.29166666666667
116858, 1.9083333333333, -0.06, 0.29166666666667
116859, 1.9083333333333, -0.08, 0.27083333333333
116860, 1.8875, -0.08, 0.29166666666667
116861, 1.9083333333333, -0.1, 0.29166666666667
116862, 1.9083333333333, -0.12, 0.27083333333333
116863, 1.8875, -0.12, 0.29166666666667
116864, 1.9083333333333, -0.14, 0.29166666666667
116865, 1.9083333333333, -0.16, 0.27083333333333
116866, 1.8875, -0.16, 0.29166666666667
116867, 1.9083333333333, -0.18, 0.29166666666667
116868, 1.95, -0.02, 0.29166666666667
116869, 1.95, -0.04, 0.27083333333333
116870, 1.9291666666667, -0.04, 0.29166666666667
116871, 1.95, -0.06, 0.29166666666667
116872, 1.95, -0.08, 0.27083333333333
116873, 1.9291666666667, -0.08, 0.29166666666667
116874, 1.95, -0.1, 0.29166666666667
116875, 1.95, -0.12, 0.27083333333333
116876, 1.9291666666667, -0.12, 0.29166666666667
116877, 1.95, -0.14, 0.29166666666667
116878, 1.95, -0.16, 0.27083333333333
116879, 1.9291666666667, -0.16, 0.29166666666667
116880, 1.95, -0.18, 0.29166666666667
116881, 1.9916666666667, -0.02, 0.29166666666667
116882, 1.9916666666667, -0.04, 0.27083333333333
116883, 1.9708333333333, -0.04, 0.29166666666667
116884, 1.9916666666667, -0.06, 0.29166666666667
116885, 1.9916666666667, -0.08, 0.27083333333333
116886, 1.9708333333333, -0.08, 0.29166666666667
116887, 1.9916666666667, -0.1, 0.29166666666667
116888, 1.9916666666667, -0.12, 0.27083333333333
116889, 1.9708333333333, -0.12, 0.29166666666667
116890, 1.9916666666667, -0.14, 0.29166666666667
116891, 1.9916666666667, -0.16, 0.27083333333333
116892, 1.9708333333333, -0.16, 0.29166666666667
116893, 1.9916666666667, -0.18, 0.29166666666667
116894, 2.0333333333333, -0.02, 0.29166666666667
116895, 2.0333333333333, -0.04, 0.27083333333333
116896, 2.0125, -0.04, 0.29166666666667
116897, 2.0333333333333, -0.06, 0.29166666666667
116898, 2.0333333333333, -0.08, 0.27083333333333
116899, 2.0125, -0.08, 0.29166666666667
116900, 2.0333333333333, -0.1, 0.29166666666667
116901, 2.0333333333333, -0.12, 0.27083333333333
116902, 2.0125, -0.12, 0.29166666666667
116903, 2.0333333333333, -0.14, 0.29166666666667
116904, 2.0333333333333, -0.16, 0.27083333333333
116905, 2.0125, -0.16, 0.29166666666667
116906, 2.0333333333333, -0.18, 0.29166666666667
116907, 2.075, -0.02, 0.29166666666667
116908, 2.075, -0.04, 0.27083333333333
116909, 2.0541666666667, -0.04, 0.29166666666667
116910, 2.075, -0.06, 0.29166666666667
116911, 2.075, -0.08, 0.27083333333333
116912, 2.0541666666667, -0.08, 0.29166666666667
116913, 2.075, -0.1, 0.29166666666667
116914, 2.075, -0.12, 0.27083333333333
116915, 2.0541666666667, -0.12, 0.29166666666667
116916, 2.075, -0.14, 0.29166666666667
116917, 2.075, -0.16, 0.27083333333333
116918, 2.0541666666667, -0.16, 0.29166666666667
116919, 2.075, -0.18, 0.29166666666667
116920, 2.1166666666667, -0.02, 0.29166666666667
116921, 2.1166666666667, -0.04, 0.27083333333333
116922, 2.0958333333333, -0.04, 0.29166666666667
116923, 2.1166666666667, -0.06, 0.29166666666667
116924, 2.1166666666667, -0.08, 0.27083333333333
116925, 2.0958333333333, -0.08, 0.29166666666667
116926, 2.1166666666667, -0.1, 0.29166666666667
116927, 2.1166666666667, -0.12, 0.27083333333333
116928, 2.0958333333333, -0.12, 0.29166666666667
116929, 2.1166666666667, -0.14, 0.29166666666667
116930, 2.1166666666667, -0.16, 0.27083333333333
116931, 2.0958333333333, -0.16, 0.29166666666667
116932, 2.1166666666667, -0.18, 0.29166666666667
116933, 2.1583333333333, -0.02, 0.29166666666667
116934, 2.1583333333333, -0.04, 0.27083333333333
116935, 2.1375, -0.04, 0.29166666666667
116936, 2.1583333333333, -0.06, 0.29166666666667
116937, 2.1583333333333, -0.08, 0.27083333333333
116938, 2.1375, -0.08, 0.29166666666667
116939, 2.1583333333333, -0.1, 0.29166666666667
116940, 2.1583333333333, -0.12, 0.27083333333333
116941, 2.1375, -0.12, 0.29166666666667
116942, 2.1583333333333, -0.14, 0.29166666666667
116943, 2.1583333333333, -0.16, 0.27083333333333
116944, 2.1375, -0.16, 0.29166666666667
116945, 2.1583333333333, -0.18, 0.29166666666667
116946, 2.1791666666667, -0.04, 0.29166666666667
116947, 2.1791666666667, -0.08, 0.29166666666667
116948, 2.1791666666667, -0.12, 0.29166666666667
116949, 2.1791666666667, -0.16, 0.29166666666667
116950, 1.2416666666667, -0.02, 0.33333333333333
116951, 1.2416666666667, -0.04, 0.3125
116952, 1.2208333333333, -0.04, 0.33333333333333
116953, 1.2416666666667, -0.06, 0.33333333333333
116954, 1.2416666666667, -0.08, 0.3125
116955, 1.2208333333333, -0.08, 0.33333333333333
116956, 1.2416666666667, -0.1, 0.33333333333333
116957, 1.2416666666667, -0.12, 0.3125
116958, 1.2208333333333, -0.12, 0.33333333333333
116959, 1.2416666666667, -0.14, 0.33333333333333
116960, 1.2416666666667, -0.16, 0.3125
116961, 1.2208333333333, -0.16, 0.33333333333333
116962, 1.2416666666667, -0.18, 0.33333333333333
116963, 1.2833333333333, -0.02, 0.33333333333333
116964, 1.2833333333333, -0.04, 0.3125
116965, 1.2625, -0.04, 0.33333333333333
116966, 1.2833333333333, -0.06, 0.33333333333333
116967, 1.2833333333333, -0.08, 0.3125
116968, 1.2625, -0.08, 0.33333333333333
116969, 1.2833333333333, -0.1, 0.33333333333333
116970, 1.2833333333333, -0.12, 0.3125
116971, 1.2625, -0.12, 0.33333333333333
116972, 1.2833333333333, -0.14, 0.33333333333333
116973, 1.2833333333333, -0.16, 0.3125
116974, 1.2625, -0.16, 0.33333333333333
116975, 1.2833333333333, -0.18, 0.33333333333333
116976, 1.325, -0.02, 0.33333333333333
116977, 1.325, -0.04, 0.3125
116978, 1.3041666666667, -0.04, 0.33333333333333
116979, 1.325, -0.06, 0.33333333333333
116980, 1.325, -0.08, 0.3125
116981, 1.3041666666667, -0.08, 0.33333333333333
116982, 1.325, -0.1, 0.33333333333333
116983, 1.325, -0.12, 0.3125
116984, 1.3041666666667, -0.12, 0.33333333333333
116985, 1.325, -0.14, 0.33333333333333
116986, 1.325, -0.16, 0.3125
116987, 1.3041666666667, -0.16, 0.33333333333333
116988, 1.325, -0.18, 0.33333333333333
116989, 1.3666666666667, -0.02, 0.33333333333333
116990, 1.3666666666667, -0.04, 0.3125
116991, 1.3458333333333, -0.04, 0.33333333333333
116992, 1.3666666666667, -0.06, 0.33333333333333
116993, 1.3666666666667, -0.08, 0.3125
116994, 1.3458333333333, -0.08, 0.33333333333333
116995, 1.3666666666667, -0.1, 0.33333333333333
116996, 1.3666666666667, -0.12, 0.3125
116997, 1.3458333333333, -0.12, 0.33333333333333
116998, 1.3666666666667, -0.14, 0.33333333333333
116999, 1.3666666666667, -0.16, 0.3125
117000, 1.3458333333333, -0.16, 0.33333333333333
117001, 1.3666666666667, -0.18, 0.33333333333333
117002, 1.4083333333333, -0.02, 0.33333333333333
117003, 1.4083333333333, -0.04, 0.3125
117004, 1.3875, -0.04, 0.33333333333333
117005, 1.4083333333333, -0.06, 0.33333333333333
117006, 1.4083333333333, -0.08, 0.3125
117007, 1.3875, -0.08, 0.33333333333333
117008, 1.4083333333333, -0.1, 0.33333333333333
117009, 1.4083333333333, -0.12, 0.3125
117010, 1.3875, -0.12, 0.33333333333333
117011, 1.4083333333333, -0.14, 0.33333333333333
117012, 1.4083333333333, -0.16, 0.3125
117013, 1.3875, -0.16, 0.33333333333333
117014, 1.4083333333333, -0.18, 0.33333333333333
117015, 1.45, -0.02, 0.33333333333333
117016, 1.45, -0.04, 0.3125
117017, 1.4291666666667, -0.04, 0.33333333333333
117018, 1.45, -0.06, 0.33333333333333
117019, 1.45, -0.08, 0.3125
117020, 1.4291666666667, -0.08, 0.33333333333333
117021, 1.45, -0.1, 0.33333333333333
117022, 1.45, -0.12, 0.3125
117023, 1.4291666666667, -0.12, 0.33333333333333
117024, 1.45, -0.14, 0.33333333333333
117025, 1.45, -0.16, 0.3125
117026, 1.4291666666667, -0.16, 0.33333333333333
117027, 1.45, -0.18, 0.33333333333333
117028, 1.4916666666667, -0.02, 0.33333333333333
117029, 1.4916666666667, -0.04, 0.3125
117030, 1.4708333333333, -0.04, 0.33333333333333
117031, 1.4916666666667, -0.06, 0.33333333333333
117032, 1.4916666666667, -0.08, 0.3125
117033, 1.4708333333333, -0.08, 0.33333333333333
117034, 1.4916666666667, -0.1, 0.33333333333333
117035, 1.4916666666667, -0.12, 0.3125
117036, 1.4708333333333, -0.12, 0.33333333333333
117037, 1.4916666666667, -0.14, 0.33333333333333
117038, 1.4916666666667, -0.16, 0.3125
117039, 1.4708333333333, -0.16, 0.33333333333333
117040, 1.4916666666667, -0.18, 0.33333333333333
117041, 1.5333333333333, -0.02, 0.33333333333333
117042, 1.5333333333333, -0.04, 0.3125
117043, 1.5125, -0.04, 0.33333333333333
117044, 1.5333333333333, -0.06, 0.33333333333333
117045, 1.5333333333333, -0.08, 0.3125
117046, 1.5125, -0.08, 0.33333333333333
117047, 1.5333333333333, -0.1, 0.33333333333333
117048, 1.5333333333333, -0.12, 0.3125
117049, 1.5125, -0.12, 0.33333333333333
117050, 1.5333333333333, -0.14, 0.33333333333333
117051, 1.5333333333333, -0.16, 0.3125
117052, 1.5125, -0.16, 0.33333333333333
117053, 1.5333333333333, -0.18, 0.33333333333333
117054, 1.575, -0.02, 0.33333333333333
117055, 1.575, -0.04, 0.3125
117056, 1.5541666666667, -0.04, 0.33333333333333
117057, 1.575, -0.06, 0.33333333333333
117058, 1.575, -0.08, 0.3125
117059, 1.5541666666667, -0.08, 0.33333333333333
117060, 1.575, -0.1, 0.33333333333333
117061, 1.575, -0.12, 0.3125
117062, 1.5541666666667, -0.12, 0.33333333333333
117063, 1.575, -0.14, 0.33333333333333
117064, 1.575, -0.16, 0.3125
117065, 1.5541666666667, -0.16, 0.33333333333333
117066, 1.575, -0.18, 0.33333333333333
117067, 1.6166666666667, -0.02, 0.33333333333333
117068, 1.6166666666667, -0.04, 0.3125
117069, 1.5958333333333, -0.04, 0.33333333333333
117070, 1.6166666666667, -0.06, 0.33333333333333
117071, 1.6166666666667, -0.08, 0.3125
117072, 1.5958333333333, -0.08, 0.33333333333333
117073, 1.6166666666667, -0.1, 0.33333333333333
117074, 1.6166666666667, -0.12, 0.3125
117075, 1.5958333333333, -0.12, 0.33333333333333
117076, 1.6166666666667, -0.14, 0.33333333333333
117077, 1.6166666666667, -0.16, 0.3125
117078, 1.5958333333333, -0.16, 0.33333333333333
117079, 1.6166666666667, -0.18, 0.33333333333333
117080, 1.6583333333333, -0.02, 0.33333333333333
117081, 1.6583333333333, -0.04, 0.3125
117082, 1.6375, -0.04, 0.33333333333333
117083, 1.6583333333333, -0.06, 0.33333333333333
117084, 1.6583333333333, -0.08, 0.3125
117085, 1.6375, -0.08, 0.33333333333333
117086, 1.6583333333333, -0.1, 0.33333333333333
117087, 1.6583333333333, -0.12, 0.3125
117088, 1.6375, -0.12, 0.33333333333333
117089, 1.6583333333333, -0.14, 0.33333333333333
117090, 1.6583333333333, -0.16, 0.3125
117091, 1.6375, -0.16, 0.33333333333333
117092, 1.6583333333333, -0.18, 0.33333333333333
117093, 1.7, -0.02, 0.33333333333333
117094, 1.7, -0.04, 0.3125
117095, 1.6791666666667, -0.04, 0.33333333333333
117096, 1.7, -0.06, 0.33333333333333
117097, 1.7, -0.08, 0.3125
117098, 1.6791666666667, -0.08, 0.33333333333333
117099, 1.7, -0.1, 0.33333333333333
117100, 1.7, -0.12, 0.3125
117101, 1.6791666666667, -0.12, 0.33333333333333
117102, 1.7, -0.14, 0.33333333333333
117103, 1.7, -0.16, 0.3125
117104, 1.6791666666667, -0.16, 0.33333333333333
117105, 1.7, -0.18, 0.33333333333333
117106, 1.7416666666667, -0.02, 0.33333333333333
117107, 1.7416666666667, -0.04, 0.3125
117108, 1.7208333333333, -0.04, 0.33333333333333
117109, 1.7416666666667, -0.06, 0.33333333333333
117110, 1.7416666666667, -0.08, 0.3125
117111, 1.7208333333333, -0.08, 0.33333333333333
117112, 1.7416666666667, -0.1, 0.33333333333333
117113, 1.7416666666667, -0.12, 0.3125
117114, 1.7208333333333, -0.12, 0.33333333333333
117115, 1.7416666666667, -0.14, 0.33333333333333
117116, 1.7416666666667, -0.16, 0.3125
117117, 1.7208333333333, -0.16, 0.33333333333333
117118, 1.7416666666667, -0.18, 0.33333333333333
117119, 1.7833333333333, -0.02, 0.33333333333333
117120, 1.7833333333333, -0.04, 0.3125
117121, 1.7625, -0.04, 0.33333333333333
117122, 1.7833333333333, -0.06, 0.33333333333333
117123, 1.7833333333333, -0.08, 0.3125
117124, 1.7625, -0.08, 0.33333333333333
117125, 1.7833333333333, -0.1, 0.33333333333333
117126, 1.7833333333333, -0.12, 0.3125
117127, 1.7625, -0.12, 0.33333333333333
117128, 1.7833333333333, -0.14, 0.33333333333333
117129, 1.7833333333333, -0.16, 0.3125
117130, 1.7625, -0.16, 0.33333333333333
117131, 1.7833333333333, -0.18, 0.33333333333333
117132, 1.825, -0.02, 0.33333333333333
117133, 1.825, -0.04, 0.3125
117134, 1.8041666666667, -0.04, 0.33333333333333
117135, 1.825, -0.06, 0.33333333333333
117136, 1.825, -0.08, 0.3125
117137, 1.8041666666667, -0.08, 0.33333333333333
117138, 1.825, -0.1, 0.33333333333333
117139, 1.825, -0.12, 0.3125
117140, 1.8041666666667, -0.12, 0.33333333333333
117141, 1.825, -0.14, 0.33333333333333
117142, 1.825, -0.16, 0.3125
117143, 1.8041666666667, -0.16, 0.33333333333333
117144, 1.825, -0.18, 0.33333333333333
117145, 1.8666666666667, -0.02, 0.33333333333333
117146, 1.8666666666667, -0.04, 0.3125
117147, 1.8458333333333, -0.04, 0.33333333333333
117148, 1.8666666666667, -0.06, 0.33333333333333
117149, 1.8666666666667, -0.08, 0.3125
117150, 1.8458333333333, -0.08, 0.33333333333333
117151, 1.8666666666667, -0.1, 0.33333333333333
117152, 1.8666666666667, -0.12, 0.3125
117153, 1.8458333333333, -0.12, 0.33333333333333
117154, 1.8666666666667, -0.14, 0.33333333333333
117155, 1.8666666666667, -0.16, 0.3125
117156, 1.8458333333333, -0.16, 0.33333333333333
117157, 1.8666666666667, -0.18, 0.33333333333333
117158, 1.9083333333333, -0.02, 0.33333333333333
117159, 1.9083333333333, -0.04, 0.3125
117160, 1.8875, -0.04, 0.33333333333333
117161, 1.9083333333333, -0.06, 0.33333333333333
117162, 1.9083333333333, -0.08, 0.3125
117163, 1.8875, -0.08, 0.33333333333333
117164, 1.9083333333333, -0.1, 0.33333333333333
117165, 1.9083333333333, -0.12, 0.3125
117166, 1.8875, -0.12, 0.33333333333333
117167, 1.9083333333333, -0.14, 0.33333333333333
117168, 1.9083333333333, -0.16, 0.3125
117169, 1.8875, -0.16, 0.33333333333333
117170, 1.9083333333333, -0.18, 0.33333333333333
117171, 1.95, -0.02, 0.33333333333333
117172, 1.95, -0.04, 0.3125
117173, 1.9291666666667, -0.04, 0.33333333333333
117174, 1.95, -0.06, 0.33333333333333
117175, 1.95, -0.08, 0.3125
117176, 1.9291666666667, -0.08, 0.33333333333333
117177, 1.95, -0.1, 0.33333333333333
117178, 1.95, -0.12, 0.3125
117179, 1.9291666666667, -0.12, 0.33333333333333
117180, 1.95, -0.14, 0.33333333333333
117181, 1.95, -0.16, 0.3125
117182, 1.9291666666667, -0.16, 0.33333333333333
117183, 1.95, -0.18, 0.33333333333333
117184, 1.9916666666667, -0.02, 0.33333333333333
117185, 1.9916666666667, -0.04, 0.3125
117186, 1.9708333333333, -0.04, 0.33333333333333
117187, 1.9916666666667, -0.06, 0.33333333333333
117188, 1.9916666666667, -0.08, 0.3125
117189, 1.9708333333333, -0.08, 0.33333333333333
117190, 1.9916666666667, -0.1, 0.33333333333333
117191, 1.9916666666667, -0.12, 0.3125
117192, 1.9708333333333, -0.12, 0.33333333333333
117193, 1.9916666666667, -0.14, 0.33333333333333
117194, 1.9916666666667, -0.16, 0.3125
117195, 1.9708333333333, -0.16, 0.33333333333333
117196, 1.9916666666667, -0.18, 0.33333333333333
117197, 2.0333333333333, -0.02, 0.33333333333333
117198, 2.0333333333333, -0.04, 0.3125
117199, 2.0125, -0.04, 0.33333333333333
117200, 2.0333333333333, -0.06, 0.33333333333333
117201, 2.0333333333333, -0.08, 0.3125
117202, 2.0125, -0.08, 0.33333333333333
117203, 2.0333333333333, -0.1, 0.33333333333333
117204, 2.0333333333333, -0.12, 0.3125
117205, 2.0125, -0.12, 0.33333333333333
117206, 2.0333333333333, -0.14, 0.33333333333333
117207, 2.0333333333333, -0.16, 0.3125
117208, 2.0125, -0.16, 0.33333333333333
117209, 2.0333333333333, -0.18, 0.33333333333333
117210, 2.075, -0.02, 0.33333333333333
117211, 2.075, -0.04, 0.3125
117212, 2.0541666666667, -0.04, 0.33333333333333
117213, 2.075, -0.06, 0.33333333333333
117214, 2.075, -0.08, 0.3125
117215, 2.0541666666667, -0.08, 0.33333333333333
117216, 2.075, -0.1, 0.33333333333333
117217, 2.075, -0.12, 0.3125
117218, 2.0541666666667, -0.12, 0.33333333333333
117219, 2.075, -0.14, 0.33333333333333
117220, 2.075, -0.16, 0.3125
117221, 2.0541666666667, -0.16, 0.33333333333333
117222, 2.075, -0.18, 0.33333333333333
117223, 2.1166666666667, -0.02, 0.33333333333333
117224, 2.1166666666667, -0.04, 0.3125
117225, 2.0958333333333, -0.04, 0.33333333333333
117226, 2.1166666666667, -0.06, 0.33333333333333
117227, 2.1166666666667, -0.08, 0.3125
117228, 2.0958333333333, -0.08, 0.33333333333333
117229, 2.1166666666667, -0.1, 0.33333333333333
117230, 2.1166666666667, -0.12, 0.3125
117231, 2.0958333333333, -0.12, 0.33333333333333
117232, 2.1166666666667, -0.14, 0.33333333333333
117233, 2.1166666666667, -0.16, 0.3125
117234, 2.0958333333333, -0.16, 0.33333333333333
117235, 2.1166666666667, -0.18, 0.33333333333333
117236, 2.1583333333333, -0.02, 0.33333333333333
117237, 2.1583333333333, -0.04, 0.3125
117238, 2.1375, -0.04, 0.33333333333333
117239, 2.1583333333333, -0.06, 0.33333333333333
117240, 2.1583333333333, -0.08, 0.3125
117241, 2.1375, -0.08, 0.33333333333333
117242, 2.1583333333333, -0.1, 0.33333333333333
117243, 2.1583333333333, -0.12, 0.3125
117244, 2.1375, -0.12, 0.33333333333333
117245, 2.1583333333333, -0.14, 0.33333333333333
117246, 2.1583333333333, -0.16, 0.3125
117247, 2.1375, -0.16, 0.33333333333333
117248, 2.1583333333333, -0.18, 0.33333333333333
117249, 2.1791666666667, -0.04, 0.33333333333333
117250, 2.1791666666667, -0.08, 0.33333333333333
117251, 2.1791666666667, -0.12, 0.33333333333333
117252, 2.1791666666667, -0.16, 0.33333333333333
117253, 1.2416666666667, -0.02, 0.375
117254, 1.2416666666667, -0.04, 0.35416666666667
117255, 1.2208333333333, -0.04, 0.375
117256, 1.2416666666667, -0.06, 0.375
117257, 1.2416666666667, -0.08, 0.35416666666667
117258, 1.2208333333333, -0.08, 0.375
117259, 1.2416666666667, -0.1, 0.375
117260, 1.2416666666667, -0.12, 0.35416666666667
117261, 1.2208333333333, -0.12, 0.375
117262, 1.2416666666667, -0.14, 0.375
117263, 1.2416666666667, -0.16, 0.35416666666667
117264, 1.2208333333333, -0.16, 0.375
117265, 1.2416666666667, -0.18, 0.375
117266, 1.2833333333333, -0.02, 0.375
117267, 1.2833333333333, -0.04, 0.35416666666667
117268, 1.2625, -0.04, 0.375
117269, 1.2833333333333, -0.06, 0.375
117270, 1.2833333333333, -0.08, 0.35416666666667
117271, 1.2625, -0.08, 0.375
117272, 1.2833333333333, -0.1, 0.375
117273, 1.2833333333333, -0.12, 0.35416666666667
117274, 1.2625, -0.12, 0.375
117275, 1.2833333333333, -0.14, 0.375
117276, 1.2833333333333, -0.16, 0.35416666666667
117277, 1.2625, -0.16, 0.375
117278, 1.2833333333333, -0.18, 0.375
117279, 1.325, -0.02, 0.375
117280, 1.325, -0.04, 0.35416666666667
117281, 1.3041666666667, -0.04, 0.375
117282, 1.325, -0.06, 0.375
117283, 1.325, -0.08, 0.35416666666667
117284, 1.3041666666667, -0.08, 0.375
117285, 1.325, -0.1, 0.375
117286, 1.325, -0.12, 0.35416666666667
117287, 1.3041666666667, -0.12, 0.375
117288, 1.325, -0.14, 0.375
117289, 1.325, -0.16, 0.35416666666667
117290, 1.3041666666667, -0.16, 0.375
117291, 1.325, -0.18, 0.375
117292, 1.3666666666667, -0.02, 0.375
117293, 1.3666666666667, -0.04, 0.35416666666667
117294, 1.3458333333333, -0.04, 0.375
117295, 1.3666666666667, -0.06, 0.375
117296, 1.3666666666667, -0.08, 0.35416666666667
117297, 1.3458333333333, -0.08, 0.375
117298, 1.3666666666667, -0.1, 0.375
117299, 1.3666666666667, -0.12, 0.35416666666667
117300, 1.3458333333333, -0.12, 0.375
117301, 1.3666666666667, -0.14, 0.375
117302, 1.3666666666667, -0.16, 0.35416666666667
117303, 1.3458333333333, -0.16, 0.375
117304, 1.3666666666667, -0.18, 0.375
117305, 1.4083333333333, -0.02, 0.375
117306, 1.4083333333333, -0.04, 0.35416666666667
117307, 1.3875, -0.04, 0.375
117308, 1.4083333333333, -0.06, 0.375
117309, 1.4083333333333, -0.08, 0.35416666666667
117310, 1.3875, -0.08, 0.375
117311, 1.4083333333333, -0.1, 0.375
117312, 1.4083333333333, -0.12, 0.35416666666667
117313, 1.3875, -0.12, 0.375
117314, 1.4083333333333, -0.14, 0.375
117315, 1.4083333333333, -0.16, 0.35416666666667
117316, 1.3875, -0.16, 0.375
117317, 1.4083333333333, -0.18, 0.375
117318, 1.45, -0.02, 0.375
117319, 1.45, -0.04, 0.35416666666667
117320, 1.4291666666667, -0.04, 0.375
117321, 1.45, -0.06, 0.375
117322, 1.45, -0.08, 0.35416666666667
117323, 1.4291666666667, -0.08, 0.375
117324, 1.45, -0.1, 0.375
117325, 1.45, -0.12, 0.35416666666667
117326, 1.4291666666667, -0.12, 0.375
117327, 1.45, -0.14, 0.375
117328, 1.45, -0.16, 0.35416666666667
117329, 1.4291666666667, -0.16, 0.375
117330, 1.45, -0.18, 0.375
117331, 1.4916666666667, -0.02, 0.375
117332, 1.4916666666667, -0.04, 0.35416666666667
117333, 1.4708333333333, -0.04, 0.375
117334, 1.4916666666667, -0.06, 0.375
117335, 1.4916666666667, -0.08, 0.35416666666667
117336, 1.4708333333333, -0.08, 0.375
117337, 1.4916666666667, -0.1, 0.375
117338, 1.4916666666667, -0.12, 0.35416666666667
117339, 1.4708333333333, -0.12, 0.375
117340, 1.4916666666667, -0.14, 0.375
117341, 1.4916666666667, -0.16, 0.35416666666667
117342, 1.4708333333333, -0.16, 0.375
117343, 1.4916666666667, -0.18, 0.375
117344, 1.5333333333333, -0.02, 0.375
117345, 1.5333333333333, -0.04, 0.35416666666667
117346, 1.5125, -0.04, 0.375
117347, 1.5333333333333, -0.06, 0.375
117348, 1.5333333333333, -0.08, 0.35416666666667
117349, 1.5125, -0.08, 0.375
117350, 1.5333333333333, -0.1, 0.375
117351, 1.5333333333333, -0.12, 0.35416666666667
117352, 1.5125, -0.12, 0.375
117353, 1.5333333333333, -0.14, 0.375
117354, 1.5333333333333, -0.16, 0.35416666666667
117355, 1.5125, -0.16, 0.375
117356, 1.5333333333333, -0.18, 0.375
117357, 1.575, -0.02, 0.375
117358, 1.575, -0.04, 0.35416666666667
117359, 1.5541666666667, -0.04, 0.375
117360, 1.575, -0.06, 0.375
117361, 1.575, -0.08, 0.35416666666667
117362, 1.5541666666667, -0.08, 0.375
117363, 1.575, -0.1, 0.375
117364, 1.575, -0.12, 0.35416666666667
117365, 1.5541666666667, -0.12, 0.375
117366, 1.575, -0.14, 0.375
117367, 1.575, -0.16, 0.35416666666667
117368, 1.5541666666667, -0.16, 0.375
117369, 1.575, -0.18, 0.375
117370, 1.6166666666667, -0.02, 0.375
117371, 1.6166666666667, -0.04, 0.35416666666667
117372, 1.5958333333333, -0.04, 0.375
117373, 1.6166666666667, -0.06, 0.375
117374, 1.6166666666667, -0.08, 0.35416666666667
117375, 1.5958333333333, -0.08, 0.375
117376, 1.6166666666667, -0.1, 0.375
117377, 1.6166666666667, -0.12, 0.35416666666667
117378, 1.5958333333333, -0.12, 0.375
117379, 1.6166666666667, -0.14, 0.375
117380, 1.6166666666667, -0.16, 0.35416666666667
117381, 1.5958333333333, -0.16, 0.375
117382, 1.6166666666667, -0.18, 0.375
117383, 1.6583333333333, -0.02, 0.375
117384, 1.6583333333333, -0.04, 0.35416666666667
117385, 1.6375, -0.04, 0.375
117386, 1.6583333333333, -0.06, 0.375
117387, 1.6583333333333, -0.08, 0.35416666666667
117388, 1.6375, -0.08, 0.375
117389, 1.6583333333333, -0.1, 0.375
117390, 1.6583333333333, -0.12, 0.35416666666667
117391, 1.6375, -0.12, 0.375
117392, 1.6583333333333, -0.14, 0.375
117393, 1.6583333333333, -0.16, 0.35416666666667
117394, 1.6375, -0.16, 0.375
117395, 1.6583333333333, -0.18, 0.375
117396, 1.7, -0.02, 0.375
117397, 1.7, -0.04, 0.35416666666667
117398, 1.6791666666667, -0.04, 0.375
117399, 1.7, -0.06, 0.375
117400, 1.7, -0.08, 0.35416666666667
117401, 1.6791666666667, -0.08, 0.375
117402, 1.7, -0.1, 0.375
117403, 1.7, -0.12, 0.35416666666667
117404, 1.6791666666667, -0.12, 0.375
117405, 1.7, -0.14, 0.375
117406, 1.7, -0.16, 0.35416666666667
117407, 1.6791666666667, -0.16, 0.375
117408, 1.7, -0.18, 0.375
117409, 1.7416666666667, -0.02, 0.375
117410, 1.7416666666667, -0.04, 0.35416666666667
117411, 1.7208333333333, -0.04, 0.375
117412, 1.7416666666667, -0.06, 0.375
117413, 1.7416666666667, -0.08, 0.35416666666667
117414, 1.7208333333333, -0.08, 0.375
117415, 1.7416666666667, -0.1, 0.375
117416, 1.7416666666667, -0.12, 0.35416666666667
117417, 1.7208333333333, -0.12, 0.375
117418, 1.7416666666667, -0.14, 0.375
117419, 1.7416666666667, -0.16, 0.35416666666667
117420, 1.7208333333333, -0.16, 0.375
117421, 1.7416666666667, -0.18, 0.375
117422, 1.7833333333333, -0.02, 0.375
117423, 1.7833333333333, -0.04, 0.35416666666667
117424, 1.7625, -0.04, 0.375
117425, 1.7833333333333, -0.06, 0.375
117426, 1.7833333333333, -0.08, 0.35416666666667
117427, 1.7625, -0.08, 0.375
117428, 1.7833333333333, -0.1, 0.375
117429, 1.7833333333333, -0.12, 0.35416666666667
117430, 1.7625, -0.12, 0.375
117431, 1.7833333333333, -0.14, 0.375
117432, 1.7833333333333, -0.16, 0.35416666666667
117433, 1.7625, -0.16, 0.375
117434, 1.7833333333333, -0.18, 0.375
117435, 1.825, -0.02, 0.375
117436, 1.825, -0.04, 0.35416666666667
117437, 1.8041666666667, -0.04, 0.375
117438, 1.825, -0.06, 0.375
117439, 1.825, -0.08, 0.35416666666667
117440, 1.8041666666667, -0.08, 0.375
117441, 1.825, -0.1, 0.375
117442, 1.825, -0.12, 0.35416666666667
117443, 1.8041666666667, -0.12, 0.375
117444, 1.825, -0.14, 0.375
117445, 1.825, -0.16, 0.35416666666667
117446, 1.8041666666667, -0.16, 0.375
117447, 1.825, -0.18, 0.375
117448, 1.8666666666667, -0.02, 0.375
117449, 1.8666666666667, -0.04, 0.35416666666667
117450, 1.8458333333333, -0.04, 0.375
117451, 1.8666666666667, -0.06, 0.375
117452, 1.8666666666667, -0.08, 0.35416666666667
117453, 1.8458333333333, -0.08, 0.375
117454, 1.8666666666667, -0.1, 0.375
117455, 1.8666666666667, -0.12, 0.35416666666667
117456, 1.8458333333333, -0.12, 0.375
117457, 1.8666666666667, -0.14, 0.375
117458, 1.8666666666667, -0.16, 0.35416666666667
117459, 1.8458333333333, -0.16, 0.375
117460, 1.8666666666667, -0.18, 0.375
117461, 1.9083333333333, -0.02, 0.375
117462, 1.9083333333333, -0.04, 0.35416666666667
117463, 1.8875, -0.04, 0.375
117464, 1.9083333333333, -0.06, 0.375
117465, 1.9083333333333, -0.08, 0.35416666666667
117466, 1.8875, -0.08, 0.375
117467, 1.9083333333333, -0.1, 0.375
117468, 1.9083333333333, -0.12, 0.35416666666667
117469, 1.8875, -0.12, 0.375
117470, 1.9083333333333, -0.14, 0.375
117471, 1.9083333333333, -0.16, 0.35416666666667
117472, 1.8875, -0.16, 0.375
117473, 1.9083333333333, -0.18, 0.375
117474, 1.95, -0.02, 0.375
117475, 1.95, -0.04, 0.35416666666667
117476, 1.9291666666667, -0.04, 0.375
117477, 1.95, -0.06, 0.375
117478, 1.95, -0.08, 0.35416666666667
117479, 1.9291666666667, -0.08, 0.375
117480, 1.95, -0.1, 0.375
117481, 1.95, -0.12, 0.35416666666667
117482, 1.9291666666667, -0.12, 0.375
117483, 1.95, -0.14, 0.375
117484, 1.95, -0.16, 0.35416666666667
117485, 1.9291666666667, -0.16, 0.375
117486, 1.95, -0.18, 0.375
117487, 1.9916666666667, -0.02, 0.375
117488, 1.9916666666667, -0.04, 0.35416666666667
117489, 1.9708333333333, -0.04, 0.375
117490, 1.9916666666667, -0.06, 0.375
117491, 1.9916666666667, -0.08, 0.35416666666667
117492, 1.9708333333333, -0.08, 0.375
117493, 1.9916666666667, -0.1, 0.375
117494, 1.9916666666667, -0.12, 0.35416666666667
117495, 1.9708333333333, -0.12, 0.375
117496, 1.9916666666667, -0.14, 0.375
117497, 1.9916666666667, -0.16, 0.35416666666667
117498, 1.9708333333333, -0.16, 0.375
117499, 1.9916666666667, -0.18, 0.375
117500, 2.0333333333333, -0.02, 0.375
117501, 2.0333333333333, -0.04, 0.35416666666667
117502, 2.0125, -0.04, 0.375
117503, 2.0333333333333, -0.06, 0.375
117504, 2.0333333333333, -0.08, 0.35416666666667
117505, 2.0125, -0.08, 0.375
117506, 2.0333333333333, -0.1, 0.375
117507, 2.0333333333333, -0.12, 0.35416666666667
117508, 2.0125, -0.12, 0.375
117509, 2.0333333333333, -0.14, 0.375
117510, 2.0333333333333, -0.16, 0.35416666666667
117511, 2.0125, -0.16, 0.375
117512, 2.0333333333333, -0.18, 0.375
117513, 2.075, -0.02, 0.375
117514, 2.075, -0.04, 0.35416666666667
117515, 2.0541666666667, -0.04, 0.375
117516, 2.075, -0.06, 0.375
117517, 2.075, -0.08, 0.35416666666667
117518, 2.0541666666667, -0.08, 0.375
117519, 2.075, -0.1, 0.375
117520, 2.075, -0.12, 0.35416666666667
117521, 2.0541666666667, -0.12, 0.375
117522, 2.075, -0.14, 0.375
117523, 2.075, -0.16, 0.35416666666667
117524, 2.0541666666667, -0.16, 0.375
117525, 2.075, -0.18, 0.375
117526, 2.1166666666667, -0.02, 0.375
117527, 2.1166666666667, -0.04, 0.35416666666667
117528, 2.0958333333333, -0.04, 0.375
117529, 2.1166666666667, -0.06, 0.375
117530, 2.1166666666667, -0.08, 0.35416666666667
117531, 2.0958333333333, -0.08, 0.375
117532, 2.1166666666667, -0.1, 0.375
117533, 2.1166666666667, -0.12, 0.35416666666667
117534, 2.0958333333333, -0.12, 0.375
117535, 2.1166666666667, -0.14, 0.375
117536, 2.1166666666667, -0.16, 0.35416666666667
117537, 2.0958333333333, -0.16, 0.375
117538, 2.1166666666667, -0.18, 0.375
117539, 2.1583333333333, -0.02, 0.375
117540, 2.1583333333333, -0.04, 0.35416666666667
117541, 2.1375, -0.04, 0.375
117542, 2.1583333333333, -0.06, 0.375
117543, 2.1583333333333, -0.08, 0.35416666666667
117544, 2.1375, -0.08, 0.375
117545, 2.1583333333333, -0.1, 0.375
117546, 2.1583333333333, -0.12, 0.35416666666667
117547, 2.1375, -0.12, 0.375
117548, 2.1583333333333, -0.14, 0.375
117549, 2.1583333333333, -0.16, 0.35416666666667
117550, 2.1375, -0.16, 0.375
117551, 2.1583333333333, -0.18, 0.375
117552, 2.1791666666667, -0.04, 0.375
117553, 2.1791666666667, -0.08, 0.375
117554, 2.1791666666667, -0.12, 0.375
117555, 2.1791666666667, -0.16, 0.375
117556, 1.2416666666667, -0.02, 0.41666666666667
117557, 1.2416666666667, -0.04, 0.39583333333333
117558, 1.2208333333333, -0.04, 0.41666666666667
117559, 1.2416666666667, -0.06, 0.41666666666667
117560, 1.2416666666667, -0.08, 0.39583333333333
117561, 1.2208333333333, -0.08, 0.41666666666667
117562, 1.2416666666667, -0.1, 0.41666666666667
117563, 1.2416666666667, -0.12, 0.39583333333333
117564, 1.2208333333333, -0.12, 0.41666666666667
117565, 1.2416666666667, -0.14, 0.41666666666667
117566, 1.2416666666667, -0.16, 0.39583333333333
117567, 1.2208333333333, -0.16, 0.41666666666667
117568, 1.2416666666667, -0.18, 0.41666666666667
117569, 1.2833333333333, -0.02, 0.41666666666667
117570, 1.2833333333333, -0.04, 0.39583333333333
117571, 1.2625, -0.04, 0.41666666666667
117572, 1.2833333333333, -0.06, 0.41666666666667
117573, 1.2833333333333, -0.08, 0.39583333333333
117574, 1.2625, -0.08, 0.41666666666667
117575, 1.2833333333333, -0.1, 0.41666666666667
117576, 1.2833333333333, -0.12, 0.39583333333333
117577, 1.2625, -0.12, 0.41666666666667
117578, 1.2833333333333, -0.14, 0.41666666666667
117579, 1.2833333333333, -0.16, 0.39583333333333
117580, 1.2625, -0.16, 0.41666666666667
117581, 1.2833333333333, -0.18, 0.41666666666667
117582, 1.325, -0.02, 0.41666666666667
117583, 1.325, -0.04, 0.39583333333333
117584, 1.3041666666667, -0.04, 0.41666666666667
117585, 1.325, -0.06, 0.41666666666667
117586, 1.325, -0.08, 0.39583333333333
117587, 1.3041666666667, -0.08, 0.41666666666667
117588, 1.325, -0.1, 0.41666666666667
117589, 1.325, -0.12, 0.39583333333333
117590, 1.3041666666667, -0.12, 0.41666666666667
117591, 1.325, -0.14, 0.41666666666667
117592, 1.325, -0.16, 0.39583333333333
117593, 1.3041666666667, -0.16, 0.41666666666667
117594, 1.325, -0.18, 0.41666666666667
117595, 1.3666666666667, -0.02, 0.41666666666667
117596, 1.3666666666667, -0.04, 0.39583333333333
117597, 1.3458333333333, -0.04, 0.41666666666667
117598, 1.3666666666667, -0.06, 0.41666666666667
117599, 1.3666666666667, -0.08, 0.39583333333333
117600, 1.3458333333333, -0.08, 0.41666666666667
117601, 1.3666666666667, -0.1, 0.41666666666667
117602, 1.3666666666667, -0.12, 0.39583333333333
117603, 1.3458333333333, -0.12, 0.41666666666667
117604, 1.3666666666667, -0.14, 0.41666666666667
117605, 1.3666666666667, -0.16, 0.39583333333333
117606, 1.3458333333333, -0.16, 0.41666666666667
117607, 1.3666666666667, -0.18, 0.41666666666667
117608, 1.4083333333333, -0.02, 0.41666666666667
117609, 1.4083333333333, -0.04, 0.39583333333333
117610, 1.3875, -0.04, 0.41666666666667
117611, 1.4083333333333, -0.06, 0.41666666666667
117612, 1.4083333333333, -0.08, 0.39583333333333
117613, 1.3875, -0.08, 0.41666666666667
117614, 1.4083333333333, -0.1, 0.41666666666667
117615, 1.4083333333333, -0.12, 0.39583333333333
117616, 1.3875, -0.12, 0.41666666666667
117617, 1.4083333333333, -0.14, 0.41666666666667
117618, 1.4083333333333, -0.16, 0.39583333333333
117619, 1.3875, -0.16, 0.41666666666667
117620, 1.4083333333333, -0.18, 0.41666666666667
117621, 1.45, -0.02, 0.41666666666667
117622, 1.45, -0.04, 0.39583333333333
117623, 1.4291666666667, -0.04, 0.41666666666667
117624, 1.45, -0.06, 0.41666666666667
117625, 1.45, -0.08, 0.39583333333333
117626, 1.4291666666667, -0.08, 0.41666666666667
117627, 1.45, -0.1, 0.41666666666667
117628, 1.45, -0.12, 0.39583333333333
117629, 1.4291666666667, -0.12, 0.41666666666667
117630, 1.45, -0.14, 0.41666666666667
117631, 1.45, -0.16, 0.39583333333333
117632, 1.4291666666667, -0.16, 0.41666666666667
117633, 1.45, -0.18, 0.41666666666667
117634, 1.4916666666667, -0.02, 0.41666666666667
117635, 1.4916666666667, -0.04, 0.39583333333333
117636, 1.4708333333333, -0.04, 0.41666666666667
117637, 1.4916666666667, -0.06, 0.41666666666667
117638, 1.4916666666667, -0.08, 0.39583333333333
117639, 1.4708333333333, -0.08, 0.41666666666667
117640, 1.4916666666667, -0.1, 0.41666666666667
117641, 1.4916666666667, -0.12, 0.39583333333333
117642, 1.4708333333333, -0.12, 0.41666666666667
117643, 1.4916666666667, -0.14, 0.41666666666667
117644, 1.4916666666667, -0.16, 0.39583333333333
117645, 1.4708333333333, -0.16, 0.41666666666667
117646, 1.4916666666667, -0.18, 0.41666666666667
117647, 1.5333333333333, -0.02, 0.41666666666667
117648, 1.5333333333333, -0.04, 0.39583333333333
117649, 1.5125, -0.04, 0.41666666666667
117650, 1.5333333333333, -0.06, 0.41666666666667
117651, 1.5333333333333, -0.08, 0.39583333333333
117652, 1.5125, -0.08, 0.41666666666667
117653, 1.5333333333333, -0.1, 0.41666666666667
117654, 1.5333333333333, -0.12, 0.39583333333333
117655, 1.5125, -0.12, 0.41666666666667
117656, 1.5333333333333, -0.14, 0.41666666666667
117657, 1.5333333333333, -0.16, 0.39583333333333
117658, 1.5125, -0.16, 0.41666666666667
117659, 1.5333333333333, -0.18, 0.41666666666667
117660, 1.575, -0.02, 0.41666666666667
117661, 1.575, -0.04, 0.39583333333333
117662, 1.5541666666667, -0.04, 0.41666666666667
117663, 1.575, -0.06, 0.41666666666667
117664, 1.575, -0.08, 0.39583333333333
117665, 1.5541666666667, -0.08, 0.41666666666667
117666, 1.575, -0.1, 0.41666666666667
117667, 1.575, -0.12, 0.39583333333333
117668, 1.5541666666667, -0.12, 0.41666666666667
117669, 1.575, -0.14, 0.41666666666667
117670, 1.575, -0.16, 0.39583333333333
117671, 1.5541666666667, -0.16, 0.41666666666667
117672, 1.575, -0.18, 0.41666666666667
117673, 1.6166666666667, -0.02, 0.41666666666667
117674, 1.6166666666667, -0.04, 0.39583333333333
117675, 1.5958333333333, -0.04, 0.41666666666667
117676, 1.6166666666667, -0.06, 0.41666666666667
117677, 1.6166666666667, -0.08, 0.39583333333333
117678, 1.5958333333333, -0.08, 0.41666666666667
117679, 1.6166666666667, -0.1, 0.41666666666667
117680, 1.6166666666667, -0.12, 0.39583333333333
117681, 1.5958333333333, -0.12, 0.41666666666667
117682, 1.6166666666667, -0.14, 0.41666666666667
117683, 1.6166666666667, -0.16, 0.39583333333333
117684, 1.5958333333333, -0.16, 0.41666666666667
117685, 1.6166666666667, -0.18, 0.41666666666667
117686, 1.6583333333333, -0.02, 0.41666666666667
117687, 1.6583333333333, -0.04, 0.39583333333333
117688, 1.6375, -0.04, 0.41666666666667
117689, 1.6583333333333, -0.06, 0.41666666666667
117690, 1.6583333333333, -0.08, 0.39583333333333
117691, 1.6375, -0.08, 0.41666666666667
117692, 1.6583333333333, -0.1, 0.41666666666667
117693, 1.6583333333333, -0.12, 0.39583333333333
117694, 1.6375, -0.12, 0.41666666666667
117695, 1.6583333333333, -0.14, 0.41666666666667
117696, 1.6583333333333, -0.16, 0.39583333333333
117697, 1.6375, -0.16, 0.41666666666667
117698, 1.6583333333333, -0.18, 0.41666666666667
117699, 1.7, -0.02, 0.41666666666667
117700, 1.7, -0.04, 0.39583333333333
117701, 1.6791666666667, -0.04, 0.41666666666667
117702, 1.7, -0.06, 0.41666666666667
117703, 1.7, -0.08, 0.39583333333333
117704, 1.6791666666667, -0.08, 0.41666666666667
117705, 1.7, -0.1, 0.41666666666667
117706, 1.7, -0.12, 0.39583333333333
117707, 1.6791666666667, -0.12, 0.41666666666667
117708, 1.7, -0.14, 0.41666666666667
117709, 1.7, -0.16, 0.39583333333333
117710, 1.6791666666667, -0.16, 0.41666666666667
117711, 1.7, -0.18, 0.41666666666667
117712, 1.7416666666667, -0.02, 0.41666666666667
117713, 1.7416666666667, -0.04, 0.39583333333333
117714, 1.7208333333333, -0.04, 0.41666666666667
117715, 1.7416666666667, -0.06, 0.41666666666667
117716, 1.7416666666667, -0.08, 0.39583333333333
117717, 1.7208333333333, -0.08, 0.41666666666667
117718, 1.7416666666667, -0.1, 0.41666666666667
117719, 1.7416666666667, -0.12, 0.39583333333333
117720, 1.7208333333333, -0.12, 0.41666666666667
117721, 1.7416666666667, -0.14, 0.41666666666667
117722, 1.7416666666667, -0.16, 0.39583333333333
117723, 1.7208333333333, -0.16, 0.41666666666667
117724, 1.7416666666667, -0.18, 0.41666666666667
117725, 1.7833333333333, -0.02, 0.41666666666667
117726, 1.7833333333333, -0.04, 0.39583333333333
117727, 1.7625, -0.04, 0.41666666666667
117728, 1.7833333333333, -0.06, 0.41666666666667
117729, 1.7833333333333, -0.08, 0.39583333333333
117730, 1.7625, -0.08, 0.41666666666667
117731, 1.7833333333333, -0.1, 0.41666666666667
117732, 1.7833333333333, -0.12, 0.39583333333333
117733, 1.7625, -0.12, 0.41666666666667
117734, 1.7833333333333, -0.14, 0.41666666666667
117735, 1.7833333333333, -0.16, 0.39583333333333
117736, 1.7625, -0.16, 0.41666666666667
117737, 1.7833333333333, -0.18, 0.41666666666667
117738, 1.825, -0.02, 0.41666666666667
117739, 1.825, -0.04, 0.39583333333333
117740, 1.8041666666667, -0.04, 0.41666666666667
117741, 1.825, -0.06, 0.41666666666667
117742, 1.825, -0.08, 0.39583333333333
117743, 1.8041666666667, -0.08, 0.41666666666667
117744, 1.825, -0.1, 0.41666666666667
117745, 1.825, -0.12, 0.39583333333333
117746, 1.8041666666667, -0.12, 0.41666666666667
117747, 1.825, -0.14, 0.41666666666667
117748, 1.825, -0.16, 0.39583333333333
117749, 1.8041666666667, -0.16, 0.41666666666667
117750, 1.825, -0.18, 0.41666666666667
117751, 1.8666666666667, -0.02, 0.41666666666667
117752, 1.8666666666667, -0.04, 0.39583333333333
117753, 1.8458333333333, -0.04, 0.41666666666667
117754, 1.8666666666667, -0.06, 0.41666666666667
117755, 1.8666666666667, -0.08, 0.39583333333333
117756, 1.8458333333333, -0.08, 0.41666666666667
117757, 1.8666666666667, -0.1, 0.41666666666667
117758, 1.8666666666667, -0.12, 0.39583333333333
117759, 1.8458333333333, -0.12, 0.41666666666667
117760, 1.8666666666667, -0.14, 0.41666666666667
117761, 1.8666666666667, -0.16, 0.39583333333333
117762, 1.8458333333333, -0.16, 0.41666666666667
117763, 1.8666666666667, -0.18, 0.41666666666667
117764, 1.9083333333333, -0.02, 0.41666666666667
117765, 1.9083333333333, -0.04, 0.39583333333333
117766, 1.8875, -0.04, 0.41666666666667
117767, 1.9083333333333, -0.06, 0.41666666666667
117768, 1.9083333333333, -0.08, 0.39583333333333
117769, 1.8875, -0.08, 0.41666666666667
117770, 1.9083333333333, -0.1, 0.41666666666667
117771, 1.9083333333333, -0.12, 0.39583333333333
117772, 1.8875, -0.12, 0.41666666666667
117773, 1.9083333333333, -0.14, 0.41666666666667
117774, 1.9083333333333, -0.16, 0.39583333333333
117775, 1.8875, -0.16, 0.41666666666667
117776, 1.9083333333333, -0.18, 0.41666666666667
117777, 1.95, -0.02, 0.41666666666667
117778, 1.95, -0.04, 0.39583333333333
117779, 1.9291666666667, -0.04, 0.41666666666667
117780, 1.95, -0.06, 0.41666666666667
117781, 1.95, -0.08, 0.39583333333333
117782, 1.9291666666667, -0.08, 0.41666666666667
117783, 1.95, -0.1, 0.41666666666667
117784, 1.95, -0.12, 0.39583333333333
117785, 1.9291666666667, -0.12, 0.41666666666667
117786, 1.95, -0.14, 0.41666666666667
117787, 1.95, -0.16, 0.39583333333333
117788, 1.9291666666667, -0.16, 0.41666666666667
117789, 1.95, -0.18, 0.41666666666667
117790, 1.9916666666667, -0.02, 0.41666666666667
117791, 1.9916666666667, -0.04, 0.39583333333333
117792, 1.9708333333333, -0.04, 0.41666666666667
117793, 1.9916666666667, -0.06, 0.41666666666667
117794, 1.9916666666667, -0.08, 0.39583333333333
117795, 1.9708333333333, -0.08, 0.41666666666667
117796, 1.9916666666667, -0.1, 0.41666666666667
117797, 1.9916666666667, -0.12, 0.39583333333333
117798, 1.9708333333333, -0.12, 0.41666666666667
117799, 1.9916666666667, -0.14, 0.41666666666667
117800, 1.9916666666667, -0.16, 0.39583333333333
117801, 1.9708333333333, -0.16, 0.41666666666667
117802, 1.9916666666667, -0.18, 0.41666666666667
117803, 2.0333333333333, -0.02, 0.41666666666667
117804, 2.0333333333333, -0.04, 0.39583333333333
117805, 2.0125, -0.04, 0.41666666666667
117806, 2.0333333333333, -0.06, 0.41666666666667
117807, 2.0333333333333, -0.08, 0.39583333333333
117808, 2.0125, -0.08, 0.41666666666667
117809, 2.0333333333333, -0.1, 0.41666666666667
117810, 2.0333333333333, -0.12, 0.39583333333333
117811, 2.0125, -0.12, 0.41666666666667
117812, 2.0333333333333, -0.14, 0.41666666666667
117813, 2.0333333333333, -0.16, 0.39583333333333
117814, 2.0125, -0.16, 0.41666666666667
117815, 2.0333333333333, -0.18, 0.41666666666667
117816, 2.075, -0.02, 0.41666666666667
117817, 2.075, -0.04, 0.39583333333333
117818, 2.0541666666667, -0.04, 0.41666666666667
117819, 2.075, -0.06, 0.41666666666667
117820, 2.075, -0.08, 0.39583333333333
117821, 2.0541666666667, -0.08, 0.41666666666667
117822, 2.075, -0.1, 0.41666666666667
117823, 2.075, -0.12, 0.39583333333333
117824, 2.0541666666667, -0.12, 0.41666666666667
117825, 2.075, -0.14, 0.41666666666667
117826, 2.075, -0.16, 0.39583333333333
117827, 2.0541666666667, -0.16, 0.41666666666667
117828, 2.075, -0.18, 0.41666666666667
117829, 2.1166666666667, -0.02, 0.41666666666667
117830, 2.1166666666667, -0.04, 0.39583333333333
117831, 2.0958333333333, -0.04, 0.41666666666667
117832, 2.1166666666667, -0.06, 0.41666666666667
117833, 2.1166666666667, -0.08, 0.39583333333333
117834, 2.0958333333333, -0.08, 0.41666666666667
117835, 2.1166666666667, -0.1, 0.41666666666667
117836, 2.1166666666667, -0.12, 0.39583333333333
117837, 2.0958333333333, -0.12, 0.41666666666667
117838, 2.1166666666667, -0.14, 0.41666666666667
117839, 2.1166666666667, -0.16, 0.39583333333333
117840, 2.0958333333333, -0.16, 0.41666666666667
117841, 2.1166666666667, -0.18, 0.41666666666667
117842, 2.1583333333333, -0.02, 0.41666666666667
117843, 2.1583333333333, -0.04, 0.39583333333333
117844, 2.1375, -0.04, 0.41666666666667
117845, 2.1583333333333, -0.06, 0.41666666666667
117846, 2.1583333333333, -0.08, 0.39583333333333
117847, 2.1375, -0.08, 0.41666666666667
117848, 2.1583333333333, -0.1, 0.41666666666667
117849, 2.1583333333333, -0.12, 0.39583333333333
117850, 2.1375, -0.12, 0.41666666666667
117851, 2.1583333333333, -0.14, 0.41666666666667
117852, 2.1583333333333, -0.16, 0.39583333333333
117853, 2.1375, -0.16, 0.41666666666667
117854, 2.1583333333333, -0.18, 0.41666666666667
117855, 2.1791666666667, -0.04, 0.41666666666667
117856, 2.1791666666667, -0.08, 0.41666666666667
117857, 2.1791666666667, -0.12, 0.41666666666667
117858, 2.1791666666667, -0.16, 0.41666666666667
117859, 1.2416666666667, -0.02, 0.45833333333333
117860, 1.2416666666667, -0.04, 0.4375
117861, 1.2208333333333, -0.04, 0.45833333333333
117862, 1.2416666666667, -0.06, 0.45833333333333
117863, 1.2416666666667, -0.08, 0.4375
117864, 1.2208333333333, -0.08, 0.45833333333333
117865, 1.2416666666667, -0.1, 0.45833333333333
117866, 1.2416666666667, -0.12, 0.4375
117867, 1.2208333333333, -0.12, 0.45833333333333
117868, 1.2416666666667, -0.14, 0.45833333333333
117869, 1.2416666666667, -0.16, 0.4375
117870, 1.2208333333333, -0.16, 0.45833333333333
117871, 1.2416666666667, -0.18, 0.45833333333333
117872, 1.2833333333333, -0.02, 0.45833333333333
117873, 1.2833333333333, -0.04, 0.4375
117874, 1.2625, -0.04, 0.45833333333333
117875, 1.2833333333333, -0.06, 0.45833333333333
117876, 1.2833333333333, -0.08, 0.4375
117877, 1.2625, -0.08, 0.45833333333333
117878, 1.2833333333333, -0.1, 0.45833333333333
117879, 1.2833333333333, -0.12, 0.4375
117880, 1.2625, -0.12, 0.45833333333333
117881, 1.2833333333333, -0.14, 0.45833333333333
117882, 1.2833333333333, -0.16, 0.4375
117883, 1.2625, -0.16, 0.45833333333333
117884, 1.2833333333333, -0.18, 0.45833333333333
117885, 1.325, -0.02, 0.45833333333333
117886, 1.325, -0.04, 0.4375
117887, 1.3041666666667, -0.04, 0.45833333333333
117888, 1.325, -0.06, 0.45833333333333
117889, 1.325, -0.08, 0.4375
117890, 1.3041666666667, -0.08, 0.45833333333333
117891, 1.325, -0.1, 0.45833333333333
117892, 1.325, -0.12, 0.4375
117893, 1.3041666666667, -0.12, 0.45833333333333
117894, 1.325, -0.14, 0.45833333333333
117895, 1.325, -0.16, 0.4375
117896, 1.3041666666667, -0.16, 0.45833333333333
117897, 1.325, -0.18, 0.45833333333333
117898, 1.3666666666667, -0.02, 0.45833333333333
117899, 1.3666666666667, -0.04, 0.4375
117900, 1.3458333333333, -0.04, 0.45833333333333
117901, 1.3666666666667, -0.06, 0.45833333333333
117902, 1.3666666666667, -0.08, 0.4375
117903, 1.3458333333333, -0.08, 0.45833333333333
117904, 1.3666666666667, -0.1, 0.45833333333333
117905, 1.3666666666667, -0.12, 0.4375
117906, 1.3458333333333, -0.12, 0.45833333333333
117907, 1.3666666666667, -0.14, 0.45833333333333
117908, 1.3666666666667, -0.16, 0.4375
117909, 1.3458333333333, -0.16, 0.45833333333333
117910, 1.3666666666667, -0.18, 0.45833333333333
117911, 1.4083333333333, -0.02, 0.45833333333333
117912, 1.4083333333333, -0.04, 0.4375
117913, 1.3875, -0.04, 0.45833333333333
117914, 1.4083333333333, -0.06, 0.45833333333333
117915, 1.4083333333333, -0.08, 0.4375
117916, 1.3875, -0.08, 0.45833333333333
117917, 1.4083333333333, -0.1, 0.45833333333333
117918, 1.4083333333333, -0.12, 0.4375
117919, 1.3875, -0.12, 0.45833333333333
117920, 1.4083333333333, -0.14, 0.45833333333333
117921, 1.4083333333333, -0.16, 0.4375
117922, 1.3875, -0.16, 0.45833333333333
117923, 1.4083333333333, -0.18, 0.45833333333333
117924, 1.45, -0.02, 0.45833333333333
117925, 1.45, -0.04, 0.4375
117926, 1.4291666666667, -0.04, 0.45833333333333
117927, 1.45, -0.06, 0.45833333333333
117928, 1.45, -0.08, 0.4375
117929, 1.4291666666667, -0.08, 0.45833333333333
117930, 1.45, -0.1, 0.45833333333333
117931, 1.45, -0.12, 0.4375
117932, 1.4291666666667, -0.12, 0.45833333333333
117933, 1.45, -0.14, 0.45833333333333
117934, 1.45, -0.16, 0.4375
117935, 1.4291666666667, -0.16, 0.45833333333333
117936, 1.45, -0.18, 0.45833333333333
117937, 1.4916666666667, -0.02, 0.45833333333333
117938, 1.4916666666667, -0.04, 0.4375
117939, 1.4708333333333, -0.04, 0.45833333333333
117940, 1.4916666666667, -0.06, 0.45833333333333
117941, 1.4916666666667, -0.08, 0.4375
117942, 1.4708333333333, -0.08, 0.45833333333333
117943, 1.4916666666667, -0.1, 0.45833333333333
117944, 1.4916666666667, -0.12, 0.4375
117945, 1.4708333333333, -0.12, 0.45833333333333
117946, 1.4916666666667, -0.14, 0.45833333333333
117947, 1.4916666666667, -0.16, 0.4375
117948, 1.4708333333333, -0.16, 0.45833333333333
117949, 1.4916666666667, -0.18, 0.45833333333333
117950, 1.5333333333333, -0.02, 0.45833333333333
117951, 1.5333333333333, -0.04, 0.4375
117952, 1.5125, -0.04, 0.45833333333333
117953, 1.5333333333333, -0.06, 0.45833333333333
117954, 1.5333333333333, -0.08, 0.4375
117955, 1.5125, -0.08, 0.45833333333333
117956, 1.5333333333333, -0.1, 0.45833333333333
117957, 1.5333333333333, -0.12, 0.4375
117958, 1.5125, -0.12, 0.45833333333333
117959, 1.5333333333333, -0.14, 0.45833333333333
117960, 1.5333333333333, -0.16, 0.4375
117961, 1.5125, -0.16, 0.45833333333333
117962, 1.5333333333333, -0.18, 0.45833333333333
117963, 1.575, -0.02, 0.45833333333333
117964, 1.575, -0.04, 0.4375
117965, 1.5541666666667, -0.04, 0.45833333333333
117966, 1.575, -0.06, 0.45833333333333
117967, 1.575, -0.08, 0.4375
117968, 1.5541666666667, -0.08, 0.45833333333333
117969, 1.575, -0.1, 0.45833333333333
117970, 1.575, -0.12, 0.4375
117971, 1.5541666666667, -0.12, 0.45833333333333
117972, 1.575, -0.14, 0.45833333333333
117973, 1.575, -0.16, 0.4375
117974, 1.5541666666667, -0.16, 0.45833333333333
117975, 1.575, -0.18, 0.45833333333333
117976, 1.6166666666667, -0.02, 0.45833333333333
117977, 1.6166666666667, -0.04, 0.4375
117978, 1.5958333333333, -0.04, 0.45833333333333
117979, 1.6166666666667, -0.06, 0.45833333333333
117980, 1.6166666666667, -0.08, 0.4375
117981, 1.5958333333333, -0.08, 0.45833333333333
117982, 1.6166666666667, -0.1, 0.45833333333333
117983, 1.6166666666667, -0.12, 0.4375
117984, 1.5958333333333, -0.12, 0.45833333333333
117985, 1.6166666666667, -0.14, 0.45833333333333
117986, 1.6166666666667, -0.16, 0.4375
117987, 1.5958333333333, -0.16, 0.45833333333333
117988, 1.6166666666667, -0.18, 0.45833333333333
117989, 1.6583333333333, -0.02, 0.45833333333333
117990, 1.6583333333333, -0.04, 0.4375
117991, 1.6375, -0.04, 0.45833333333333
117992, 1.6583333333333, -0.06, 0.45833333333333
117993, 1.6583333333333, -0.08, 0.4375
117994, 1.6375, -0.08, 0.45833333333333
117995, 1.6583333333333, -0.1, 0.45833333333333
117996, 1.6583333333333, -0.12, 0.4375
117997, 1.6375, -0.12, 0.45833333333333
117998, 1.6583333333333, -0.14, 0.45833333333333
117999, 1.6583333333333, -0.16, 0.4375
118000, 1.6375, -0.16, 0.45833333333333
118001, 1.6583333333333, -0.18, 0.45833333333333
118002, 1.7, -0.02, 0.45833333333333
118003, 1.7, -0.04, 0.4375
118004, 1.6791666666667, -0.04, 0.45833333333333
118005, 1.7, -0.06, 0.45833333333333
118006, 1.7, -0.08, 0.4375
118007, 1.6791666666667, -0.08, 0.45833333333333
118008, 1.7, -0.1, 0.45833333333333
118009, 1.7, -0.12, 0.4375
118010, 1.6791666666667, -0.12, 0.45833333333333
118011, 1.7, -0.14, 0.45833333333333
118012, 1.7, -0.16, 0.4375
118013, 1.6791666666667, -0.16, 0.45833333333333
118014, 1.7, -0.18, 0.45833333333333
118015, 1.7416666666667, -0.02, 0.45833333333333
118016, 1.7416666666667, -0.04, 0.4375
118017, 1.7208333333333, -0.04, 0.45833333333333
118018, 1.7416666666667, -0.06, 0.45833333333333
118019, 1.7416666666667, -0.08, 0.4375
118020, 1.7208333333333, -0.08, 0.45833333333333
118021, 1.7416666666667, -0.1, 0.45833333333333
118022, 1.7416666666667, -0.12, 0.4375
118023, 1.7208333333333, -0.12, 0.45833333333333
118024, 1.7416666666667, -0.14, 0.45833333333333
118025, 1.7416666666667, -0.16, 0.4375
118026, 1.7208333333333, -0.16, 0.45833333333333
118027, 1.7416666666667, -0.18, 0.45833333333333
118028, 1.7833333333333, -0.02, 0.45833333333333
118029, 1.7833333333333, -0.04, 0.4375
118030, 1.7625, -0.04, 0.45833333333333
118031, 1.7833333333333, -0.06, 0.45833333333333
118032, 1.7833333333333, -0.08, 0.4375
118033, 1.7625, -0.08, 0.45833333333333
118034, 1.7833333333333, -0.1, 0.45833333333333
118035, 1.7833333333333, -0.12, 0.4375
118036, 1.7625, -0.12, 0.45833333333333
118037, 1.7833333333333, -0.14, 0.45833333333333
118038, 1.7833333333333, -0.16, 0.4375
118039, 1.7625, -0.16, 0.45833333333333
118040, 1.7833333333333, -0.18, 0.45833333333333
118041, 1.825, -0.02, 0.45833333333333
118042, 1.825, -0.04, 0.4375
118043, 1.8041666666667, -0.04, 0.45833333333333
118044, 1.825, -0.06, 0.45833333333333
118045, 1.825, -0.08, 0.4375
118046, 1.8041666666667, -0.08, 0.45833333333333
118047, 1.825, -0.1, 0.45833333333333
118048, 1.825, -0.12, 0.4375
118049, 1.8041666666667, -0.12, 0.45833333333333
118050, 1.825, -0.14, 0.45833333333333
118051, 1.825, -0.16, 0.4375
118052, 1.8041666666667, -0.16, 0.45833333333333
118053, 1.825, -0.18, 0.45833333333333
118054, 1.8666666666667, -0.02, 0.45833333333333
118055, 1.8666666666667, -0.04, 0.4375
118056, 1.8458333333333, -0.04, 0.45833333333333
118057, 1.8666666666667, -0.06, 0.45833333333333
118058, 1.8666666666667, -0.08, 0.4375
118059, 1.8458333333333, -0.08, 0.45833333333333
118060, 1.8666666666667, -0.1, 0.45833333333333
118061, 1.8666666666667, -0.12, 0.4375
118062, 1.8458333333333, -0.12, 0.45833333333333
118063, 1.8666666666667, -0.14, 0.45833333333333
118064, 1.8666666666667, -0.16, 0.4375
118065, 1.8458333333333, -0.16, 0.45833333333333
118066, 1.8666666666667, -0.18, 0.45833333333333
118067, 1.9083333333333, -0.02, 0.45833333333333
118068, 1.9083333333333, -0.04, 0.4375
118069, 1.8875, -0.04, 0.45833333333333
118070, 1.9083333333333, -0.06, 0.45833333333333
118071, 1.9083333333333, -0.08, 0.4375
118072, 1.8875, -0.08, 0.45833333333333
118073, 1.9083333333333, -0.1, 0.45833333333333
118074, 1.9083333333333, -0.12, 0.4375
118075, 1.8875, -0.12, 0.45833333333333
118076, 1.9083333333333, -0.14, 0.45833333333333
118077, 1.9083333333333, -0.16, 0.4375
118078, 1.8875, -0.16, 0.45833333333333
118079, 1.9083333333333, -0.18, 0.45833333333333
118080, 1.95, -0.02, 0.45833333333333
118081, 1.95, -0.04, 0.4375
118082, 1.9291666666667, -0.04, 0.45833333333333
118083, 1.95, -0.06, 0.45833333333333
118084, 1.95, -0.08, 0.4375
118085, 1.9291666666667, -0.08, 0.45833333333333
118086, 1.95, -0.1, 0.45833333333333
118087, 1.95, -0.12, 0.4375
118088, 1.9291666666667, -0.12, 0.45833333333333
118089, 1.95, -0.14, 0.45833333333333
118090, 1.95, -0.16, 0.4375
118091, 1.9291666666667, -0.16, 0.45833333333333
118092, 1.95, -0.18, 0.45833333333333
118093, 1.9916666666667, -0.02, 0.45833333333333
118094, 1.9916666666667, -0.04, 0.4375
118095, 1.9708333333333, -0.04, 0.45833333333333
118096, 1.9916666666667, -0.06, 0.45833333333333
118097, 1.9916666666667, -0.08, 0.4375
118098, 1.9708333333333, -0.08, 0.45833333333333
118099, 1.9916666666667, -0.1, 0.45833333333333
118100, 1.9916666666667, -0.12, 0.4375
118101, 1.9708333333333, -0.12, 0.45833333333333
118102, 1.9916666666667, -0.14, 0.45833333333333
118103, 1.9916666666667, -0.16, 0.4375
118104, 1.9708333333333, -0.16, 0.45833333333333
118105, 1.9916666666667, -0.18, 0.45833333333333
118106, 2.0333333333333, -0.02, 0.45833333333333
118107, 2.0333333333333, -0.04, 0.4375
118108, 2.0125, -0.04, 0.45833333333333
118109, 2.0333333333333, -0.06, 0.45833333333333
118110, 2.0333333333333, -0.08, 0.4375
118111, 2.0125, -0.08, 0.45833333333333
118112, 2.0333333333333, -0.1, 0.45833333333333
118113, 2.0333333333333, -0.12, 0.4375
118114, 2.0125, -0.12, 0.45833333333333
118115, 2.0333333333333, -0.14, 0.45833333333333
118116, 2.0333333333333, -0.16, 0.4375
118117, 2.0125, -0.16, 0.45833333333333
118118, 2.0333333333333, -0.18, 0.45833333333333
118119, 2.075, -0.02, 0.45833333333333
118120, 2.075, -0.04, 0.4375
118121, 2.0541666666667, -0.04, 0.45833333333333
118122, 2.075, -0.06, 0.45833333333333
118123, 2.075, -0.08, 0.4375
118124, 2.0541666666667, -0.08, 0.45833333333333
118125, 2.075, -0.1, 0.45833333333333
118126, 2.075, -0.12, 0.4375
118127, 2.0541666666667, -0.12, 0.45833333333333
118128, 2.075, -0.14, 0.45833333333333
118129, 2.075, -0.16, 0.4375
118130, 2.0541666666667, -0.16, 0.45833333333333
118131, 2.075, -0.18, 0.45833333333333
118132, 2.1166666666667, -0.02, 0.45833333333333
118133, 2.1166666666667, -0.04, 0.4375
118134, 2.0958333333333, -0.04, 0.45833333333333
118135, 2.1166666666667, -0.06, 0.45833333333333
118136, 2.1166666666667, -0.08, 0.4375
118137, 2.0958333333333, -0.08, 0.45833333333333
118138, 2.1166666666667, -0.1, 0.45833333333333
118139, 2.1166666666667, -0.12, 0.4375
118140, 2.0958333333333, -0.12, 0.45833333333333
118141, 2.1166666666667, -0.14, 0.45833333333333
118142, 2.1166666666667, -0.16, 0.4375
118143, 2.0958333333333, -0.16, 0.45833333333333
118144, 2.1166666666667, -0.18, 0.45833333333333
118145, 2.1583333333333, -0.02, 0.45833333333333
118146, 2.1583333333333, -0.04, 0.4375
118147, 2.1375, -0.04, 0.45833333333333
118148, 2.1583333333333, -0.06, 0.45833333333333
118149, 2.1583333333333, -0.08, 0.4375
118150, 2.1375, -0.08, 0.45833333333333
118151, 2.1583333333333, -0.1, 0.45833333333333
118152, 2.1583333333333, -0.12, 0.4375
118153, 2.1375, -0.12, 0.45833333333333
118154, 2.1583333333333, -0.14, 0.45833333333333
118155, 2.1583333333333, -0.16, 0.4375
118156, 2.1375, -0.16, 0.45833333333333
118157, 2.1583333333333, -0.18, 0.45833333333333
118158, 2.1791666666667, -0.04, 0.45833333333333
118159, 2.1791666666667, -0.08, 0.45833333333333
118160, 2.1791666666667, -0.12, 0.45833333333333
118161, 2.1791666666667, -0.16, 0.45833333333333
118162, 1.2416666666667, -0.04, 0.47916666666667
118163, 1.2416666666667, -0.08, 0.47916666666667
118164, 1.2416666666667, -0.12, 0.47916666666667
118165, 1.2416666666667, -0.16, 0.47916666666667
118166, 1.2833333333333, -0.04, 0.47916666666667
118167, 1.2833333333333, -0.08, 0.47916666666667
118168, 1.2833333333333, -0.12, 0.47916666666667
118169, 1.2833333333333, -0.16, 0.47916666666667
118170, 1.325, -0.04, 0.47916666666667
118171, 1.325, -0.08, 0.47916666666667
118172, 1.325, -0.12, 0.47916666666667
118173, 1.325, -0.16, 0.47916666666667
118174, 1.3666666666667, -0.04, 0.47916666666667
118175, 1.3666666666667, -0.08, 0.47916666666667
118176, 1.3666666666667, -0.12, 0.47916666666667
118177, 1.3666666666667, -0.16, 0.47916666666667
118178, 1.4083333333333, -0.04, 0.47916666666667
118179, 1.4083333333333, -0.08, 0.47916666666667
118180, 1.4083333333333, -0.12, 0.47916666666667
118181, 1.4083333333333, -0.16, 0.47916666666667
118182, 1.45, -0.04, 0.47916666666667
118183, 1.45, -0.08, 0.47916666666667
118184, 1.45, -0.12, 0.47916666666667
118185, 1.45, -0.16, 0.47916666666667
118186, 1.4916666666667, -0.04, 0.47916666666667
118187, 1.4916666666667, -0.08, 0.47916666666667
118188, 1.4916666666667, -0.12, 0.47916666666667
118189, 1.4916666666667, -0.16, 0.47916666666667
118190, 1.5333333333333, -0.04, 0.47916666666667
118191, 1.5333333333333, -0.08, 0.47916666666667
118192, 1.5333333333333, -0.12, 0.47916666666667
118193, 1.5333333333333, -0.16, 0.47916666666667
118194, 1.575, -0.04, 0.47916666666667
118195, 1.575, -0.08, 0.47916666666667
118196, 1.575, -0.12, 0.47916666666667
118197, 1.575, -0.16, 0.47916666666667
118198, 1.6166666666667, -0.04, 0.47916666666667
118199, 1.6166666666667, -0.08, 0.47916666666667
118200, 1.6166666666667, -0.12, 0.47916666666667
118201, 1.6166666666667, -0.16, 0.47916666666667
118202, 1.6583333333333, -0.04, 0.47916666666667
118203, 1.6583333333333, -0.08, 0.47916666666667
118204, 1.6583333333333, -0.12, 0.47916666666667
118205, 1.6583333333333, -0.16, 0.47916666666667
118206, 1.7, -0.04, 0.47916666666667
118207, 1.7, -0.08, 0.47916666666667
118208, 1.7, -0.12, 0.47916666666667
118209, 1.7, -0.16, 0.47916666666667
118210, 1.7416666666667, -0.04, 0.47916666666667
118211, 1.7416666666667, -0.08, 0.47916666666667
118212, 1.7416666666667, -0.12, 0.47916666666667
118213, 1.7416666666667, -0.16, 0.47916666666667
118214, 1.7833333333333, -0.04, 0.47916666666667
118215, 1.7833333333333, -0.08, 0.47916666666667
118216, 1.7833333333333, -0.12, 0.47916666666667
118217, 1.7833333333333, -0.16, 0.47916666666667
118218, 1.825, -0.04, 0.47916666666667
118219, 1.825, -0.08, 0.47916666666667
118220, 1.825, -0.12, 0.47916666666667
118221, 1.825, -0.16, 0.47916666666667
118222, 1.8666666666667, -0.04, 0.47916666666667
118223, 1.8666666666667, -0.08, 0.47916666666667
118224, 1.8666666666667, -0.12, 0.47916666666667
118225, 1.8666666666667, -0.16, 0.47916666666667
118226, 1.9083333333333, -0.04, 0.47916666666667
118227, 1.9083333333333, -0.08, 0.47916666666667
118228, 1.9083333333333, -0.12, 0.47916666666667
118229, 1.9083333333333, -0.16, 0.47916666666667
118230, 1.95, -0.04, 0.47916666666667
118231, 1.95, -0.08, 0.47916666666667
118232, 1.95, -0.12, 0.47916666666667
118233, 1.95, -0.16, 0.47916666666667
118234, 1.9916666666667, -0.04, 0.47916666666667
118235, 1.9916666666667, -0.08, 0.47916666666667
118236, 1.9916666666667, -0.12, 0.47916666666667
118237, 1.9916666666667, -0.16, 0.47916666666667
118238, 2.0333333333333, -0.04, 0.47916666666667
118239, 2.0333333333333, -0.08, 0.47916666666667
118240, 2.0333333333333, -0.12, 0.47916666666667
118241, 2.0333333333333, -0.16, 0.47916666666667
118242, 2.075, -0.04, 0.47916666666667
118243, 2.075, -0.08, 0.47916666666667
118244, 2.075, -0.12, 0.47916666666667
118245, 2.075, -0.16, 0.47916666666667
118246, 2.1166666666667, -0.04, 0.47916666666667
118247, 2.1166666666667, -0.08, 0.47916666666667
118248, 2.1166666666667, -0.12, 0.47916666666667
118249, 2.1166666666667, -0.16, 0.47916666666667
118250, 2.1583333333333, -0.04, 0.47916666666667
118251, 2.1583333333333, -0.08, 0.47916666666667
118252, 2.1583333333333, -0.12, 0.47916666666667
118253, 2.1583333333333, -0.16, 0.47916666666667
118254, 2.25, -0.04, 0.041666666666667
118255, 2.25, -0.08, 0.041666666666667
118256, 2.25, -0.12, 0.041666666666667
118257, 2.25, -0.16, 0.041666666666667
118258, 2.25, -0.04, 0.083333333333333
118259, 2.25, -0.08, 0.083333333333333
118260, 2.25, -0.12, 0.083333333333333
118261, 2.25, -0.16, 0.083333333333333
118262, 2.25, -0.04, 0.125
118263, 2.25, -0.08, 0.125
118264, 2.25, -0.12, 0.125
118265, 2.25, -0.16, 0.125
118266, 2.25, -0.04, 0.16666666666667
118267, 2.25, -0.08, 0.16666666666667
118268, 2.25, -0.12, 0.16666666666667
118269, 2.25, -0.16, 0.16666666666667
118270, 2.25, -0.04, 0.20833333333333
118271, 2.25, -0.08, 0.20833333333333
118272, 2.25, -0.12, 0.20833333333333
118273, 2.25, -0.16, 0.20833333333333
118274, 2.25, -0.04, 0.25
118275, 2.25, -0.08, 0.25
118276, 2.25, -0.12, 0.25
118277, 2.25, -0.16, 0.25
118278, 2.25, -0.04, 0.29166666666667
118279, 2.25, -0.08, 0.29166666666667
