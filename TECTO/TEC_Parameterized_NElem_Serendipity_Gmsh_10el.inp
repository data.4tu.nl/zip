87475, 1.6583333333333, 0.975, 0.29166666666667
87476, 1.6583333333333, 0.95, 0.27083333333333
87477, 1.6375, 0.95, 0.29166666666667
87478, 1.6583333333333, 0.925, 0.29166666666667
87479, 1.6583333333333, 0.9, 0.27083333333333
87480, 1.6375, 0.9, 0.29166666666667
87481, 1.6583333333333, 0.875, 0.29166666666667
87482, 1.6583333333333, 0.85, 0.27083333333333
87483, 1.6375, 0.85, 0.29166666666667
87484, 1.6583333333333, 0.825, 0.29166666666667
87485, 1.6583333333333, 0.8, 0.27083333333333
87486, 1.6375, 0.8, 0.29166666666667
87487, 1.6583333333333, 0.775, 0.29166666666667
87488, 1.6583333333333, 0.75, 0.27083333333333
87489, 1.6375, 0.75, 0.29166666666667
87490, 1.6583333333333, 0.725, 0.29166666666667
87491, 1.6583333333333, 0.7, 0.27083333333333
87492, 1.6375, 0.7, 0.29166666666667
87493, 1.6583333333333, 0.675, 0.29166666666667
87494, 1.6583333333333, 0.65, 0.27083333333333
87495, 1.6375, 0.65, 0.29166666666667
87496, 1.6583333333333, 0.625, 0.29166666666667
87497, 1.6583333333333, 0.6, 0.27083333333333
87498, 1.6375, 0.6, 0.29166666666667
87499, 1.6583333333333, 0.575, 0.29166666666667
87500, 1.6583333333333, 0.55, 0.27083333333333
87501, 1.6375, 0.55, 0.29166666666667
87502, 1.6583333333333, 0.525, 0.29166666666667
87503, 1.6583333333333, 0.5, 0.27083333333333
87504, 1.6375, 0.5, 0.29166666666667
87505, 1.6583333333333, 0.475, 0.29166666666667
87506, 1.6583333333333, 0.45, 0.27083333333333
87507, 1.6375, 0.45, 0.29166666666667
87508, 1.6583333333333, 0.425, 0.29166666666667
87509, 1.6583333333333, 0.4, 0.27083333333333
87510, 1.6375, 0.4, 0.29166666666667
87511, 1.6583333333333, 0.375, 0.29166666666667
87512, 1.6583333333333, 0.35, 0.27083333333333
87513, 1.6375, 0.35, 0.29166666666667
87514, 1.6583333333333, 0.325, 0.29166666666667
87515, 1.6583333333333, 0.3, 0.27083333333333
87516, 1.6375, 0.3, 0.29166666666667
87517, 1.6583333333333, 0.275, 0.29166666666667
87518, 1.6583333333333, 0.25, 0.27083333333333
87519, 1.6375, 0.25, 0.29166666666667
87520, 1.6583333333333, 0.225, 0.29166666666667
87521, 1.6583333333333, 0.2, 0.27083333333333
87522, 1.6375, 0.2, 0.29166666666667
87523, 1.6583333333333, 0.175, 0.29166666666667
87524, 1.7, 1.325, 0.29166666666667
87525, 1.7, 1.3, 0.27083333333333
87526, 1.6791666666667, 1.3, 0.29166666666667
87527, 1.7, 1.275, 0.29166666666667
87528, 1.7, 1.25, 0.27083333333333
87529, 1.6791666666667, 1.25, 0.29166666666667
87530, 1.7, 1.225, 0.29166666666667
87531, 1.7, 1.2, 0.27083333333333
87532, 1.6791666666667, 1.2, 0.29166666666667
87533, 1.7, 1.175, 0.29166666666667
87534, 1.7, 1.15, 0.27083333333333
87535, 1.6791666666667, 1.15, 0.29166666666667
87536, 1.7, 1.125, 0.29166666666667
87537, 1.7, 1.1, 0.27083333333333
87538, 1.6791666666667, 1.1, 0.29166666666667
87539, 1.7, 1.075, 0.29166666666667
87540, 1.7, 1.05, 0.27083333333333
87541, 1.6791666666667, 1.05, 0.29166666666667
87542, 1.7, 1.025, 0.29166666666667
87543, 1.7, 1, 0.27083333333333
87544, 1.6791666666667, 1, 0.29166666666667
87545, 1.7, 0.975, 0.29166666666667
87546, 1.7, 0.95, 0.27083333333333
87547, 1.6791666666667, 0.95, 0.29166666666667
87548, 1.7, 0.925, 0.29166666666667
87549, 1.7, 0.9, 0.27083333333333
87550, 1.6791666666667, 0.9, 0.29166666666667
87551, 1.7, 0.875, 0.29166666666667
87552, 1.7, 0.85, 0.27083333333333
87553, 1.6791666666667, 0.85, 0.29166666666667
87554, 1.7, 0.825, 0.29166666666667
87555, 1.7, 0.8, 0.27083333333333
87556, 1.6791666666667, 0.8, 0.29166666666667
87557, 1.7, 0.775, 0.29166666666667
87558, 1.7, 0.75, 0.27083333333333
87559, 1.6791666666667, 0.75, 0.29166666666667
87560, 1.7, 0.725, 0.29166666666667
87561, 1.7, 0.7, 0.27083333333333
87562, 1.6791666666667, 0.7, 0.29166666666667
87563, 1.7, 0.675, 0.29166666666667
87564, 1.7, 0.65, 0.27083333333333
87565, 1.6791666666667, 0.65, 0.29166666666667
87566, 1.7, 0.625, 0.29166666666667
87567, 1.7, 0.6, 0.27083333333333
87568, 1.6791666666667, 0.6, 0.29166666666667
87569, 1.7, 0.575, 0.29166666666667
87570, 1.7, 0.55, 0.27083333333333
87571, 1.6791666666667, 0.55, 0.29166666666667
87572, 1.7, 0.525, 0.29166666666667
87573, 1.7, 0.5, 0.27083333333333
87574, 1.6791666666667, 0.5, 0.29166666666667
87575, 1.7, 0.475, 0.29166666666667
87576, 1.7, 0.45, 0.27083333333333
87577, 1.6791666666667, 0.45, 0.29166666666667
87578, 1.7, 0.425, 0.29166666666667
87579, 1.7, 0.4, 0.27083333333333
87580, 1.6791666666667, 0.4, 0.29166666666667
87581, 1.7, 0.375, 0.29166666666667
87582, 1.7, 0.35, 0.27083333333333
87583, 1.6791666666667, 0.35, 0.29166666666667
87584, 1.7, 0.325, 0.29166666666667
87585, 1.7, 0.3, 0.27083333333333
87586, 1.6791666666667, 0.3, 0.29166666666667
87587, 1.7, 0.275, 0.29166666666667
87588, 1.7, 0.25, 0.27083333333333
87589, 1.6791666666667, 0.25, 0.29166666666667
87590, 1.7, 0.225, 0.29166666666667
87591, 1.7, 0.2, 0.27083333333333
87592, 1.6791666666667, 0.2, 0.29166666666667
87593, 1.7, 0.175, 0.29166666666667
87594, 1.7416666666667, 1.325, 0.29166666666667
87595, 1.7416666666667, 1.3, 0.27083333333333
87596, 1.7208333333333, 1.3, 0.29166666666667
87597, 1.7416666666667, 1.275, 0.29166666666667
87598, 1.7416666666667, 1.25, 0.27083333333333
87599, 1.7208333333333, 1.25, 0.29166666666667
87600, 1.7416666666667, 1.225, 0.29166666666667
87601, 1.7416666666667, 1.2, 0.27083333333333
87602, 1.7208333333333, 1.2, 0.29166666666667
87603, 1.7416666666667, 1.175, 0.29166666666667
87604, 1.7416666666667, 1.15, 0.27083333333333
87605, 1.7208333333333, 1.15, 0.29166666666667
87606, 1.7416666666667, 1.125, 0.29166666666667
87607, 1.7416666666667, 1.1, 0.27083333333333
87608, 1.7208333333333, 1.1, 0.29166666666667
87609, 1.7416666666667, 1.075, 0.29166666666667
87610, 1.7416666666667, 1.05, 0.27083333333333
87611, 1.7208333333333, 1.05, 0.29166666666667
87612, 1.7416666666667, 1.025, 0.29166666666667
87613, 1.7416666666667, 1, 0.27083333333333
87614, 1.7208333333333, 1, 0.29166666666667
87615, 1.7416666666667, 0.975, 0.29166666666667
87616, 1.7416666666667, 0.95, 0.27083333333333
87617, 1.7208333333333, 0.95, 0.29166666666667
87618, 1.7416666666667, 0.925, 0.29166666666667
87619, 1.7416666666667, 0.9, 0.27083333333333
87620, 1.7208333333333, 0.9, 0.29166666666667
87621, 1.7416666666667, 0.875, 0.29166666666667
87622, 1.7416666666667, 0.85, 0.27083333333333
87623, 1.7208333333333, 0.85, 0.29166666666667
87624, 1.7416666666667, 0.825, 0.29166666666667
87625, 1.7416666666667, 0.8, 0.27083333333333
87626, 1.7208333333333, 0.8, 0.29166666666667
87627, 1.7416666666667, 0.775, 0.29166666666667
87628, 1.7416666666667, 0.75, 0.27083333333333
87629, 1.7208333333333, 0.75, 0.29166666666667
87630, 1.7416666666667, 0.725, 0.29166666666667
87631, 1.7416666666667, 0.7, 0.27083333333333
87632, 1.7208333333333, 0.7, 0.29166666666667
87633, 1.7416666666667, 0.675, 0.29166666666667
87634, 1.7416666666667, 0.65, 0.27083333333333
87635, 1.7208333333333, 0.65, 0.29166666666667
87636, 1.7416666666667, 0.625, 0.29166666666667
87637, 1.7416666666667, 0.6, 0.27083333333333
87638, 1.7208333333333, 0.6, 0.29166666666667
87639, 1.7416666666667, 0.575, 0.29166666666667
87640, 1.7416666666667, 0.55, 0.27083333333333
87641, 1.7208333333333, 0.55, 0.29166666666667
87642, 1.7416666666667, 0.525, 0.29166666666667
87643, 1.7416666666667, 0.5, 0.27083333333333
87644, 1.7208333333333, 0.5, 0.29166666666667
87645, 1.7416666666667, 0.475, 0.29166666666667
87646, 1.7416666666667, 0.45, 0.27083333333333
87647, 1.7208333333333, 0.45, 0.29166666666667
87648, 1.7416666666667, 0.425, 0.29166666666667
87649, 1.7416666666667, 0.4, 0.27083333333333
87650, 1.7208333333333, 0.4, 0.29166666666667
87651, 1.7416666666667, 0.375, 0.29166666666667
87652, 1.7416666666667, 0.35, 0.27083333333333
87653, 1.7208333333333, 0.35, 0.29166666666667
87654, 1.7416666666667, 0.325, 0.29166666666667
87655, 1.7416666666667, 0.3, 0.27083333333333
87656, 1.7208333333333, 0.3, 0.29166666666667
87657, 1.7416666666667, 0.275, 0.29166666666667
87658, 1.7416666666667, 0.25, 0.27083333333333
87659, 1.7208333333333, 0.25, 0.29166666666667
87660, 1.7416666666667, 0.225, 0.29166666666667
87661, 1.7416666666667, 0.2, 0.27083333333333
87662, 1.7208333333333, 0.2, 0.29166666666667
87663, 1.7416666666667, 0.175, 0.29166666666667
87664, 1.7833333333333, 1.325, 0.29166666666667
87665, 1.7833333333333, 1.3, 0.27083333333333
87666, 1.7625, 1.3, 0.29166666666667
87667, 1.7833333333333, 1.275, 0.29166666666667
87668, 1.7833333333333, 1.25, 0.27083333333333
87669, 1.7625, 1.25, 0.29166666666667
87670, 1.7833333333333, 1.225, 0.29166666666667
87671, 1.7833333333333, 1.2, 0.27083333333333
87672, 1.7625, 1.2, 0.29166666666667
87673, 1.7833333333333, 1.175, 0.29166666666667
87674, 1.7833333333333, 1.15, 0.27083333333333
87675, 1.7625, 1.15, 0.29166666666667
87676, 1.7833333333333, 1.125, 0.29166666666667
87677, 1.7833333333333, 1.1, 0.27083333333333
87678, 1.7625, 1.1, 0.29166666666667
87679, 1.7833333333333, 1.075, 0.29166666666667
87680, 1.7833333333333, 1.05, 0.27083333333333
87681, 1.7625, 1.05, 0.29166666666667
87682, 1.7833333333333, 1.025, 0.29166666666667
87683, 1.7833333333333, 1, 0.27083333333333
87684, 1.7625, 1, 0.29166666666667
87685, 1.7833333333333, 0.975, 0.29166666666667
87686, 1.7833333333333, 0.95, 0.27083333333333
87687, 1.7625, 0.95, 0.29166666666667
87688, 1.7833333333333, 0.925, 0.29166666666667
87689, 1.7833333333333, 0.9, 0.27083333333333
87690, 1.7625, 0.9, 0.29166666666667
87691, 1.7833333333333, 0.875, 0.29166666666667
87692, 1.7833333333333, 0.85, 0.27083333333333
87693, 1.7625, 0.85, 0.29166666666667
87694, 1.7833333333333, 0.825, 0.29166666666667
87695, 1.7833333333333, 0.8, 0.27083333333333
87696, 1.7625, 0.8, 0.29166666666667
87697, 1.7833333333333, 0.775, 0.29166666666667
87698, 1.7833333333333, 0.75, 0.27083333333333
87699, 1.7625, 0.75, 0.29166666666667
87700, 1.7833333333333, 0.725, 0.29166666666667
87701, 1.7833333333333, 0.7, 0.27083333333333
87702, 1.7625, 0.7, 0.29166666666667
87703, 1.7833333333333, 0.675, 0.29166666666667
87704, 1.7833333333333, 0.65, 0.27083333333333
87705, 1.7625, 0.65, 0.29166666666667
87706, 1.7833333333333, 0.625, 0.29166666666667
87707, 1.7833333333333, 0.6, 0.27083333333333
87708, 1.7625, 0.6, 0.29166666666667
87709, 1.7833333333333, 0.575, 0.29166666666667
87710, 1.7833333333333, 0.55, 0.27083333333333
87711, 1.7625, 0.55, 0.29166666666667
87712, 1.7833333333333, 0.525, 0.29166666666667
87713, 1.7833333333333, 0.5, 0.27083333333333
87714, 1.7625, 0.5, 0.29166666666667
87715, 1.7833333333333, 0.475, 0.29166666666667
87716, 1.7833333333333, 0.45, 0.27083333333333
87717, 1.7625, 0.45, 0.29166666666667
87718, 1.7833333333333, 0.425, 0.29166666666667
87719, 1.7833333333333, 0.4, 0.27083333333333
87720, 1.7625, 0.4, 0.29166666666667
87721, 1.7833333333333, 0.375, 0.29166666666667
87722, 1.7833333333333, 0.35, 0.27083333333333
87723, 1.7625, 0.35, 0.29166666666667
87724, 1.7833333333333, 0.325, 0.29166666666667
87725, 1.7833333333333, 0.3, 0.27083333333333
87726, 1.7625, 0.3, 0.29166666666667
87727, 1.7833333333333, 0.275, 0.29166666666667
87728, 1.7833333333333, 0.25, 0.27083333333333
87729, 1.7625, 0.25, 0.29166666666667
87730, 1.7833333333333, 0.225, 0.29166666666667
87731, 1.7833333333333, 0.2, 0.27083333333333
87732, 1.7625, 0.2, 0.29166666666667
87733, 1.7833333333333, 0.175, 0.29166666666667
87734, 1.825, 1.325, 0.29166666666667
87735, 1.825, 1.3, 0.27083333333333
87736, 1.8041666666667, 1.3, 0.29166666666667
87737, 1.825, 1.275, 0.29166666666667
87738, 1.825, 1.25, 0.27083333333333
87739, 1.8041666666667, 1.25, 0.29166666666667
87740, 1.825, 1.225, 0.29166666666667
87741, 1.825, 1.2, 0.27083333333333
87742, 1.8041666666667, 1.2, 0.29166666666667
87743, 1.825, 1.175, 0.29166666666667
87744, 1.825, 1.15, 0.27083333333333
87745, 1.8041666666667, 1.15, 0.29166666666667
87746, 1.825, 1.125, 0.29166666666667
87747, 1.825, 1.1, 0.27083333333333
87748, 1.8041666666667, 1.1, 0.29166666666667
87749, 1.825, 1.075, 0.29166666666667
87750, 1.825, 1.05, 0.27083333333333
87751, 1.8041666666667, 1.05, 0.29166666666667
87752, 1.825, 1.025, 0.29166666666667
87753, 1.825, 1, 0.27083333333333
87754, 1.8041666666667, 1, 0.29166666666667
87755, 1.825, 0.975, 0.29166666666667
87756, 1.825, 0.95, 0.27083333333333
87757, 1.8041666666667, 0.95, 0.29166666666667
87758, 1.825, 0.925, 0.29166666666667
87759, 1.825, 0.9, 0.27083333333333
87760, 1.8041666666667, 0.9, 0.29166666666667
87761, 1.825, 0.875, 0.29166666666667
87762, 1.825, 0.85, 0.27083333333333
87763, 1.8041666666667, 0.85, 0.29166666666667
87764, 1.825, 0.825, 0.29166666666667
87765, 1.825, 0.8, 0.27083333333333
87766, 1.8041666666667, 0.8, 0.29166666666667
87767, 1.825, 0.775, 0.29166666666667
87768, 1.825, 0.75, 0.27083333333333
87769, 1.8041666666667, 0.75, 0.29166666666667
87770, 1.825, 0.725, 0.29166666666667
87771, 1.825, 0.7, 0.27083333333333
87772, 1.8041666666667, 0.7, 0.29166666666667
87773, 1.825, 0.675, 0.29166666666667
87774, 1.825, 0.65, 0.27083333333333
87775, 1.8041666666667, 0.65, 0.29166666666667
87776, 1.825, 0.625, 0.29166666666667
87777, 1.825, 0.6, 0.27083333333333
87778, 1.8041666666667, 0.6, 0.29166666666667
87779, 1.825, 0.575, 0.29166666666667
87780, 1.825, 0.55, 0.27083333333333
87781, 1.8041666666667, 0.55, 0.29166666666667
87782, 1.825, 0.525, 0.29166666666667
87783, 1.825, 0.5, 0.27083333333333
87784, 1.8041666666667, 0.5, 0.29166666666667
87785, 1.825, 0.475, 0.29166666666667
87786, 1.825, 0.45, 0.27083333333333
87787, 1.8041666666667, 0.45, 0.29166666666667
87788, 1.825, 0.425, 0.29166666666667
87789, 1.825, 0.4, 0.27083333333333
87790, 1.8041666666667, 0.4, 0.29166666666667
87791, 1.825, 0.375, 0.29166666666667
87792, 1.825, 0.35, 0.27083333333333
87793, 1.8041666666667, 0.35, 0.29166666666667
87794, 1.825, 0.325, 0.29166666666667
87795, 1.825, 0.3, 0.27083333333333
87796, 1.8041666666667, 0.3, 0.29166666666667
87797, 1.825, 0.275, 0.29166666666667
87798, 1.825, 0.25, 0.27083333333333
87799, 1.8041666666667, 0.25, 0.29166666666667
87800, 1.825, 0.225, 0.29166666666667
87801, 1.825, 0.2, 0.27083333333333
87802, 1.8041666666667, 0.2, 0.29166666666667
87803, 1.825, 0.175, 0.29166666666667
87804, 1.8666666666667, 1.325, 0.29166666666667
87805, 1.8666666666667, 1.3, 0.27083333333333
87806, 1.8458333333333, 1.3, 0.29166666666667
87807, 1.8666666666667, 1.275, 0.29166666666667
87808, 1.8666666666667, 1.25, 0.27083333333333
87809, 1.8458333333333, 1.25, 0.29166666666667
87810, 1.8666666666667, 1.225, 0.29166666666667
87811, 1.8666666666667, 1.2, 0.27083333333333
87812, 1.8458333333333, 1.2, 0.29166666666667
87813, 1.8666666666667, 1.175, 0.29166666666667
87814, 1.8666666666667, 1.15, 0.27083333333333
87815, 1.8458333333333, 1.15, 0.29166666666667
87816, 1.8666666666667, 1.125, 0.29166666666667
87817, 1.8666666666667, 1.1, 0.27083333333333
87818, 1.8458333333333, 1.1, 0.29166666666667
87819, 1.8666666666667, 1.075, 0.29166666666667
87820, 1.8666666666667, 1.05, 0.27083333333333
87821, 1.8458333333333, 1.05, 0.29166666666667
87822, 1.8666666666667, 1.025, 0.29166666666667
87823, 1.8666666666667, 1, 0.27083333333333
87824, 1.8458333333333, 1, 0.29166666666667
87825, 1.8666666666667, 0.975, 0.29166666666667
87826, 1.8666666666667, 0.95, 0.27083333333333
87827, 1.8458333333333, 0.95, 0.29166666666667
87828, 1.8666666666667, 0.925, 0.29166666666667
87829, 1.8666666666667, 0.9, 0.27083333333333
87830, 1.8458333333333, 0.9, 0.29166666666667
87831, 1.8666666666667, 0.875, 0.29166666666667
87832, 1.8666666666667, 0.85, 0.27083333333333
87833, 1.8458333333333, 0.85, 0.29166666666667
87834, 1.8666666666667, 0.825, 0.29166666666667
87835, 1.8666666666667, 0.8, 0.27083333333333
87836, 1.8458333333333, 0.8, 0.29166666666667
87837, 1.8666666666667, 0.775, 0.29166666666667
87838, 1.8666666666667, 0.75, 0.27083333333333
87839, 1.8458333333333, 0.75, 0.29166666666667
87840, 1.8666666666667, 0.725, 0.29166666666667
87841, 1.8666666666667, 0.7, 0.27083333333333
87842, 1.8458333333333, 0.7, 0.29166666666667
87843, 1.8666666666667, 0.675, 0.29166666666667
87844, 1.8666666666667, 0.65, 0.27083333333333
87845, 1.8458333333333, 0.65, 0.29166666666667
87846, 1.8666666666667, 0.625, 0.29166666666667
87847, 1.8666666666667, 0.6, 0.27083333333333
87848, 1.8458333333333, 0.6, 0.29166666666667
87849, 1.8666666666667, 0.575, 0.29166666666667
87850, 1.8666666666667, 0.55, 0.27083333333333
87851, 1.8458333333333, 0.55, 0.29166666666667
87852, 1.8666666666667, 0.525, 0.29166666666667
87853, 1.8666666666667, 0.5, 0.27083333333333
87854, 1.8458333333333, 0.5, 0.29166666666667
87855, 1.8666666666667, 0.475, 0.29166666666667
87856, 1.8666666666667, 0.45, 0.27083333333333
87857, 1.8458333333333, 0.45, 0.29166666666667
87858, 1.8666666666667, 0.425, 0.29166666666667
87859, 1.8666666666667, 0.4, 0.27083333333333
87860, 1.8458333333333, 0.4, 0.29166666666667
87861, 1.8666666666667, 0.375, 0.29166666666667
87862, 1.8666666666667, 0.35, 0.27083333333333
87863, 1.8458333333333, 0.35, 0.29166666666667
87864, 1.8666666666667, 0.325, 0.29166666666667
87865, 1.8666666666667, 0.3, 0.27083333333333
87866, 1.8458333333333, 0.3, 0.29166666666667
87867, 1.8666666666667, 0.275, 0.29166666666667
87868, 1.8666666666667, 0.25, 0.27083333333333
87869, 1.8458333333333, 0.25, 0.29166666666667
87870, 1.8666666666667, 0.225, 0.29166666666667
87871, 1.8666666666667, 0.2, 0.27083333333333
87872, 1.8458333333333, 0.2, 0.29166666666667
87873, 1.8666666666667, 0.175, 0.29166666666667
87874, 1.9083333333333, 1.325, 0.29166666666667
87875, 1.9083333333333, 1.3, 0.27083333333333
87876, 1.8875, 1.3, 0.29166666666667
87877, 1.9083333333333, 1.275, 0.29166666666667
87878, 1.9083333333333, 1.25, 0.27083333333333
87879, 1.8875, 1.25, 0.29166666666667
87880, 1.9083333333333, 1.225, 0.29166666666667
87881, 1.9083333333333, 1.2, 0.27083333333333
87882, 1.8875, 1.2, 0.29166666666667
87883, 1.9083333333333, 1.175, 0.29166666666667
87884, 1.9083333333333, 1.15, 0.27083333333333
87885, 1.8875, 1.15, 0.29166666666667
87886, 1.9083333333333, 1.125, 0.29166666666667
87887, 1.9083333333333, 1.1, 0.27083333333333
87888, 1.8875, 1.1, 0.29166666666667
87889, 1.9083333333333, 1.075, 0.29166666666667
87890, 1.9083333333333, 1.05, 0.27083333333333
87891, 1.8875, 1.05, 0.29166666666667
87892, 1.9083333333333, 1.025, 0.29166666666667
87893, 1.9083333333333, 1, 0.27083333333333
87894, 1.8875, 1, 0.29166666666667
87895, 1.9083333333333, 0.975, 0.29166666666667
87896, 1.9083333333333, 0.95, 0.27083333333333
87897, 1.8875, 0.95, 0.29166666666667
87898, 1.9083333333333, 0.925, 0.29166666666667
87899, 1.9083333333333, 0.9, 0.27083333333333
87900, 1.8875, 0.9, 0.29166666666667
87901, 1.9083333333333, 0.875, 0.29166666666667
87902, 1.9083333333333, 0.85, 0.27083333333333
87903, 1.8875, 0.85, 0.29166666666667
87904, 1.9083333333333, 0.825, 0.29166666666667
87905, 1.9083333333333, 0.8, 0.27083333333333
87906, 1.8875, 0.8, 0.29166666666667
87907, 1.9083333333333, 0.775, 0.29166666666667
87908, 1.9083333333333, 0.75, 0.27083333333333
87909, 1.8875, 0.75, 0.29166666666667
87910, 1.9083333333333, 0.725, 0.29166666666667
87911, 1.9083333333333, 0.7, 0.27083333333333
87912, 1.8875, 0.7, 0.29166666666667
87913, 1.9083333333333, 0.675, 0.29166666666667
87914, 1.9083333333333, 0.65, 0.27083333333333
87915, 1.8875, 0.65, 0.29166666666667
87916, 1.9083333333333, 0.625, 0.29166666666667
87917, 1.9083333333333, 0.6, 0.27083333333333
87918, 1.8875, 0.6, 0.29166666666667
87919, 1.9083333333333, 0.575, 0.29166666666667
87920, 1.9083333333333, 0.55, 0.27083333333333
87921, 1.8875, 0.55, 0.29166666666667
87922, 1.9083333333333, 0.525, 0.29166666666667
87923, 1.9083333333333, 0.5, 0.27083333333333
87924, 1.8875, 0.5, 0.29166666666667
87925, 1.9083333333333, 0.475, 0.29166666666667
87926, 1.9083333333333, 0.45, 0.27083333333333
87927, 1.8875, 0.45, 0.29166666666667
87928, 1.9083333333333, 0.425, 0.29166666666667
87929, 1.9083333333333, 0.4, 0.27083333333333
87930, 1.8875, 0.4, 0.29166666666667
87931, 1.9083333333333, 0.375, 0.29166666666667
87932, 1.9083333333333, 0.35, 0.27083333333333
87933, 1.8875, 0.35, 0.29166666666667
87934, 1.9083333333333, 0.325, 0.29166666666667
87935, 1.9083333333333, 0.3, 0.27083333333333
87936, 1.8875, 0.3, 0.29166666666667
87937, 1.9083333333333, 0.275, 0.29166666666667
87938, 1.9083333333333, 0.25, 0.27083333333333
87939, 1.8875, 0.25, 0.29166666666667
87940, 1.9083333333333, 0.225, 0.29166666666667
87941, 1.9083333333333, 0.2, 0.27083333333333
87942, 1.8875, 0.2, 0.29166666666667
87943, 1.9083333333333, 0.175, 0.29166666666667
87944, 1.95, 1.325, 0.29166666666667
87945, 1.95, 1.3, 0.27083333333333
87946, 1.9291666666667, 1.3, 0.29166666666667
87947, 1.95, 1.275, 0.29166666666667
87948, 1.95, 1.25, 0.27083333333333
87949, 1.9291666666667, 1.25, 0.29166666666667
87950, 1.95, 1.225, 0.29166666666667
87951, 1.95, 1.2, 0.27083333333333
87952, 1.9291666666667, 1.2, 0.29166666666667
87953, 1.95, 1.175, 0.29166666666667
87954, 1.95, 1.15, 0.27083333333333
87955, 1.9291666666667, 1.15, 0.29166666666667
87956, 1.95, 1.125, 0.29166666666667
87957, 1.95, 1.1, 0.27083333333333
87958, 1.9291666666667, 1.1, 0.29166666666667
87959, 1.95, 1.075, 0.29166666666667
87960, 1.95, 1.05, 0.27083333333333
87961, 1.9291666666667, 1.05, 0.29166666666667
87962, 1.95, 1.025, 0.29166666666667
87963, 1.95, 1, 0.27083333333333
87964, 1.9291666666667, 1, 0.29166666666667
87965, 1.95, 0.975, 0.29166666666667
87966, 1.95, 0.95, 0.27083333333333
87967, 1.9291666666667, 0.95, 0.29166666666667
87968, 1.95, 0.925, 0.29166666666667
87969, 1.95, 0.9, 0.27083333333333
87970, 1.9291666666667, 0.9, 0.29166666666667
87971, 1.95, 0.875, 0.29166666666667
87972, 1.95, 0.85, 0.27083333333333
87973, 1.9291666666667, 0.85, 0.29166666666667
87974, 1.95, 0.825, 0.29166666666667
87975, 1.95, 0.8, 0.27083333333333
87976, 1.9291666666667, 0.8, 0.29166666666667
87977, 1.95, 0.775, 0.29166666666667
87978, 1.95, 0.75, 0.27083333333333
87979, 1.9291666666667, 0.75, 0.29166666666667
87980, 1.95, 0.725, 0.29166666666667
87981, 1.95, 0.7, 0.27083333333333
87982, 1.9291666666667, 0.7, 0.29166666666667
87983, 1.95, 0.675, 0.29166666666667
87984, 1.95, 0.65, 0.27083333333333
87985, 1.9291666666667, 0.65, 0.29166666666667
87986, 1.95, 0.625, 0.29166666666667
87987, 1.95, 0.6, 0.27083333333333
87988, 1.9291666666667, 0.6, 0.29166666666667
87989, 1.95, 0.575, 0.29166666666667
87990, 1.95, 0.55, 0.27083333333333
87991, 1.9291666666667, 0.55, 0.29166666666667
87992, 1.95, 0.525, 0.29166666666667
87993, 1.95, 0.5, 0.27083333333333
87994, 1.9291666666667, 0.5, 0.29166666666667
87995, 1.95, 0.475, 0.29166666666667
87996, 1.95, 0.45, 0.27083333333333
87997, 1.9291666666667, 0.45, 0.29166666666667
87998, 1.95, 0.425, 0.29166666666667
87999, 1.95, 0.4, 0.27083333333333
88000, 1.9291666666667, 0.4, 0.29166666666667
88001, 1.95, 0.375, 0.29166666666667
88002, 1.95, 0.35, 0.27083333333333
88003, 1.9291666666667, 0.35, 0.29166666666667
88004, 1.95, 0.325, 0.29166666666667
88005, 1.95, 0.3, 0.27083333333333
88006, 1.9291666666667, 0.3, 0.29166666666667
88007, 1.95, 0.275, 0.29166666666667
88008, 1.95, 0.25, 0.27083333333333
88009, 1.9291666666667, 0.25, 0.29166666666667
88010, 1.95, 0.225, 0.29166666666667
88011, 1.95, 0.2, 0.27083333333333
88012, 1.9291666666667, 0.2, 0.29166666666667
88013, 1.95, 0.175, 0.29166666666667
88014, 1.9916666666667, 1.325, 0.29166666666667
88015, 1.9916666666667, 1.3, 0.27083333333333
88016, 1.9708333333333, 1.3, 0.29166666666667
88017, 1.9916666666667, 1.275, 0.29166666666667
88018, 1.9916666666667, 1.25, 0.27083333333333
88019, 1.9708333333333, 1.25, 0.29166666666667
88020, 1.9916666666667, 1.225, 0.29166666666667
88021, 1.9916666666667, 1.2, 0.27083333333333
88022, 1.9708333333333, 1.2, 0.29166666666667
88023, 1.9916666666667, 1.175, 0.29166666666667
88024, 1.9916666666667, 1.15, 0.27083333333333
88025, 1.9708333333333, 1.15, 0.29166666666667
88026, 1.9916666666667, 1.125, 0.29166666666667
88027, 1.9916666666667, 1.1, 0.27083333333333
88028, 1.9708333333333, 1.1, 0.29166666666667
88029, 1.9916666666667, 1.075, 0.29166666666667
88030, 1.9916666666667, 1.05, 0.27083333333333
88031, 1.9708333333333, 1.05, 0.29166666666667
88032, 1.9916666666667, 1.025, 0.29166666666667
88033, 1.9916666666667, 1, 0.27083333333333
88034, 1.9708333333333, 1, 0.29166666666667
88035, 1.9916666666667, 0.975, 0.29166666666667
88036, 1.9916666666667, 0.95, 0.27083333333333
88037, 1.9708333333333, 0.95, 0.29166666666667
88038, 1.9916666666667, 0.925, 0.29166666666667
88039, 1.9916666666667, 0.9, 0.27083333333333
88040, 1.9708333333333, 0.9, 0.29166666666667
88041, 1.9916666666667, 0.875, 0.29166666666667
88042, 1.9916666666667, 0.85, 0.27083333333333
88043, 1.9708333333333, 0.85, 0.29166666666667
88044, 1.9916666666667, 0.825, 0.29166666666667
88045, 1.9916666666667, 0.8, 0.27083333333333
88046, 1.9708333333333, 0.8, 0.29166666666667
88047, 1.9916666666667, 0.775, 0.29166666666667
88048, 1.9916666666667, 0.75, 0.27083333333333
88049, 1.9708333333333, 0.75, 0.29166666666667
88050, 1.9916666666667, 0.725, 0.29166666666667
88051, 1.9916666666667, 0.7, 0.27083333333333
88052, 1.9708333333333, 0.7, 0.29166666666667
88053, 1.9916666666667, 0.675, 0.29166666666667
88054, 1.9916666666667, 0.65, 0.27083333333333
88055, 1.9708333333333, 0.65, 0.29166666666667
88056, 1.9916666666667, 0.625, 0.29166666666667
88057, 1.9916666666667, 0.6, 0.27083333333333
88058, 1.9708333333333, 0.6, 0.29166666666667
88059, 1.9916666666667, 0.575, 0.29166666666667
88060, 1.9916666666667, 0.55, 0.27083333333333
88061, 1.9708333333333, 0.55, 0.29166666666667
88062, 1.9916666666667, 0.525, 0.29166666666667
88063, 1.9916666666667, 0.5, 0.27083333333333
88064, 1.9708333333333, 0.5, 0.29166666666667
88065, 1.9916666666667, 0.475, 0.29166666666667
88066, 1.9916666666667, 0.45, 0.27083333333333
88067, 1.9708333333333, 0.45, 0.29166666666667
88068, 1.9916666666667, 0.425, 0.29166666666667
88069, 1.9916666666667, 0.4, 0.27083333333333
88070, 1.9708333333333, 0.4, 0.29166666666667
88071, 1.9916666666667, 0.375, 0.29166666666667
88072, 1.9916666666667, 0.35, 0.27083333333333
88073, 1.9708333333333, 0.35, 0.29166666666667
88074, 1.9916666666667, 0.325, 0.29166666666667
88075, 1.9916666666667, 0.3, 0.27083333333333
88076, 1.9708333333333, 0.3, 0.29166666666667
88077, 1.9916666666667, 0.275, 0.29166666666667
88078, 1.9916666666667, 0.25, 0.27083333333333
88079, 1.9708333333333, 0.25, 0.29166666666667
88080, 1.9916666666667, 0.225, 0.29166666666667
88081, 1.9916666666667, 0.2, 0.27083333333333
88082, 1.9708333333333, 0.2, 0.29166666666667
88083, 1.9916666666667, 0.175, 0.29166666666667
88084, 2.0333333333333, 1.325, 0.29166666666667
88085, 2.0333333333333, 1.3, 0.27083333333333
88086, 2.0125, 1.3, 0.29166666666667
88087, 2.0333333333333, 1.275, 0.29166666666667
88088, 2.0333333333333, 1.25, 0.27083333333333
88089, 2.0125, 1.25, 0.29166666666667
88090, 2.0333333333333, 1.225, 0.29166666666667
88091, 2.0333333333333, 1.2, 0.27083333333333
88092, 2.0125, 1.2, 0.29166666666667
88093, 2.0333333333333, 1.175, 0.29166666666667
88094, 2.0333333333333, 1.15, 0.27083333333333
88095, 2.0125, 1.15, 0.29166666666667
88096, 2.0333333333333, 1.125, 0.29166666666667
88097, 2.0333333333333, 1.1, 0.27083333333333
88098, 2.0125, 1.1, 0.29166666666667
88099, 2.0333333333333, 1.075, 0.29166666666667
88100, 2.0333333333333, 1.05, 0.27083333333333
88101, 2.0125, 1.05, 0.29166666666667
88102, 2.0333333333333, 1.025, 0.29166666666667
88103, 2.0333333333333, 1, 0.27083333333333
88104, 2.0125, 1, 0.29166666666667
88105, 2.0333333333333, 0.975, 0.29166666666667
88106, 2.0333333333333, 0.95, 0.27083333333333
88107, 2.0125, 0.95, 0.29166666666667
88108, 2.0333333333333, 0.925, 0.29166666666667
88109, 2.0333333333333, 0.9, 0.27083333333333
88110, 2.0125, 0.9, 0.29166666666667
88111, 2.0333333333333, 0.875, 0.29166666666667
88112, 2.0333333333333, 0.85, 0.27083333333333
88113, 2.0125, 0.85, 0.29166666666667
88114, 2.0333333333333, 0.825, 0.29166666666667
88115, 2.0333333333333, 0.8, 0.27083333333333
88116, 2.0125, 0.8, 0.29166666666667
88117, 2.0333333333333, 0.775, 0.29166666666667
88118, 2.0333333333333, 0.75, 0.27083333333333
88119, 2.0125, 0.75, 0.29166666666667
88120, 2.0333333333333, 0.725, 0.29166666666667
88121, 2.0333333333333, 0.7, 0.27083333333333
88122, 2.0125, 0.7, 0.29166666666667
88123, 2.0333333333333, 0.675, 0.29166666666667
88124, 2.0333333333333, 0.65, 0.27083333333333
88125, 2.0125, 0.65, 0.29166666666667
88126, 2.0333333333333, 0.625, 0.29166666666667
88127, 2.0333333333333, 0.6, 0.27083333333333
88128, 2.0125, 0.6, 0.29166666666667
88129, 2.0333333333333, 0.575, 0.29166666666667
88130, 2.0333333333333, 0.55, 0.27083333333333
88131, 2.0125, 0.55, 0.29166666666667
88132, 2.0333333333333, 0.525, 0.29166666666667
88133, 2.0333333333333, 0.5, 0.27083333333333
88134, 2.0125, 0.5, 0.29166666666667
88135, 2.0333333333333, 0.475, 0.29166666666667
88136, 2.0333333333333, 0.45, 0.27083333333333
88137, 2.0125, 0.45, 0.29166666666667
88138, 2.0333333333333, 0.425, 0.29166666666667
88139, 2.0333333333333, 0.4, 0.27083333333333
88140, 2.0125, 0.4, 0.29166666666667
88141, 2.0333333333333, 0.375, 0.29166666666667
88142, 2.0333333333333, 0.35, 0.27083333333333
88143, 2.0125, 0.35, 0.29166666666667
88144, 2.0333333333333, 0.325, 0.29166666666667
88145, 2.0333333333333, 0.3, 0.27083333333333
88146, 2.0125, 0.3, 0.29166666666667
88147, 2.0333333333333, 0.275, 0.29166666666667
88148, 2.0333333333333, 0.25, 0.27083333333333
88149, 2.0125, 0.25, 0.29166666666667
88150, 2.0333333333333, 0.225, 0.29166666666667
88151, 2.0333333333333, 0.2, 0.27083333333333
88152, 2.0125, 0.2, 0.29166666666667
88153, 2.0333333333333, 0.175, 0.29166666666667
88154, 2.075, 1.325, 0.29166666666667
88155, 2.075, 1.3, 0.27083333333333
88156, 2.0541666666667, 1.3, 0.29166666666667
88157, 2.075, 1.275, 0.29166666666667
88158, 2.075, 1.25, 0.27083333333333
88159, 2.0541666666667, 1.25, 0.29166666666667
88160, 2.075, 1.225, 0.29166666666667
88161, 2.075, 1.2, 0.27083333333333
88162, 2.0541666666667, 1.2, 0.29166666666667
88163, 2.075, 1.175, 0.29166666666667
88164, 2.075, 1.15, 0.27083333333333
88165, 2.0541666666667, 1.15, 0.29166666666667
88166, 2.075, 1.125, 0.29166666666667
88167, 2.075, 1.1, 0.27083333333333
88168, 2.0541666666667, 1.1, 0.29166666666667
88169, 2.075, 1.075, 0.29166666666667
88170, 2.075, 1.05, 0.27083333333333
88171, 2.0541666666667, 1.05, 0.29166666666667
88172, 2.075, 1.025, 0.29166666666667
88173, 2.075, 1, 0.27083333333333
88174, 2.0541666666667, 1, 0.29166666666667
88175, 2.075, 0.975, 0.29166666666667
88176, 2.075, 0.95, 0.27083333333333
88177, 2.0541666666667, 0.95, 0.29166666666667
88178, 2.075, 0.925, 0.29166666666667
88179, 2.075, 0.9, 0.27083333333333
88180, 2.0541666666667, 0.9, 0.29166666666667
88181, 2.075, 0.875, 0.29166666666667
88182, 2.075, 0.85, 0.27083333333333
88183, 2.0541666666667, 0.85, 0.29166666666667
88184, 2.075, 0.825, 0.29166666666667
88185, 2.075, 0.8, 0.27083333333333
88186, 2.0541666666667, 0.8, 0.29166666666667
88187, 2.075, 0.775, 0.29166666666667
88188, 2.075, 0.75, 0.27083333333333
88189, 2.0541666666667, 0.75, 0.29166666666667
88190, 2.075, 0.725, 0.29166666666667
88191, 2.075, 0.7, 0.27083333333333
88192, 2.0541666666667, 0.7, 0.29166666666667
88193, 2.075, 0.675, 0.29166666666667
88194, 2.075, 0.65, 0.27083333333333
88195, 2.0541666666667, 0.65, 0.29166666666667
88196, 2.075, 0.625, 0.29166666666667
88197, 2.075, 0.6, 0.27083333333333
88198, 2.0541666666667, 0.6, 0.29166666666667
88199, 2.075, 0.575, 0.29166666666667
88200, 2.075, 0.55, 0.27083333333333
88201, 2.0541666666667, 0.55, 0.29166666666667
88202, 2.075, 0.525, 0.29166666666667
88203, 2.075, 0.5, 0.27083333333333
88204, 2.0541666666667, 0.5, 0.29166666666667
88205, 2.075, 0.475, 0.29166666666667
88206, 2.075, 0.45, 0.27083333333333
88207, 2.0541666666667, 0.45, 0.29166666666667
88208, 2.075, 0.425, 0.29166666666667
88209, 2.075, 0.4, 0.27083333333333
88210, 2.0541666666667, 0.4, 0.29166666666667
88211, 2.075, 0.375, 0.29166666666667
88212, 2.075, 0.35, 0.27083333333333
88213, 2.0541666666667, 0.35, 0.29166666666667
88214, 2.075, 0.325, 0.29166666666667
88215, 2.075, 0.3, 0.27083333333333
88216, 2.0541666666667, 0.3, 0.29166666666667
88217, 2.075, 0.275, 0.29166666666667
88218, 2.075, 0.25, 0.27083333333333
88219, 2.0541666666667, 0.25, 0.29166666666667
88220, 2.075, 0.225, 0.29166666666667
88221, 2.075, 0.2, 0.27083333333333
88222, 2.0541666666667, 0.2, 0.29166666666667
88223, 2.075, 0.175, 0.29166666666667
88224, 2.1166666666667, 1.325, 0.29166666666667
88225, 2.1166666666667, 1.3, 0.27083333333333
88226, 2.0958333333333, 1.3, 0.29166666666667
88227, 2.1166666666667, 1.275, 0.29166666666667
88228, 2.1166666666667, 1.25, 0.27083333333333
88229, 2.0958333333333, 1.25, 0.29166666666667
88230, 2.1166666666667, 1.225, 0.29166666666667
88231, 2.1166666666667, 1.2, 0.27083333333333
88232, 2.0958333333333, 1.2, 0.29166666666667
88233, 2.1166666666667, 1.175, 0.29166666666667
88234, 2.1166666666667, 1.15, 0.27083333333333
88235, 2.0958333333333, 1.15, 0.29166666666667
88236, 2.1166666666667, 1.125, 0.29166666666667
88237, 2.1166666666667, 1.1, 0.27083333333333
88238, 2.0958333333333, 1.1, 0.29166666666667
88239, 2.1166666666667, 1.075, 0.29166666666667
88240, 2.1166666666667, 1.05, 0.27083333333333
88241, 2.0958333333333, 1.05, 0.29166666666667
88242, 2.1166666666667, 1.025, 0.29166666666667
88243, 2.1166666666667, 1, 0.27083333333333
88244, 2.0958333333333, 1, 0.29166666666667
88245, 2.1166666666667, 0.975, 0.29166666666667
88246, 2.1166666666667, 0.95, 0.27083333333333
88247, 2.0958333333333, 0.95, 0.29166666666667
88248, 2.1166666666667, 0.925, 0.29166666666667
88249, 2.1166666666667, 0.9, 0.27083333333333
88250, 2.0958333333333, 0.9, 0.29166666666667
88251, 2.1166666666667, 0.875, 0.29166666666667
88252, 2.1166666666667, 0.85, 0.27083333333333
88253, 2.0958333333333, 0.85, 0.29166666666667
88254, 2.1166666666667, 0.825, 0.29166666666667
88255, 2.1166666666667, 0.8, 0.27083333333333
88256, 2.0958333333333, 0.8, 0.29166666666667
88257, 2.1166666666667, 0.775, 0.29166666666667
88258, 2.1166666666667, 0.75, 0.27083333333333
88259, 2.0958333333333, 0.75, 0.29166666666667
88260, 2.1166666666667, 0.725, 0.29166666666667
88261, 2.1166666666667, 0.7, 0.27083333333333
88262, 2.0958333333333, 0.7, 0.29166666666667
88263, 2.1166666666667, 0.675, 0.29166666666667
88264, 2.1166666666667, 0.65, 0.27083333333333
88265, 2.0958333333333, 0.65, 0.29166666666667
88266, 2.1166666666667, 0.625, 0.29166666666667
88267, 2.1166666666667, 0.6, 0.27083333333333
88268, 2.0958333333333, 0.6, 0.29166666666667
88269, 2.1166666666667, 0.575, 0.29166666666667
88270, 2.1166666666667, 0.55, 0.27083333333333
88271, 2.0958333333333, 0.55, 0.29166666666667
88272, 2.1166666666667, 0.525, 0.29166666666667
88273, 2.1166666666667, 0.5, 0.27083333333333
88274, 2.0958333333333, 0.5, 0.29166666666667
88275, 2.1166666666667, 0.475, 0.29166666666667
88276, 2.1166666666667, 0.45, 0.27083333333333
88277, 2.0958333333333, 0.45, 0.29166666666667
88278, 2.1166666666667, 0.425, 0.29166666666667
88279, 2.1166666666667, 0.4, 0.27083333333333
88280, 2.0958333333333, 0.4, 0.29166666666667
88281, 2.1166666666667, 0.375, 0.29166666666667
88282, 2.1166666666667, 0.35, 0.27083333333333
88283, 2.0958333333333, 0.35, 0.29166666666667
88284, 2.1166666666667, 0.325, 0.29166666666667
88285, 2.1166666666667, 0.3, 0.27083333333333
88286, 2.0958333333333, 0.3, 0.29166666666667
88287, 2.1166666666667, 0.275, 0.29166666666667
88288, 2.1166666666667, 0.25, 0.27083333333333
88289, 2.0958333333333, 0.25, 0.29166666666667
88290, 2.1166666666667, 0.225, 0.29166666666667
88291, 2.1166666666667, 0.2, 0.27083333333333
88292, 2.0958333333333, 0.2, 0.29166666666667
88293, 2.1166666666667, 0.175, 0.29166666666667
88294, 2.1583333333333, 1.325, 0.29166666666667
88295, 2.1583333333333, 1.3, 0.27083333333333
88296, 2.1375, 1.3, 0.29166666666667
88297, 2.1583333333333, 1.275, 0.29166666666667
88298, 2.1583333333333, 1.25, 0.27083333333333
88299, 2.1375, 1.25, 0.29166666666667
88300, 2.1583333333333, 1.225, 0.29166666666667
88301, 2.1583333333333, 1.2, 0.27083333333333
88302, 2.1375, 1.2, 0.29166666666667
88303, 2.1583333333333, 1.175, 0.29166666666667
88304, 2.1583333333333, 1.15, 0.27083333333333
88305, 2.1375, 1.15, 0.29166666666667
88306, 2.1583333333333, 1.125, 0.29166666666667
88307, 2.1583333333333, 1.1, 0.27083333333333
88308, 2.1375, 1.1, 0.29166666666667
88309, 2.1583333333333, 1.075, 0.29166666666667
88310, 2.1583333333333, 1.05, 0.27083333333333
88311, 2.1375, 1.05, 0.29166666666667
88312, 2.1583333333333, 1.025, 0.29166666666667
88313, 2.1583333333333, 1, 0.27083333333333
88314, 2.1375, 1, 0.29166666666667
88315, 2.1583333333333, 0.975, 0.29166666666667
88316, 2.1583333333333, 0.95, 0.27083333333333
88317, 2.1375, 0.95, 0.29166666666667
88318, 2.1583333333333, 0.925, 0.29166666666667
88319, 2.1583333333333, 0.9, 0.27083333333333
88320, 2.1375, 0.9, 0.29166666666667
88321, 2.1583333333333, 0.875, 0.29166666666667
88322, 2.1583333333333, 0.85, 0.27083333333333
88323, 2.1375, 0.85, 0.29166666666667
88324, 2.1583333333333, 0.825, 0.29166666666667
88325, 2.1583333333333, 0.8, 0.27083333333333
88326, 2.1375, 0.8, 0.29166666666667
88327, 2.1583333333333, 0.775, 0.29166666666667
88328, 2.1583333333333, 0.75, 0.27083333333333
88329, 2.1375, 0.75, 0.29166666666667
88330, 2.1583333333333, 0.725, 0.29166666666667
88331, 2.1583333333333, 0.7, 0.27083333333333
88332, 2.1375, 0.7, 0.29166666666667
88333, 2.1583333333333, 0.675, 0.29166666666667
88334, 2.1583333333333, 0.65, 0.27083333333333
88335, 2.1375, 0.65, 0.29166666666667
88336, 2.1583333333333, 0.625, 0.29166666666667
88337, 2.1583333333333, 0.6, 0.27083333333333
88338, 2.1375, 0.6, 0.29166666666667
88339, 2.1583333333333, 0.575, 0.29166666666667
88340, 2.1583333333333, 0.55, 0.27083333333333
88341, 2.1375, 0.55, 0.29166666666667
88342, 2.1583333333333, 0.525, 0.29166666666667
88343, 2.1583333333333, 0.5, 0.27083333333333
88344, 2.1375, 0.5, 0.29166666666667
88345, 2.1583333333333, 0.475, 0.29166666666667
88346, 2.1583333333333, 0.45, 0.27083333333333
88347, 2.1375, 0.45, 0.29166666666667
88348, 2.1583333333333, 0.425, 0.29166666666667
88349, 2.1583333333333, 0.4, 0.27083333333333
88350, 2.1375, 0.4, 0.29166666666667
88351, 2.1583333333333, 0.375, 0.29166666666667
88352, 2.1583333333333, 0.35, 0.27083333333333
88353, 2.1375, 0.35, 0.29166666666667
88354, 2.1583333333333, 0.325, 0.29166666666667
88355, 2.1583333333333, 0.3, 0.27083333333333
88356, 2.1375, 0.3, 0.29166666666667
88357, 2.1583333333333, 0.275, 0.29166666666667
88358, 2.1583333333333, 0.25, 0.27083333333333
88359, 2.1375, 0.25, 0.29166666666667
88360, 2.1583333333333, 0.225, 0.29166666666667
88361, 2.1583333333333, 0.2, 0.27083333333333
88362, 2.1375, 0.2, 0.29166666666667
88363, 2.1583333333333, 0.175, 0.29166666666667
88364, 2.1791666666667, 1.3, 0.29166666666667
88365, 2.1791666666667, 1.25, 0.29166666666667
88366, 2.1791666666667, 1.2, 0.29166666666667
88367, 2.1791666666667, 1.15, 0.29166666666667
88368, 2.1791666666667, 1.1, 0.29166666666667
88369, 2.1791666666667, 1.05, 0.29166666666667
88370, 2.1791666666667, 1, 0.29166666666667
88371, 2.1791666666667, 0.95, 0.29166666666667
88372, 2.1791666666667, 0.9, 0.29166666666667
88373, 2.1791666666667, 0.85, 0.29166666666667
88374, 2.1791666666667, 0.8, 0.29166666666667
88375, 2.1791666666667, 0.75, 0.29166666666667
88376, 2.1791666666667, 0.7, 0.29166666666667
88377, 2.1791666666667, 0.65, 0.29166666666667
88378, 2.1791666666667, 0.6, 0.29166666666667
88379, 2.1791666666667, 0.55, 0.29166666666667
88380, 2.1791666666667, 0.5, 0.29166666666667
88381, 2.1791666666667, 0.45, 0.29166666666667
88382, 2.1791666666667, 0.4, 0.29166666666667
88383, 2.1791666666667, 0.35, 0.29166666666667
88384, 2.1791666666667, 0.3, 0.29166666666667
88385, 2.1791666666667, 0.25, 0.29166666666667
88386, 2.1791666666667, 0.2, 0.29166666666667
88387, 1.2416666666667, 1.325, 0.33333333333333
88388, 1.2416666666667, 1.3, 0.3125
88389, 1.2208333333333, 1.3, 0.33333333333333
88390, 1.2416666666667, 1.275, 0.33333333333333
88391, 1.2416666666667, 1.25, 0.3125
88392, 1.2208333333333, 1.25, 0.33333333333333
88393, 1.2416666666667, 1.225, 0.33333333333333
88394, 1.2416666666667, 1.2, 0.3125
88395, 1.2208333333333, 1.2, 0.33333333333333
88396, 1.2416666666667, 1.175, 0.33333333333333
88397, 1.2416666666667, 1.15, 0.3125
88398, 1.2208333333333, 1.15, 0.33333333333333
88399, 1.2416666666667, 1.125, 0.33333333333333
88400, 1.2416666666667, 1.1, 0.3125
88401, 1.2208333333333, 1.1, 0.33333333333333
88402, 1.2416666666667, 1.075, 0.33333333333333
88403, 1.2416666666667, 1.05, 0.3125
88404, 1.2208333333333, 1.05, 0.33333333333333
88405, 1.2416666666667, 1.025, 0.33333333333333
88406, 1.2416666666667, 1, 0.3125
88407, 1.2208333333333, 1, 0.33333333333333
88408, 1.2416666666667, 0.975, 0.33333333333333
88409, 1.2416666666667, 0.95, 0.3125
88410, 1.2208333333333, 0.95, 0.33333333333333
88411, 1.2416666666667, 0.925, 0.33333333333333
88412, 1.2416666666667, 0.9, 0.3125
88413, 1.2208333333333, 0.9, 0.33333333333333
88414, 1.2416666666667, 0.875, 0.33333333333333
88415, 1.2416666666667, 0.85, 0.3125
88416, 1.2208333333333, 0.85, 0.33333333333333
88417, 1.2416666666667, 0.825, 0.33333333333333
88418, 1.2416666666667, 0.8, 0.3125
88419, 1.2208333333333, 0.8, 0.33333333333333
88420, 1.2416666666667, 0.775, 0.33333333333333
88421, 1.2416666666667, 0.75, 0.3125
88422, 1.2208333333333, 0.75, 0.33333333333333
88423, 1.2416666666667, 0.725, 0.33333333333333
88424, 1.2416666666667, 0.7, 0.3125
88425, 1.2208333333333, 0.7, 0.33333333333333
88426, 1.2416666666667, 0.675, 0.33333333333333
88427, 1.2416666666667, 0.65, 0.3125
88428, 1.2208333333333, 0.65, 0.33333333333333
88429, 1.2416666666667, 0.625, 0.33333333333333
88430, 1.2416666666667, 0.6, 0.3125
88431, 1.2208333333333, 0.6, 0.33333333333333
88432, 1.2416666666667, 0.575, 0.33333333333333
88433, 1.2416666666667, 0.55, 0.3125
88434, 1.2208333333333, 0.55, 0.33333333333333
88435, 1.2416666666667, 0.525, 0.33333333333333
88436, 1.2416666666667, 0.5, 0.3125
88437, 1.2208333333333, 0.5, 0.33333333333333
88438, 1.2416666666667, 0.475, 0.33333333333333
88439, 1.2416666666667, 0.45, 0.3125
88440, 1.2208333333333, 0.45, 0.33333333333333
88441, 1.2416666666667, 0.425, 0.33333333333333
88442, 1.2416666666667, 0.4, 0.3125
88443, 1.2208333333333, 0.4, 0.33333333333333
88444, 1.2416666666667, 0.375, 0.33333333333333
88445, 1.2416666666667, 0.35, 0.3125
88446, 1.2208333333333, 0.35, 0.33333333333333
88447, 1.2416666666667, 0.325, 0.33333333333333
88448, 1.2416666666667, 0.3, 0.3125
88449, 1.2208333333333, 0.3, 0.33333333333333
88450, 1.2416666666667, 0.275, 0.33333333333333
88451, 1.2416666666667, 0.25, 0.3125
88452, 1.2208333333333, 0.25, 0.33333333333333
88453, 1.2416666666667, 0.225, 0.33333333333333
88454, 1.2416666666667, 0.2, 0.3125
88455, 1.2208333333333, 0.2, 0.33333333333333
88456, 1.2416666666667, 0.175, 0.33333333333333
88457, 1.2833333333333, 1.325, 0.33333333333333
88458, 1.2833333333333, 1.3, 0.3125
88459, 1.2625, 1.3, 0.33333333333333
88460, 1.2833333333333, 1.275, 0.33333333333333
88461, 1.2833333333333, 1.25, 0.3125
88462, 1.2625, 1.25, 0.33333333333333
88463, 1.2833333333333, 1.225, 0.33333333333333
88464, 1.2833333333333, 1.2, 0.3125
88465, 1.2625, 1.2, 0.33333333333333
88466, 1.2833333333333, 1.175, 0.33333333333333
88467, 1.2833333333333, 1.15, 0.3125
88468, 1.2625, 1.15, 0.33333333333333
88469, 1.2833333333333, 1.125, 0.33333333333333
88470, 1.2833333333333, 1.1, 0.3125
88471, 1.2625, 1.1, 0.33333333333333
88472, 1.2833333333333, 1.075, 0.33333333333333
88473, 1.2833333333333, 1.05, 0.3125
88474, 1.2625, 1.05, 0.33333333333333
88475, 1.2833333333333, 1.025, 0.33333333333333
88476, 1.2833333333333, 1, 0.3125
88477, 1.2625, 1, 0.33333333333333
88478, 1.2833333333333, 0.975, 0.33333333333333
88479, 1.2833333333333, 0.95, 0.3125
88480, 1.2625, 0.95, 0.33333333333333
88481, 1.2833333333333, 0.925, 0.33333333333333
88482, 1.2833333333333, 0.9, 0.3125
88483, 1.2625, 0.9, 0.33333333333333
88484, 1.2833333333333, 0.875, 0.33333333333333
88485, 1.2833333333333, 0.85, 0.3125
88486, 1.2625, 0.85, 0.33333333333333
88487, 1.2833333333333, 0.825, 0.33333333333333
88488, 1.2833333333333, 0.8, 0.3125
88489, 1.2625, 0.8, 0.33333333333333
88490, 1.2833333333333, 0.775, 0.33333333333333
88491, 1.2833333333333, 0.75, 0.3125
88492, 1.2625, 0.75, 0.33333333333333
88493, 1.2833333333333, 0.725, 0.33333333333333
88494, 1.2833333333333, 0.7, 0.3125
88495, 1.2625, 0.7, 0.33333333333333
88496, 1.2833333333333, 0.675, 0.33333333333333
88497, 1.2833333333333, 0.65, 0.3125
88498, 1.2625, 0.65, 0.33333333333333
88499, 1.2833333333333, 0.625, 0.33333333333333
88500, 1.2833333333333, 0.6, 0.3125
88501, 1.2625, 0.6, 0.33333333333333
88502, 1.2833333333333, 0.575, 0.33333333333333
88503, 1.2833333333333, 0.55, 0.3125
88504, 1.2625, 0.55, 0.33333333333333
88505, 1.2833333333333, 0.525, 0.33333333333333
88506, 1.2833333333333, 0.5, 0.3125
88507, 1.2625, 0.5, 0.33333333333333
88508, 1.2833333333333, 0.475, 0.33333333333333
88509, 1.2833333333333, 0.45, 0.3125
88510, 1.2625, 0.45, 0.33333333333333
88511, 1.2833333333333, 0.425, 0.33333333333333
88512, 1.2833333333333, 0.4, 0.3125
88513, 1.2625, 0.4, 0.33333333333333
88514, 1.2833333333333, 0.375, 0.33333333333333
88515, 1.2833333333333, 0.35, 0.3125
88516, 1.2625, 0.35, 0.33333333333333
88517, 1.2833333333333, 0.325, 0.33333333333333
88518, 1.2833333333333, 0.3, 0.3125
88519, 1.2625, 0.3, 0.33333333333333
88520, 1.2833333333333, 0.275, 0.33333333333333
88521, 1.2833333333333, 0.25, 0.3125
88522, 1.2625, 0.25, 0.33333333333333
88523, 1.2833333333333, 0.225, 0.33333333333333
88524, 1.2833333333333, 0.2, 0.3125
88525, 1.2625, 0.2, 0.33333333333333
88526, 1.2833333333333, 0.175, 0.33333333333333
88527, 1.325, 1.325, 0.33333333333333
88528, 1.325, 1.3, 0.3125
88529, 1.3041666666667, 1.3, 0.33333333333333
88530, 1.325, 1.275, 0.33333333333333
88531, 1.325, 1.25, 0.3125
88532, 1.3041666666667, 1.25, 0.33333333333333
88533, 1.325, 1.225, 0.33333333333333
88534, 1.325, 1.2, 0.3125
88535, 1.3041666666667, 1.2, 0.33333333333333
88536, 1.325, 1.175, 0.33333333333333
88537, 1.325, 1.15, 0.3125
88538, 1.3041666666667, 1.15, 0.33333333333333
88539, 1.325, 1.125, 0.33333333333333
88540, 1.325, 1.1, 0.3125
88541, 1.3041666666667, 1.1, 0.33333333333333
88542, 1.325, 1.075, 0.33333333333333
88543, 1.325, 1.05, 0.3125
88544, 1.3041666666667, 1.05, 0.33333333333333
88545, 1.325, 1.025, 0.33333333333333
88546, 1.325, 1, 0.3125
88547, 1.3041666666667, 1, 0.33333333333333
88548, 1.325, 0.975, 0.33333333333333
88549, 1.325, 0.95, 0.3125
88550, 1.3041666666667, 0.95, 0.33333333333333
88551, 1.325, 0.925, 0.33333333333333
88552, 1.325, 0.9, 0.3125
88553, 1.3041666666667, 0.9, 0.33333333333333
88554, 1.325, 0.875, 0.33333333333333
88555, 1.325, 0.85, 0.3125
88556, 1.3041666666667, 0.85, 0.33333333333333
88557, 1.325, 0.825, 0.33333333333333
88558, 1.325, 0.8, 0.3125
88559, 1.3041666666667, 0.8, 0.33333333333333
88560, 1.325, 0.775, 0.33333333333333
88561, 1.325, 0.75, 0.3125
88562, 1.3041666666667, 0.75, 0.33333333333333
88563, 1.325, 0.725, 0.33333333333333
88564, 1.325, 0.7, 0.3125
88565, 1.3041666666667, 0.7, 0.33333333333333
88566, 1.325, 0.675, 0.33333333333333
88567, 1.325, 0.65, 0.3125
88568, 1.3041666666667, 0.65, 0.33333333333333
88569, 1.325, 0.625, 0.33333333333333
88570, 1.325, 0.6, 0.3125
88571, 1.3041666666667, 0.6, 0.33333333333333
88572, 1.325, 0.575, 0.33333333333333
88573, 1.325, 0.55, 0.3125
88574, 1.3041666666667, 0.55, 0.33333333333333
88575, 1.325, 0.525, 0.33333333333333
88576, 1.325, 0.5, 0.3125
88577, 1.3041666666667, 0.5, 0.33333333333333
88578, 1.325, 0.475, 0.33333333333333
88579, 1.325, 0.45, 0.3125
88580, 1.3041666666667, 0.45, 0.33333333333333
88581, 1.325, 0.425, 0.33333333333333
88582, 1.325, 0.4, 0.3125
88583, 1.3041666666667, 0.4, 0.33333333333333
88584, 1.325, 0.375, 0.33333333333333
88585, 1.325, 0.35, 0.3125
88586, 1.3041666666667, 0.35, 0.33333333333333
88587, 1.325, 0.325, 0.33333333333333
88588, 1.325, 0.3, 0.3125
88589, 1.3041666666667, 0.3, 0.33333333333333
88590, 1.325, 0.275, 0.33333333333333
88591, 1.325, 0.25, 0.3125
88592, 1.3041666666667, 0.25, 0.33333333333333
88593, 1.325, 0.225, 0.33333333333333
88594, 1.325, 0.2, 0.3125
88595, 1.3041666666667, 0.2, 0.33333333333333
88596, 1.325, 0.175, 0.33333333333333
88597, 1.3666666666667, 1.325, 0.33333333333333
88598, 1.3666666666667, 1.3, 0.3125
88599, 1.3458333333333, 1.3, 0.33333333333333
88600, 1.3666666666667, 1.275, 0.33333333333333
88601, 1.3666666666667, 1.25, 0.3125
88602, 1.3458333333333, 1.25, 0.33333333333333
88603, 1.3666666666667, 1.225, 0.33333333333333
88604, 1.3666666666667, 1.2, 0.3125
88605, 1.3458333333333, 1.2, 0.33333333333333
88606, 1.3666666666667, 1.175, 0.33333333333333
88607, 1.3666666666667, 1.15, 0.3125
88608, 1.3458333333333, 1.15, 0.33333333333333
88609, 1.3666666666667, 1.125, 0.33333333333333
88610, 1.3666666666667, 1.1, 0.3125
88611, 1.3458333333333, 1.1, 0.33333333333333
88612, 1.3666666666667, 1.075, 0.33333333333333
88613, 1.3666666666667, 1.05, 0.3125
88614, 1.3458333333333, 1.05, 0.33333333333333
88615, 1.3666666666667, 1.025, 0.33333333333333
88616, 1.3666666666667, 1, 0.3125
88617, 1.3458333333333, 1, 0.33333333333333
88618, 1.3666666666667, 0.975, 0.33333333333333
88619, 1.3666666666667, 0.95, 0.3125
88620, 1.3458333333333, 0.95, 0.33333333333333
88621, 1.3666666666667, 0.925, 0.33333333333333
88622, 1.3666666666667, 0.9, 0.3125
88623, 1.3458333333333, 0.9, 0.33333333333333
88624, 1.3666666666667, 0.875, 0.33333333333333
88625, 1.3666666666667, 0.85, 0.3125
88626, 1.3458333333333, 0.85, 0.33333333333333
88627, 1.3666666666667, 0.825, 0.33333333333333
88628, 1.3666666666667, 0.8, 0.3125
88629, 1.3458333333333, 0.8, 0.33333333333333
88630, 1.3666666666667, 0.775, 0.33333333333333
88631, 1.3666666666667, 0.75, 0.3125
88632, 1.3458333333333, 0.75, 0.33333333333333
88633, 1.3666666666667, 0.725, 0.33333333333333
88634, 1.3666666666667, 0.7, 0.3125
88635, 1.3458333333333, 0.7, 0.33333333333333
88636, 1.3666666666667, 0.675, 0.33333333333333
88637, 1.3666666666667, 0.65, 0.3125
88638, 1.3458333333333, 0.65, 0.33333333333333
88639, 1.3666666666667, 0.625, 0.33333333333333
88640, 1.3666666666667, 0.6, 0.3125
88641, 1.3458333333333, 0.6, 0.33333333333333
88642, 1.3666666666667, 0.575, 0.33333333333333
88643, 1.3666666666667, 0.55, 0.3125
88644, 1.3458333333333, 0.55, 0.33333333333333
88645, 1.3666666666667, 0.525, 0.33333333333333
88646, 1.3666666666667, 0.5, 0.3125
88647, 1.3458333333333, 0.5, 0.33333333333333
88648, 1.3666666666667, 0.475, 0.33333333333333
88649, 1.3666666666667, 0.45, 0.3125
88650, 1.3458333333333, 0.45, 0.33333333333333
88651, 1.3666666666667, 0.425, 0.33333333333333
88652, 1.3666666666667, 0.4, 0.3125
88653, 1.3458333333333, 0.4, 0.33333333333333
88654, 1.3666666666667, 0.375, 0.33333333333333
88655, 1.3666666666667, 0.35, 0.3125
88656, 1.3458333333333, 0.35, 0.33333333333333
88657, 1.3666666666667, 0.325, 0.33333333333333
88658, 1.3666666666667, 0.3, 0.3125
88659, 1.3458333333333, 0.3, 0.33333333333333
88660, 1.3666666666667, 0.275, 0.33333333333333
88661, 1.3666666666667, 0.25, 0.3125
88662, 1.3458333333333, 0.25, 0.33333333333333
88663, 1.3666666666667, 0.225, 0.33333333333333
88664, 1.3666666666667, 0.2, 0.3125
88665, 1.3458333333333, 0.2, 0.33333333333333
88666, 1.3666666666667, 0.175, 0.33333333333333
88667, 1.4083333333333, 1.325, 0.33333333333333
88668, 1.4083333333333, 1.3, 0.3125
88669, 1.3875, 1.3, 0.33333333333333
88670, 1.4083333333333, 1.275, 0.33333333333333
88671, 1.4083333333333, 1.25, 0.3125
88672, 1.3875, 1.25, 0.33333333333333
88673, 1.4083333333333, 1.225, 0.33333333333333
88674, 1.4083333333333, 1.2, 0.3125
88675, 1.3875, 1.2, 0.33333333333333
88676, 1.4083333333333, 1.175, 0.33333333333333
88677, 1.4083333333333, 1.15, 0.3125
88678, 1.3875, 1.15, 0.33333333333333
88679, 1.4083333333333, 1.125, 0.33333333333333
88680, 1.4083333333333, 1.1, 0.3125
88681, 1.3875, 1.1, 0.33333333333333
88682, 1.4083333333333, 1.075, 0.33333333333333
88683, 1.4083333333333, 1.05, 0.3125
88684, 1.3875, 1.05, 0.33333333333333
88685, 1.4083333333333, 1.025, 0.33333333333333
88686, 1.4083333333333, 1, 0.3125
88687, 1.3875, 1, 0.33333333333333
88688, 1.4083333333333, 0.975, 0.33333333333333
88689, 1.4083333333333, 0.95, 0.3125
88690, 1.3875, 0.95, 0.33333333333333
88691, 1.4083333333333, 0.925, 0.33333333333333
88692, 1.4083333333333, 0.9, 0.3125
88693, 1.3875, 0.9, 0.33333333333333
88694, 1.4083333333333, 0.875, 0.33333333333333
88695, 1.4083333333333, 0.85, 0.3125
88696, 1.3875, 0.85, 0.33333333333333
88697, 1.4083333333333, 0.825, 0.33333333333333
88698, 1.4083333333333, 0.8, 0.3125
88699, 1.3875, 0.8, 0.33333333333333
88700, 1.4083333333333, 0.775, 0.33333333333333
88701, 1.4083333333333, 0.75, 0.3125
88702, 1.3875, 0.75, 0.33333333333333
88703, 1.4083333333333, 0.725, 0.33333333333333
88704, 1.4083333333333, 0.7, 0.3125
88705, 1.3875, 0.7, 0.33333333333333
88706, 1.4083333333333, 0.675, 0.33333333333333
88707, 1.4083333333333, 0.65, 0.3125
88708, 1.3875, 0.65, 0.33333333333333
88709, 1.4083333333333, 0.625, 0.33333333333333
88710, 1.4083333333333, 0.6, 0.3125
88711, 1.3875, 0.6, 0.33333333333333
88712, 1.4083333333333, 0.575, 0.33333333333333
88713, 1.4083333333333, 0.55, 0.3125
88714, 1.3875, 0.55, 0.33333333333333
88715, 1.4083333333333, 0.525, 0.33333333333333
88716, 1.4083333333333, 0.5, 0.3125
88717, 1.3875, 0.5, 0.33333333333333
88718, 1.4083333333333, 0.475, 0.33333333333333
88719, 1.4083333333333, 0.45, 0.3125
88720, 1.3875, 0.45, 0.33333333333333
88721, 1.4083333333333, 0.425, 0.33333333333333
88722, 1.4083333333333, 0.4, 0.3125
88723, 1.3875, 0.4, 0.33333333333333
88724, 1.4083333333333, 0.375, 0.33333333333333
88725, 1.4083333333333, 0.35, 0.3125
88726, 1.3875, 0.35, 0.33333333333333
88727, 1.4083333333333, 0.325, 0.33333333333333
88728, 1.4083333333333, 0.3, 0.3125
88729, 1.3875, 0.3, 0.33333333333333
88730, 1.4083333333333, 0.275, 0.33333333333333
88731, 1.4083333333333, 0.25, 0.3125
88732, 1.3875, 0.25, 0.33333333333333
88733, 1.4083333333333, 0.225, 0.33333333333333
88734, 1.4083333333333, 0.2, 0.3125
88735, 1.3875, 0.2, 0.33333333333333
88736, 1.4083333333333, 0.175, 0.33333333333333
88737, 1.45, 1.325, 0.33333333333333
88738, 1.45, 1.3, 0.3125
88739, 1.4291666666667, 1.3, 0.33333333333333
88740, 1.45, 1.275, 0.33333333333333
88741, 1.45, 1.25, 0.3125
88742, 1.4291666666667, 1.25, 0.33333333333333
88743, 1.45, 1.225, 0.33333333333333
88744, 1.45, 1.2, 0.3125
88745, 1.4291666666667, 1.2, 0.33333333333333
88746, 1.45, 1.175, 0.33333333333333
88747, 1.45, 1.15, 0.3125
88748, 1.4291666666667, 1.15, 0.33333333333333
88749, 1.45, 1.125, 0.33333333333333
88750, 1.45, 1.1, 0.3125
88751, 1.4291666666667, 1.1, 0.33333333333333
88752, 1.45, 1.075, 0.33333333333333
88753, 1.45, 1.05, 0.3125
88754, 1.4291666666667, 1.05, 0.33333333333333
88755, 1.45, 1.025, 0.33333333333333
88756, 1.45, 1, 0.3125
88757, 1.4291666666667, 1, 0.33333333333333
88758, 1.45, 0.975, 0.33333333333333
88759, 1.45, 0.95, 0.3125
88760, 1.4291666666667, 0.95, 0.33333333333333
88761, 1.45, 0.925, 0.33333333333333
88762, 1.45, 0.9, 0.3125
88763, 1.4291666666667, 0.9, 0.33333333333333
88764, 1.45, 0.875, 0.33333333333333
88765, 1.45, 0.85, 0.3125
88766, 1.4291666666667, 0.85, 0.33333333333333
88767, 1.45, 0.825, 0.33333333333333
88768, 1.45, 0.8, 0.3125
88769, 1.4291666666667, 0.8, 0.33333333333333
88770, 1.45, 0.775, 0.33333333333333
88771, 1.45, 0.75, 0.3125
88772, 1.4291666666667, 0.75, 0.33333333333333
88773, 1.45, 0.725, 0.33333333333333
88774, 1.45, 0.7, 0.3125
88775, 1.4291666666667, 0.7, 0.33333333333333
88776, 1.45, 0.675, 0.33333333333333
88777, 1.45, 0.65, 0.3125
88778, 1.4291666666667, 0.65, 0.33333333333333
88779, 1.45, 0.625, 0.33333333333333
88780, 1.45, 0.6, 0.3125
88781, 1.4291666666667, 0.6, 0.33333333333333
88782, 1.45, 0.575, 0.33333333333333
88783, 1.45, 0.55, 0.3125
88784, 1.4291666666667, 0.55, 0.33333333333333
88785, 1.45, 0.525, 0.33333333333333
88786, 1.45, 0.5, 0.3125
88787, 1.4291666666667, 0.5, 0.33333333333333
88788, 1.45, 0.475, 0.33333333333333
88789, 1.45, 0.45, 0.3125
88790, 1.4291666666667, 0.45, 0.33333333333333
88791, 1.45, 0.425, 0.33333333333333
88792, 1.45, 0.4, 0.3125
88793, 1.4291666666667, 0.4, 0.33333333333333
88794, 1.45, 0.375, 0.33333333333333
88795, 1.45, 0.35, 0.3125
88796, 1.4291666666667, 0.35, 0.33333333333333
88797, 1.45, 0.325, 0.33333333333333
88798, 1.45, 0.3, 0.3125
88799, 1.4291666666667, 0.3, 0.33333333333333
88800, 1.45, 0.275, 0.33333333333333
88801, 1.45, 0.25, 0.3125
88802, 1.4291666666667, 0.25, 0.33333333333333
88803, 1.45, 0.225, 0.33333333333333
88804, 1.45, 0.2, 0.3125
88805, 1.4291666666667, 0.2, 0.33333333333333
88806, 1.45, 0.175, 0.33333333333333
88807, 1.4916666666667, 1.325, 0.33333333333333
88808, 1.4916666666667, 1.3, 0.3125
88809, 1.4708333333333, 1.3, 0.33333333333333
88810, 1.4916666666667, 1.275, 0.33333333333333
88811, 1.4916666666667, 1.25, 0.3125
88812, 1.4708333333333, 1.25, 0.33333333333333
88813, 1.4916666666667, 1.225, 0.33333333333333
88814, 1.4916666666667, 1.2, 0.3125
88815, 1.4708333333333, 1.2, 0.33333333333333
88816, 1.4916666666667, 1.175, 0.33333333333333
88817, 1.4916666666667, 1.15, 0.3125
88818, 1.4708333333333, 1.15, 0.33333333333333
88819, 1.4916666666667, 1.125, 0.33333333333333
88820, 1.4916666666667, 1.1, 0.3125
88821, 1.4708333333333, 1.1, 0.33333333333333
88822, 1.4916666666667, 1.075, 0.33333333333333
88823, 1.4916666666667, 1.05, 0.3125
88824, 1.4708333333333, 1.05, 0.33333333333333
88825, 1.4916666666667, 1.025, 0.33333333333333
88826, 1.4916666666667, 1, 0.3125
88827, 1.4708333333333, 1, 0.33333333333333
88828, 1.4916666666667, 0.975, 0.33333333333333
88829, 1.4916666666667, 0.95, 0.3125
88830, 1.4708333333333, 0.95, 0.33333333333333
88831, 1.4916666666667, 0.925, 0.33333333333333
88832, 1.4916666666667, 0.9, 0.3125
88833, 1.4708333333333, 0.9, 0.33333333333333
88834, 1.4916666666667, 0.875, 0.33333333333333
88835, 1.4916666666667, 0.85, 0.3125
88836, 1.4708333333333, 0.85, 0.33333333333333
88837, 1.4916666666667, 0.825, 0.33333333333333
88838, 1.4916666666667, 0.8, 0.3125
88839, 1.4708333333333, 0.8, 0.33333333333333
88840, 1.4916666666667, 0.775, 0.33333333333333
88841, 1.4916666666667, 0.75, 0.3125
88842, 1.4708333333333, 0.75, 0.33333333333333
88843, 1.4916666666667, 0.725, 0.33333333333333
88844, 1.4916666666667, 0.7, 0.3125
88845, 1.4708333333333, 0.7, 0.33333333333333
88846, 1.4916666666667, 0.675, 0.33333333333333
88847, 1.4916666666667, 0.65, 0.3125
88848, 1.4708333333333, 0.65, 0.33333333333333
88849, 1.4916666666667, 0.625, 0.33333333333333
88850, 1.4916666666667, 0.6, 0.3125
88851, 1.4708333333333, 0.6, 0.33333333333333
88852, 1.4916666666667, 0.575, 0.33333333333333
88853, 1.4916666666667, 0.55, 0.3125
88854, 1.4708333333333, 0.55, 0.33333333333333
88855, 1.4916666666667, 0.525, 0.33333333333333
88856, 1.4916666666667, 0.5, 0.3125
88857, 1.4708333333333, 0.5, 0.33333333333333
88858, 1.4916666666667, 0.475, 0.33333333333333
88859, 1.4916666666667, 0.45, 0.3125
88860, 1.4708333333333, 0.45, 0.33333333333333
88861, 1.4916666666667, 0.425, 0.33333333333333
88862, 1.4916666666667, 0.4, 0.3125
88863, 1.4708333333333, 0.4, 0.33333333333333
88864, 1.4916666666667, 0.375, 0.33333333333333
88865, 1.4916666666667, 0.35, 0.3125
88866, 1.4708333333333, 0.35, 0.33333333333333
88867, 1.4916666666667, 0.325, 0.33333333333333
88868, 1.4916666666667, 0.3, 0.3125
88869, 1.4708333333333, 0.3, 0.33333333333333
88870, 1.4916666666667, 0.275, 0.33333333333333
88871, 1.4916666666667, 0.25, 0.3125
88872, 1.4708333333333, 0.25, 0.33333333333333
88873, 1.4916666666667, 0.225, 0.33333333333333
88874, 1.4916666666667, 0.2, 0.3125
88875, 1.4708333333333, 0.2, 0.33333333333333
88876, 1.4916666666667, 0.175, 0.33333333333333
88877, 1.5333333333333, 1.325, 0.33333333333333
88878, 1.5333333333333, 1.3, 0.3125
88879, 1.5125, 1.3, 0.33333333333333
88880, 1.5333333333333, 1.275, 0.33333333333333
88881, 1.5333333333333, 1.25, 0.3125
88882, 1.5125, 1.25, 0.33333333333333
88883, 1.5333333333333, 1.225, 0.33333333333333
88884, 1.5333333333333, 1.2, 0.3125
88885, 1.5125, 1.2, 0.33333333333333
88886, 1.5333333333333, 1.175, 0.33333333333333
88887, 1.5333333333333, 1.15, 0.3125
88888, 1.5125, 1.15, 0.33333333333333
88889, 1.5333333333333, 1.125, 0.33333333333333
88890, 1.5333333333333, 1.1, 0.3125
88891, 1.5125, 1.1, 0.33333333333333
88892, 1.5333333333333, 1.075, 0.33333333333333
88893, 1.5333333333333, 1.05, 0.3125
88894, 1.5125, 1.05, 0.33333333333333
88895, 1.5333333333333, 1.025, 0.33333333333333
88896, 1.5333333333333, 1, 0.3125
88897, 1.5125, 1, 0.33333333333333
88898, 1.5333333333333, 0.975, 0.33333333333333
88899, 1.5333333333333, 0.95, 0.3125
88900, 1.5125, 0.95, 0.33333333333333
88901, 1.5333333333333, 0.925, 0.33333333333333
88902, 1.5333333333333, 0.9, 0.3125
88903, 1.5125, 0.9, 0.33333333333333
88904, 1.5333333333333, 0.875, 0.33333333333333
88905, 1.5333333333333, 0.85, 0.3125
88906, 1.5125, 0.85, 0.33333333333333
88907, 1.5333333333333, 0.825, 0.33333333333333
88908, 1.5333333333333, 0.8, 0.3125
88909, 1.5125, 0.8, 0.33333333333333
88910, 1.5333333333333, 0.775, 0.33333333333333
88911, 1.5333333333333, 0.75, 0.3125
88912, 1.5125, 0.75, 0.33333333333333
88913, 1.5333333333333, 0.725, 0.33333333333333
88914, 1.5333333333333, 0.7, 0.3125
88915, 1.5125, 0.7, 0.33333333333333
88916, 1.5333333333333, 0.675, 0.33333333333333
88917, 1.5333333333333, 0.65, 0.3125
88918, 1.5125, 0.65, 0.33333333333333
88919, 1.5333333333333, 0.625, 0.33333333333333
88920, 1.5333333333333, 0.6, 0.3125
88921, 1.5125, 0.6, 0.33333333333333
88922, 1.5333333333333, 0.575, 0.33333333333333
88923, 1.5333333333333, 0.55, 0.3125
88924, 1.5125, 0.55, 0.33333333333333
88925, 1.5333333333333, 0.525, 0.33333333333333
88926, 1.5333333333333, 0.5, 0.3125
88927, 1.5125, 0.5, 0.33333333333333
88928, 1.5333333333333, 0.475, 0.33333333333333
88929, 1.5333333333333, 0.45, 0.3125
88930, 1.5125, 0.45, 0.33333333333333
88931, 1.5333333333333, 0.425, 0.33333333333333
88932, 1.5333333333333, 0.4, 0.3125
88933, 1.5125, 0.4, 0.33333333333333
88934, 1.5333333333333, 0.375, 0.33333333333333
88935, 1.5333333333333, 0.35, 0.3125
88936, 1.5125, 0.35, 0.33333333333333
88937, 1.5333333333333, 0.325, 0.33333333333333
88938, 1.5333333333333, 0.3, 0.3125
88939, 1.5125, 0.3, 0.33333333333333
88940, 1.5333333333333, 0.275, 0.33333333333333
88941, 1.5333333333333, 0.25, 0.3125
88942, 1.5125, 0.25, 0.33333333333333
88943, 1.5333333333333, 0.225, 0.33333333333333
88944, 1.5333333333333, 0.2, 0.3125
88945, 1.5125, 0.2, 0.33333333333333
88946, 1.5333333333333, 0.175, 0.33333333333333
88947, 1.575, 1.325, 0.33333333333333
88948, 1.575, 1.3, 0.3125
88949, 1.5541666666667, 1.3, 0.33333333333333
88950, 1.575, 1.275, 0.33333333333333
88951, 1.575, 1.25, 0.3125
88952, 1.5541666666667, 1.25, 0.33333333333333
88953, 1.575, 1.225, 0.33333333333333
88954, 1.575, 1.2, 0.3125
88955, 1.5541666666667, 1.2, 0.33333333333333
88956, 1.575, 1.175, 0.33333333333333
88957, 1.575, 1.15, 0.3125
88958, 1.5541666666667, 1.15, 0.33333333333333
88959, 1.575, 1.125, 0.33333333333333
88960, 1.575, 1.1, 0.3125
88961, 1.5541666666667, 1.1, 0.33333333333333
88962, 1.575, 1.075, 0.33333333333333
88963, 1.575, 1.05, 0.3125
88964, 1.5541666666667, 1.05, 0.33333333333333
88965, 1.575, 1.025, 0.33333333333333
88966, 1.575, 1, 0.3125
88967, 1.5541666666667, 1, 0.33333333333333
88968, 1.575, 0.975, 0.33333333333333
88969, 1.575, 0.95, 0.3125
88970, 1.5541666666667, 0.95, 0.33333333333333
88971, 1.575, 0.925, 0.33333333333333
88972, 1.575, 0.9, 0.3125
88973, 1.5541666666667, 0.9, 0.33333333333333
88974, 1.575, 0.875, 0.33333333333333
88975, 1.575, 0.85, 0.3125
88976, 1.5541666666667, 0.85, 0.33333333333333
88977, 1.575, 0.825, 0.33333333333333
88978, 1.575, 0.8, 0.3125
88979, 1.5541666666667, 0.8, 0.33333333333333
88980, 1.575, 0.775, 0.33333333333333
88981, 1.575, 0.75, 0.3125
88982, 1.5541666666667, 0.75, 0.33333333333333
88983, 1.575, 0.725, 0.33333333333333
88984, 1.575, 0.7, 0.3125
88985, 1.5541666666667, 0.7, 0.33333333333333
88986, 1.575, 0.675, 0.33333333333333
88987, 1.575, 0.65, 0.3125
88988, 1.5541666666667, 0.65, 0.33333333333333
88989, 1.575, 0.625, 0.33333333333333
88990, 1.575, 0.6, 0.3125
88991, 1.5541666666667, 0.6, 0.33333333333333
88992, 1.575, 0.575, 0.33333333333333
88993, 1.575, 0.55, 0.3125
88994, 1.5541666666667, 0.55, 0.33333333333333
88995, 1.575, 0.525, 0.33333333333333
88996, 1.575, 0.5, 0.3125
88997, 1.5541666666667, 0.5, 0.33333333333333
88998, 1.575, 0.475, 0.33333333333333
88999, 1.575, 0.45, 0.3125
89000, 1.5541666666667, 0.45, 0.33333333333333
89001, 1.575, 0.425, 0.33333333333333
89002, 1.575, 0.4, 0.3125
89003, 1.5541666666667, 0.4, 0.33333333333333
89004, 1.575, 0.375, 0.33333333333333
89005, 1.575, 0.35, 0.3125
89006, 1.5541666666667, 0.35, 0.33333333333333
89007, 1.575, 0.325, 0.33333333333333
89008, 1.575, 0.3, 0.3125
89009, 1.5541666666667, 0.3, 0.33333333333333
89010, 1.575, 0.275, 0.33333333333333
89011, 1.575, 0.25, 0.3125
89012, 1.5541666666667, 0.25, 0.33333333333333
89013, 1.575, 0.225, 0.33333333333333
89014, 1.575, 0.2, 0.3125
89015, 1.5541666666667, 0.2, 0.33333333333333
89016, 1.575, 0.175, 0.33333333333333
89017, 1.6166666666667, 1.325, 0.33333333333333
89018, 1.6166666666667, 1.3, 0.3125
89019, 1.5958333333333, 1.3, 0.33333333333333
89020, 1.6166666666667, 1.275, 0.33333333333333
89021, 1.6166666666667, 1.25, 0.3125
89022, 1.5958333333333, 1.25, 0.33333333333333
89023, 1.6166666666667, 1.225, 0.33333333333333
89024, 1.6166666666667, 1.2, 0.3125
89025, 1.5958333333333, 1.2, 0.33333333333333
89026, 1.6166666666667, 1.175, 0.33333333333333
89027, 1.6166666666667, 1.15, 0.3125
89028, 1.5958333333333, 1.15, 0.33333333333333
89029, 1.6166666666667, 1.125, 0.33333333333333
89030, 1.6166666666667, 1.1, 0.3125
89031, 1.5958333333333, 1.1, 0.33333333333333
89032, 1.6166666666667, 1.075, 0.33333333333333
89033, 1.6166666666667, 1.05, 0.3125
89034, 1.5958333333333, 1.05, 0.33333333333333
89035, 1.6166666666667, 1.025, 0.33333333333333
89036, 1.6166666666667, 1, 0.3125
89037, 1.5958333333333, 1, 0.33333333333333
89038, 1.6166666666667, 0.975, 0.33333333333333
89039, 1.6166666666667, 0.95, 0.3125
89040, 1.5958333333333, 0.95, 0.33333333333333
89041, 1.6166666666667, 0.925, 0.33333333333333
89042, 1.6166666666667, 0.9, 0.3125
89043, 1.5958333333333, 0.9, 0.33333333333333
89044, 1.6166666666667, 0.875, 0.33333333333333
89045, 1.6166666666667, 0.85, 0.3125
89046, 1.5958333333333, 0.85, 0.33333333333333
89047, 1.6166666666667, 0.825, 0.33333333333333
89048, 1.6166666666667, 0.8, 0.3125
89049, 1.5958333333333, 0.8, 0.33333333333333
89050, 1.6166666666667, 0.775, 0.33333333333333
89051, 1.6166666666667, 0.75, 0.3125
89052, 1.5958333333333, 0.75, 0.33333333333333
89053, 1.6166666666667, 0.725, 0.33333333333333
89054, 1.6166666666667, 0.7, 0.3125
89055, 1.5958333333333, 0.7, 0.33333333333333
89056, 1.6166666666667, 0.675, 0.33333333333333
89057, 1.6166666666667, 0.65, 0.3125
89058, 1.5958333333333, 0.65, 0.33333333333333
89059, 1.6166666666667, 0.625, 0.33333333333333
89060, 1.6166666666667, 0.6, 0.3125
89061, 1.5958333333333, 0.6, 0.33333333333333
89062, 1.6166666666667, 0.575, 0.33333333333333
89063, 1.6166666666667, 0.55, 0.3125
89064, 1.5958333333333, 0.55, 0.33333333333333
89065, 1.6166666666667, 0.525, 0.33333333333333
89066, 1.6166666666667, 0.5, 0.3125
89067, 1.5958333333333, 0.5, 0.33333333333333
89068, 1.6166666666667, 0.475, 0.33333333333333
89069, 1.6166666666667, 0.45, 0.3125
89070, 1.5958333333333, 0.45, 0.33333333333333
89071, 1.6166666666667, 0.425, 0.33333333333333
89072, 1.6166666666667, 0.4, 0.3125
89073, 1.5958333333333, 0.4, 0.33333333333333
89074, 1.6166666666667, 0.375, 0.33333333333333
89075, 1.6166666666667, 0.35, 0.3125
89076, 1.5958333333333, 0.35, 0.33333333333333
89077, 1.6166666666667, 0.325, 0.33333333333333
89078, 1.6166666666667, 0.3, 0.3125
89079, 1.5958333333333, 0.3, 0.33333333333333
89080, 1.6166666666667, 0.275, 0.33333333333333
89081, 1.6166666666667, 0.25, 0.3125
89082, 1.5958333333333, 0.25, 0.33333333333333
89083, 1.6166666666667, 0.225, 0.33333333333333
89084, 1.6166666666667, 0.2, 0.3125
89085, 1.5958333333333, 0.2, 0.33333333333333
89086, 1.6166666666667, 0.175, 0.33333333333333
89087, 1.6583333333333, 1.325, 0.33333333333333
89088, 1.6583333333333, 1.3, 0.3125
89089, 1.6375, 1.3, 0.33333333333333
89090, 1.6583333333333, 1.275, 0.33333333333333
89091, 1.6583333333333, 1.25, 0.3125
89092, 1.6375, 1.25, 0.33333333333333
89093, 1.6583333333333, 1.225, 0.33333333333333
89094, 1.6583333333333, 1.2, 0.3125
89095, 1.6375, 1.2, 0.33333333333333
89096, 1.6583333333333, 1.175, 0.33333333333333
89097, 1.6583333333333, 1.15, 0.3125
89098, 1.6375, 1.15, 0.33333333333333
89099, 1.6583333333333, 1.125, 0.33333333333333
89100, 1.6583333333333, 1.1, 0.3125
89101, 1.6375, 1.1, 0.33333333333333
89102, 1.6583333333333, 1.075, 0.33333333333333
89103, 1.6583333333333, 1.05, 0.3125
89104, 1.6375, 1.05, 0.33333333333333
89105, 1.6583333333333, 1.025, 0.33333333333333
89106, 1.6583333333333, 1, 0.3125
89107, 1.6375, 1, 0.33333333333333
89108, 1.6583333333333, 0.975, 0.33333333333333
89109, 1.6583333333333, 0.95, 0.3125
89110, 1.6375, 0.95, 0.33333333333333
89111, 1.6583333333333, 0.925, 0.33333333333333
89112, 1.6583333333333, 0.9, 0.3125
89113, 1.6375, 0.9, 0.33333333333333
89114, 1.6583333333333, 0.875, 0.33333333333333
89115, 1.6583333333333, 0.85, 0.3125
89116, 1.6375, 0.85, 0.33333333333333
89117, 1.6583333333333, 0.825, 0.33333333333333
89118, 1.6583333333333, 0.8, 0.3125
89119, 1.6375, 0.8, 0.33333333333333
89120, 1.6583333333333, 0.775, 0.33333333333333
89121, 1.6583333333333, 0.75, 0.3125
89122, 1.6375, 0.75, 0.33333333333333
89123, 1.6583333333333, 0.725, 0.33333333333333
89124, 1.6583333333333, 0.7, 0.3125
89125, 1.6375, 0.7, 0.33333333333333
89126, 1.6583333333333, 0.675, 0.33333333333333
89127, 1.6583333333333, 0.65, 0.3125
89128, 1.6375, 0.65, 0.33333333333333
89129, 1.6583333333333, 0.625, 0.33333333333333
89130, 1.6583333333333, 0.6, 0.3125
89131, 1.6375, 0.6, 0.33333333333333
89132, 1.6583333333333, 0.575, 0.33333333333333
89133, 1.6583333333333, 0.55, 0.3125
89134, 1.6375, 0.55, 0.33333333333333
89135, 1.6583333333333, 0.525, 0.33333333333333
89136, 1.6583333333333, 0.5, 0.3125
89137, 1.6375, 0.5, 0.33333333333333
89138, 1.6583333333333, 0.475, 0.33333333333333
89139, 1.6583333333333, 0.45, 0.3125
89140, 1.6375, 0.45, 0.33333333333333
89141, 1.6583333333333, 0.425, 0.33333333333333
89142, 1.6583333333333, 0.4, 0.3125
89143, 1.6375, 0.4, 0.33333333333333
89144, 1.6583333333333, 0.375, 0.33333333333333
89145, 1.6583333333333, 0.35, 0.3125
89146, 1.6375, 0.35, 0.33333333333333
89147, 1.6583333333333, 0.325, 0.33333333333333
89148, 1.6583333333333, 0.3, 0.3125
89149, 1.6375, 0.3, 0.33333333333333
89150, 1.6583333333333, 0.275, 0.33333333333333
89151, 1.6583333333333, 0.25, 0.3125
89152, 1.6375, 0.25, 0.33333333333333
89153, 1.6583333333333, 0.225, 0.33333333333333
89154, 1.6583333333333, 0.2, 0.3125
89155, 1.6375, 0.2, 0.33333333333333
89156, 1.6583333333333, 0.175, 0.33333333333333
89157, 1.7, 1.325, 0.33333333333333
89158, 1.7, 1.3, 0.3125
89159, 1.6791666666667, 1.3, 0.33333333333333
89160, 1.7, 1.275, 0.33333333333333
89161, 1.7, 1.25, 0.3125
89162, 1.6791666666667, 1.25, 0.33333333333333
89163, 1.7, 1.225, 0.33333333333333
89164, 1.7, 1.2, 0.3125
89165, 1.6791666666667, 1.2, 0.33333333333333
89166, 1.7, 1.175, 0.33333333333333
89167, 1.7, 1.15, 0.3125
89168, 1.6791666666667, 1.15, 0.33333333333333
89169, 1.7, 1.125, 0.33333333333333
89170, 1.7, 1.1, 0.3125
89171, 1.6791666666667, 1.1, 0.33333333333333
89172, 1.7, 1.075, 0.33333333333333
89173, 1.7, 1.05, 0.3125
89174, 1.6791666666667, 1.05, 0.33333333333333
89175, 1.7, 1.025, 0.33333333333333
89176, 1.7, 1, 0.3125
89177, 1.6791666666667, 1, 0.33333333333333
89178, 1.7, 0.975, 0.33333333333333
89179, 1.7, 0.95, 0.3125
89180, 1.6791666666667, 0.95, 0.33333333333333
89181, 1.7, 0.925, 0.33333333333333
89182, 1.7, 0.9, 0.3125
89183, 1.6791666666667, 0.9, 0.33333333333333
89184, 1.7, 0.875, 0.33333333333333
89185, 1.7, 0.85, 0.3125
89186, 1.6791666666667, 0.85, 0.33333333333333
89187, 1.7, 0.825, 0.33333333333333
89188, 1.7, 0.8, 0.3125
89189, 1.6791666666667, 0.8, 0.33333333333333
89190, 1.7, 0.775, 0.33333333333333
89191, 1.7, 0.75, 0.3125
89192, 1.6791666666667, 0.75, 0.33333333333333
89193, 1.7, 0.725, 0.33333333333333
89194, 1.7, 0.7, 0.3125
89195, 1.6791666666667, 0.7, 0.33333333333333
89196, 1.7, 0.675, 0.33333333333333
89197, 1.7, 0.65, 0.3125
89198, 1.6791666666667, 0.65, 0.33333333333333
89199, 1.7, 0.625, 0.33333333333333
89200, 1.7, 0.6, 0.3125
89201, 1.6791666666667, 0.6, 0.33333333333333
89202, 1.7, 0.575, 0.33333333333333
89203, 1.7, 0.55, 0.3125
89204, 1.6791666666667, 0.55, 0.33333333333333
89205, 1.7, 0.525, 0.33333333333333
89206, 1.7, 0.5, 0.3125
89207, 1.6791666666667, 0.5, 0.33333333333333
89208, 1.7, 0.475, 0.33333333333333
89209, 1.7, 0.45, 0.3125
89210, 1.6791666666667, 0.45, 0.33333333333333
89211, 1.7, 0.425, 0.33333333333333
89212, 1.7, 0.4, 0.3125
89213, 1.6791666666667, 0.4, 0.33333333333333
89214, 1.7, 0.375, 0.33333333333333
89215, 1.7, 0.35, 0.3125
89216, 1.6791666666667, 0.35, 0.33333333333333
89217, 1.7, 0.325, 0.33333333333333
89218, 1.7, 0.3, 0.3125
89219, 1.6791666666667, 0.3, 0.33333333333333
89220, 1.7, 0.275, 0.33333333333333
89221, 1.7, 0.25, 0.3125
89222, 1.6791666666667, 0.25, 0.33333333333333
89223, 1.7, 0.225, 0.33333333333333
89224, 1.7, 0.2, 0.3125
89225, 1.6791666666667, 0.2, 0.33333333333333
89226, 1.7, 0.175, 0.33333333333333
89227, 1.7416666666667, 1.325, 0.33333333333333
89228, 1.7416666666667, 1.3, 0.3125
89229, 1.7208333333333, 1.3, 0.33333333333333
89230, 1.7416666666667, 1.275, 0.33333333333333
89231, 1.7416666666667, 1.25, 0.3125
89232, 1.7208333333333, 1.25, 0.33333333333333
89233, 1.7416666666667, 1.225, 0.33333333333333
89234, 1.7416666666667, 1.2, 0.3125
89235, 1.7208333333333, 1.2, 0.33333333333333
89236, 1.7416666666667, 1.175, 0.33333333333333
89237, 1.7416666666667, 1.15, 0.3125
89238, 1.7208333333333, 1.15, 0.33333333333333
89239, 1.7416666666667, 1.125, 0.33333333333333
89240, 1.7416666666667, 1.1, 0.3125
89241, 1.7208333333333, 1.1, 0.33333333333333
89242, 1.7416666666667, 1.075, 0.33333333333333
89243, 1.7416666666667, 1.05, 0.3125
89244, 1.7208333333333, 1.05, 0.33333333333333
89245, 1.7416666666667, 1.025, 0.33333333333333
89246, 1.7416666666667, 1, 0.3125
89247, 1.7208333333333, 1, 0.33333333333333
89248, 1.7416666666667, 0.975, 0.33333333333333
89249, 1.7416666666667, 0.95, 0.3125
89250, 1.7208333333333, 0.95, 0.33333333333333
89251, 1.7416666666667, 0.925, 0.33333333333333
89252, 1.7416666666667, 0.9, 0.3125
89253, 1.7208333333333, 0.9, 0.33333333333333
89254, 1.7416666666667, 0.875, 0.33333333333333
89255, 1.7416666666667, 0.85, 0.3125
89256, 1.7208333333333, 0.85, 0.33333333333333
89257, 1.7416666666667, 0.825, 0.33333333333333
89258, 1.7416666666667, 0.8, 0.3125
89259, 1.7208333333333, 0.8, 0.33333333333333
89260, 1.7416666666667, 0.775, 0.33333333333333
89261, 1.7416666666667, 0.75, 0.3125
89262, 1.7208333333333, 0.75, 0.33333333333333
89263, 1.7416666666667, 0.725, 0.33333333333333
89264, 1.7416666666667, 0.7, 0.3125
89265, 1.7208333333333, 0.7, 0.33333333333333
89266, 1.7416666666667, 0.675, 0.33333333333333
89267, 1.7416666666667, 0.65, 0.3125
89268, 1.7208333333333, 0.65, 0.33333333333333
89269, 1.7416666666667, 0.625, 0.33333333333333
89270, 1.7416666666667, 0.6, 0.3125
89271, 1.7208333333333, 0.6, 0.33333333333333
89272, 1.7416666666667, 0.575, 0.33333333333333
89273, 1.7416666666667, 0.55, 0.3125
89274, 1.7208333333333, 0.55, 0.33333333333333
89275, 1.7416666666667, 0.525, 0.33333333333333
89276, 1.7416666666667, 0.5, 0.3125
89277, 1.7208333333333, 0.5, 0.33333333333333
89278, 1.7416666666667, 0.475, 0.33333333333333
89279, 1.7416666666667, 0.45, 0.3125
89280, 1.7208333333333, 0.45, 0.33333333333333
89281, 1.7416666666667, 0.425, 0.33333333333333
89282, 1.7416666666667, 0.4, 0.3125
89283, 1.7208333333333, 0.4, 0.33333333333333
89284, 1.7416666666667, 0.375, 0.33333333333333
89285, 1.7416666666667, 0.35, 0.3125
89286, 1.7208333333333, 0.35, 0.33333333333333
89287, 1.7416666666667, 0.325, 0.33333333333333
89288, 1.7416666666667, 0.3, 0.3125
89289, 1.7208333333333, 0.3, 0.33333333333333
89290, 1.7416666666667, 0.275, 0.33333333333333
89291, 1.7416666666667, 0.25, 0.3125
89292, 1.7208333333333, 0.25, 0.33333333333333
89293, 1.7416666666667, 0.225, 0.33333333333333
89294, 1.7416666666667, 0.2, 0.3125
89295, 1.7208333333333, 0.2, 0.33333333333333
89296, 1.7416666666667, 0.175, 0.33333333333333
89297, 1.7833333333333, 1.325, 0.33333333333333
89298, 1.7833333333333, 1.3, 0.3125
89299, 1.7625, 1.3, 0.33333333333333
89300, 1.7833333333333, 1.275, 0.33333333333333
89301, 1.7833333333333, 1.25, 0.3125
89302, 1.7625, 1.25, 0.33333333333333
89303, 1.7833333333333, 1.225, 0.33333333333333
89304, 1.7833333333333, 1.2, 0.3125
89305, 1.7625, 1.2, 0.33333333333333
89306, 1.7833333333333, 1.175, 0.33333333333333
89307, 1.7833333333333, 1.15, 0.3125
89308, 1.7625, 1.15, 0.33333333333333
89309, 1.7833333333333, 1.125, 0.33333333333333
89310, 1.7833333333333, 1.1, 0.3125
89311, 1.7625, 1.1, 0.33333333333333
89312, 1.7833333333333, 1.075, 0.33333333333333
89313, 1.7833333333333, 1.05, 0.3125
89314, 1.7625, 1.05, 0.33333333333333
89315, 1.7833333333333, 1.025, 0.33333333333333
89316, 1.7833333333333, 1, 0.3125
89317, 1.7625, 1, 0.33333333333333
89318, 1.7833333333333, 0.975, 0.33333333333333
89319, 1.7833333333333, 0.95, 0.3125
89320, 1.7625, 0.95, 0.33333333333333
89321, 1.7833333333333, 0.925, 0.33333333333333
89322, 1.7833333333333, 0.9, 0.3125
89323, 1.7625, 0.9, 0.33333333333333
89324, 1.7833333333333, 0.875, 0.33333333333333
89325, 1.7833333333333, 0.85, 0.3125
89326, 1.7625, 0.85, 0.33333333333333
89327, 1.7833333333333, 0.825, 0.33333333333333
89328, 1.7833333333333, 0.8, 0.3125
89329, 1.7625, 0.8, 0.33333333333333
89330, 1.7833333333333, 0.775, 0.33333333333333
89331, 1.7833333333333, 0.75, 0.3125
89332, 1.7625, 0.75, 0.33333333333333
89333, 1.7833333333333, 0.725, 0.33333333333333
89334, 1.7833333333333, 0.7, 0.3125
89335, 1.7625, 0.7, 0.33333333333333
89336, 1.7833333333333, 0.675, 0.33333333333333
89337, 1.7833333333333, 0.65, 0.3125
89338, 1.7625, 0.65, 0.33333333333333
89339, 1.7833333333333, 0.625, 0.33333333333333
89340, 1.7833333333333, 0.6, 0.3125
89341, 1.7625, 0.6, 0.33333333333333
89342, 1.7833333333333, 0.575, 0.33333333333333
89343, 1.7833333333333, 0.55, 0.3125
89344, 1.7625, 0.55, 0.33333333333333
89345, 1.7833333333333, 0.525, 0.33333333333333
89346, 1.7833333333333, 0.5, 0.3125
89347, 1.7625, 0.5, 0.33333333333333
89348, 1.7833333333333, 0.475, 0.33333333333333
89349, 1.7833333333333, 0.45, 0.3125
89350, 1.7625, 0.45, 0.33333333333333
89351, 1.7833333333333, 0.425, 0.33333333333333
89352, 1.7833333333333, 0.4, 0.3125
89353, 1.7625, 0.4, 0.33333333333333
89354, 1.7833333333333, 0.375, 0.33333333333333
89355, 1.7833333333333, 0.35, 0.3125
89356, 1.7625, 0.35, 0.33333333333333
89357, 1.7833333333333, 0.325, 0.33333333333333
89358, 1.7833333333333, 0.3, 0.3125
89359, 1.7625, 0.3, 0.33333333333333
89360, 1.7833333333333, 0.275, 0.33333333333333
89361, 1.7833333333333, 0.25, 0.3125
89362, 1.7625, 0.25, 0.33333333333333
89363, 1.7833333333333, 0.225, 0.33333333333333
89364, 1.7833333333333, 0.2, 0.3125
89365, 1.7625, 0.2, 0.33333333333333
89366, 1.7833333333333, 0.175, 0.33333333333333
89367, 1.825, 1.325, 0.33333333333333
89368, 1.825, 1.3, 0.3125
89369, 1.8041666666667, 1.3, 0.33333333333333
89370, 1.825, 1.275, 0.33333333333333
89371, 1.825, 1.25, 0.3125
89372, 1.8041666666667, 1.25, 0.33333333333333
89373, 1.825, 1.225, 0.33333333333333
89374, 1.825, 1.2, 0.3125
89375, 1.8041666666667, 1.2, 0.33333333333333
89376, 1.825, 1.175, 0.33333333333333
89377, 1.825, 1.15, 0.3125
89378, 1.8041666666667, 1.15, 0.33333333333333
89379, 1.825, 1.125, 0.33333333333333
89380, 1.825, 1.1, 0.3125
89381, 1.8041666666667, 1.1, 0.33333333333333
89382, 1.825, 1.075, 0.33333333333333
89383, 1.825, 1.05, 0.3125
89384, 1.8041666666667, 1.05, 0.33333333333333
89385, 1.825, 1.025, 0.33333333333333
89386, 1.825, 1, 0.3125
89387, 1.8041666666667, 1, 0.33333333333333
89388, 1.825, 0.975, 0.33333333333333
89389, 1.825, 0.95, 0.3125
89390, 1.8041666666667, 0.95, 0.33333333333333
89391, 1.825, 0.925, 0.33333333333333
89392, 1.825, 0.9, 0.3125
89393, 1.8041666666667, 0.9, 0.33333333333333
89394, 1.825, 0.875, 0.33333333333333
89395, 1.825, 0.85, 0.3125
89396, 1.8041666666667, 0.85, 0.33333333333333
89397, 1.825, 0.825, 0.33333333333333
89398, 1.825, 0.8, 0.3125
89399, 1.8041666666667, 0.8, 0.33333333333333
89400, 1.825, 0.775, 0.33333333333333
89401, 1.825, 0.75, 0.3125
89402, 1.8041666666667, 0.75, 0.33333333333333
89403, 1.825, 0.725, 0.33333333333333
89404, 1.825, 0.7, 0.3125
89405, 1.8041666666667, 0.7, 0.33333333333333
89406, 1.825, 0.675, 0.33333333333333
89407, 1.825, 0.65, 0.3125
89408, 1.8041666666667, 0.65, 0.33333333333333
89409, 1.825, 0.625, 0.33333333333333
89410, 1.825, 0.6, 0.3125
89411, 1.8041666666667, 0.6, 0.33333333333333
89412, 1.825, 0.575, 0.33333333333333
89413, 1.825, 0.55, 0.3125
89414, 1.8041666666667, 0.55, 0.33333333333333
89415, 1.825, 0.525, 0.33333333333333
89416, 1.825, 0.5, 0.3125
89417, 1.8041666666667, 0.5, 0.33333333333333
89418, 1.825, 0.475, 0.33333333333333
89419, 1.825, 0.45, 0.3125
89420, 1.8041666666667, 0.45, 0.33333333333333
89421, 1.825, 0.425, 0.33333333333333
89422, 1.825, 0.4, 0.3125
89423, 1.8041666666667, 0.4, 0.33333333333333
89424, 1.825, 0.375, 0.33333333333333
89425, 1.825, 0.35, 0.3125
89426, 1.8041666666667, 0.35, 0.33333333333333
89427, 1.825, 0.325, 0.33333333333333
89428, 1.825, 0.3, 0.3125
89429, 1.8041666666667, 0.3, 0.33333333333333
89430, 1.825, 0.275, 0.33333333333333
89431, 1.825, 0.25, 0.3125
89432, 1.8041666666667, 0.25, 0.33333333333333
89433, 1.825, 0.225, 0.33333333333333
89434, 1.825, 0.2, 0.3125
89435, 1.8041666666667, 0.2, 0.33333333333333
89436, 1.825, 0.175, 0.33333333333333
89437, 1.8666666666667, 1.325, 0.33333333333333
89438, 1.8666666666667, 1.3, 0.3125
89439, 1.8458333333333, 1.3, 0.33333333333333
89440, 1.8666666666667, 1.275, 0.33333333333333
89441, 1.8666666666667, 1.25, 0.3125
89442, 1.8458333333333, 1.25, 0.33333333333333
89443, 1.8666666666667, 1.225, 0.33333333333333
89444, 1.8666666666667, 1.2, 0.3125
89445, 1.8458333333333, 1.2, 0.33333333333333
89446, 1.8666666666667, 1.175, 0.33333333333333
89447, 1.8666666666667, 1.15, 0.3125
89448, 1.8458333333333, 1.15, 0.33333333333333
89449, 1.8666666666667, 1.125, 0.33333333333333
89450, 1.8666666666667, 1.1, 0.3125
89451, 1.8458333333333, 1.1, 0.33333333333333
89452, 1.8666666666667, 1.075, 0.33333333333333
89453, 1.8666666666667, 1.05, 0.3125
89454, 1.8458333333333, 1.05, 0.33333333333333
89455, 1.8666666666667, 1.025, 0.33333333333333
89456, 1.8666666666667, 1, 0.3125
89457, 1.8458333333333, 1, 0.33333333333333
89458, 1.8666666666667, 0.975, 0.33333333333333
89459, 1.8666666666667, 0.95, 0.3125
89460, 1.8458333333333, 0.95, 0.33333333333333
89461, 1.8666666666667, 0.925, 0.33333333333333
89462, 1.8666666666667, 0.9, 0.3125
89463, 1.8458333333333, 0.9, 0.33333333333333
89464, 1.8666666666667, 0.875, 0.33333333333333
89465, 1.8666666666667, 0.85, 0.3125
89466, 1.8458333333333, 0.85, 0.33333333333333
89467, 1.8666666666667, 0.825, 0.33333333333333
89468, 1.8666666666667, 0.8, 0.3125
89469, 1.8458333333333, 0.8, 0.33333333333333
89470, 1.8666666666667, 0.775, 0.33333333333333
89471, 1.8666666666667, 0.75, 0.3125
89472, 1.8458333333333, 0.75, 0.33333333333333
89473, 1.8666666666667, 0.725, 0.33333333333333
89474, 1.8666666666667, 0.7, 0.3125
89475, 1.8458333333333, 0.7, 0.33333333333333
89476, 1.8666666666667, 0.675, 0.33333333333333
89477, 1.8666666666667, 0.65, 0.3125
89478, 1.8458333333333, 0.65, 0.33333333333333
89479, 1.8666666666667, 0.625, 0.33333333333333
89480, 1.8666666666667, 0.6, 0.3125
89481, 1.8458333333333, 0.6, 0.33333333333333
89482, 1.8666666666667, 0.575, 0.33333333333333
89483, 1.8666666666667, 0.55, 0.3125
89484, 1.8458333333333, 0.55, 0.33333333333333
89485, 1.8666666666667, 0.525, 0.33333333333333
89486, 1.8666666666667, 0.5, 0.3125
89487, 1.8458333333333, 0.5, 0.33333333333333
89488, 1.8666666666667, 0.475, 0.33333333333333
89489, 1.8666666666667, 0.45, 0.3125
89490, 1.8458333333333, 0.45, 0.33333333333333
89491, 1.8666666666667, 0.425, 0.33333333333333
89492, 1.8666666666667, 0.4, 0.3125
89493, 1.8458333333333, 0.4, 0.33333333333333
89494, 1.8666666666667, 0.375, 0.33333333333333
89495, 1.8666666666667, 0.35, 0.3125
89496, 1.8458333333333, 0.35, 0.33333333333333
89497, 1.8666666666667, 0.325, 0.33333333333333
89498, 1.8666666666667, 0.3, 0.3125
89499, 1.8458333333333, 0.3, 0.33333333333333
89500, 1.8666666666667, 0.275, 0.33333333333333
89501, 1.8666666666667, 0.25, 0.3125
89502, 1.8458333333333, 0.25, 0.33333333333333
89503, 1.8666666666667, 0.225, 0.33333333333333
89504, 1.8666666666667, 0.2, 0.3125
89505, 1.8458333333333, 0.2, 0.33333333333333
89506, 1.8666666666667, 0.175, 0.33333333333333
89507, 1.9083333333333, 1.325, 0.33333333333333
89508, 1.9083333333333, 1.3, 0.3125
89509, 1.8875, 1.3, 0.33333333333333
89510, 1.9083333333333, 1.275, 0.33333333333333
89511, 1.9083333333333, 1.25, 0.3125
89512, 1.8875, 1.25, 0.33333333333333
89513, 1.9083333333333, 1.225, 0.33333333333333
89514, 1.9083333333333, 1.2, 0.3125
89515, 1.8875, 1.2, 0.33333333333333
89516, 1.9083333333333, 1.175, 0.33333333333333
89517, 1.9083333333333, 1.15, 0.3125
89518, 1.8875, 1.15, 0.33333333333333
89519, 1.9083333333333, 1.125, 0.33333333333333
89520, 1.9083333333333, 1.1, 0.3125
89521, 1.8875, 1.1, 0.33333333333333
89522, 1.9083333333333, 1.075, 0.33333333333333
89523, 1.9083333333333, 1.05, 0.3125
89524, 1.8875, 1.05, 0.33333333333333
89525, 1.9083333333333, 1.025, 0.33333333333333
89526, 1.9083333333333, 1, 0.3125
89527, 1.8875, 1, 0.33333333333333
89528, 1.9083333333333, 0.975, 0.33333333333333
89529, 1.9083333333333, 0.95, 0.3125
89530, 1.8875, 0.95, 0.33333333333333
89531, 1.9083333333333, 0.925, 0.33333333333333
89532, 1.9083333333333, 0.9, 0.3125
89533, 1.8875, 0.9, 0.33333333333333
89534, 1.9083333333333, 0.875, 0.33333333333333
89535, 1.9083333333333, 0.85, 0.3125
89536, 1.8875, 0.85, 0.33333333333333
89537, 1.9083333333333, 0.825, 0.33333333333333
89538, 1.9083333333333, 0.8, 0.3125
89539, 1.8875, 0.8, 0.33333333333333
89540, 1.9083333333333, 0.775, 0.33333333333333
89541, 1.9083333333333, 0.75, 0.3125
89542, 1.8875, 0.75, 0.33333333333333
89543, 1.9083333333333, 0.725, 0.33333333333333
89544, 1.9083333333333, 0.7, 0.3125
89545, 1.8875, 0.7, 0.33333333333333
89546, 1.9083333333333, 0.675, 0.33333333333333
89547, 1.9083333333333, 0.65, 0.3125
89548, 1.8875, 0.65, 0.33333333333333
89549, 1.9083333333333, 0.625, 0.33333333333333
89550, 1.9083333333333, 0.6, 0.3125
89551, 1.8875, 0.6, 0.33333333333333
89552, 1.9083333333333, 0.575, 0.33333333333333
89553, 1.9083333333333, 0.55, 0.3125
89554, 1.8875, 0.55, 0.33333333333333
89555, 1.9083333333333, 0.525, 0.33333333333333
89556, 1.9083333333333, 0.5, 0.3125
89557, 1.8875, 0.5, 0.33333333333333
89558, 1.9083333333333, 0.475, 0.33333333333333
89559, 1.9083333333333, 0.45, 0.3125
89560, 1.8875, 0.45, 0.33333333333333
89561, 1.9083333333333, 0.425, 0.33333333333333
89562, 1.9083333333333, 0.4, 0.3125
89563, 1.8875, 0.4, 0.33333333333333
89564, 1.9083333333333, 0.375, 0.33333333333333
89565, 1.9083333333333, 0.35, 0.3125
89566, 1.8875, 0.35, 0.33333333333333
89567, 1.9083333333333, 0.325, 0.33333333333333
89568, 1.9083333333333, 0.3, 0.3125
89569, 1.8875, 0.3, 0.33333333333333
89570, 1.9083333333333, 0.275, 0.33333333333333
89571, 1.9083333333333, 0.25, 0.3125
89572, 1.8875, 0.25, 0.33333333333333
89573, 1.9083333333333, 0.225, 0.33333333333333
89574, 1.9083333333333, 0.2, 0.3125
89575, 1.8875, 0.2, 0.33333333333333
89576, 1.9083333333333, 0.175, 0.33333333333333
89577, 1.95, 1.325, 0.33333333333333
89578, 1.95, 1.3, 0.3125
89579, 1.9291666666667, 1.3, 0.33333333333333
89580, 1.95, 1.275, 0.33333333333333
89581, 1.95, 1.25, 0.3125
89582, 1.9291666666667, 1.25, 0.33333333333333
89583, 1.95, 1.225, 0.33333333333333
89584, 1.95, 1.2, 0.3125
89585, 1.9291666666667, 1.2, 0.33333333333333
89586, 1.95, 1.175, 0.33333333333333
89587, 1.95, 1.15, 0.3125
89588, 1.9291666666667, 1.15, 0.33333333333333
89589, 1.95, 1.125, 0.33333333333333
89590, 1.95, 1.1, 0.3125
89591, 1.9291666666667, 1.1, 0.33333333333333
89592, 1.95, 1.075, 0.33333333333333
89593, 1.95, 1.05, 0.3125
89594, 1.9291666666667, 1.05, 0.33333333333333
89595, 1.95, 1.025, 0.33333333333333
89596, 1.95, 1, 0.3125
89597, 1.9291666666667, 1, 0.33333333333333
89598, 1.95, 0.975, 0.33333333333333
89599, 1.95, 0.95, 0.3125
89600, 1.9291666666667, 0.95, 0.33333333333333
89601, 1.95, 0.925, 0.33333333333333
89602, 1.95, 0.9, 0.3125
89603, 1.9291666666667, 0.9, 0.33333333333333
89604, 1.95, 0.875, 0.33333333333333
89605, 1.95, 0.85, 0.3125
89606, 1.9291666666667, 0.85, 0.33333333333333
89607, 1.95, 0.825, 0.33333333333333
89608, 1.95, 0.8, 0.3125
89609, 1.9291666666667, 0.8, 0.33333333333333
89610, 1.95, 0.775, 0.33333333333333
89611, 1.95, 0.75, 0.3125
89612, 1.9291666666667, 0.75, 0.33333333333333
89613, 1.95, 0.725, 0.33333333333333
89614, 1.95, 0.7, 0.3125
89615, 1.9291666666667, 0.7, 0.33333333333333
89616, 1.95, 0.675, 0.33333333333333
89617, 1.95, 0.65, 0.3125
89618, 1.9291666666667, 0.65, 0.33333333333333
89619, 1.95, 0.625, 0.33333333333333
89620, 1.95, 0.6, 0.3125
89621, 1.9291666666667, 0.6, 0.33333333333333
89622, 1.95, 0.575, 0.33333333333333
89623, 1.95, 0.55, 0.3125
89624, 1.9291666666667, 0.55, 0.33333333333333
89625, 1.95, 0.525, 0.33333333333333
89626, 1.95, 0.5, 0.3125
89627, 1.9291666666667, 0.5, 0.33333333333333
89628, 1.95, 0.475, 0.33333333333333
89629, 1.95, 0.45, 0.3125
89630, 1.9291666666667, 0.45, 0.33333333333333
89631, 1.95, 0.425, 0.33333333333333
89632, 1.95, 0.4, 0.3125
89633, 1.9291666666667, 0.4, 0.33333333333333
89634, 1.95, 0.375, 0.33333333333333
89635, 1.95, 0.35, 0.3125
89636, 1.9291666666667, 0.35, 0.33333333333333
89637, 1.95, 0.325, 0.33333333333333
89638, 1.95, 0.3, 0.3125
89639, 1.9291666666667, 0.3, 0.33333333333333
89640, 1.95, 0.275, 0.33333333333333
89641, 1.95, 0.25, 0.3125
89642, 1.9291666666667, 0.25, 0.33333333333333
89643, 1.95, 0.225, 0.33333333333333
89644, 1.95, 0.2, 0.3125
89645, 1.9291666666667, 0.2, 0.33333333333333
89646, 1.95, 0.175, 0.33333333333333
89647, 1.9916666666667, 1.325, 0.33333333333333
89648, 1.9916666666667, 1.3, 0.3125
89649, 1.9708333333333, 1.3, 0.33333333333333
89650, 1.9916666666667, 1.275, 0.33333333333333
89651, 1.9916666666667, 1.25, 0.3125
89652, 1.9708333333333, 1.25, 0.33333333333333
89653, 1.9916666666667, 1.225, 0.33333333333333
89654, 1.9916666666667, 1.2, 0.3125
89655, 1.9708333333333, 1.2, 0.33333333333333
89656, 1.9916666666667, 1.175, 0.33333333333333
89657, 1.9916666666667, 1.15, 0.3125
89658, 1.9708333333333, 1.15, 0.33333333333333
89659, 1.9916666666667, 1.125, 0.33333333333333
89660, 1.9916666666667, 1.1, 0.3125
89661, 1.9708333333333, 1.1, 0.33333333333333
89662, 1.9916666666667, 1.075, 0.33333333333333
89663, 1.9916666666667, 1.05, 0.3125
89664, 1.9708333333333, 1.05, 0.33333333333333
89665, 1.9916666666667, 1.025, 0.33333333333333
89666, 1.9916666666667, 1, 0.3125
89667, 1.9708333333333, 1, 0.33333333333333
89668, 1.9916666666667, 0.975, 0.33333333333333
89669, 1.9916666666667, 0.95, 0.3125
89670, 1.9708333333333, 0.95, 0.33333333333333
89671, 1.9916666666667, 0.925, 0.33333333333333
89672, 1.9916666666667, 0.9, 0.3125
89673, 1.9708333333333, 0.9, 0.33333333333333
89674, 1.9916666666667, 0.875, 0.33333333333333
89675, 1.9916666666667, 0.85, 0.3125
89676, 1.9708333333333, 0.85, 0.33333333333333
89677, 1.9916666666667, 0.825, 0.33333333333333
89678, 1.9916666666667, 0.8, 0.3125
89679, 1.9708333333333, 0.8, 0.33333333333333
89680, 1.9916666666667, 0.775, 0.33333333333333
89681, 1.9916666666667, 0.75, 0.3125
89682, 1.9708333333333, 0.75, 0.33333333333333
89683, 1.9916666666667, 0.725, 0.33333333333333
89684, 1.9916666666667, 0.7, 0.3125
89685, 1.9708333333333, 0.7, 0.33333333333333
89686, 1.9916666666667, 0.675, 0.33333333333333
89687, 1.9916666666667, 0.65, 0.3125
89688, 1.9708333333333, 0.65, 0.33333333333333
89689, 1.9916666666667, 0.625, 0.33333333333333
89690, 1.9916666666667, 0.6, 0.3125
89691, 1.9708333333333, 0.6, 0.33333333333333
89692, 1.9916666666667, 0.575, 0.33333333333333
89693, 1.9916666666667, 0.55, 0.3125
89694, 1.9708333333333, 0.55, 0.33333333333333
89695, 1.9916666666667, 0.525, 0.33333333333333
89696, 1.9916666666667, 0.5, 0.3125
89697, 1.9708333333333, 0.5, 0.33333333333333
89698, 1.9916666666667, 0.475, 0.33333333333333
89699, 1.9916666666667, 0.45, 0.3125
89700, 1.9708333333333, 0.45, 0.33333333333333
89701, 1.9916666666667, 0.425, 0.33333333333333
89702, 1.9916666666667, 0.4, 0.3125
89703, 1.9708333333333, 0.4, 0.33333333333333
89704, 1.9916666666667, 0.375, 0.33333333333333
89705, 1.9916666666667, 0.35, 0.3125
89706, 1.9708333333333, 0.35, 0.33333333333333
89707, 1.9916666666667, 0.325, 0.33333333333333
89708, 1.9916666666667, 0.3, 0.3125
89709, 1.9708333333333, 0.3, 0.33333333333333
89710, 1.9916666666667, 0.275, 0.33333333333333
89711, 1.9916666666667, 0.25, 0.3125
89712, 1.9708333333333, 0.25, 0.33333333333333
89713, 1.9916666666667, 0.225, 0.33333333333333
89714, 1.9916666666667, 0.2, 0.3125
89715, 1.9708333333333, 0.2, 0.33333333333333
89716, 1.9916666666667, 0.175, 0.33333333333333
89717, 2.0333333333333, 1.325, 0.33333333333333
89718, 2.0333333333333, 1.3, 0.3125
89719, 2.0125, 1.3, 0.33333333333333
89720, 2.0333333333333, 1.275, 0.33333333333333
89721, 2.0333333333333, 1.25, 0.3125
89722, 2.0125, 1.25, 0.33333333333333
89723, 2.0333333333333, 1.225, 0.33333333333333
89724, 2.0333333333333, 1.2, 0.3125
89725, 2.0125, 1.2, 0.33333333333333
89726, 2.0333333333333, 1.175, 0.33333333333333
89727, 2.0333333333333, 1.15, 0.3125
89728, 2.0125, 1.15, 0.33333333333333
89729, 2.0333333333333, 1.125, 0.33333333333333
89730, 2.0333333333333, 1.1, 0.3125
89731, 2.0125, 1.1, 0.33333333333333
89732, 2.0333333333333, 1.075, 0.33333333333333
89733, 2.0333333333333, 1.05, 0.3125
89734, 2.0125, 1.05, 0.33333333333333
89735, 2.0333333333333, 1.025, 0.33333333333333
89736, 2.0333333333333, 1, 0.3125
89737, 2.0125, 1, 0.33333333333333
89738, 2.0333333333333, 0.975, 0.33333333333333
89739, 2.0333333333333, 0.95, 0.3125
89740, 2.0125, 0.95, 0.33333333333333
89741, 2.0333333333333, 0.925, 0.33333333333333
89742, 2.0333333333333, 0.9, 0.3125
89743, 2.0125, 0.9, 0.33333333333333
89744, 2.0333333333333, 0.875, 0.33333333333333
89745, 2.0333333333333, 0.85, 0.3125
89746, 2.0125, 0.85, 0.33333333333333
89747, 2.0333333333333, 0.825, 0.33333333333333
89748, 2.0333333333333, 0.8, 0.3125
89749, 2.0125, 0.8, 0.33333333333333
89750, 2.0333333333333, 0.775, 0.33333333333333
89751, 2.0333333333333, 0.75, 0.3125
89752, 2.0125, 0.75, 0.33333333333333
89753, 2.0333333333333, 0.725, 0.33333333333333
89754, 2.0333333333333, 0.7, 0.3125
89755, 2.0125, 0.7, 0.33333333333333
89756, 2.0333333333333, 0.675, 0.33333333333333
89757, 2.0333333333333, 0.65, 0.3125
89758, 2.0125, 0.65, 0.33333333333333
89759, 2.0333333333333, 0.625, 0.33333333333333
89760, 2.0333333333333, 0.6, 0.3125
89761, 2.0125, 0.6, 0.33333333333333
89762, 2.0333333333333, 0.575, 0.33333333333333
89763, 2.0333333333333, 0.55, 0.3125
89764, 2.0125, 0.55, 0.33333333333333
89765, 2.0333333333333, 0.525, 0.33333333333333
89766, 2.0333333333333, 0.5, 0.3125
89767, 2.0125, 0.5, 0.33333333333333
89768, 2.0333333333333, 0.475, 0.33333333333333
89769, 2.0333333333333, 0.45, 0.3125
89770, 2.0125, 0.45, 0.33333333333333
89771, 2.0333333333333, 0.425, 0.33333333333333
89772, 2.0333333333333, 0.4, 0.3125
89773, 2.0125, 0.4, 0.33333333333333
89774, 2.0333333333333, 0.375, 0.33333333333333
89775, 2.0333333333333, 0.35, 0.3125
89776, 2.0125, 0.35, 0.33333333333333
89777, 2.0333333333333, 0.325, 0.33333333333333
89778, 2.0333333333333, 0.3, 0.3125
89779, 2.0125, 0.3, 0.33333333333333
89780, 2.0333333333333, 0.275, 0.33333333333333
89781, 2.0333333333333, 0.25, 0.3125
89782, 2.0125, 0.25, 0.33333333333333
89783, 2.0333333333333, 0.225, 0.33333333333333
89784, 2.0333333333333, 0.2, 0.3125
89785, 2.0125, 0.2, 0.33333333333333
89786, 2.0333333333333, 0.175, 0.33333333333333
89787, 2.075, 1.325, 0.33333333333333
89788, 2.075, 1.3, 0.3125
89789, 2.0541666666667, 1.3, 0.33333333333333
89790, 2.075, 1.275, 0.33333333333333
89791, 2.075, 1.25, 0.3125
89792, 2.0541666666667, 1.25, 0.33333333333333
89793, 2.075, 1.225, 0.33333333333333
89794, 2.075, 1.2, 0.3125
89795, 2.0541666666667, 1.2, 0.33333333333333
89796, 2.075, 1.175, 0.33333333333333
89797, 2.075, 1.15, 0.3125
89798, 2.0541666666667, 1.15, 0.33333333333333
89799, 2.075, 1.125, 0.33333333333333
89800, 2.075, 1.1, 0.3125
89801, 2.0541666666667, 1.1, 0.33333333333333
89802, 2.075, 1.075, 0.33333333333333
89803, 2.075, 1.05, 0.3125
89804, 2.0541666666667, 1.05, 0.33333333333333
89805, 2.075, 1.025, 0.33333333333333
89806, 2.075, 1, 0.3125
89807, 2.0541666666667, 1, 0.33333333333333
89808, 2.075, 0.975, 0.33333333333333
89809, 2.075, 0.95, 0.3125
89810, 2.0541666666667, 0.95, 0.33333333333333
89811, 2.075, 0.925, 0.33333333333333
89812, 2.075, 0.9, 0.3125
89813, 2.0541666666667, 0.9, 0.33333333333333
89814, 2.075, 0.875, 0.33333333333333
89815, 2.075, 0.85, 0.3125
89816, 2.0541666666667, 0.85, 0.33333333333333
89817, 2.075, 0.825, 0.33333333333333
89818, 2.075, 0.8, 0.3125
89819, 2.0541666666667, 0.8, 0.33333333333333
89820, 2.075, 0.775, 0.33333333333333
89821, 2.075, 0.75, 0.3125
89822, 2.0541666666667, 0.75, 0.33333333333333
89823, 2.075, 0.725, 0.33333333333333
89824, 2.075, 0.7, 0.3125
89825, 2.0541666666667, 0.7, 0.33333333333333
89826, 2.075, 0.675, 0.33333333333333
89827, 2.075, 0.65, 0.3125
89828, 2.0541666666667, 0.65, 0.33333333333333
89829, 2.075, 0.625, 0.33333333333333
89830, 2.075, 0.6, 0.3125
89831, 2.0541666666667, 0.6, 0.33333333333333
89832, 2.075, 0.575, 0.33333333333333
89833, 2.075, 0.55, 0.3125
89834, 2.0541666666667, 0.55, 0.33333333333333
89835, 2.075, 0.525, 0.33333333333333
89836, 2.075, 0.5, 0.3125
89837, 2.0541666666667, 0.5, 0.33333333333333
89838, 2.075, 0.475, 0.33333333333333
89839, 2.075, 0.45, 0.3125
89840, 2.0541666666667, 0.45, 0.33333333333333
89841, 2.075, 0.425, 0.33333333333333
89842, 2.075, 0.4, 0.3125
89843, 2.0541666666667, 0.4, 0.33333333333333
89844, 2.075, 0.375, 0.33333333333333
89845, 2.075, 0.35, 0.3125
89846, 2.0541666666667, 0.35, 0.33333333333333
89847, 2.075, 0.325, 0.33333333333333
89848, 2.075, 0.3, 0.3125
89849, 2.0541666666667, 0.3, 0.33333333333333
89850, 2.075, 0.275, 0.33333333333333
89851, 2.075, 0.25, 0.3125
89852, 2.0541666666667, 0.25, 0.33333333333333
89853, 2.075, 0.225, 0.33333333333333
89854, 2.075, 0.2, 0.3125
89855, 2.0541666666667, 0.2, 0.33333333333333
89856, 2.075, 0.175, 0.33333333333333
89857, 2.1166666666667, 1.325, 0.33333333333333
89858, 2.1166666666667, 1.3, 0.3125
89859, 2.0958333333333, 1.3, 0.33333333333333
89860, 2.1166666666667, 1.275, 0.33333333333333
89861, 2.1166666666667, 1.25, 0.3125
89862, 2.0958333333333, 1.25, 0.33333333333333
89863, 2.1166666666667, 1.225, 0.33333333333333
89864, 2.1166666666667, 1.2, 0.3125
89865, 2.0958333333333, 1.2, 0.33333333333333
89866, 2.1166666666667, 1.175, 0.33333333333333
89867, 2.1166666666667, 1.15, 0.3125
89868, 2.0958333333333, 1.15, 0.33333333333333
89869, 2.1166666666667, 1.125, 0.33333333333333
89870, 2.1166666666667, 1.1, 0.3125
89871, 2.0958333333333, 1.1, 0.33333333333333
89872, 2.1166666666667, 1.075, 0.33333333333333
89873, 2.1166666666667, 1.05, 0.3125
89874, 2.0958333333333, 1.05, 0.33333333333333
89875, 2.1166666666667, 1.025, 0.33333333333333
89876, 2.1166666666667, 1, 0.3125
89877, 2.0958333333333, 1, 0.33333333333333
