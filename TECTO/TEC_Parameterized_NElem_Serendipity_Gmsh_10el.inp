15949, 38883, 4162, 4161, 38837, 38884, 4173, 4172, 38838, 40094, 4433, 39931, 40095, 40097, 4456, 39934, 
40098, 40096, 4457, 4455, 39933
15950, 38884, 4173, 4172, 38838, 38885, 4184, 4183, 38839, 40097, 4456, 39934, 40098, 40100, 4479, 39937, 
40101, 40099, 4480, 4478, 39936
15951, 38885, 4184, 4183, 38839, 38886, 4195, 4194, 38840, 40100, 4479, 39937, 40101, 40103, 4502, 39940, 
40104, 40102, 4503, 4501, 39939
15952, 38886, 4195, 4194, 38840, 38887, 4206, 4205, 38841, 40103, 4502, 39940, 40104, 40106, 4525, 39943, 
40107, 40105, 4526, 4524, 39942
15953, 38887, 4206, 4205, 38841, 38888, 4217, 4216, 38842, 40106, 4525, 39943, 40107, 40109, 4548, 39946, 
40110, 40108, 4549, 4547, 39945
15954, 38888, 4217, 4216, 38842, 38889, 4228, 4227, 38843, 40109, 4548, 39946, 40110, 40112, 4571, 39949, 
40113, 40111, 4572, 4570, 39948
15955, 38889, 4228, 4227, 38843, 38890, 4239, 4238, 38844, 40112, 4571, 39949, 40113, 40115, 4594, 39952, 
40116, 40114, 4595, 4593, 39951
15956, 38890, 4239, 4238, 38844, 38891, 4250, 4249, 38845, 40115, 4594, 39952, 40116, 40118, 4617, 39955, 
40119, 40117, 4618, 4616, 39954
15957, 38891, 4250, 4249, 38845, 38892, 4261, 4260, 38846, 40118, 4617, 39955, 40119, 40121, 4640, 39958, 
40122, 40120, 4641, 4639, 39957
15958, 38892, 4261, 4260, 38846, 38893, 4272, 4271, 38847, 40121, 4640, 39958, 40122, 40124, 4663, 39961, 
40125, 40123, 4664, 4662, 39960
15959, 38893, 4272, 4271, 38847, 38894, 4283, 4282, 38848, 40124, 4663, 39961, 40125, 40127, 4686, 39964, 
40128, 40126, 4687, 4685, 39963
15960, 38894, 4283, 4282, 38848, 38895, 4294, 4293, 38849, 40127, 4686, 39964, 40128, 40130, 4709, 39967, 
40131, 40129, 4710, 4708, 39966
15961, 38895, 4294, 4293, 38849, 38896, 4305, 4304, 38850, 40130, 4709, 39967, 40131, 40133, 4732, 39970, 
40134, 40132, 4733, 4731, 39969
15962, 38896, 4305, 4304, 38850, 38897, 4316, 4315, 38851, 40133, 4732, 39970, 40134, 40136, 4755, 39973, 
40137, 40135, 4756, 4754, 39972
15963, 38897, 4316, 4315, 38851, 38898, 4327, 4326, 38852, 40136, 4755, 39973, 40137, 40139, 4778, 39976, 
40140, 40138, 4779, 4777, 39975
15964, 38898, 4327, 4326, 38852, 38899, 4338, 4337, 38853, 40139, 4778, 39976, 40140, 40142, 4801, 39979, 
40143, 40141, 4802, 4800, 39978
15965, 38899, 4338, 4337, 38853, 38900, 4349, 4348, 38854, 40142, 4801, 39979, 40143, 40145, 4824, 39982, 
40146, 40144, 4825, 4823, 39981
15966, 38900, 4349, 4348, 38854, 38901, 4360, 4359, 38855, 40145, 4824, 39982, 40146, 40148, 4847, 39985, 
40149, 40147, 4848, 4846, 39984
15967, 38901, 4360, 4359, 38855, 38902, 4371, 4370, 38856, 40148, 4847, 39985, 40149, 40151, 4870, 39988, 
40152, 40150, 4871, 4869, 39987
15968, 38902, 4371, 4370, 38856, 38903, 4382, 4381, 38857, 40151, 4870, 39988, 40152, 40154, 4893, 39991, 
40155, 40153, 4894, 4892, 39990
15969, 38903, 4382, 4381, 38857, 38904, 4393, 4392, 38858, 40154, 4893, 39991, 40155, 40157, 4916, 39994, 
40158, 40156, 4917, 4915, 39993
15970, 38904, 4393, 4392, 38858, 4078, 159, 158, 4076, 40157, 4916, 39994, 40158, 4119, 170, 4114, 
4118, 40159, 4933, 4932, 39996
15971, 4000, 3999, 3997, 3998, 38905, 38882, 38836, 38859, 4041, 4040, 4036, 4042, 40161, 40092, 39998, 
40162, 40160, 40090, 39927, 39997
15972, 38905, 38882, 38836, 38859, 38906, 38883, 38837, 38860, 40161, 40092, 39998, 40162, 40164, 40095, 40001, 
40165, 40163, 40093, 39930, 40000
15973, 38906, 38883, 38837, 38860, 38907, 38884, 38838, 38861, 40164, 40095, 40001, 40165, 40167, 40098, 40004, 
40168, 40166, 40096, 39933, 40003
15974, 38907, 38884, 38838, 38861, 38908, 38885, 38839, 38862, 40167, 40098, 40004, 40168, 40170, 40101, 40007, 
40171, 40169, 40099, 39936, 40006
15975, 38908, 38885, 38839, 38862, 38909, 38886, 38840, 38863, 40170, 40101, 40007, 40171, 40173, 40104, 40010, 
40174, 40172, 40102, 39939, 40009
15976, 38909, 38886, 38840, 38863, 38910, 38887, 38841, 38864, 40173, 40104, 40010, 40174, 40176, 40107, 40013, 
40177, 40175, 40105, 39942, 40012
15977, 38910, 38887, 38841, 38864, 38911, 38888, 38842, 38865, 40176, 40107, 40013, 40177, 40179, 40110, 40016, 
40180, 40178, 40108, 39945, 40015
15978, 38911, 38888, 38842, 38865, 38912, 38889, 38843, 38866, 40179, 40110, 40016, 40180, 40182, 40113, 40019, 
40183, 40181, 40111, 39948, 40018
15979, 38912, 38889, 38843, 38866, 38913, 38890, 38844, 38867, 40182, 40113, 40019, 40183, 40185, 40116, 40022, 
40186, 40184, 40114, 39951, 40021
15980, 38913, 38890, 38844, 38867, 38914, 38891, 38845, 38868, 40185, 40116, 40022, 40186, 40188, 40119, 40025, 
40189, 40187, 40117, 39954, 40024
15981, 38914, 38891, 38845, 38868, 38915, 38892, 38846, 38869, 40188, 40119, 40025, 40189, 40191, 40122, 40028, 
40192, 40190, 40120, 39957, 40027
15982, 38915, 38892, 38846, 38869, 38916, 38893, 38847, 38870, 40191, 40122, 40028, 40192, 40194, 40125, 40031, 
40195, 40193, 40123, 39960, 40030
15983, 38916, 38893, 38847, 38870, 38917, 38894, 38848, 38871, 40194, 40125, 40031, 40195, 40197, 40128, 40034, 
40198, 40196, 40126, 39963, 40033
15984, 38917, 38894, 38848, 38871, 38918, 38895, 38849, 38872, 40197, 40128, 40034, 40198, 40200, 40131, 40037, 
40201, 40199, 40129, 39966, 40036
15985, 38918, 38895, 38849, 38872, 38919, 38896, 38850, 38873, 40200, 40131, 40037, 40201, 40203, 40134, 40040, 
40204, 40202, 40132, 39969, 40039
15986, 38919, 38896, 38850, 38873, 38920, 38897, 38851, 38874, 40203, 40134, 40040, 40204, 40206, 40137, 40043, 
40207, 40205, 40135, 39972, 40042
15987, 38920, 38897, 38851, 38874, 38921, 38898, 38852, 38875, 40206, 40137, 40043, 40207, 40209, 40140, 40046, 
40210, 40208, 40138, 39975, 40045
15988, 38921, 38898, 38852, 38875, 38922, 38899, 38853, 38876, 40209, 40140, 40046, 40210, 40212, 40143, 40049, 
40213, 40211, 40141, 39978, 40048
15989, 38922, 38899, 38853, 38876, 38923, 38900, 38854, 38877, 40212, 40143, 40049, 40213, 40215, 40146, 40052, 
40216, 40214, 40144, 39981, 40051
15990, 38923, 38900, 38854, 38877, 38924, 38901, 38855, 38878, 40215, 40146, 40052, 40216, 40218, 40149, 40055, 
40219, 40217, 40147, 39984, 40054
15991, 38924, 38901, 38855, 38878, 38925, 38902, 38856, 38879, 40218, 40149, 40055, 40219, 40221, 40152, 40058, 
40222, 40220, 40150, 39987, 40057
15992, 38925, 38902, 38856, 38879, 38926, 38903, 38857, 38880, 40221, 40152, 40058, 40222, 40224, 40155, 40061, 
40225, 40223, 40153, 39990, 40060
15993, 38926, 38903, 38857, 38880, 38927, 38904, 38858, 38881, 40224, 40155, 40061, 40225, 40227, 40158, 40064, 
40228, 40226, 40156, 39993, 40063
15994, 38927, 38904, 38858, 38881, 4079, 4078, 4076, 4077, 40227, 40158, 40064, 40228, 4121, 4118, 4116, 
4120, 40229, 40159, 39996, 40066
15995, 131, 4000, 3998, 130, 4944, 38905, 38859, 4943, 4043, 4042, 4038, 142, 40230, 40162, 40067, 
5204, 5203, 40160, 39997, 5201
15996, 4944, 38905, 38859, 4943, 4955, 38906, 38860, 4954, 40230, 40162, 40067, 5204, 40231, 40165, 40068, 
5227, 5226, 40163, 40000, 5224
15997, 4955, 38906, 38860, 4954, 4966, 38907, 38861, 4965, 40231, 40165, 40068, 5227, 40232, 40168, 40069, 
5250, 5249, 40166, 40003, 5247
15998, 4966, 38907, 38861, 4965, 4977, 38908, 38862, 4976, 40232, 40168, 40069, 5250, 40233, 40171, 40070, 
5273, 5272, 40169, 40006, 5270
15999, 4977, 38908, 38862, 4976, 4988, 38909, 38863, 4987, 40233, 40171, 40070, 5273, 40234, 40174, 40071, 
5296, 5295, 40172, 40009, 5293
16000, 4988, 38909, 38863, 4987, 4999, 38910, 38864, 4998, 40234, 40174, 40071, 5296, 40235, 40177, 40072, 
5319, 5318, 40175, 40012, 5316
16001, 4999, 38910, 38864, 4998, 5010, 38911, 38865, 5009, 40235, 40177, 40072, 5319, 40236, 40180, 40073, 
5342, 5341, 40178, 40015, 5339
16002, 5010, 38911, 38865, 5009, 5021, 38912, 38866, 5020, 40236, 40180, 40073, 5342, 40237, 40183, 40074, 
5365, 5364, 40181, 40018, 5362
16003, 5021, 38912, 38866, 5020, 5032, 38913, 38867, 5031, 40237, 40183, 40074, 5365, 40238, 40186, 40075, 
5388, 5387, 40184, 40021, 5385
16004, 5032, 38913, 38867, 5031, 5043, 38914, 38868, 5042, 40238, 40186, 40075, 5388, 40239, 40189, 40076, 
5411, 5410, 40187, 40024, 5408
16005, 5043, 38914, 38868, 5042, 5054, 38915, 38869, 5053, 40239, 40189, 40076, 5411, 40240, 40192, 40077, 
5434, 5433, 40190, 40027, 5431
16006, 5054, 38915, 38869, 5053, 5065, 38916, 38870, 5064, 40240, 40192, 40077, 5434, 40241, 40195, 40078, 
5457, 5456, 40193, 40030, 5454
16007, 5065, 38916, 38870, 5064, 5076, 38917, 38871, 5075, 40241, 40195, 40078, 5457, 40242, 40198, 40079, 
5480, 5479, 40196, 40033, 5477
16008, 5076, 38917, 38871, 5075, 5087, 38918, 38872, 5086, 40242, 40198, 40079, 5480, 40243, 40201, 40080, 
5503, 5502, 40199, 40036, 5500
16009, 5087, 38918, 38872, 5086, 5098, 38919, 38873, 5097, 40243, 40201, 40080, 5503, 40244, 40204, 40081, 
5526, 5525, 40202, 40039, 5523
16010, 5098, 38919, 38873, 5097, 5109, 38920, 38874, 5108, 40244, 40204, 40081, 5526, 40245, 40207, 40082, 
5549, 5548, 40205, 40042, 5546
16011, 5109, 38920, 38874, 5108, 5120, 38921, 38875, 5119, 40245, 40207, 40082, 5549, 40246, 40210, 40083, 
5572, 5571, 40208, 40045, 5569
16012, 5120, 38921, 38875, 5119, 5131, 38922, 38876, 5130, 40246, 40210, 40083, 5572, 40247, 40213, 40084, 
5595, 5594, 40211, 40048, 5592
16013, 5131, 38922, 38876, 5130, 5142, 38923, 38877, 5141, 40247, 40213, 40084, 5595, 40248, 40216, 40085, 
5618, 5617, 40214, 40051, 5615
16014, 5142, 38923, 38877, 5141, 5153, 38924, 38878, 5152, 40248, 40216, 40085, 5618, 40249, 40219, 40086, 
5641, 5640, 40217, 40054, 5638
16015, 5153, 38924, 38878, 5152, 5164, 38925, 38879, 5163, 40249, 40219, 40086, 5641, 40250, 40222, 40087, 
5664, 5663, 40220, 40057, 5661
16016, 5164, 38925, 38879, 5163, 5175, 38926, 38880, 5174, 40250, 40222, 40087, 5664, 40251, 40225, 40088, 
5687, 5686, 40223, 40060, 5684
16017, 5175, 38926, 38880, 5174, 5186, 38927, 38881, 5185, 40251, 40225, 40088, 5687, 40252, 40228, 40089, 
5710, 5709, 40226, 40063, 5707
16018, 5186, 38927, 38881, 5185, 187, 4079, 4077, 186, 40252, 40228, 40089, 5710, 4122, 4120, 4117, 
198, 5726, 40229, 40066, 5725
16019, 4001, 104, 103, 3999, 38928, 4152, 4151, 38882, 4044, 115, 4039, 4045, 40254, 4412, 40091, 
40255, 40253, 4413, 4411, 40090
16020, 38928, 4152, 4151, 38882, 38929, 4163, 4162, 38883, 40254, 4412, 40091, 40255, 40257, 4435, 40094, 
40258, 40256, 4436, 4434, 40093
16021, 38929, 4163, 4162, 38883, 38930, 4174, 4173, 38884, 40257, 4435, 40094, 40258, 40260, 4458, 40097, 
40261, 40259, 4459, 4457, 40096
16022, 38930, 4174, 4173, 38884, 38931, 4185, 4184, 38885, 40260, 4458, 40097, 40261, 40263, 4481, 40100, 
40264, 40262, 4482, 4480, 40099
16023, 38931, 4185, 4184, 38885, 38932, 4196, 4195, 38886, 40263, 4481, 40100, 40264, 40266, 4504, 40103, 
40267, 40265, 4505, 4503, 40102
16024, 38932, 4196, 4195, 38886, 38933, 4207, 4206, 38887, 40266, 4504, 40103, 40267, 40269, 4527, 40106, 
40270, 40268, 4528, 4526, 40105
16025, 38933, 4207, 4206, 38887, 38934, 4218, 4217, 38888, 40269, 4527, 40106, 40270, 40272, 4550, 40109, 
40273, 40271, 4551, 4549, 40108
16026, 38934, 4218, 4217, 38888, 38935, 4229, 4228, 38889, 40272, 4550, 40109, 40273, 40275, 4573, 40112, 
40276, 40274, 4574, 4572, 40111
16027, 38935, 4229, 4228, 38889, 38936, 4240, 4239, 38890, 40275, 4573, 40112, 40276, 40278, 4596, 40115, 
40279, 40277, 4597, 4595, 40114
16028, 38936, 4240, 4239, 38890, 38937, 4251, 4250, 38891, 40278, 4596, 40115, 40279, 40281, 4619, 40118, 
40282, 40280, 4620, 4618, 40117
16029, 38937, 4251, 4250, 38891, 38938, 4262, 4261, 38892, 40281, 4619, 40118, 40282, 40284, 4642, 40121, 
40285, 40283, 4643, 4641, 40120
16030, 38938, 4262, 4261, 38892, 38939, 4273, 4272, 38893, 40284, 4642, 40121, 40285, 40287, 4665, 40124, 
40288, 40286, 4666, 4664, 40123
16031, 38939, 4273, 4272, 38893, 38940, 4284, 4283, 38894, 40287, 4665, 40124, 40288, 40290, 4688, 40127, 
40291, 40289, 4689, 4687, 40126
16032, 38940, 4284, 4283, 38894, 38941, 4295, 4294, 38895, 40290, 4688, 40127, 40291, 40293, 4711, 40130, 
40294, 40292, 4712, 4710, 40129
16033, 38941, 4295, 4294, 38895, 38942, 4306, 4305, 38896, 40293, 4711, 40130, 40294, 40296, 4734, 40133, 
40297, 40295, 4735, 4733, 40132
16034, 38942, 4306, 4305, 38896, 38943, 4317, 4316, 38897, 40296, 4734, 40133, 40297, 40299, 4757, 40136, 
40300, 40298, 4758, 4756, 40135
16035, 38943, 4317, 4316, 38897, 38944, 4328, 4327, 38898, 40299, 4757, 40136, 40300, 40302, 4780, 40139, 
40303, 40301, 4781, 4779, 40138
16036, 38944, 4328, 4327, 38898, 38945, 4339, 4338, 38899, 40302, 4780, 40139, 40303, 40305, 4803, 40142, 
40306, 40304, 4804, 4802, 40141
16037, 38945, 4339, 4338, 38899, 38946, 4350, 4349, 38900, 40305, 4803, 40142, 40306, 40308, 4826, 40145, 
40309, 40307, 4827, 4825, 40144
16038, 38946, 4350, 4349, 38900, 38947, 4361, 4360, 38901, 40308, 4826, 40145, 40309, 40311, 4849, 40148, 
40312, 40310, 4850, 4848, 40147
16039, 38947, 4361, 4360, 38901, 38948, 4372, 4371, 38902, 40311, 4849, 40148, 40312, 40314, 4872, 40151, 
40315, 40313, 4873, 4871, 40150
16040, 38948, 4372, 4371, 38902, 38949, 4383, 4382, 38903, 40314, 4872, 40151, 40315, 40317, 4895, 40154, 
40318, 40316, 4896, 4894, 40153
16041, 38949, 4383, 4382, 38903, 38950, 4394, 4393, 38904, 40317, 4895, 40154, 40318, 40320, 4918, 40157, 
40321, 40319, 4919, 4917, 40156
16042, 38950, 4394, 4393, 38904, 4080, 160, 159, 4078, 40320, 4918, 40157, 40321, 4124, 171, 4119, 
4123, 40322, 4934, 4933, 40159
16043, 4002, 4001, 3999, 4000, 38951, 38928, 38882, 38905, 4046, 4045, 4041, 4047, 40324, 40255, 40161, 
40325, 40323, 40253, 40090, 40160
16044, 38951, 38928, 38882, 38905, 38952, 38929, 38883, 38906, 40324, 40255, 40161, 40325, 40327, 40258, 40164, 
40328, 40326, 40256, 40093, 40163
16045, 38952, 38929, 38883, 38906, 38953, 38930, 38884, 38907, 40327, 40258, 40164, 40328, 40330, 40261, 40167, 
40331, 40329, 40259, 40096, 40166
16046, 38953, 38930, 38884, 38907, 38954, 38931, 38885, 38908, 40330, 40261, 40167, 40331, 40333, 40264, 40170, 
40334, 40332, 40262, 40099, 40169
16047, 38954, 38931, 38885, 38908, 38955, 38932, 38886, 38909, 40333, 40264, 40170, 40334, 40336, 40267, 40173, 
40337, 40335, 40265, 40102, 40172
16048, 38955, 38932, 38886, 38909, 38956, 38933, 38887, 38910, 40336, 40267, 40173, 40337, 40339, 40270, 40176, 
40340, 40338, 40268, 40105, 40175
16049, 38956, 38933, 38887, 38910, 38957, 38934, 38888, 38911, 40339, 40270, 40176, 40340, 40342, 40273, 40179, 
40343, 40341, 40271, 40108, 40178
16050, 38957, 38934, 38888, 38911, 38958, 38935, 38889, 38912, 40342, 40273, 40179, 40343, 40345, 40276, 40182, 
40346, 40344, 40274, 40111, 40181
16051, 38958, 38935, 38889, 38912, 38959, 38936, 38890, 38913, 40345, 40276, 40182, 40346, 40348, 40279, 40185, 
40349, 40347, 40277, 40114, 40184
16052, 38959, 38936, 38890, 38913, 38960, 38937, 38891, 38914, 40348, 40279, 40185, 40349, 40351, 40282, 40188, 
40352, 40350, 40280, 40117, 40187
16053, 38960, 38937, 38891, 38914, 38961, 38938, 38892, 38915, 40351, 40282, 40188, 40352, 40354, 40285, 40191, 
40355, 40353, 40283, 40120, 40190
16054, 38961, 38938, 38892, 38915, 38962, 38939, 38893, 38916, 40354, 40285, 40191, 40355, 40357, 40288, 40194, 
40358, 40356, 40286, 40123, 40193
16055, 38962, 38939, 38893, 38916, 38963, 38940, 38894, 38917, 40357, 40288, 40194, 40358, 40360, 40291, 40197, 
40361, 40359, 40289, 40126, 40196
16056, 38963, 38940, 38894, 38917, 38964, 38941, 38895, 38918, 40360, 40291, 40197, 40361, 40363, 40294, 40200, 
40364, 40362, 40292, 40129, 40199
16057, 38964, 38941, 38895, 38918, 38965, 38942, 38896, 38919, 40363, 40294, 40200, 40364, 40366, 40297, 40203, 
40367, 40365, 40295, 40132, 40202
16058, 38965, 38942, 38896, 38919, 38966, 38943, 38897, 38920, 40366, 40297, 40203, 40367, 40369, 40300, 40206, 
40370, 40368, 40298, 40135, 40205
16059, 38966, 38943, 38897, 38920, 38967, 38944, 38898, 38921, 40369, 40300, 40206, 40370, 40372, 40303, 40209, 
40373, 40371, 40301, 40138, 40208
16060, 38967, 38944, 38898, 38921, 38968, 38945, 38899, 38922, 40372, 40303, 40209, 40373, 40375, 40306, 40212, 
40376, 40374, 40304, 40141, 40211
16061, 38968, 38945, 38899, 38922, 38969, 38946, 38900, 38923, 40375, 40306, 40212, 40376, 40378, 40309, 40215, 
40379, 40377, 40307, 40144, 40214
16062, 38969, 38946, 38900, 38923, 38970, 38947, 38901, 38924, 40378, 40309, 40215, 40379, 40381, 40312, 40218, 
40382, 40380, 40310, 40147, 40217
16063, 38970, 38947, 38901, 38924, 38971, 38948, 38902, 38925, 40381, 40312, 40218, 40382, 40384, 40315, 40221, 
40385, 40383, 40313, 40150, 40220
16064, 38971, 38948, 38902, 38925, 38972, 38949, 38903, 38926, 40384, 40315, 40221, 40385, 40387, 40318, 40224, 
40388, 40386, 40316, 40153, 40223
16065, 38972, 38949, 38903, 38926, 38973, 38950, 38904, 38927, 40387, 40318, 40224, 40388, 40390, 40321, 40227, 
40391, 40389, 40319, 40156, 40226
16066, 38973, 38950, 38904, 38927, 4081, 4080, 4078, 4079, 40390, 40321, 40227, 40391, 4126, 4123, 4121, 
4125, 40392, 40322, 40159, 40229
16067, 132, 4002, 4000, 131, 4945, 38951, 38905, 4944, 4048, 4047, 4043, 143, 40393, 40325, 40230, 
5206, 5205, 40323, 40160, 5203
16068, 4945, 38951, 38905, 4944, 4956, 38952, 38906, 4955, 40393, 40325, 40230, 5206, 40394, 40328, 40231, 
5229, 5228, 40326, 40163, 5226
16069, 4956, 38952, 38906, 4955, 4967, 38953, 38907, 4966, 40394, 40328, 40231, 5229, 40395, 40331, 40232, 
5252, 5251, 40329, 40166, 5249
16070, 4967, 38953, 38907, 4966, 4978, 38954, 38908, 4977, 40395, 40331, 40232, 5252, 40396, 40334, 40233, 
5275, 5274, 40332, 40169, 5272
16071, 4978, 38954, 38908, 4977, 4989, 38955, 38909, 4988, 40396, 40334, 40233, 5275, 40397, 40337, 40234, 
5298, 5297, 40335, 40172, 5295
16072, 4989, 38955, 38909, 4988, 5000, 38956, 38910, 4999, 40397, 40337, 40234, 5298, 40398, 40340, 40235, 
5321, 5320, 40338, 40175, 5318
16073, 5000, 38956, 38910, 4999, 5011, 38957, 38911, 5010, 40398, 40340, 40235, 5321, 40399, 40343, 40236, 
5344, 5343, 40341, 40178, 5341
16074, 5011, 38957, 38911, 5010, 5022, 38958, 38912, 5021, 40399, 40343, 40236, 5344, 40400, 40346, 40237, 
5367, 5366, 40344, 40181, 5364
16075, 5022, 38958, 38912, 5021, 5033, 38959, 38913, 5032, 40400, 40346, 40237, 5367, 40401, 40349, 40238, 
5390, 5389, 40347, 40184, 5387
16076, 5033, 38959, 38913, 5032, 5044, 38960, 38914, 5043, 40401, 40349, 40238, 5390, 40402, 40352, 40239, 
5413, 5412, 40350, 40187, 5410
16077, 5044, 38960, 38914, 5043, 5055, 38961, 38915, 5054, 40402, 40352, 40239, 5413, 40403, 40355, 40240, 
5436, 5435, 40353, 40190, 5433
16078, 5055, 38961, 38915, 5054, 5066, 38962, 38916, 5065, 40403, 40355, 40240, 5436, 40404, 40358, 40241, 
5459, 5458, 40356, 40193, 5456
16079, 5066, 38962, 38916, 5065, 5077, 38963, 38917, 5076, 40404, 40358, 40241, 5459, 40405, 40361, 40242, 
5482, 5481, 40359, 40196, 5479
16080, 5077, 38963, 38917, 5076, 5088, 38964, 38918, 5087, 40405, 40361, 40242, 5482, 40406, 40364, 40243, 
5505, 5504, 40362, 40199, 5502
16081, 5088, 38964, 38918, 5087, 5099, 38965, 38919, 5098, 40406, 40364, 40243, 5505, 40407, 40367, 40244, 
5528, 5527, 40365, 40202, 5525
16082, 5099, 38965, 38919, 5098, 5110, 38966, 38920, 5109, 40407, 40367, 40244, 5528, 40408, 40370, 40245, 
5551, 5550, 40368, 40205, 5548
16083, 5110, 38966, 38920, 5109, 5121, 38967, 38921, 5120, 40408, 40370, 40245, 5551, 40409, 40373, 40246, 
5574, 5573, 40371, 40208, 5571
16084, 5121, 38967, 38921, 5120, 5132, 38968, 38922, 5131, 40409, 40373, 40246, 5574, 40410, 40376, 40247, 
5597, 5596, 40374, 40211, 5594
16085, 5132, 38968, 38922, 5131, 5143, 38969, 38923, 5142, 40410, 40376, 40247, 5597, 40411, 40379, 40248, 
5620, 5619, 40377, 40214, 5617
16086, 5143, 38969, 38923, 5142, 5154, 38970, 38924, 5153, 40411, 40379, 40248, 5620, 40412, 40382, 40249, 
5643, 5642, 40380, 40217, 5640
16087, 5154, 38970, 38924, 5153, 5165, 38971, 38925, 5164, 40412, 40382, 40249, 5643, 40413, 40385, 40250, 
5666, 5665, 40383, 40220, 5663
16088, 5165, 38971, 38925, 5164, 5176, 38972, 38926, 5175, 40413, 40385, 40250, 5666, 40414, 40388, 40251, 
5689, 5688, 40386, 40223, 5686
16089, 5176, 38972, 38926, 5175, 5187, 38973, 38927, 5186, 40414, 40388, 40251, 5689, 40415, 40391, 40252, 
5712, 5711, 40389, 40226, 5709
16090, 5187, 38973, 38927, 5186, 188, 4081, 4079, 187, 40415, 40391, 40252, 5712, 4127, 4125, 4122, 
199, 5727, 40392, 40229, 5726
16091, 4003, 105, 104, 4001, 38974, 4153, 4152, 38928, 4049, 116, 4044, 4050, 40417, 4414, 40254, 
40418, 40416, 4415, 4413, 40253
16092, 38974, 4153, 4152, 38928, 38975, 4164, 4163, 38929, 40417, 4414, 40254, 40418, 40420, 4437, 40257, 
40421, 40419, 4438, 4436, 40256
16093, 38975, 4164, 4163, 38929, 38976, 4175, 4174, 38930, 40420, 4437, 40257, 40421, 40423, 4460, 40260, 
40424, 40422, 4461, 4459, 40259
16094, 38976, 4175, 4174, 38930, 38977, 4186, 4185, 38931, 40423, 4460, 40260, 40424, 40426, 4483, 40263, 
40427, 40425, 4484, 4482, 40262
16095, 38977, 4186, 4185, 38931, 38978, 4197, 4196, 38932, 40426, 4483, 40263, 40427, 40429, 4506, 40266, 
40430, 40428, 4507, 4505, 40265
16096, 38978, 4197, 4196, 38932, 38979, 4208, 4207, 38933, 40429, 4506, 40266, 40430, 40432, 4529, 40269, 
40433, 40431, 4530, 4528, 40268
16097, 38979, 4208, 4207, 38933, 38980, 4219, 4218, 38934, 40432, 4529, 40269, 40433, 40435, 4552, 40272, 
40436, 40434, 4553, 4551, 40271
16098, 38980, 4219, 4218, 38934, 38981, 4230, 4229, 38935, 40435, 4552, 40272, 40436, 40438, 4575, 40275, 
40439, 40437, 4576, 4574, 40274
16099, 38981, 4230, 4229, 38935, 38982, 4241, 4240, 38936, 40438, 4575, 40275, 40439, 40441, 4598, 40278, 
40442, 40440, 4599, 4597, 40277
16100, 38982, 4241, 4240, 38936, 38983, 4252, 4251, 38937, 40441, 4598, 40278, 40442, 40444, 4621, 40281, 
40445, 40443, 4622, 4620, 40280
16101, 38983, 4252, 4251, 38937, 38984, 4263, 4262, 38938, 40444, 4621, 40281, 40445, 40447, 4644, 40284, 
40448, 40446, 4645, 4643, 40283
16102, 38984, 4263, 4262, 38938, 38985, 4274, 4273, 38939, 40447, 4644, 40284, 40448, 40450, 4667, 40287, 
40451, 40449, 4668, 4666, 40286
16103, 38985, 4274, 4273, 38939, 38986, 4285, 4284, 38940, 40450, 4667, 40287, 40451, 40453, 4690, 40290, 
40454, 40452, 4691, 4689, 40289
16104, 38986, 4285, 4284, 38940, 38987, 4296, 4295, 38941, 40453, 4690, 40290, 40454, 40456, 4713, 40293, 
40457, 40455, 4714, 4712, 40292
16105, 38987, 4296, 4295, 38941, 38988, 4307, 4306, 38942, 40456, 4713, 40293, 40457, 40459, 4736, 40296, 
40460, 40458, 4737, 4735, 40295
16106, 38988, 4307, 4306, 38942, 38989, 4318, 4317, 38943, 40459, 4736, 40296, 40460, 40462, 4759, 40299, 
40463, 40461, 4760, 4758, 40298
16107, 38989, 4318, 4317, 38943, 38990, 4329, 4328, 38944, 40462, 4759, 40299, 40463, 40465, 4782, 40302, 
40466, 40464, 4783, 4781, 40301
16108, 38990, 4329, 4328, 38944, 38991, 4340, 4339, 38945, 40465, 4782, 40302, 40466, 40468, 4805, 40305, 
40469, 40467, 4806, 4804, 40304
16109, 38991, 4340, 4339, 38945, 38992, 4351, 4350, 38946, 40468, 4805, 40305, 40469, 40471, 4828, 40308, 
40472, 40470, 4829, 4827, 40307
16110, 38992, 4351, 4350, 38946, 38993, 4362, 4361, 38947, 40471, 4828, 40308, 40472, 40474, 4851, 40311, 
40475, 40473, 4852, 4850, 40310
16111, 38993, 4362, 4361, 38947, 38994, 4373, 4372, 38948, 40474, 4851, 40311, 40475, 40477, 4874, 40314, 
40478, 40476, 4875, 4873, 40313
16112, 38994, 4373, 4372, 38948, 38995, 4384, 4383, 38949, 40477, 4874, 40314, 40478, 40480, 4897, 40317, 
40481, 40479, 4898, 4896, 40316
16113, 38995, 4384, 4383, 38949, 38996, 4395, 4394, 38950, 40480, 4897, 40317, 40481, 40483, 4920, 40320, 
40484, 40482, 4921, 4919, 40319
16114, 38996, 4395, 4394, 38950, 4082, 161, 160, 4080, 40483, 4920, 40320, 40484, 4129, 172, 4124, 
4128, 40485, 4935, 4934, 40322
16115, 4004, 4003, 4001, 4002, 38997, 38974, 38928, 38951, 4051, 4050, 4046, 4052, 40487, 40418, 40324, 
40488, 40486, 40416, 40253, 40323
16116, 38997, 38974, 38928, 38951, 38998, 38975, 38929, 38952, 40487, 40418, 40324, 40488, 40490, 40421, 40327, 
40491, 40489, 40419, 40256, 40326
16117, 38998, 38975, 38929, 38952, 38999, 38976, 38930, 38953, 40490, 40421, 40327, 40491, 40493, 40424, 40330, 
40494, 40492, 40422, 40259, 40329
16118, 38999, 38976, 38930, 38953, 39000, 38977, 38931, 38954, 40493, 40424, 40330, 40494, 40496, 40427, 40333, 
40497, 40495, 40425, 40262, 40332
16119, 39000, 38977, 38931, 38954, 39001, 38978, 38932, 38955, 40496, 40427, 40333, 40497, 40499, 40430, 40336, 
40500, 40498, 40428, 40265, 40335
16120, 39001, 38978, 38932, 38955, 39002, 38979, 38933, 38956, 40499, 40430, 40336, 40500, 40502, 40433, 40339, 
40503, 40501, 40431, 40268, 40338
16121, 39002, 38979, 38933, 38956, 39003, 38980, 38934, 38957, 40502, 40433, 40339, 40503, 40505, 40436, 40342, 
40506, 40504, 40434, 40271, 40341
16122, 39003, 38980, 38934, 38957, 39004, 38981, 38935, 38958, 40505, 40436, 40342, 40506, 40508, 40439, 40345, 
40509, 40507, 40437, 40274, 40344
16123, 39004, 38981, 38935, 38958, 39005, 38982, 38936, 38959, 40508, 40439, 40345, 40509, 40511, 40442, 40348, 
40512, 40510, 40440, 40277, 40347
16124, 39005, 38982, 38936, 38959, 39006, 38983, 38937, 38960, 40511, 40442, 40348, 40512, 40514, 40445, 40351, 
40515, 40513, 40443, 40280, 40350
16125, 39006, 38983, 38937, 38960, 39007, 38984, 38938, 38961, 40514, 40445, 40351, 40515, 40517, 40448, 40354, 
40518, 40516, 40446, 40283, 40353
16126, 39007, 38984, 38938, 38961, 39008, 38985, 38939, 38962, 40517, 40448, 40354, 40518, 40520, 40451, 40357, 
40521, 40519, 40449, 40286, 40356
16127, 39008, 38985, 38939, 38962, 39009, 38986, 38940, 38963, 40520, 40451, 40357, 40521, 40523, 40454, 40360, 
40524, 40522, 40452, 40289, 40359
16128, 39009, 38986, 38940, 38963, 39010, 38987, 38941, 38964, 40523, 40454, 40360, 40524, 40526, 40457, 40363, 
40527, 40525, 40455, 40292, 40362
16129, 39010, 38987, 38941, 38964, 39011, 38988, 38942, 38965, 40526, 40457, 40363, 40527, 40529, 40460, 40366, 
40530, 40528, 40458, 40295, 40365
16130, 39011, 38988, 38942, 38965, 39012, 38989, 38943, 38966, 40529, 40460, 40366, 40530, 40532, 40463, 40369, 
40533, 40531, 40461, 40298, 40368
16131, 39012, 38989, 38943, 38966, 39013, 38990, 38944, 38967, 40532, 40463, 40369, 40533, 40535, 40466, 40372, 
40536, 40534, 40464, 40301, 40371
16132, 39013, 38990, 38944, 38967, 39014, 38991, 38945, 38968, 40535, 40466, 40372, 40536, 40538, 40469, 40375, 
40539, 40537, 40467, 40304, 40374
16133, 39014, 38991, 38945, 38968, 39015, 38992, 38946, 38969, 40538, 40469, 40375, 40539, 40541, 40472, 40378, 
40542, 40540, 40470, 40307, 40377
16134, 39015, 38992, 38946, 38969, 39016, 38993, 38947, 38970, 40541, 40472, 40378, 40542, 40544, 40475, 40381, 
40545, 40543, 40473, 40310, 40380
16135, 39016, 38993, 38947, 38970, 39017, 38994, 38948, 38971, 40544, 40475, 40381, 40545, 40547, 40478, 40384, 
40548, 40546, 40476, 40313, 40383
16136, 39017, 38994, 38948, 38971, 39018, 38995, 38949, 38972, 40547, 40478, 40384, 40548, 40550, 40481, 40387, 
40551, 40549, 40479, 40316, 40386
16137, 39018, 38995, 38949, 38972, 39019, 38996, 38950, 38973, 40550, 40481, 40387, 40551, 40553, 40484, 40390, 
40554, 40552, 40482, 40319, 40389
16138, 39019, 38996, 38950, 38973, 4083, 4082, 4080, 4081, 40553, 40484, 40390, 40554, 4131, 4128, 4126, 
4130, 40555, 40485, 40322, 40392
16139, 133, 4004, 4002, 132, 4946, 38997, 38951, 4945, 4053, 4052, 4048, 144, 40556, 40488, 40393, 
5208, 5207, 40486, 40323, 5205
16140, 4946, 38997, 38951, 4945, 4957, 38998, 38952, 4956, 40556, 40488, 40393, 5208, 40557, 40491, 40394, 
5231, 5230, 40489, 40326, 5228
16141, 4957, 38998, 38952, 4956, 4968, 38999, 38953, 4967, 40557, 40491, 40394, 5231, 40558, 40494, 40395, 
5254, 5253, 40492, 40329, 5251
16142, 4968, 38999, 38953, 4967, 4979, 39000, 38954, 4978, 40558, 40494, 40395, 5254, 40559, 40497, 40396, 
5277, 5276, 40495, 40332, 5274
16143, 4979, 39000, 38954, 4978, 4990, 39001, 38955, 4989, 40559, 40497, 40396, 5277, 40560, 40500, 40397, 
5300, 5299, 40498, 40335, 5297
16144, 4990, 39001, 38955, 4989, 5001, 39002, 38956, 5000, 40560, 40500, 40397, 5300, 40561, 40503, 40398, 
5323, 5322, 40501, 40338, 5320
16145, 5001, 39002, 38956, 5000, 5012, 39003, 38957, 5011, 40561, 40503, 40398, 5323, 40562, 40506, 40399, 
5346, 5345, 40504, 40341, 5343
16146, 5012, 39003, 38957, 5011, 5023, 39004, 38958, 5022, 40562, 40506, 40399, 5346, 40563, 40509, 40400, 
5369, 5368, 40507, 40344, 5366
16147, 5023, 39004, 38958, 5022, 5034, 39005, 38959, 5033, 40563, 40509, 40400, 5369, 40564, 40512, 40401, 
5392, 5391, 40510, 40347, 5389
16148, 5034, 39005, 38959, 5033, 5045, 39006, 38960, 5044, 40564, 40512, 40401, 5392, 40565, 40515, 40402, 
5415, 5414, 40513, 40350, 5412
16149, 5045, 39006, 38960, 5044, 5056, 39007, 38961, 5055, 40565, 40515, 40402, 5415, 40566, 40518, 40403, 
5438, 5437, 40516, 40353, 5435
16150, 5056, 39007, 38961, 5055, 5067, 39008, 38962, 5066, 40566, 40518, 40403, 5438, 40567, 40521, 40404, 
5461, 5460, 40519, 40356, 5458
16151, 5067, 39008, 38962, 5066, 5078, 39009, 38963, 5077, 40567, 40521, 40404, 5461, 40568, 40524, 40405, 
5484, 5483, 40522, 40359, 5481
16152, 5078, 39009, 38963, 5077, 5089, 39010, 38964, 5088, 40568, 40524, 40405, 5484, 40569, 40527, 40406, 
5507, 5506, 40525, 40362, 5504
16153, 5089, 39010, 38964, 5088, 5100, 39011, 38965, 5099, 40569, 40527, 40406, 5507, 40570, 40530, 40407, 
5530, 5529, 40528, 40365, 5527
16154, 5100, 39011, 38965, 5099, 5111, 39012, 38966, 5110, 40570, 40530, 40407, 5530, 40571, 40533, 40408, 
5553, 5552, 40531, 40368, 5550
16155, 5111, 39012, 38966, 5110, 5122, 39013, 38967, 5121, 40571, 40533, 40408, 5553, 40572, 40536, 40409, 
5576, 5575, 40534, 40371, 5573
16156, 5122, 39013, 38967, 5121, 5133, 39014, 38968, 5132, 40572, 40536, 40409, 5576, 40573, 40539, 40410, 
5599, 5598, 40537, 40374, 5596
16157, 5133, 39014, 38968, 5132, 5144, 39015, 38969, 5143, 40573, 40539, 40410, 5599, 40574, 40542, 40411, 
5622, 5621, 40540, 40377, 5619
16158, 5144, 39015, 38969, 5143, 5155, 39016, 38970, 5154, 40574, 40542, 40411, 5622, 40575, 40545, 40412, 
5645, 5644, 40543, 40380, 5642
16159, 5155, 39016, 38970, 5154, 5166, 39017, 38971, 5165, 40575, 40545, 40412, 5645, 40576, 40548, 40413, 
5668, 5667, 40546, 40383, 5665
16160, 5166, 39017, 38971, 5165, 5177, 39018, 38972, 5176, 40576, 40548, 40413, 5668, 40577, 40551, 40414, 
5691, 5690, 40549, 40386, 5688
16161, 5177, 39018, 38972, 5176, 5188, 39019, 38973, 5187, 40577, 40551, 40414, 5691, 40578, 40554, 40415, 
5714, 5713, 40552, 40389, 5711
16162, 5188, 39019, 38973, 5187, 189, 4083, 4081, 188, 40578, 40554, 40415, 5714, 4132, 4130, 4127, 
200, 5728, 40555, 40392, 5727
16163, 4005, 106, 105, 4003, 39020, 4154, 4153, 38974, 4054, 117, 4049, 4055, 40580, 4416, 40417, 
40581, 40579, 4417, 4415, 40416
16164, 39020, 4154, 4153, 38974, 39021, 4165, 4164, 38975, 40580, 4416, 40417, 40581, 40583, 4439, 40420, 
40584, 40582, 4440, 4438, 40419
16165, 39021, 4165, 4164, 38975, 39022, 4176, 4175, 38976, 40583, 4439, 40420, 40584, 40586, 4462, 40423, 
40587, 40585, 4463, 4461, 40422
16166, 39022, 4176, 4175, 38976, 39023, 4187, 4186, 38977, 40586, 4462, 40423, 40587, 40589, 4485, 40426, 
40590, 40588, 4486, 4484, 40425
16167, 39023, 4187, 4186, 38977, 39024, 4198, 4197, 38978, 40589, 4485, 40426, 40590, 40592, 4508, 40429, 
40593, 40591, 4509, 4507, 40428
16168, 39024, 4198, 4197, 38978, 39025, 4209, 4208, 38979, 40592, 4508, 40429, 40593, 40595, 4531, 40432, 
40596, 40594, 4532, 4530, 40431
16169, 39025, 4209, 4208, 38979, 39026, 4220, 4219, 38980, 40595, 4531, 40432, 40596, 40598, 4554, 40435, 
40599, 40597, 4555, 4553, 40434
16170, 39026, 4220, 4219, 38980, 39027, 4231, 4230, 38981, 40598, 4554, 40435, 40599, 40601, 4577, 40438, 
40602, 40600, 4578, 4576, 40437
16171, 39027, 4231, 4230, 38981, 39028, 4242, 4241, 38982, 40601, 4577, 40438, 40602, 40604, 4600, 40441, 
40605, 40603, 4601, 4599, 40440
16172, 39028, 4242, 4241, 38982, 39029, 4253, 4252, 38983, 40604, 4600, 40441, 40605, 40607, 4623, 40444, 
40608, 40606, 4624, 4622, 40443
16173, 39029, 4253, 4252, 38983, 39030, 4264, 4263, 38984, 40607, 4623, 40444, 40608, 40610, 4646, 40447, 
40611, 40609, 4647, 4645, 40446
16174, 39030, 4264, 4263, 38984, 39031, 4275, 4274, 38985, 40610, 4646, 40447, 40611, 40613, 4669, 40450, 
40614, 40612, 4670, 4668, 40449
16175, 39031, 4275, 4274, 38985, 39032, 4286, 4285, 38986, 40613, 4669, 40450, 40614, 40616, 4692, 40453, 
40617, 40615, 4693, 4691, 40452
16176, 39032, 4286, 4285, 38986, 39033, 4297, 4296, 38987, 40616, 4692, 40453, 40617, 40619, 4715, 40456, 
40620, 40618, 4716, 4714, 40455
16177, 39033, 4297, 4296, 38987, 39034, 4308, 4307, 38988, 40619, 4715, 40456, 40620, 40622, 4738, 40459, 
40623, 40621, 4739, 4737, 40458
16178, 39034, 4308, 4307, 38988, 39035, 4319, 4318, 38989, 40622, 4738, 40459, 40623, 40625, 4761, 40462, 
40626, 40624, 4762, 4760, 40461
16179, 39035, 4319, 4318, 38989, 39036, 4330, 4329, 38990, 40625, 4761, 40462, 40626, 40628, 4784, 40465, 
40629, 40627, 4785, 4783, 40464
16180, 39036, 4330, 4329, 38990, 39037, 4341, 4340, 38991, 40628, 4784, 40465, 40629, 40631, 4807, 40468, 
40632, 40630, 4808, 4806, 40467
16181, 39037, 4341, 4340, 38991, 39038, 4352, 4351, 38992, 40631, 4807, 40468, 40632, 40634, 4830, 40471, 
40635, 40633, 4831, 4829, 40470
16182, 39038, 4352, 4351, 38992, 39039, 4363, 4362, 38993, 40634, 4830, 40471, 40635, 40637, 4853, 40474, 
40638, 40636, 4854, 4852, 40473
16183, 39039, 4363, 4362, 38993, 39040, 4374, 4373, 38994, 40637, 4853, 40474, 40638, 40640, 4876, 40477, 
40641, 40639, 4877, 4875, 40476
16184, 39040, 4374, 4373, 38994, 39041, 4385, 4384, 38995, 40640, 4876, 40477, 40641, 40643, 4899, 40480, 
40644, 40642, 4900, 4898, 40479
16185, 39041, 4385, 4384, 38995, 39042, 4396, 4395, 38996, 40643, 4899, 40480, 40644, 40646, 4922, 40483, 
40647, 40645, 4923, 4921, 40482
16186, 39042, 4396, 4395, 38996, 4084, 162, 161, 4082, 40646, 4922, 40483, 40647, 4134, 173, 4129, 
4133, 40648, 4936, 4935, 40485
16187, 4006, 4005, 4003, 4004, 39043, 39020, 38974, 38997, 4056, 4055, 4051, 4057, 40650, 40581, 40487, 
40651, 40649, 40579, 40416, 40486
16188, 39043, 39020, 38974, 38997, 39044, 39021, 38975, 38998, 40650, 40581, 40487, 40651, 40653, 40584, 40490, 
40654, 40652, 40582, 40419, 40489
16189, 39044, 39021, 38975, 38998, 39045, 39022, 38976, 38999, 40653, 40584, 40490, 40654, 40656, 40587, 40493, 
40657, 40655, 40585, 40422, 40492
16190, 39045, 39022, 38976, 38999, 39046, 39023, 38977, 39000, 40656, 40587, 40493, 40657, 40659, 40590, 40496, 
40660, 40658, 40588, 40425, 40495
16191, 39046, 39023, 38977, 39000, 39047, 39024, 38978, 39001, 40659, 40590, 40496, 40660, 40662, 40593, 40499, 
40663, 40661, 40591, 40428, 40498
16192, 39047, 39024, 38978, 39001, 39048, 39025, 38979, 39002, 40662, 40593, 40499, 40663, 40665, 40596, 40502, 
40666, 40664, 40594, 40431, 40501
16193, 39048, 39025, 38979, 39002, 39049, 39026, 38980, 39003, 40665, 40596, 40502, 40666, 40668, 40599, 40505, 
40669, 40667, 40597, 40434, 40504
16194, 39049, 39026, 38980, 39003, 39050, 39027, 38981, 39004, 40668, 40599, 40505, 40669, 40671, 40602, 40508, 
40672, 40670, 40600, 40437, 40507
16195, 39050, 39027, 38981, 39004, 39051, 39028, 38982, 39005, 40671, 40602, 40508, 40672, 40674, 40605, 40511, 
40675, 40673, 40603, 40440, 40510
16196, 39051, 39028, 38982, 39005, 39052, 39029, 38983, 39006, 40674, 40605, 40511, 40675, 40677, 40608, 40514, 
40678, 40676, 40606, 40443, 40513
16197, 39052, 39029, 38983, 39006, 39053, 39030, 38984, 39007, 40677, 40608, 40514, 40678, 40680, 40611, 40517, 
40681, 40679, 40609, 40446, 40516
16198, 39053, 39030, 38984, 39007, 39054, 39031, 38985, 39008, 40680, 40611, 40517, 40681, 40683, 40614, 40520, 
40684, 40682, 40612, 40449, 40519
16199, 39054, 39031, 38985, 39008, 39055, 39032, 38986, 39009, 40683, 40614, 40520, 40684, 40686, 40617, 40523, 
40687, 40685, 40615, 40452, 40522
16200, 39055, 39032, 38986, 39009, 39056, 39033, 38987, 39010, 40686, 40617, 40523, 40687, 40689, 40620, 40526, 
40690, 40688, 40618, 40455, 40525
16201, 39056, 39033, 38987, 39010, 39057, 39034, 38988, 39011, 40689, 40620, 40526, 40690, 40692, 40623, 40529, 
40693, 40691, 40621, 40458, 40528
16202, 39057, 39034, 38988, 39011, 39058, 39035, 38989, 39012, 40692, 40623, 40529, 40693, 40695, 40626, 40532, 
40696, 40694, 40624, 40461, 40531
16203, 39058, 39035, 38989, 39012, 39059, 39036, 38990, 39013, 40695, 40626, 40532, 40696, 40698, 40629, 40535, 
40699, 40697, 40627, 40464, 40534
16204, 39059, 39036, 38990, 39013, 39060, 39037, 38991, 39014, 40698, 40629, 40535, 40699, 40701, 40632, 40538, 
40702, 40700, 40630, 40467, 40537
16205, 39060, 39037, 38991, 39014, 39061, 39038, 38992, 39015, 40701, 40632, 40538, 40702, 40704, 40635, 40541, 
40705, 40703, 40633, 40470, 40540
16206, 39061, 39038, 38992, 39015, 39062, 39039, 38993, 39016, 40704, 40635, 40541, 40705, 40707, 40638, 40544, 
40708, 40706, 40636, 40473, 40543
16207, 39062, 39039, 38993, 39016, 39063, 39040, 38994, 39017, 40707, 40638, 40544, 40708, 40710, 40641, 40547, 
40711, 40709, 40639, 40476, 40546
16208, 39063, 39040, 38994, 39017, 39064, 39041, 38995, 39018, 40710, 40641, 40547, 40711, 40713, 40644, 40550, 
40714, 40712, 40642, 40479, 40549
16209, 39064, 39041, 38995, 39018, 39065, 39042, 38996, 39019, 40713, 40644, 40550, 40714, 40716, 40647, 40553, 
40717, 40715, 40645, 40482, 40552
16210, 39065, 39042, 38996, 39019, 4085, 4084, 4082, 4083, 40716, 40647, 40553, 40717, 4136, 4133, 4131, 
4135, 40718, 40648, 40485, 40555
16211, 134, 4006, 4004, 133, 4947, 39043, 38997, 4946, 4058, 4057, 4053, 145, 40719, 40651, 40556, 
5210, 5209, 40649, 40486, 5207
16212, 4947, 39043, 38997, 4946, 4958, 39044, 38998, 4957, 40719, 40651, 40556, 5210, 40720, 40654, 40557, 
5233, 5232, 40652, 40489, 5230
16213, 4958, 39044, 38998, 4957, 4969, 39045, 38999, 4968, 40720, 40654, 40557, 5233, 40721, 40657, 40558, 
5256, 5255, 40655, 40492, 5253
16214, 4969, 39045, 38999, 4968, 4980, 39046, 39000, 4979, 40721, 40657, 40558, 5256, 40722, 40660, 40559, 
5279, 5278, 40658, 40495, 5276
16215, 4980, 39046, 39000, 4979, 4991, 39047, 39001, 4990, 40722, 40660, 40559, 5279, 40723, 40663, 40560, 
5302, 5301, 40661, 40498, 5299
16216, 4991, 39047, 39001, 4990, 5002, 39048, 39002, 5001, 40723, 40663, 40560, 5302, 40724, 40666, 40561, 
5325, 5324, 40664, 40501, 5322
16217, 5002, 39048, 39002, 5001, 5013, 39049, 39003, 5012, 40724, 40666, 40561, 5325, 40725, 40669, 40562, 
5348, 5347, 40667, 40504, 5345
16218, 5013, 39049, 39003, 5012, 5024, 39050, 39004, 5023, 40725, 40669, 40562, 5348, 40726, 40672, 40563, 
5371, 5370, 40670, 40507, 5368
16219, 5024, 39050, 39004, 5023, 5035, 39051, 39005, 5034, 40726, 40672, 40563, 5371, 40727, 40675, 40564, 
5394, 5393, 40673, 40510, 5391
16220, 5035, 39051, 39005, 5034, 5046, 39052, 39006, 5045, 40727, 40675, 40564, 5394, 40728, 40678, 40565, 
5417, 5416, 40676, 40513, 5414
16221, 5046, 39052, 39006, 5045, 5057, 39053, 39007, 5056, 40728, 40678, 40565, 5417, 40729, 40681, 40566, 
5440, 5439, 40679, 40516, 5437
16222, 5057, 39053, 39007, 5056, 5068, 39054, 39008, 5067, 40729, 40681, 40566, 5440, 40730, 40684, 40567, 
5463, 5462, 40682, 40519, 5460
16223, 5068, 39054, 39008, 5067, 5079, 39055, 39009, 5078, 40730, 40684, 40567, 5463, 40731, 40687, 40568, 
5486, 5485, 40685, 40522, 5483
16224, 5079, 39055, 39009, 5078, 5090, 39056, 39010, 5089, 40731, 40687, 40568, 5486, 40732, 40690, 40569, 
5509, 5508, 40688, 40525, 5506
16225, 5090, 39056, 39010, 5089, 5101, 39057, 39011, 5100, 40732, 40690, 40569, 5509, 40733, 40693, 40570, 
5532, 5531, 40691, 40528, 5529
16226, 5101, 39057, 39011, 5100, 5112, 39058, 39012, 5111, 40733, 40693, 40570, 5532, 40734, 40696, 40571, 
5555, 5554, 40694, 40531, 5552
16227, 5112, 39058, 39012, 5111, 5123, 39059, 39013, 5122, 40734, 40696, 40571, 5555, 40735, 40699, 40572, 
5578, 5577, 40697, 40534, 5575
16228, 5123, 39059, 39013, 5122, 5134, 39060, 39014, 5133, 40735, 40699, 40572, 5578, 40736, 40702, 40573, 
5601, 5600, 40700, 40537, 5598
16229, 5134, 39060, 39014, 5133, 5145, 39061, 39015, 5144, 40736, 40702, 40573, 5601, 40737, 40705, 40574, 
5624, 5623, 40703, 40540, 5621
16230, 5145, 39061, 39015, 5144, 5156, 39062, 39016, 5155, 40737, 40705, 40574, 5624, 40738, 40708, 40575, 
5647, 5646, 40706, 40543, 5644
16231, 5156, 39062, 39016, 5155, 5167, 39063, 39017, 5166, 40738, 40708, 40575, 5647, 40739, 40711, 40576, 
5670, 5669, 40709, 40546, 5667
16232, 5167, 39063, 39017, 5166, 5178, 39064, 39018, 5177, 40739, 40711, 40576, 5670, 40740, 40714, 40577, 
5693, 5692, 40712, 40549, 5690
16233, 5178, 39064, 39018, 5177, 5189, 39065, 39019, 5188, 40740, 40714, 40577, 5693, 40741, 40717, 40578, 
5716, 5715, 40715, 40552, 5713
16234, 5189, 39065, 39019, 5188, 190, 4085, 4083, 189, 40741, 40717, 40578, 5716, 4137, 4135, 4132, 
201, 5729, 40718, 40555, 5728
16235, 4007, 107, 106, 4005, 39066, 4155, 4154, 39020, 4059, 118, 4054, 4060, 40743, 4418, 40580, 
40744, 40742, 4419, 4417, 40579
16236, 39066, 4155, 4154, 39020, 39067, 4166, 4165, 39021, 40743, 4418, 40580, 40744, 40746, 4441, 40583, 
40747, 40745, 4442, 4440, 40582
16237, 39067, 4166, 4165, 39021, 39068, 4177, 4176, 39022, 40746, 4441, 40583, 40747, 40749, 4464, 40586, 
40750, 40748, 4465, 4463, 40585
16238, 39068, 4177, 4176, 39022, 39069, 4188, 4187, 39023, 40749, 4464, 40586, 40750, 40752, 4487, 40589, 
40753, 40751, 4488, 4486, 40588
16239, 39069, 4188, 4187, 39023, 39070, 4199, 4198, 39024, 40752, 4487, 40589, 40753, 40755, 4510, 40592, 
40756, 40754, 4511, 4509, 40591
16240, 39070, 4199, 4198, 39024, 39071, 4210, 4209, 39025, 40755, 4510, 40592, 40756, 40758, 4533, 40595, 
40759, 40757, 4534, 4532, 40594
16241, 39071, 4210, 4209, 39025, 39072, 4221, 4220, 39026, 40758, 4533, 40595, 40759, 40761, 4556, 40598, 
40762, 40760, 4557, 4555, 40597
16242, 39072, 4221, 4220, 39026, 39073, 4232, 4231, 39027, 40761, 4556, 40598, 40762, 40764, 4579, 40601, 
40765, 40763, 4580, 4578, 40600
16243, 39073, 4232, 4231, 39027, 39074, 4243, 4242, 39028, 40764, 4579, 40601, 40765, 40767, 4602, 40604, 
40768, 40766, 4603, 4601, 40603
16244, 39074, 4243, 4242, 39028, 39075, 4254, 4253, 39029, 40767, 4602, 40604, 40768, 40770, 4625, 40607, 
40771, 40769, 4626, 4624, 40606
16245, 39075, 4254, 4253, 39029, 39076, 4265, 4264, 39030, 40770, 4625, 40607, 40771, 40773, 4648, 40610, 
40774, 40772, 4649, 4647, 40609
16246, 39076, 4265, 4264, 39030, 39077, 4276, 4275, 39031, 40773, 4648, 40610, 40774, 40776, 4671, 40613, 
40777, 40775, 4672, 4670, 40612
16247, 39077, 4276, 4275, 39031, 39078, 4287, 4286, 39032, 40776, 4671, 40613, 40777, 40779, 4694, 40616, 
40780, 40778, 4695, 4693, 40615
16248, 39078, 4287, 4286, 39032, 39079, 4298, 4297, 39033, 40779, 4694, 40616, 40780, 40782, 4717, 40619, 
40783, 40781, 4718, 4716, 40618
16249, 39079, 4298, 4297, 39033, 39080, 4309, 4308, 39034, 40782, 4717, 40619, 40783, 40785, 4740, 40622, 
40786, 40784, 4741, 4739, 40621
16250, 39080, 4309, 4308, 39034, 39081, 4320, 4319, 39035, 40785, 4740, 40622, 40786, 40788, 4763, 40625, 
40789, 40787, 4764, 4762, 40624
16251, 39081, 4320, 4319, 39035, 39082, 4331, 4330, 39036, 40788, 4763, 40625, 40789, 40791, 4786, 40628, 
40792, 40790, 4787, 4785, 40627
16252, 39082, 4331, 4330, 39036, 39083, 4342, 4341, 39037, 40791, 4786, 40628, 40792, 40794, 4809, 40631, 
40795, 40793, 4810, 4808, 40630
16253, 39083, 4342, 4341, 39037, 39084, 4353, 4352, 39038, 40794, 4809, 40631, 40795, 40797, 4832, 40634, 
40798, 40796, 4833, 4831, 40633
16254, 39084, 4353, 4352, 39038, 39085, 4364, 4363, 39039, 40797, 4832, 40634, 40798, 40800, 4855, 40637, 
40801, 40799, 4856, 4854, 40636
16255, 39085, 4364, 4363, 39039, 39086, 4375, 4374, 39040, 40800, 4855, 40637, 40801, 40803, 4878, 40640, 
40804, 40802, 4879, 4877, 40639
16256, 39086, 4375, 4374, 39040, 39087, 4386, 4385, 39041, 40803, 4878, 40640, 40804, 40806, 4901, 40643, 
40807, 40805, 4902, 4900, 40642
16257, 39087, 4386, 4385, 39041, 39088, 4397, 4396, 39042, 40806, 4901, 40643, 40807, 40809, 4924, 40646, 
40810, 40808, 4925, 4923, 40645
16258, 39088, 4397, 4396, 39042, 4086, 163, 162, 4084, 40809, 4924, 40646, 40810, 4139, 174, 4134, 
4138, 40811, 4937, 4936, 40648
16259, 4008, 4007, 4005, 4006, 39089, 39066, 39020, 39043, 4061, 4060, 4056, 4062, 40813, 40744, 40650, 
40814, 40812, 40742, 40579, 40649
16260, 39089, 39066, 39020, 39043, 39090, 39067, 39021, 39044, 40813, 40744, 40650, 40814, 40816, 40747, 40653, 
40817, 40815, 40745, 40582, 40652
16261, 39090, 39067, 39021, 39044, 39091, 39068, 39022, 39045, 40816, 40747, 40653, 40817, 40819, 40750, 40656, 
40820, 40818, 40748, 40585, 40655
16262, 39091, 39068, 39022, 39045, 39092, 39069, 39023, 39046, 40819, 40750, 40656, 40820, 40822, 40753, 40659, 
40823, 40821, 40751, 40588, 40658
16263, 39092, 39069, 39023, 39046, 39093, 39070, 39024, 39047, 40822, 40753, 40659, 40823, 40825, 40756, 40662, 
40826, 40824, 40754, 40591, 40661
16264, 39093, 39070, 39024, 39047, 39094, 39071, 39025, 39048, 40825, 40756, 40662, 40826, 40828, 40759, 40665, 
40829, 40827, 40757, 40594, 40664
16265, 39094, 39071, 39025, 39048, 39095, 39072, 39026, 39049, 40828, 40759, 40665, 40829, 40831, 40762, 40668, 
40832, 40830, 40760, 40597, 40667
16266, 39095, 39072, 39026, 39049, 39096, 39073, 39027, 39050, 40831, 40762, 40668, 40832, 40834, 40765, 40671, 
40835, 40833, 40763, 40600, 40670
16267, 39096, 39073, 39027, 39050, 39097, 39074, 39028, 39051, 40834, 40765, 40671, 40835, 40837, 40768, 40674, 
40838, 40836, 40766, 40603, 40673
16268, 39097, 39074, 39028, 39051, 39098, 39075, 39029, 39052, 40837, 40768, 40674, 40838, 40840, 40771, 40677, 
40841, 40839, 40769, 40606, 40676
16269, 39098, 39075, 39029, 39052, 39099, 39076, 39030, 39053, 40840, 40771, 40677, 40841, 40843, 40774, 40680, 
40844, 40842, 40772, 40609, 40679
16270, 39099, 39076, 39030, 39053, 39100, 39077, 39031, 39054, 40843, 40774, 40680, 40844, 40846, 40777, 40683, 
40847, 40845, 40775, 40612, 40682
16271, 39100, 39077, 39031, 39054, 39101, 39078, 39032, 39055, 40846, 40777, 40683, 40847, 40849, 40780, 40686, 
40850, 40848, 40778, 40615, 40685
16272, 39101, 39078, 39032, 39055, 39102, 39079, 39033, 39056, 40849, 40780, 40686, 40850, 40852, 40783, 40689, 
40853, 40851, 40781, 40618, 40688
16273, 39102, 39079, 39033, 39056, 39103, 39080, 39034, 39057, 40852, 40783, 40689, 40853, 40855, 40786, 40692, 
40856, 40854, 40784, 40621, 40691
16274, 39103, 39080, 39034, 39057, 39104, 39081, 39035, 39058, 40855, 40786, 40692, 40856, 40858, 40789, 40695, 
40859, 40857, 40787, 40624, 40694
16275, 39104, 39081, 39035, 39058, 39105, 39082, 39036, 39059, 40858, 40789, 40695, 40859, 40861, 40792, 40698, 
40862, 40860, 40790, 40627, 40697
16276, 39105, 39082, 39036, 39059, 39106, 39083, 39037, 39060, 40861, 40792, 40698, 40862, 40864, 40795, 40701, 
40865, 40863, 40793, 40630, 40700
16277, 39106, 39083, 39037, 39060, 39107, 39084, 39038, 39061, 40864, 40795, 40701, 40865, 40867, 40798, 40704, 
40868, 40866, 40796, 40633, 40703
16278, 39107, 39084, 39038, 39061, 39108, 39085, 39039, 39062, 40867, 40798, 40704, 40868, 40870, 40801, 40707, 
40871, 40869, 40799, 40636, 40706
16279, 39108, 39085, 39039, 39062, 39109, 39086, 39040, 39063, 40870, 40801, 40707, 40871, 40873, 40804, 40710, 
40874, 40872, 40802, 40639, 40709
16280, 39109, 39086, 39040, 39063, 39110, 39087, 39041, 39064, 40873, 40804, 40710, 40874, 40876, 40807, 40713, 
40877, 40875, 40805, 40642, 40712
16281, 39110, 39087, 39041, 39064, 39111, 39088, 39042, 39065, 40876, 40807, 40713, 40877, 40879, 40810, 40716, 
40880, 40878, 40808, 40645, 40715
16282, 39111, 39088, 39042, 39065, 4087, 4086, 4084, 4085, 40879, 40810, 40716, 40880, 4141, 4138, 4136, 
4140, 40881, 40811, 40648, 40718
16283, 135, 4008, 4006, 134, 4948, 39089, 39043, 4947, 4063, 4062, 4058, 146, 40882, 40814, 40719, 
5212, 5211, 40812, 40649, 5209
16284, 4948, 39089, 39043, 4947, 4959, 39090, 39044, 4958, 40882, 40814, 40719, 5212, 40883, 40817, 40720, 
5235, 5234, 40815, 40652, 5232
16285, 4959, 39090, 39044, 4958, 4970, 39091, 39045, 4969, 40883, 40817, 40720, 5235, 40884, 40820, 40721, 
5258, 5257, 40818, 40655, 5255
16286, 4970, 39091, 39045, 4969, 4981, 39092, 39046, 4980, 40884, 40820, 40721, 5258, 40885, 40823, 40722, 
5281, 5280, 40821, 40658, 5278
16287, 4981, 39092, 39046, 4980, 4992, 39093, 39047, 4991, 40885, 40823, 40722, 5281, 40886, 40826, 40723, 
5304, 5303, 40824, 40661, 5301
16288, 4992, 39093, 39047, 4991, 5003, 39094, 39048, 5002, 40886, 40826, 40723, 5304, 40887, 40829, 40724, 
5327, 5326, 40827, 40664, 5324
16289, 5003, 39094, 39048, 5002, 5014, 39095, 39049, 5013, 40887, 40829, 40724, 5327, 40888, 40832, 40725, 
5350, 5349, 40830, 40667, 5347
16290, 5014, 39095, 39049, 5013, 5025, 39096, 39050, 5024, 40888, 40832, 40725, 5350, 40889, 40835, 40726, 
5373, 5372, 40833, 40670, 5370
16291, 5025, 39096, 39050, 5024, 5036, 39097, 39051, 5035, 40889, 40835, 40726, 5373, 40890, 40838, 40727, 
5396, 5395, 40836, 40673, 5393
16292, 5036, 39097, 39051, 5035, 5047, 39098, 39052, 5046, 40890, 40838, 40727, 5396, 40891, 40841, 40728, 
5419, 5418, 40839, 40676, 5416
16293, 5047, 39098, 39052, 5046, 5058, 39099, 39053, 5057, 40891, 40841, 40728, 5419, 40892, 40844, 40729, 
5442, 5441, 40842, 40679, 5439
16294, 5058, 39099, 39053, 5057, 5069, 39100, 39054, 5068, 40892, 40844, 40729, 5442, 40893, 40847, 40730, 
5465, 5464, 40845, 40682, 5462
16295, 5069, 39100, 39054, 5068, 5080, 39101, 39055, 5079, 40893, 40847, 40730, 5465, 40894, 40850, 40731, 
5488, 5487, 40848, 40685, 5485
16296, 5080, 39101, 39055, 5079, 5091, 39102, 39056, 5090, 40894, 40850, 40731, 5488, 40895, 40853, 40732, 
5511, 5510, 40851, 40688, 5508
16297, 5091, 39102, 39056, 5090, 5102, 39103, 39057, 5101, 40895, 40853, 40732, 5511, 40896, 40856, 40733, 
5534, 5533, 40854, 40691, 5531
16298, 5102, 39103, 39057, 5101, 5113, 39104, 39058, 5112, 40896, 40856, 40733, 5534, 40897, 40859, 40734, 
5557, 5556, 40857, 40694, 5554
16299, 5113, 39104, 39058, 5112, 5124, 39105, 39059, 5123, 40897, 40859, 40734, 5557, 40898, 40862, 40735, 
5580, 5579, 40860, 40697, 5577
16300, 5124, 39105, 39059, 5123, 5135, 39106, 39060, 5134, 40898, 40862, 40735, 5580, 40899, 40865, 40736, 
5603, 5602, 40863, 40700, 5600
16301, 5135, 39106, 39060, 5134, 5146, 39107, 39061, 5145, 40899, 40865, 40736, 5603, 40900, 40868, 40737, 
5626, 5625, 40866, 40703, 5623
16302, 5146, 39107, 39061, 5145, 5157, 39108, 39062, 5156, 40900, 40868, 40737, 5626, 40901, 40871, 40738, 
5649, 5648, 40869, 40706, 5646
16303, 5157, 39108, 39062, 5156, 5168, 39109, 39063, 5167, 40901, 40871, 40738, 5649, 40902, 40874, 40739, 
5672, 5671, 40872, 40709, 5669
16304, 5168, 39109, 39063, 5167, 5179, 39110, 39064, 5178, 40902, 40874, 40739, 5672, 40903, 40877, 40740, 
5695, 5694, 40875, 40712, 5692
16305, 5179, 39110, 39064, 5178, 5190, 39111, 39065, 5189, 40903, 40877, 40740, 5695, 40904, 40880, 40741, 
5718, 5717, 40878, 40715, 5715
16306, 5190, 39111, 39065, 5189, 191, 4087, 4085, 190, 40904, 40880, 40741, 5718, 4142, 4140, 4137, 
202, 5730, 40881, 40718, 5729
16307, 120, 1, 107, 4007, 5894, 256, 4155, 39066, 122, 119, 4059, 4064, 5940, 4420, 40743, 
40905, 5941, 279, 4419, 40742
16308, 5894, 256, 4155, 39066, 5895, 257, 4166, 39067, 5940, 4420, 40743, 40905, 5942, 4443, 40746, 
40906, 5943, 280, 4442, 40745
16309, 5895, 257, 4166, 39067, 5896, 258, 4177, 39068, 5942, 4443, 40746, 40906, 5944, 4466, 40749, 
40907, 5945, 281, 4465, 40748
16310, 5896, 258, 4177, 39068, 5897, 259, 4188, 39069, 5944, 4466, 40749, 40907, 5946, 4489, 40752, 
40908, 5947, 282, 4488, 40751
16311, 5897, 259, 4188, 39069, 5898, 260, 4199, 39070, 5946, 4489, 40752, 40908, 5948, 4512, 40755, 
40909, 5949, 283, 4511, 40754
16312, 5898, 260, 4199, 39070, 5899, 261, 4210, 39071, 5948, 4512, 40755, 40909, 5950, 4535, 40758, 
40910, 5951, 284, 4534, 40757
16313, 5899, 261, 4210, 39071, 5900, 262, 4221, 39072, 5950, 4535, 40758, 40910, 5952, 4558, 40761, 
40911, 5953, 285, 4557, 40760
16314, 5900, 262, 4221, 39072, 5901, 263, 4232, 39073, 5952, 4558, 40761, 40911, 5954, 4581, 40764, 
40912, 5955, 286, 4580, 40763
16315, 5901, 263, 4232, 39073, 5902, 264, 4243, 39074, 5954, 4581, 40764, 40912, 5956, 4604, 40767, 
40913, 5957, 287, 4603, 40766
16316, 5902, 264, 4243, 39074, 5903, 265, 4254, 39075, 5956, 4604, 40767, 40913, 5958, 4627, 40770, 
40914, 5959, 288, 4626, 40769
16317, 5903, 265, 4254, 39075, 5904, 266, 4265, 39076, 5958, 4627, 40770, 40914, 5960, 4650, 40773, 
40915, 5961, 289, 4649, 40772
16318, 5904, 266, 4265, 39076, 5905, 267, 4276, 39077, 5960, 4650, 40773, 40915, 5962, 4673, 40776, 
40916, 5963, 290, 4672, 40775
16319, 5905, 267, 4276, 39077, 5906, 268, 4287, 39078, 5962, 4673, 40776, 40916, 5964, 4696, 40779, 
40917, 5965, 291, 4695, 40778
16320, 5906, 268, 4287, 39078, 5907, 269, 4298, 39079, 5964, 4696, 40779, 40917, 5966, 4719, 40782, 
40918, 5967, 292, 4718, 40781
16321, 5907, 269, 4298, 39079, 5908, 270, 4309, 39080, 5966, 4719, 40782, 40918, 5968, 4742, 40785, 
40919, 5969, 293, 4741, 40784
16322, 5908, 270, 4309, 39080, 5909, 271, 4320, 39081, 5968, 4742, 40785, 40919, 5970, 4765, 40788, 
40920, 5971, 294, 4764, 40787
16323, 5909, 271, 4320, 39081, 5910, 272, 4331, 39082, 5970, 4765, 40788, 40920, 5972, 4788, 40791, 
40921, 5973, 295, 4787, 40790
16324, 5910, 272, 4331, 39082, 5911, 273, 4342, 39083, 5972, 4788, 40791, 40921, 5974, 4811, 40794, 
40922, 5975, 296, 4810, 40793
16325, 5911, 273, 4342, 39083, 5912, 274, 4353, 39084, 5974, 4811, 40794, 40922, 5976, 4834, 40797, 
40923, 5977, 297, 4833, 40796
16326, 5912, 274, 4353, 39084, 5913, 275, 4364, 39085, 5976, 4834, 40797, 40923, 5978, 4857, 40800, 
40924, 5979, 298, 4856, 40799
16327, 5913, 275, 4364, 39085, 5914, 276, 4375, 39086, 5978, 4857, 40800, 40924, 5980, 4880, 40803, 
40925, 5981, 299, 4879, 40802
16328, 5914, 276, 4375, 39086, 5915, 277, 4386, 39087, 5980, 4880, 40803, 40925, 5982, 4903, 40806, 
40926, 5983, 300, 4902, 40805
16329, 5915, 277, 4386, 39087, 5916, 278, 4397, 39088, 5982, 4903, 40806, 40926, 5984, 4926, 40809, 
40927, 5985, 301, 4925, 40808
16330, 5916, 278, 4397, 39088, 176, 5, 163, 4086, 5984, 4926, 40809, 40927, 178, 175, 4139, 
4143, 5986, 302, 4937, 40811
16331, 121, 120, 4007, 4008, 5917, 5894, 39066, 39089, 123, 4064, 4061, 4065, 5987, 40905, 40813, 
40928, 5988, 5941, 40742, 40812
16332, 5917, 5894, 39066, 39089, 5918, 5895, 39067, 39090, 5987, 40905, 40813, 40928, 5989, 40906, 40816, 
40929, 5990, 5943, 40745, 40815
16333, 5918, 5895, 39067, 39090, 5919, 5896, 39068, 39091, 5989, 40906, 40816, 40929, 5991, 40907, 40819, 
40930, 5992, 5945, 40748, 40818
16334, 5919, 5896, 39068, 39091, 5920, 5897, 39069, 39092, 5991, 40907, 40819, 40930, 5993, 40908, 40822, 
40931, 5994, 5947, 40751, 40821
16335, 5920, 5897, 39069, 39092, 5921, 5898, 39070, 39093, 5993, 40908, 40822, 40931, 5995, 40909, 40825, 
40932, 5996, 5949, 40754, 40824
16336, 5921, 5898, 39070, 39093, 5922, 5899, 39071, 39094, 5995, 40909, 40825, 40932, 5997, 40910, 40828, 
40933, 5998, 5951, 40757, 40827
16337, 5922, 5899, 39071, 39094, 5923, 5900, 39072, 39095, 5997, 40910, 40828, 40933, 5999, 40911, 40831, 
40934, 6000, 5953, 40760, 40830
16338, 5923, 5900, 39072, 39095, 5924, 5901, 39073, 39096, 5999, 40911, 40831, 40934, 6001, 40912, 40834, 
40935, 6002, 5955, 40763, 40833
16339, 5924, 5901, 39073, 39096, 5925, 5902, 39074, 39097, 6001, 40912, 40834, 40935, 6003, 40913, 40837, 
40936, 6004, 5957, 40766, 40836
16340, 5925, 5902, 39074, 39097, 5926, 5903, 39075, 39098, 6003, 40913, 40837, 40936, 6005, 40914, 40840, 
40937, 6006, 5959, 40769, 40839
16341, 5926, 5903, 39075, 39098, 5927, 5904, 39076, 39099, 6005, 40914, 40840, 40937, 6007, 40915, 40843, 
40938, 6008, 5961, 40772, 40842
16342, 5927, 5904, 39076, 39099, 5928, 5905, 39077, 39100, 6007, 40915, 40843, 40938, 6009, 40916, 40846, 
40939, 6010, 5963, 40775, 40845
16343, 5928, 5905, 39077, 39100, 5929, 5906, 39078, 39101, 6009, 40916, 40846, 40939, 6011, 40917, 40849, 
40940, 6012, 5965, 40778, 40848
16344, 5929, 5906, 39078, 39101, 5930, 5907, 39079, 39102, 6011, 40917, 40849, 40940, 6013, 40918, 40852, 
40941, 6014, 5967, 40781, 40851
16345, 5930, 5907, 39079, 39102, 5931, 5908, 39080, 39103, 6013, 40918, 40852, 40941, 6015, 40919, 40855, 
40942, 6016, 5969, 40784, 40854
16346, 5931, 5908, 39080, 39103, 5932, 5909, 39081, 39104, 6015, 40919, 40855, 40942, 6017, 40920, 40858, 
40943, 6018, 5971, 40787, 40857
16347, 5932, 5909, 39081, 39104, 5933, 5910, 39082, 39105, 6017, 40920, 40858, 40943, 6019, 40921, 40861, 
40944, 6020, 5973, 40790, 40860
16348, 5933, 5910, 39082, 39105, 5934, 5911, 39083, 39106, 6019, 40921, 40861, 40944, 6021, 40922, 40864, 
40945, 6022, 5975, 40793, 40863
16349, 5934, 5911, 39083, 39106, 5935, 5912, 39084, 39107, 6021, 40922, 40864, 40945, 6023, 40923, 40867, 
40946, 6024, 5977, 40796, 40866
16350, 5935, 5912, 39084, 39107, 5936, 5913, 39085, 39108, 6023, 40923, 40867, 40946, 6025, 40924, 40870, 
40947, 6026, 5979, 40799, 40869
16351, 5936, 5913, 39085, 39108, 5937, 5914, 39086, 39109, 6025, 40924, 40870, 40947, 6027, 40925, 40873, 
40948, 6028, 5981, 40802, 40872
16352, 5937, 5914, 39086, 39109, 5938, 5915, 39087, 39110, 6027, 40925, 40873, 40948, 6029, 40926, 40876, 
40949, 6030, 5983, 40805, 40875
16353, 5938, 5915, 39087, 39110, 5939, 5916, 39088, 39111, 6029, 40926, 40876, 40949, 6031, 40927, 40879, 
40950, 6032, 5985, 40808, 40878
16354, 5939, 5916, 39088, 39111, 177, 176, 4086, 4087, 6031, 40927, 40879, 40950, 179, 4143, 4141, 
4144, 6033, 5986, 40811, 40881
16355, 3, 121, 4008, 135, 350, 5917, 39089, 4948, 124, 4065, 4063, 147, 6034, 40928, 40882, 
5213, 373, 5988, 40812, 5211
16356, 350, 5917, 39089, 4948, 351, 5918, 39090, 4959, 6034, 40928, 40882, 5213, 6035, 40929, 40883, 
5236, 374, 5990, 40815, 5234
16357, 351, 5918, 39090, 4959, 352, 5919, 39091, 4970, 6035, 40929, 40883, 5236, 6036, 40930, 40884, 
5259, 375, 5992, 40818, 5257
16358, 352, 5919, 39091, 4970, 353, 5920, 39092, 4981, 6036, 40930, 40884, 5259, 6037, 40931, 40885, 
5282, 376, 5994, 40821, 5280
16359, 353, 5920, 39092, 4981, 354, 5921, 39093, 4992, 6037, 40931, 40885, 5282, 6038, 40932, 40886, 
5305, 377, 5996, 40824, 5303
16360, 354, 5921, 39093, 4992, 355, 5922, 39094, 5003, 6038, 40932, 40886, 5305, 6039, 40933, 40887, 
5328, 378, 5998, 40827, 5326
16361, 355, 5922, 39094, 5003, 356, 5923, 39095, 5014, 6039, 40933, 40887, 5328, 6040, 40934, 40888, 
5351, 379, 6000, 40830, 5349
16362, 356, 5923, 39095, 5014, 357, 5924, 39096, 5025, 6040, 40934, 40888, 5351, 6041, 40935, 40889, 
5374, 380, 6002, 40833, 5372
16363, 357, 5924, 39096, 5025, 358, 5925, 39097, 5036, 6041, 40935, 40889, 5374, 6042, 40936, 40890, 
5397, 381, 6004, 40836, 5395
16364, 358, 5925, 39097, 5036, 359, 5926, 39098, 5047, 6042, 40936, 40890, 5397, 6043, 40937, 40891, 
5420, 382, 6006, 40839, 5418
16365, 359, 5926, 39098, 5047, 360, 5927, 39099, 5058, 6043, 40937, 40891, 5420, 6044, 40938, 40892, 
5443, 383, 6008, 40842, 5441
16366, 360, 5927, 39099, 5058, 361, 5928, 39100, 5069, 6044, 40938, 40892, 5443, 6045, 40939, 40893, 
5466, 384, 6010, 40845, 5464
16367, 361, 5928, 39100, 5069, 362, 5929, 39101, 5080, 6045, 40939, 40893, 5466, 6046, 40940, 40894, 
5489, 385, 6012, 40848, 5487
16368, 362, 5929, 39101, 5080, 363, 5930, 39102, 5091, 6046, 40940, 40894, 5489, 6047, 40941, 40895, 
5512, 386, 6014, 40851, 5510
16369, 363, 5930, 39102, 5091, 364, 5931, 39103, 5102, 6047, 40941, 40895, 5512, 6048, 40942, 40896, 
5535, 387, 6016, 40854, 5533
16370, 364, 5931, 39103, 5102, 365, 5932, 39104, 5113, 6048, 40942, 40896, 5535, 6049, 40943, 40897, 
5558, 388, 6018, 40857, 5556
16371, 365, 5932, 39104, 5113, 366, 5933, 39105, 5124, 6049, 40943, 40897, 5558, 6050, 40944, 40898, 
5581, 389, 6020, 40860, 5579
16372, 366, 5933, 39105, 5124, 367, 5934, 39106, 5135, 6050, 40944, 40898, 5581, 6051, 40945, 40899, 
5604, 390, 6022, 40863, 5602
16373, 367, 5934, 39106, 5135, 368, 5935, 39107, 5146, 6051, 40945, 40899, 5604, 6052, 40946, 40900, 
5627, 391, 6024, 40866, 5625
16374, 368, 5935, 39107, 5146, 369, 5936, 39108, 5157, 6052, 40946, 40900, 5627, 6053, 40947, 40901, 
5650, 392, 6026, 40869, 5648
16375, 369, 5936, 39108, 5157, 370, 5937, 39109, 5168, 6053, 40947, 40901, 5650, 6054, 40948, 40902, 
5673, 393, 6028, 40872, 5671
16376, 370, 5937, 39109, 5168, 371, 5938, 39110, 5179, 6054, 40948, 40902, 5673, 6055, 40949, 40903, 
5696, 394, 6030, 40875, 5694
16377, 371, 5938, 39110, 5179, 372, 5939, 39111, 5190, 6055, 40949, 40903, 5696, 6056, 40950, 40904, 
5719, 395, 6032, 40878, 5717
16378, 372, 5939, 39111, 5190, 7, 177, 4087, 191, 6056, 40950, 40904, 5719, 180, 4144, 4142, 
203, 396, 6033, 40881, 5730
*ELEMENT, type=C3D20, ELSET=Volume2
16379, 4, 125, 4938, 303, 10, 518, 6125, 399, 136, 5191, 5192, 326, 529, 6378, 6379, 
422, 398, 6114, 40951, 6057
16380, 125, 126, 4939, 4938, 518, 519, 6126, 6125, 137, 5193, 5194, 5191, 530, 6380, 6381, 
6378, 6114, 6115, 40952, 40951
16381, 126, 127, 4940, 4939, 519, 520, 6127, 6126, 138, 5195, 5196, 5193, 531, 6382, 6383, 
6380, 6115, 6116, 40953, 40952
16382, 127, 128, 4941, 4940, 520, 521, 6128, 6127, 139, 5197, 5198, 5195, 532, 6384, 6385, 
6382, 6116, 6117, 40954, 40953
16383, 128, 129, 4942, 4941, 521, 522, 6129, 6128, 140, 5199, 5200, 5197, 533, 6386, 6387, 
6384, 6117, 6118, 40955, 40954
16384, 129, 130, 4943, 4942, 522, 523, 6130, 6129, 141, 5201, 5202, 5199, 534, 6388, 6389, 
6386, 6118, 6119, 40956, 40955
16385, 130, 131, 4944, 4943, 523, 524, 6131, 6130, 142, 5203, 5204, 5201, 535, 6390, 6391, 
6388, 6119, 6120, 40957, 40956
16386, 131, 132, 4945, 4944, 524, 525, 6132, 6131, 143, 5205, 5206, 5203, 536, 6392, 6393, 
6390, 6120, 6121, 40958, 40957
16387, 132, 133, 4946, 4945, 525, 526, 6133, 6132, 144, 5207, 5208, 5205, 537, 6394, 6395, 
6392, 6121, 6122, 40959, 40958
16388, 133, 134, 4947, 4946, 526, 527, 6134, 6133, 145, 5209, 5210, 5207, 538, 6396, 6397, 
6394, 6122, 6123, 40960, 40959
16389, 134, 135, 4948, 4947, 527, 528, 6135, 6134, 146, 5211, 5212, 5209, 539, 6398, 6399, 
6396, 6123, 6124, 40961, 40960
16390, 135, 3, 350, 4948, 528, 12, 471, 6135, 147, 373, 5213, 5211, 540, 494, 6400, 
6398, 6124, 470, 6091, 40961
16391, 303, 4938, 4949, 304, 399, 6125, 6136, 400, 5192, 5214, 5215, 327, 6379, 6401, 6402, 
423, 6057, 40951, 40962, 6058
16392, 4938, 4939, 4950, 4949, 6125, 6126, 6137, 6136, 5194, 5216, 5217, 5214, 6381, 6403, 6404, 
6401, 40951, 40952, 40963, 40962
16393, 4939, 4940, 4951, 4950, 6126, 6127, 6138, 6137, 5196, 5218, 5219, 5216, 6383, 6405, 6406, 
6403, 40952, 40953, 40964, 40963
16394, 4940, 4941, 4952, 4951, 6127, 6128, 6139, 6138, 5198, 5220, 5221, 5218, 6385, 6407, 6408, 
6405, 40953, 40954, 40965, 40964
16395, 4941, 4942, 4953, 4952, 6128, 6129, 6140, 6139, 5200, 5222, 5223, 5220, 6387, 6409, 6410, 
6407, 40954, 40955, 40966, 40965
16396, 4942, 4943, 4954, 4953, 6129, 6130, 6141, 6140, 5202, 5224, 5225, 5222, 6389, 6411, 6412, 
6409, 40955, 40956, 40967, 40966
16397, 4943, 4944, 4955, 4954, 6130, 6131, 6142, 6141, 5204, 5226, 5227, 5224, 6391, 6413, 6414, 
6411, 40956, 40957, 40968, 40967
16398, 4944, 4945, 4956, 4955, 6131, 6132, 6143, 6142, 5206, 5228, 5229, 5226, 6393, 6415, 6416, 
6413, 40957, 40958, 40969, 40968
16399, 4945, 4946, 4957, 4956, 6132, 6133, 6144, 6143, 5208, 5230, 5231, 5228, 6395, 6417, 6418, 
6415, 40958, 40959, 40970, 40969
16400, 4946, 4947, 4958, 4957, 6133, 6134, 6145, 6144, 5210, 5232, 5233, 5230, 6397, 6419, 6420, 
6417, 40959, 40960, 40971, 40970
16401, 4947, 4948, 4959, 4958, 6134, 6135, 6146, 6145, 5212, 5234, 5235, 5232, 6399, 6421, 6422, 
6419, 40960, 40961, 40972, 40971
16402, 4948, 350, 351, 4959, 6135, 471, 472, 6146, 5213, 374, 5236, 5234, 6400, 495, 6423, 
6421, 40961, 6091, 6092, 40972
16403, 304, 4949, 4960, 305, 400, 6136, 6147, 401, 5215, 5237, 5238, 328, 6402, 6424, 6425, 
424, 6058, 40962, 40973, 6059
16404, 4949, 4950, 4961, 4960, 6136, 6137, 6148, 6147, 5217, 5239, 5240, 5237, 6404, 6426, 6427, 
6424, 40962, 40963, 40974, 40973
16405, 4950, 4951, 4962, 4961, 6137, 6138, 6149, 6148, 5219, 5241, 5242, 5239, 6406, 6428, 6429, 
6426, 40963, 40964, 40975, 40974
16406, 4951, 4952, 4963, 4962, 6138, 6139, 6150, 6149, 5221, 5243, 5244, 5241, 6408, 6430, 6431, 
6428, 40964, 40965, 40976, 40975
16407, 4952, 4953, 4964, 4963, 6139, 6140, 6151, 6150, 5223, 5245, 5246, 5243, 6410, 6432, 6433, 
6430, 40965, 40966, 40977, 40976
16408, 4953, 4954, 4965, 4964, 6140, 6141, 6152, 6151, 5225, 5247, 5248, 5245, 6412, 6434, 6435, 
6432, 40966, 40967, 40978, 40977
16409, 4954, 4955, 4966, 4965, 6141, 6142, 6153, 6152, 5227, 5249, 5250, 5247, 6414, 6436, 6437, 
6434, 40967, 40968, 40979, 40978
16410, 4955, 4956, 4967, 4966, 6142, 6143, 6154, 6153, 5229, 5251, 5252, 5249, 6416, 6438, 6439, 
6436, 40968, 40969, 40980, 40979
16411, 4956, 4957, 4968, 4967, 6143, 6144, 6155, 6154, 5231, 5253, 5254, 5251, 6418, 6440, 6441, 
6438, 40969, 40970, 40981, 40980
16412, 4957, 4958, 4969, 4968, 6144, 6145, 6156, 6155, 5233, 5255, 5256, 5253, 6420, 6442, 6443, 
6440, 40970, 40971, 40982, 40981
16413, 4958, 4959, 4970, 4969, 6145, 6146, 6157, 6156, 5235, 5257, 5258, 5255, 6422, 6444, 6445, 
6442, 40971, 40972, 40983, 40982
16414, 4959, 351, 352, 4970, 6146, 472, 473, 6157, 5236, 375, 5259, 5257, 6423, 496, 6446, 
6444, 40972, 6092, 6093, 40983
16415, 305, 4960, 4971, 306, 401, 6147, 6158, 402, 5238, 5260, 5261, 329, 6425, 6447, 6448, 
425, 6059, 40973, 40984, 6060
16416, 4960, 4961, 4972, 4971, 6147, 6148, 6159, 6158, 5240, 5262, 5263, 5260, 6427, 6449, 6450, 
6447, 40973, 40974, 40985, 40984
16417, 4961, 4962, 4973, 4972, 6148, 6149, 6160, 6159, 5242, 5264, 5265, 5262, 6429, 6451, 6452, 
6449, 40974, 40975, 40986, 40985
16418, 4962, 4963, 4974, 4973, 6149, 6150, 6161, 6160, 5244, 5266, 5267, 5264, 6431, 6453, 6454, 
6451, 40975, 40976, 40987, 40986
16419, 4963, 4964, 4975, 4974, 6150, 6151, 6162, 6161, 5246, 5268, 5269, 5266, 6433, 6455, 6456, 
6453, 40976, 40977, 40988, 40987
16420, 4964, 4965, 4976, 4975, 6151, 6152, 6163, 6162, 5248, 5270, 5271, 5268, 6435, 6457, 6458, 
6455, 40977, 40978, 40989, 40988
16421, 4965, 4966, 4977, 4976, 6152, 6153, 6164, 6163, 5250, 5272, 5273, 5270, 6437, 6459, 6460, 
6457, 40978, 40979, 40990, 40989
16422, 4966, 4967, 4978, 4977, 6153, 6154, 6165, 6164, 5252, 5274, 5275, 5272, 6439, 6461, 6462, 
6459, 40979, 40980, 40991, 40990
16423, 4967, 4968, 4979, 4978, 6154, 6155, 6166, 6165, 5254, 5276, 5277, 5274, 6441, 6463, 6464, 
6461, 40980, 40981, 40992, 40991
16424, 4968, 4969, 4980, 4979, 6155, 6156, 6167, 6166, 5256, 5278, 5279, 5276, 6443, 6465, 6466, 
6463, 40981, 40982, 40993, 40992
16425, 4969, 4970, 4981, 4980, 6156, 6157, 6168, 6167, 5258, 5280, 5281, 5278, 6445, 6467, 6468, 
6465, 40982, 40983, 40994, 40993
16426, 4970, 352, 353, 4981, 6157, 473, 474, 6168, 5259, 376, 5282, 5280, 6446, 497, 6469, 
6467, 40983, 6093, 6094, 40994
16427, 306, 4971, 4982, 307, 402, 6158, 6169, 403, 5261, 5283, 5284, 330, 6448, 6470, 6471, 
426, 6060, 40984, 40995, 6061
16428, 4971, 4972, 4983, 4982, 6158, 6159, 6170, 6169, 5263, 5285, 5286, 5283, 6450, 6472, 6473, 
6470, 40984, 40985, 40996, 40995
16429, 4972, 4973, 4984, 4983, 6159, 6160, 6171, 6170, 5265, 5287, 5288, 5285, 6452, 6474, 6475, 
6472, 40985, 40986, 40997, 40996
16430, 4973, 4974, 4985, 4984, 6160, 6161, 6172, 6171, 5267, 5289, 5290, 5287, 6454, 6476, 6477, 
6474, 40986, 40987, 40998, 40997
16431, 4974, 4975, 4986, 4985, 6161, 6162, 6173, 6172, 5269, 5291, 5292, 5289, 6456, 6478, 6479, 
6476, 40987, 40988, 40999, 40998
16432, 4975, 4976, 4987, 4986, 6162, 6163, 6174, 6173, 5271, 5293, 5294, 5291, 6458, 6480, 6481, 
6478, 40988, 40989, 41000, 40999
16433, 4976, 4977, 4988, 4987, 6163, 6164, 6175, 6174, 5273, 5295, 5296, 5293, 6460, 6482, 6483, 
6480, 40989, 40990, 41001, 41000
16434, 4977, 4978, 4989, 4988, 6164, 6165, 6176, 6175, 5275, 5297, 5298, 5295, 6462, 6484, 6485, 
6482, 40990, 40991, 41002, 41001
16435, 4978, 4979, 4990, 4989, 6165, 6166, 6177, 6176, 5277, 5299, 5300, 5297, 6464, 6486, 6487, 
6484, 40991, 40992, 41003, 41002
16436, 4979, 4980, 4991, 4990, 6166, 6167, 6178, 6177, 5279, 5301, 5302, 5299, 6466, 6488, 6489, 
6486, 40992, 40993, 41004, 41003
16437, 4980, 4981, 4992, 4991, 6167, 6168, 6179, 6178, 5281, 5303, 5304, 5301, 6468, 6490, 6491, 
6488, 40993, 40994, 41005, 41004
16438, 4981, 353, 354, 4992, 6168, 474, 475, 6179, 5282, 377, 5305, 5303, 6469, 498, 6492, 
6490, 40994, 6094, 6095, 41005
16439, 307, 4982, 4993, 308, 403, 6169, 6180, 404, 5284, 5306, 5307, 331, 6471, 6493, 6494, 
427, 6061, 40995, 41006, 6062
16440, 4982, 4983, 4994, 4993, 6169, 6170, 6181, 6180, 5286, 5308, 5309, 5306, 6473, 6495, 6496, 
6493, 40995, 40996, 41007, 41006
16441, 4983, 4984, 4995, 4994, 6170, 6171, 6182, 6181, 5288, 5310, 5311, 5308, 6475, 6497, 6498, 
6495, 40996, 40997, 41008, 41007
16442, 4984, 4985, 4996, 4995, 6171, 6172, 6183, 6182, 5290, 5312, 5313, 5310, 6477, 6499, 6500, 
6497, 40997, 40998, 41009, 41008
16443, 4985, 4986, 4997, 4996, 6172, 6173, 6184, 6183, 5292, 5314, 5315, 5312, 6479, 6501, 6502, 
6499, 40998, 40999, 41010, 41009
16444, 4986, 4987, 4998, 4997, 6173, 6174, 6185, 6184, 5294, 5316, 5317, 5314, 6481, 6503, 6504, 
6501, 40999, 41000, 41011, 41010
16445, 4987, 4988, 4999, 4998, 6174, 6175, 6186, 6185, 5296, 5318, 5319, 5316, 6483, 6505, 6506, 
6503, 41000, 41001, 41012, 41011
16446, 4988, 4989, 5000, 4999, 6175, 6176, 6187, 6186, 5298, 5320, 5321, 5318, 6485, 6507, 6508, 
6505, 41001, 41002, 41013, 41012
16447, 4989, 4990, 5001, 5000, 6176, 6177, 6188, 6187, 5300, 5322, 5323, 5320, 6487, 6509, 6510, 
6507, 41002, 41003, 41014, 41013
16448, 4990, 4991, 5002, 5001, 6177, 6178, 6189, 6188, 5302, 5324, 5325, 5322, 6489, 6511, 6512, 
6509, 41003, 41004, 41015, 41014
16449, 4991, 4992, 5003, 5002, 6178, 6179, 6190, 6189, 5304, 5326, 5327, 5324, 6491, 6513, 6514, 
6511, 41004, 41005, 41016, 41015
16450, 4992, 354, 355, 5003, 6179, 475, 476, 6190, 5305, 378, 5328, 5326, 6492, 499, 6515, 
6513, 41005, 6095, 6096, 41016
16451, 308, 4993, 5004, 309, 404, 6180, 6191, 405, 5307, 5329, 5330, 332, 6494, 6516, 6517, 
428, 6062, 41006, 41017, 6063
16452, 4993, 4994, 5005, 5004, 6180, 6181, 6192, 6191, 5309, 5331, 5332, 5329, 6496, 6518, 6519, 
6516, 41006, 41007, 41018, 41017
16453, 4994, 4995, 5006, 5005, 6181, 6182, 6193, 6192, 5311, 5333, 5334, 5331, 6498, 6520, 6521, 
6518, 41007, 41008, 41019, 41018
16454, 4995, 4996, 5007, 5006, 6182, 6183, 6194, 6193, 5313, 5335, 5336, 5333, 6500, 6522, 6523, 
6520, 41008, 41009, 41020, 41019
16455, 4996, 4997, 5008, 5007, 6183, 6184, 6195, 6194, 5315, 5337, 5338, 5335, 6502, 6524, 6525, 
6522, 41009, 41010, 41021, 41020
16456, 4997, 4998, 5009, 5008, 6184, 6185, 6196, 6195, 5317, 5339, 5340, 5337, 6504, 6526, 6527, 
6524, 41010, 41011, 41022, 41021
16457, 4998, 4999, 5010, 5009, 6185, 6186, 6197, 6196, 5319, 5341, 5342, 5339, 6506, 6528, 6529, 
6526, 41011, 41012, 41023, 41022
16458, 4999, 5000, 5011, 5010, 6186, 6187, 6198, 6197, 5321, 5343, 5344, 5341, 6508, 6530, 6531, 
6528, 41012, 41013, 41024, 41023
16459, 5000, 5001, 5012, 5011, 6187, 6188, 6199, 6198, 5323, 5345, 5346, 5343, 6510, 6532, 6533, 
6530, 41013, 41014, 41025, 41024
16460, 5001, 5002, 5013, 5012, 6188, 6189, 6200, 6199, 5325, 5347, 5348, 5345, 6512, 6534, 6535, 
6532, 41014, 41015, 41026, 41025
16461, 5002, 5003, 5014, 5013, 6189, 6190, 6201, 6200, 5327, 5349, 5350, 5347, 6514, 6536, 6537, 
6534, 41015, 41016, 41027, 41026
16462, 5003, 355, 356, 5014, 6190, 476, 477, 6201, 5328, 379, 5351, 5349, 6515, 500, 6538, 
6536, 41016, 6096, 6097, 41027
16463, 309, 5004, 5015, 310, 405, 6191, 6202, 406, 5330, 5352, 5353, 333, 6517, 6539, 6540, 
429, 6063, 41017, 41028, 6064
16464, 5004, 5005, 5016, 5015, 6191, 6192, 6203, 6202, 5332, 5354, 5355, 5352, 6519, 6541, 6542, 
6539, 41017, 41018, 41029, 41028
16465, 5005, 5006, 5017, 5016, 6192, 6193, 6204, 6203, 5334, 5356, 5357, 5354, 6521, 6543, 6544, 
6541, 41018, 41019, 41030, 41029
16466, 5006, 5007, 5018, 5017, 6193, 6194, 6205, 6204, 5336, 5358, 5359, 5356, 6523, 6545, 6546, 
6543, 41019, 41020, 41031, 41030
16467, 5007, 5008, 5019, 5018, 6194, 6195, 6206, 6205, 5338, 5360, 5361, 5358, 6525, 6547, 6548, 
6545, 41020, 41021, 41032, 41031
16468, 5008, 5009, 5020, 5019, 6195, 6196, 6207, 6206, 5340, 5362, 5363, 5360, 6527, 6549, 6550, 
6547, 41021, 41022, 41033, 41032
16469, 5009, 5010, 5021, 5020, 6196, 6197, 6208, 6207, 5342, 5364, 5365, 5362, 6529, 6551, 6552, 
6549, 41022, 41023, 41034, 41033
16470, 5010, 5011, 5022, 5021, 6197, 6198, 6209, 6208, 5344, 5366, 5367, 5364, 6531, 6553, 6554, 
6551, 41023, 41024, 41035, 41034
16471, 5011, 5012, 5023, 5022, 6198, 6199, 6210, 6209, 5346, 5368, 5369, 5366, 6533, 6555, 6556, 
6553, 41024, 41025, 41036, 41035
16472, 5012, 5013, 5024, 5023, 6199, 6200, 6211, 6210, 5348, 5370, 5371, 5368, 6535, 6557, 6558, 
6555, 41025, 41026, 41037, 41036
16473, 5013, 5014, 5025, 5024, 6200, 6201, 6212, 6211, 5350, 5372, 5373, 5370, 6537, 6559, 6560, 
6557, 41026, 41027, 41038, 41037
16474, 5014, 356, 357, 5025, 6201, 477, 478, 6212, 5351, 380, 5374, 5372, 6538, 501, 6561, 
6559, 41027, 6097, 6098, 41038
16475, 310, 5015, 5026, 311, 406, 6202, 6213, 407, 5353, 5375, 5376, 334, 6540, 6562, 6563, 
430, 6064, 41028, 41039, 6065
16476, 5015, 5016, 5027, 5026, 6202, 6203, 6214, 6213, 5355, 5377, 5378, 5375, 6542, 6564, 6565, 
6562, 41028, 41029, 41040, 41039
16477, 5016, 5017, 5028, 5027, 6203, 6204, 6215, 6214, 5357, 5379, 5380, 5377, 6544, 6566, 6567, 
6564, 41029, 41030, 41041, 41040
16478, 5017, 5018, 5029, 5028, 6204, 6205, 6216, 6215, 5359, 5381, 5382, 5379, 6546, 6568, 6569, 
6566, 41030, 41031, 41042, 41041
16479, 5018, 5019, 5030, 5029, 6205, 6206, 6217, 6216, 5361, 5383, 5384, 5381, 6548, 6570, 6571, 
6568, 41031, 41032, 41043, 41042
16480, 5019, 5020, 5031, 5030, 6206, 6207, 6218, 6217, 5363, 5385, 5386, 5383, 6550, 6572, 6573, 
6570, 41032, 41033, 41044, 41043
16481, 5020, 5021, 5032, 5031, 6207, 6208, 6219, 6218, 5365, 5387, 5388, 5385, 6552, 6574, 6575, 
6572, 41033, 41034, 41045, 41044
16482, 5021, 5022, 5033, 5032, 6208, 6209, 6220, 6219, 5367, 5389, 5390, 5387, 6554, 6576, 6577, 
6574, 41034, 41035, 41046, 41045
16483, 5022, 5023, 5034, 5033, 6209, 6210, 6221, 6220, 5369, 5391, 5392, 5389, 6556, 6578, 6579, 
6576, 41035, 41036, 41047, 41046
16484, 5023, 5024, 5035, 5034, 6210, 6211, 6222, 6221, 5371, 5393, 5394, 5391, 6558, 6580, 6581, 
6578, 41036, 41037, 41048, 41047
16485, 5024, 5025, 5036, 5035, 6211, 6212, 6223, 6222, 5373, 5395, 5396, 5393, 6560, 6582, 6583, 
6580, 41037, 41038, 41049, 41048
16486, 5025, 357, 358, 5036, 6212, 478, 479, 6223, 5374, 381, 5397, 5395, 6561, 502, 6584, 
6582, 41038, 6098, 6099, 41049
16487, 311, 5026, 5037, 312, 407, 6213, 6224, 408, 5376, 5398, 5399, 335, 6563, 6585, 6586, 
431, 6065, 41039, 41050, 6066
16488, 5026, 5027, 5038, 5037, 6213, 6214, 6225, 6224, 5378, 5400, 5401, 5398, 6565, 6587, 6588, 
6585, 41039, 41040, 41051, 41050
16489, 5027, 5028, 5039, 5038, 6214, 6215, 6226, 6225, 5380, 5402, 5403, 5400, 6567, 6589, 6590, 
6587, 41040, 41041, 41052, 41051
16490, 5028, 5029, 5040, 5039, 6215, 6216, 6227, 6226, 5382, 5404, 5405, 5402, 6569, 6591, 6592, 
6589, 41041, 41042, 41053, 41052
16491, 5029, 5030, 5041, 5040, 6216, 6217, 6228, 6227, 5384, 5406, 5407, 5404, 6571, 6593, 6594, 
6591, 41042, 41043, 41054, 41053
16492, 5030, 5031, 5042, 5041, 6217, 6218, 6229, 6228, 5386, 5408, 5409, 5406, 6573, 6595, 6596, 
6593, 41043, 41044, 41055, 41054
16493, 5031, 5032, 5043, 5042, 6218, 6219, 6230, 6229, 5388, 5410, 5411, 5408, 6575, 6597, 6598, 
6595, 41044, 41045, 41056, 41055
16494, 5032, 5033, 5044, 5043, 6219, 6220, 6231, 6230, 5390, 5412, 5413, 5410, 6577, 6599, 6600, 
6597, 41045, 41046, 41057, 41056
16495, 5033, 5034, 5045, 5044, 6220, 6221, 6232, 6231, 5392, 5414, 5415, 5412, 6579, 6601, 6602, 
6599, 41046, 41047, 41058, 41057
16496, 5034, 5035, 5046, 5045, 6221, 6222, 6233, 6232, 5394, 5416, 5417, 5414, 6581, 6603, 6604, 
6601, 41047, 41048, 41059, 41058
16497, 5035, 5036, 5047, 5046, 6222, 6223, 6234, 6233, 5396, 5418, 5419, 5416, 6583, 6605, 6606, 
6603, 41048, 41049, 41060, 41059
16498, 5036, 358, 359, 5047, 6223, 479, 480, 6234, 5397, 382, 5420, 5418, 6584, 503, 6607, 
6605, 41049, 6099, 6100, 41060
16499, 312, 5037, 5048, 313, 408, 6224, 6235, 409, 5399, 5421, 5422, 336, 6586, 6608, 6609, 
432, 6066, 41050, 41061, 6067
16500, 5037, 5038, 5049, 5048, 6224, 6225, 6236, 6235, 5401, 5423, 5424, 5421, 6588, 6610, 6611, 
6608, 41050, 41051, 41062, 41061
16501, 5038, 5039, 5050, 5049, 6225, 6226, 6237, 6236, 5403, 5425, 5426, 5423, 6590, 6612, 6613, 
6610, 41051, 41052, 41063, 41062
16502, 5039, 5040, 5051, 5050, 6226, 6227, 6238, 6237, 5405, 5427, 5428, 5425, 6592, 6614, 6615, 
6612, 41052, 41053, 41064, 41063
16503, 5040, 5041, 5052, 5051, 6227, 6228, 6239, 6238, 5407, 5429, 5430, 5427, 6594, 6616, 6617, 
6614, 41053, 41054, 41065, 41064
16504, 5041, 5042, 5053, 5052, 6228, 6229, 6240, 6239, 5409, 5431, 5432, 5429, 6596, 6618, 6619, 
6616, 41054, 41055, 41066, 41065
16505, 5042, 5043, 5054, 5053, 6229, 6230, 6241, 6240, 5411, 5433, 5434, 5431, 6598, 6620, 6621, 
6618, 41055, 41056, 41067, 41066
16506, 5043, 5044, 5055, 5054, 6230, 6231, 6242, 6241, 5413, 5435, 5436, 5433, 6600, 6622, 6623, 
6620, 41056, 41057, 41068, 41067
16507, 5044, 5045, 5056, 5055, 6231, 6232, 6243, 6242, 5415, 5437, 5438, 5435, 6602, 6624, 6625, 
6622, 41057, 41058, 41069, 41068
16508, 5045, 5046, 5057, 5056, 6232, 6233, 6244, 6243, 5417, 5439, 5440, 5437, 6604, 6626, 6627, 
6624, 41058, 41059, 41070, 41069
16509, 5046, 5047, 5058, 5057, 6233, 6234, 6245, 6244, 5419, 5441, 5442, 5439, 6606, 6628, 6629, 
6626, 41059, 41060, 41071, 41070
16510, 5047, 359, 360, 5058, 6234, 480, 481, 6245, 5420, 383, 5443, 5441, 6607, 504, 6630, 
6628, 41060, 6100, 6101, 41071
16511, 313, 5048, 5059, 314, 409, 6235, 6246, 410, 5422, 5444, 5445, 337, 6609, 6631, 6632, 
433, 6067, 41061, 41072, 6068
16512, 5048, 5049, 5060, 5059, 6235, 6236, 6247, 6246, 5424, 5446, 5447, 5444, 6611, 6633, 6634, 
6631, 41061, 41062, 41073, 41072
16513, 5049, 5050, 5061, 5060, 6236, 6237, 6248, 6247, 5426, 5448, 5449, 5446, 6613, 6635, 6636, 
6633, 41062, 41063, 41074, 41073
16514, 5050, 5051, 5062, 5061, 6237, 6238, 6249, 6248, 5428, 5450, 5451, 5448, 6615, 6637, 6638, 
6635, 41063, 41064, 41075, 41074
16515, 5051, 5052, 5063, 5062, 6238, 6239, 6250, 6249, 5430, 5452, 5453, 5450, 6617, 6639, 6640, 
6637, 41064, 41065, 41076, 41075
16516, 5052, 5053, 5064, 5063, 6239, 6240, 6251, 6250, 5432, 5454, 5455, 5452, 6619, 6641, 6642, 
6639, 41065, 41066, 41077, 41076
16517, 5053, 5054, 5065, 5064, 6240, 6241, 6252, 6251, 5434, 5456, 5457, 5454, 6621, 6643, 6644, 
6641, 41066, 41067, 41078, 41077
16518, 5054, 5055, 5066, 5065, 6241, 6242, 6253, 6252, 5436, 5458, 5459, 5456, 6623, 6645, 6646, 
6643, 41067, 41068, 41079, 41078
16519, 5055, 5056, 5067, 5066, 6242, 6243, 6254, 6253, 5438, 5460, 5461, 5458, 6625, 6647, 6648, 
6645, 41068, 41069, 41080, 41079
16520, 5056, 5057, 5068, 5067, 6243, 6244, 6255, 6254, 5440, 5462, 5463, 5460, 6627, 6649, 6650, 
6647, 41069, 41070, 41081, 41080
16521, 5057, 5058, 5069, 5068, 6244, 6245, 6256, 6255, 5442, 5464, 5465, 5462, 6629, 6651, 6652, 
6649, 41070, 41071, 41082, 41081
16522, 5058, 360, 361, 5069, 6245, 481, 482, 6256, 5443, 384, 5466, 5464, 6630, 505, 6653, 
6651, 41071, 6101, 6102, 41082
16523, 314, 5059, 5070, 315, 410, 6246, 6257, 411, 5445, 5467, 5468, 338, 6632, 6654, 6655, 
434, 6068, 41072, 41083, 6069
16524, 5059, 5060, 5071, 5070, 6246, 6247, 6258, 6257, 5447, 5469, 5470, 5467, 6634, 6656, 6657, 
6654, 41072, 41073, 41084, 41083
16525, 5060, 5061, 5072, 5071, 6247, 6248, 6259, 6258, 5449, 5471, 5472, 5469, 6636, 6658, 6659, 
6656, 41073, 41074, 41085, 41084
16526, 5061, 5062, 5073, 5072, 6248, 6249, 6260, 6259, 5451, 5473, 5474, 5471, 6638, 6660, 6661, 
6658, 41074, 41075, 41086, 41085
16527, 5062, 5063, 5074, 5073, 6249, 6250, 6261, 6260, 5453, 5475, 5476, 5473, 6640, 6662, 6663, 
6660, 41075, 41076, 41087, 41086
16528, 5063, 5064, 5075, 5074, 6250, 6251, 6262, 6261, 5455, 5477, 5478, 5475, 6642, 6664, 6665, 
6662, 41076, 41077, 41088, 41087
16529, 5064, 5065, 5076, 5075, 6251, 6252, 6263, 6262, 5457, 5479, 5480, 5477, 6644, 6666, 6667, 
6664, 41077, 41078, 41089, 41088
16530, 5065, 5066, 5077, 5076, 6252, 6253, 6264, 6263, 5459, 5481, 5482, 5479, 6646, 6668, 6669, 
6666, 41078, 41079, 41090, 41089
16531, 5066, 5067, 5078, 5077, 6253, 6254, 6265, 6264, 5461, 5483, 5484, 5481, 6648, 6670, 6671, 
6668, 41079, 41080, 41091, 41090
16532, 5067, 5068, 5079, 5078, 6254, 6255, 6266, 6265, 5463, 5485, 5486, 5483, 6650, 6672, 6673, 
6670, 41080, 41081, 41092, 41091
16533, 5068, 5069, 5080, 5079, 6255, 6256, 6267, 6266, 5465, 5487, 5488, 5485, 6652, 6674, 6675, 
6672, 41081, 41082, 41093, 41092
16534, 5069, 361, 362, 5080, 6256, 482, 483, 6267, 5466, 385, 5489, 5487, 6653, 506, 6676, 
6674, 41082, 6102, 6103, 41093
16535, 315, 5070, 5081, 316, 411, 6257, 6268, 412, 5468, 5490, 5491, 339, 6655, 6677, 6678, 
435, 6069, 41083, 41094, 6070
16536, 5070, 5071, 5082, 5081, 6257, 6258, 6269, 6268, 5470, 5492, 5493, 5490, 6657, 6679, 6680, 
6677, 41083, 41084, 41095, 41094
16537, 5071, 5072, 5083, 5082, 6258, 6259, 6270, 6269, 5472, 5494, 5495, 5492, 6659, 6681, 6682, 
6679, 41084, 41085, 41096, 41095
16538, 5072, 5073, 5084, 5083, 6259, 6260, 6271, 6270, 5474, 5496, 5497, 5494, 6661, 6683, 6684, 
6681, 41085, 41086, 41097, 41096
16539, 5073, 5074, 5085, 5084, 6260, 6261, 6272, 6271, 5476, 5498, 5499, 5496, 6663, 6685, 6686, 
6683, 41086, 41087, 41098, 41097
16540, 5074, 5075, 5086, 5085, 6261, 6262, 6273, 6272, 5478, 5500, 5501, 5498, 6665, 6687, 6688, 
6685, 41087, 41088, 41099, 41098
16541, 5075, 5076, 5087, 5086, 6262, 6263, 6274, 6273, 5480, 5502, 5503, 5500, 6667, 6689, 6690, 
6687, 41088, 41089, 41100, 41099
16542, 5076, 5077, 5088, 5087, 6263, 6264, 6275, 6274, 5482, 5504, 5505, 5502, 6669, 6691, 6692, 
6689, 41089, 41090, 41101, 41100
16543, 5077, 5078, 5089, 5088, 6264, 6265, 6276, 6275, 5484, 5506, 5507, 5504, 6671, 6693, 6694, 
6691, 41090, 41091, 41102, 41101
16544, 5078, 5079, 5090, 5089, 6265, 6266, 6277, 6276, 5486, 5508, 5509, 5506, 6673, 6695, 6696, 
6693, 41091, 41092, 41103, 41102
16545, 5079, 5080, 5091, 5090, 6266, 6267, 6278, 6277, 5488, 5510, 5511, 5508, 6675, 6697, 6698, 
6695, 41092, 41093, 41104, 41103
16546, 5080, 362, 363, 5091, 6267, 483, 484, 6278, 5489, 386, 5512, 5510, 6676, 507, 6699, 
6697, 41093, 6103, 6104, 41104
16547, 316, 5081, 5092, 317, 412, 6268, 6279, 413, 5491, 5513, 5514, 340, 6678, 6700, 6701, 
436, 6070, 41094, 41105, 6071
16548, 5081, 5082, 5093, 5092, 6268, 6269, 6280, 6279, 5493, 5515, 5516, 5513, 6680, 6702, 6703, 
6700, 41094, 41095, 41106, 41105
16549, 5082, 5083, 5094, 5093, 6269, 6270, 6281, 6280, 5495, 5517, 5518, 5515, 6682, 6704, 6705, 
6702, 41095, 41096, 41107, 41106
16550, 5083, 5084, 5095, 5094, 6270, 6271, 6282, 6281, 5497, 5519, 5520, 5517, 6684, 6706, 6707, 
6704, 41096, 41097, 41108, 41107
16551, 5084, 5085, 5096, 5095, 6271, 6272, 6283, 6282, 5499, 5521, 5522, 5519, 6686, 6708, 6709, 
6706, 41097, 41098, 41109, 41108
16552, 5085, 5086, 5097, 5096, 6272, 6273, 6284, 6283, 5501, 5523, 5524, 5521, 6688, 6710, 6711, 
6708, 41098, 41099, 41110, 41109
16553, 5086, 5087, 5098, 5097, 6273, 6274, 6285, 6284, 5503, 5525, 5526, 5523, 6690, 6712, 6713, 
6710, 41099, 41100, 41111, 41110
16554, 5087, 5088, 5099, 5098, 6274, 6275, 6286, 6285, 5505, 5527, 5528, 5525, 6692, 6714, 6715, 
6712, 41100, 41101, 41112, 41111
16555, 5088, 5089, 5100, 5099, 6275, 6276, 6287, 6286, 5507, 5529, 5530, 5527, 6694, 6716, 6717, 
6714, 41101, 41102, 41113, 41112
16556, 5089, 5090, 5101, 5100, 6276, 6277, 6288, 6287, 5509, 5531, 5532, 5529, 6696, 6718, 6719, 
6716, 41102, 41103, 41114, 41113
16557, 5090, 5091, 5102, 5101, 6277, 6278, 6289, 6288, 5511, 5533, 5534, 5531, 6698, 6720, 6721, 
6718, 41103, 41104, 41115, 41114
16558, 5091, 363, 364, 5102, 6278, 484, 485, 6289, 5512, 387, 5535, 5533, 6699, 508, 6722, 
6720, 41104, 6104, 6105, 41115
16559, 317, 5092, 5103, 318, 413, 6279, 6290, 414, 5514, 5536, 5537, 341, 6701, 6723, 6724, 
437, 6071, 41105, 41116, 6072
16560, 5092, 5093, 5104, 5103, 6279, 6280, 6291, 6290, 5516, 5538, 5539, 5536, 6703, 6725, 6726, 
6723, 41105, 41106, 41117, 41116
16561, 5093, 5094, 5105, 5104, 6280, 6281, 6292, 6291, 5518, 5540, 5541, 5538, 6705, 6727, 6728, 
6725, 41106, 41107, 41118, 41117
16562, 5094, 5095, 5106, 5105, 6281, 6282, 6293, 6292, 5520, 5542, 5543, 5540, 6707, 6729, 6730, 
6727, 41107, 41108, 41119, 41118
16563, 5095, 5096, 5107, 5106, 6282, 6283, 6294, 6293, 5522, 5544, 5545, 5542, 6709, 6731, 6732, 
6729, 41108, 41109, 41120, 41119
16564, 5096, 5097, 5108, 5107, 6283, 6284, 6295, 6294, 5524, 5546, 5547, 5544, 6711, 6733, 6734, 
6731, 41109, 41110, 41121, 41120
16565, 5097, 5098, 5109, 5108, 6284, 6285, 6296, 6295, 5526, 5548, 5549, 5546, 6713, 6735, 6736, 
6733, 41110, 41111, 41122, 41121
16566, 5098, 5099, 5110, 5109, 6285, 6286, 6297, 6296, 5528, 5550, 5551, 5548, 6715, 6737, 6738, 
6735, 41111, 41112, 41123, 41122
16567, 5099, 5100, 5111, 5110, 6286, 6287, 6298, 6297, 5530, 5552, 5553, 5550, 6717, 6739, 6740, 
6737, 41112, 41113, 41124, 41123
16568, 5100, 5101, 5112, 5111, 6287, 6288, 6299, 6298, 5532, 5554, 5555, 5552, 6719, 6741, 6742, 
6739, 41113, 41114, 41125, 41124
16569, 5101, 5102, 5113, 5112, 6288, 6289, 6300, 6299, 5534, 5556, 5557, 5554, 6721, 6743, 6744, 
6741, 41114, 41115, 41126, 41125
16570, 5102, 364, 365, 5113, 6289, 485, 486, 6300, 5535, 388, 5558, 5556, 6722, 509, 6745, 
6743, 41115, 6105, 6106, 41126
16571, 318, 5103, 5114, 319, 414, 6290, 6301, 415, 5537, 5559, 5560, 342, 6724, 6746, 6747, 
438, 6072, 41116, 41127, 6073
16572, 5103, 5104, 5115, 5114, 6290, 6291, 6302, 6301, 5539, 5561, 5562, 5559, 6726, 6748, 6749, 
6746, 41116, 41117, 41128, 41127
16573, 5104, 5105, 5116, 5115, 6291, 6292, 6303, 6302, 5541, 5563, 5564, 5561, 6728, 6750, 6751, 
6748, 41117, 41118, 41129, 41128
16574, 5105, 5106, 5117, 5116, 6292, 6293, 6304, 6303, 5543, 5565, 5566, 5563, 6730, 6752, 6753, 
6750, 41118, 41119, 41130, 41129
16575, 5106, 5107, 5118, 5117, 6293, 6294, 6305, 6304, 5545, 5567, 5568, 5565, 6732, 6754, 6755, 
6752, 41119, 41120, 41131, 41130
16576, 5107, 5108, 5119, 5118, 6294, 6295, 6306, 6305, 5547, 5569, 5570, 5567, 6734, 6756, 6757, 
6754, 41120, 41121, 41132, 41131
16577, 5108, 5109, 5120, 5119, 6295, 6296, 6307, 6306, 5549, 5571, 5572, 5569, 6736, 6758, 6759, 
6756, 41121, 41122, 41133, 41132
16578, 5109, 5110, 5121, 5120, 6296, 6297, 6308, 6307, 5551, 5573, 5574, 5571, 6738, 6760, 6761, 
6758, 41122, 41123, 41134, 41133
16579, 5110, 5111, 5122, 5121, 6297, 6298, 6309, 6308, 5553, 5575, 5576, 5573, 6740, 6762, 6763, 
6760, 41123, 41124, 41135, 41134
16580, 5111, 5112, 5123, 5122, 6298, 6299, 6310, 6309, 5555, 5577, 5578, 5575, 6742, 6764, 6765, 
6762, 41124, 41125, 41136, 41135
16581, 5112, 5113, 5124, 5123, 6299, 6300, 6311, 6310, 5557, 5579, 5580, 5577, 6744, 6766, 6767, 
6764, 41125, 41126, 41137, 41136
16582, 5113, 365, 366, 5124, 6300, 486, 487, 6311, 5558, 389, 5581, 5579, 6745, 510, 6768, 
6766, 41126, 6106, 6107, 41137
16583, 319, 5114, 5125, 320, 415, 6301, 6312, 416, 5560, 5582, 5583, 343, 6747, 6769, 6770, 
439, 6073, 41127, 41138, 6074
16584, 5114, 5115, 5126, 5125, 6301, 6302, 6313, 6312, 5562, 5584, 5585, 5582, 6749, 6771, 6772, 
6769, 41127, 41128, 41139, 41138
16585, 5115, 5116, 5127, 5126, 6302, 6303, 6314, 6313, 5564, 5586, 5587, 5584, 6751, 6773, 6774, 
6771, 41128, 41129, 41140, 41139
16586, 5116, 5117, 5128, 5127, 6303, 6304, 6315, 6314, 5566, 5588, 5589, 5586, 6753, 6775, 6776, 
6773, 41129, 41130, 41141, 41140
16587, 5117, 5118, 5129, 5128, 6304, 6305, 6316, 6315, 5568, 5590, 5591, 5588, 6755, 6777, 6778, 
6775, 41130, 41131, 41142, 41141
16588, 5118, 5119, 5130, 5129, 6305, 6306, 6317, 6316, 5570, 5592, 5593, 5590, 6757, 6779, 6780, 
6777, 41131, 41132, 41143, 41142
16589, 5119, 5120, 5131, 5130, 6306, 6307, 6318, 6317, 5572, 5594, 5595, 5592, 6759, 6781, 6782, 
6779, 41132, 41133, 41144, 41143
16590, 5120, 5121, 5132, 5131, 6307, 6308, 6319, 6318, 5574, 5596, 5597, 5594, 6761, 6783, 6784, 
6781, 41133, 41134, 41145, 41144
16591, 5121, 5122, 5133, 5132, 6308, 6309, 6320, 6319, 5576, 5598, 5599, 5596, 6763, 6785, 6786, 
6783, 41134, 41135, 41146, 41145
16592, 5122, 5123, 5134, 5133, 6309, 6310, 6321, 6320, 5578, 5600, 5601, 5598, 6765, 6787, 6788, 
6785, 41135, 41136, 41147, 41146
16593, 5123, 5124, 5135, 5134, 6310, 6311, 6322, 6321, 5580, 5602, 5603, 5600, 6767, 6789, 6790, 
6787, 41136, 41137, 41148, 41147
16594, 5124, 366, 367, 5135, 6311, 487, 488, 6322, 5581, 390, 5604, 5602, 6768, 511, 6791, 
6789, 41137, 6107, 6108, 41148
16595, 320, 5125, 5136, 321, 416, 6312, 6323, 417, 5583, 5605, 5606, 344, 6770, 6792, 6793, 
440, 6074, 41138, 41149, 6075
16596, 5125, 5126, 5137, 5136, 6312, 6313, 6324, 6323, 5585, 5607, 5608, 5605, 6772, 6794, 6795, 
6792, 41138, 41139, 41150, 41149
16597, 5126, 5127, 5138, 5137, 6313, 6314, 6325, 6324, 5587, 5609, 5610, 5607, 6774, 6796, 6797, 
6794, 41139, 41140, 41151, 41150
16598, 5127, 5128, 5139, 5138, 6314, 6315, 6326, 6325, 5589, 5611, 5612, 5609, 6776, 6798, 6799, 
6796, 41140, 41141, 41152, 41151
16599, 5128, 5129, 5140, 5139, 6315, 6316, 6327, 6326, 5591, 5613, 5614, 5611, 6778, 6800, 6801, 
6798, 41141, 41142, 41153, 41152
16600, 5129, 5130, 5141, 5140, 6316, 6317, 6328, 6327, 5593, 5615, 5616, 5613, 6780, 6802, 6803, 
6800, 41142, 41143, 41154, 41153
16601, 5130, 5131, 5142, 5141, 6317, 6318, 6329, 6328, 5595, 5617, 5618, 5615, 6782, 6804, 6805, 
6802, 41143, 41144, 41155, 41154
16602, 5131, 5132, 5143, 5142, 6318, 6319, 6330, 6329, 5597, 5619, 5620, 5617, 6784, 6806, 6807, 
6804, 41144, 41145, 41156, 41155
16603, 5132, 5133, 5144, 5143, 6319, 6320, 6331, 6330, 5599, 5621, 5622, 5619, 6786, 6808, 6809, 
6806, 41145, 41146, 41157, 41156
16604, 5133, 5134, 5145, 5144, 6320, 6321, 6332, 6331, 5601, 5623, 5624, 5621, 6788, 6810, 6811, 
6808, 41146, 41147, 41158, 41157
16605, 5134, 5135, 5146, 5145, 6321, 6322, 6333, 6332, 5603, 5625, 5626, 5623, 6790, 6812, 6813, 
6810, 41147, 41148, 41159, 41158
16606, 5135, 367, 368, 5146, 6322, 488, 489, 6333, 5604, 391, 5627, 5625, 6791, 512, 6814, 
6812, 41148, 6108, 6109, 41159
16607, 321, 5136, 5147, 322, 417, 6323, 6334, 418, 5606, 5628, 5629, 345, 6793, 6815, 6816, 
441, 6075, 41149, 41160, 6076
16608, 5136, 5137, 5148, 5147, 6323, 6324, 6335, 6334, 5608, 5630, 5631, 5628, 6795, 6817, 6818, 
6815, 41149, 41150, 41161, 41160
16609, 5137, 5138, 5149, 5148, 6324, 6325, 6336, 6335, 5610, 5632, 5633, 5630, 6797, 6819, 6820, 
6817, 41150, 41151, 41162, 41161
16610, 5138, 5139, 5150, 5149, 6325, 6326, 6337, 6336, 5612, 5634, 5635, 5632, 6799, 6821, 6822, 
6819, 41151, 41152, 41163, 41162
16611, 5139, 5140, 5151, 5150, 6326, 6327, 6338, 6337, 5614, 5636, 5637, 5634, 6801, 6823, 6824, 
6821, 41152, 41153, 41164, 41163
16612, 5140, 5141, 5152, 5151, 6327, 6328, 6339, 6338, 5616, 5638, 5639, 5636, 6803, 6825, 6826, 
6823, 41153, 41154, 41165, 41164
16613, 5141, 5142, 5153, 5152, 6328, 6329, 6340, 6339, 5618, 5640, 5641, 5638, 6805, 6827, 6828, 
6825, 41154, 41155, 41166, 41165
16614, 5142, 5143, 5154, 5153, 6329, 6330, 6341, 6340, 5620, 5642, 5643, 5640, 6807, 6829, 6830, 
6827, 41155, 41156, 41167, 41166
16615, 5143, 5144, 5155, 5154, 6330, 6331, 6342, 6341, 5622, 5644, 5645, 5642, 6809, 6831, 6832, 
6829, 41156, 41157, 41168, 41167
16616, 5144, 5145, 5156, 5155, 6331, 6332, 6343, 6342, 5624, 5646, 5647, 5644, 6811, 6833, 6834, 
6831, 41157, 41158, 41169, 41168
16617, 5145, 5146, 5157, 5156, 6332, 6333, 6344, 6343, 5626, 5648, 5649, 5646, 6813, 6835, 6836, 
6833, 41158, 41159, 41170, 41169
16618, 5146, 368, 369, 5157, 6333, 489, 490, 6344, 5627, 392, 5650, 5648, 6814, 513, 6837, 
6835, 41159, 6109, 6110, 41170
16619, 322, 5147, 5158, 323, 418, 6334, 6345, 419, 5629, 5651, 5652, 346, 6816, 6838, 6839, 
442, 6076, 41160, 41171, 6077
16620, 5147, 5148, 5159, 5158, 6334, 6335, 6346, 6345, 5631, 5653, 5654, 5651, 6818, 6840, 6841, 
6838, 41160, 41161, 41172, 41171
16621, 5148, 5149, 5160, 5159, 6335, 6336, 6347, 6346, 5633, 5655, 5656, 5653, 6820, 6842, 6843, 
6840, 41161, 41162, 41173, 41172
16622, 5149, 5150, 5161, 5160, 6336, 6337, 6348, 6347, 5635, 5657, 5658, 5655, 6822, 6844, 6845, 
6842, 41162, 41163, 41174, 41173
16623, 5150, 5151, 5162, 5161, 6337, 6338, 6349, 6348, 5637, 5659, 5660, 5657, 6824, 6846, 6847, 
6844, 41163, 41164, 41175, 41174
16624, 5151, 5152, 5163, 5162, 6338, 6339, 6350, 6349, 5639, 5661, 5662, 5659, 6826, 6848, 6849, 
6846, 41164, 41165, 41176, 41175
16625, 5152, 5153, 5164, 5163, 6339, 6340, 6351, 6350, 5641, 5663, 5664, 5661, 6828, 6850, 6851, 
6848, 41165, 41166, 41177, 41176
16626, 5153, 5154, 5165, 5164, 6340, 6341, 6352, 6351, 5643, 5665, 5666, 5663, 6830, 6852, 6853, 
6850, 41166, 41167, 41178, 41177
16627, 5154, 5155, 5166, 5165, 6341, 6342, 6353, 6352, 5645, 5667, 5668, 5665, 6832, 6854, 6855, 
6852, 41167, 41168, 41179, 41178
16628, 5155, 5156, 5167, 5166, 6342, 6343, 6354, 6353, 5647, 5669, 5670, 5667, 6834, 6856, 6857, 
6854, 41168, 41169, 41180, 41179
16629, 5156, 5157, 5168, 5167, 6343, 6344, 6355, 6354, 5649, 5671, 5672, 5669, 6836, 6858, 6859, 
6856, 41169, 41170, 41181, 41180
16630, 5157, 369, 370, 5168, 6344, 490, 491, 6355, 5650, 393, 5673, 5671, 6837, 514, 6860, 
6858, 41170, 6110, 6111, 41181
16631, 323, 5158, 5169, 324, 419, 6345, 6356, 420, 5652, 5674, 5675, 347, 6839, 6861, 6862, 
443, 6077, 41171, 41182, 6078
16632, 5158, 5159, 5170, 5169, 6345, 6346, 6357, 6356, 5654, 5676, 5677, 5674, 6841, 6863, 6864, 
6861, 41171, 41172, 41183, 41182
16633, 5159, 5160, 5171, 5170, 6346, 6347, 6358, 6357, 5656, 5678, 5679, 5676, 6843, 6865, 6866, 
6863, 41172, 41173, 41184, 41183
16634, 5160, 5161, 5172, 5171, 6347, 6348, 6359, 6358, 5658, 5680, 5681, 5678, 6845, 6867, 6868, 
6865, 41173, 41174, 41185, 41184
16635, 5161, 5162, 5173, 5172, 6348, 6349, 6360, 6359, 5660, 5682, 5683, 5680, 6847, 6869, 6870, 
6867, 41174, 41175, 41186, 41185
16636, 5162, 5163, 5174, 5173, 6349, 6350, 6361, 6360, 5662, 5684, 5685, 5682, 6849, 6871, 6872, 
6869, 41175, 41176, 41187, 41186
16637, 5163, 5164, 5175, 5174, 6350, 6351, 6362, 6361, 5664, 5686, 5687, 5684, 6851, 6873, 6874, 
6871, 41176, 41177, 41188, 41187
16638, 5164, 5165, 5176, 5175, 6351, 6352, 6363, 6362, 5666, 5688, 5689, 5686, 6853, 6875, 6876, 
6873, 41177, 41178, 41189, 41188
16639, 5165, 5166, 5177, 5176, 6352, 6353, 6364, 6363, 5668, 5690, 5691, 5688, 6855, 6877, 6878, 
6875, 41178, 41179, 41190, 41189
16640, 5166, 5167, 5178, 5177, 6353, 6354, 6365, 6364, 5670, 5692, 5693, 5690, 6857, 6879, 6880, 
6877, 41179, 41180, 41191, 41190
16641, 5167, 5168, 5179, 5178, 6354, 6355, 6366, 6365, 5672, 5694, 5695, 5692, 6859, 6881, 6882, 
6879, 41180, 41181, 41192, 41191
16642, 5168, 370, 371, 5179, 6355, 491, 492, 6366, 5673, 394, 5696, 5694, 6860, 515, 6883, 
6881, 41181, 6111, 6112, 41192
16643, 324, 5169, 5180, 325, 420, 6356, 6367, 421, 5675, 5697, 5698, 348, 6862, 6884, 6885, 
444, 6078, 41182, 41193, 6079
16644, 5169, 5170, 5181, 5180, 6356, 6357, 6368, 6367, 5677, 5699, 5700, 5697, 6864, 6886, 6887, 
6884, 41182, 41183, 41194, 41193
16645, 5170, 5171, 5182, 5181, 6357, 6358, 6369, 6368, 5679, 5701, 5702, 5699, 6866, 6888, 6889, 
6886, 41183, 41184, 41195, 41194
16646, 5171, 5172, 5183, 5182, 6358, 6359, 6370, 6369, 5681, 5703, 5704, 5701, 6868, 6890, 6891, 
6888, 41184, 41185, 41196, 41195
16647, 5172, 5173, 5184, 5183, 6359, 6360, 6371, 6370, 5683, 5705, 5706, 5703, 6870, 6892, 6893, 
6890, 41185, 41186, 41197, 41196
16648, 5173, 5174, 5185, 5184, 6360, 6361, 6372, 6371, 5685, 5707, 5708, 5705, 6872, 6894, 6895, 
6892, 41186, 41187, 41198, 41197
16649, 5174, 5175, 5186, 5185, 6361, 6362, 6373, 6372, 5687, 5709, 5710, 5707, 6874, 6896, 6897, 
6894, 41187, 41188, 41199, 41198
16650, 5175, 5176, 5187, 5186, 6362, 6363, 6374, 6373, 5689, 5711, 5712, 5709, 6876, 6898, 6899, 
6896, 41188, 41189, 41200, 41199
16651, 5176, 5177, 5188, 5187, 6363, 6364, 6375, 6374, 5691, 5713, 5714, 5711, 6878, 6900, 6901, 
6898, 41189, 41190, 41201, 41200
16652, 5177, 5178, 5189, 5188, 6364, 6365, 6376, 6375, 5693, 5715, 5716, 5713, 6880, 6902, 6903, 
6900, 41190, 41191, 41202, 41201
16653, 5178, 5179, 5190, 5189, 6365, 6366, 6377, 6376, 5695, 5717, 5718, 5715, 6882, 6904, 6905, 
6902, 41191, 41192, 41203, 41202
16654, 5179, 371, 372, 5190, 6366, 492, 493, 6377, 5696, 395, 5719, 5717, 6883, 516, 6906, 
6904, 41192, 6112, 6113, 41203
16655, 325, 5180, 181, 8, 421, 6367, 447, 9, 5698, 5720, 192, 349, 6885, 6907, 458, 
445, 6079, 41193, 6080, 397
16656, 5180, 5181, 182, 181, 6367, 6368, 448, 447, 5700, 5721, 193, 5720, 6887, 6908, 459, 
6907, 41193, 41194, 6081, 6080
16657, 5181, 5182, 183, 182, 6368, 6369, 449, 448, 5702, 5722, 194, 5721, 6889, 6909, 460, 
6908, 41194, 41195, 6082, 6081
16658, 5182, 5183, 184, 183, 6369, 6370, 450, 449, 5704, 5723, 195, 5722, 6891, 6910, 461, 
6909, 41195, 41196, 6083, 6082
16659, 5183, 5184, 185, 184, 6370, 6371, 451, 450, 5706, 5724, 196, 5723, 6893, 6911, 462, 
6910, 41196, 41197, 6084, 6083
16660, 5184, 5185, 186, 185, 6371, 6372, 452, 451, 5708, 5725, 197, 5724, 6895, 6912, 463, 
6911, 41197, 41198, 6085, 6084
16661, 5185, 5186, 187, 186, 6372, 6373, 453, 452, 5710, 5726, 198, 5725, 6897, 6913, 464, 
6912, 41198, 41199, 6086, 6085
16662, 5186, 5187, 188, 187, 6373, 6374, 454, 453, 5712, 5727, 199, 5726, 6899, 6914, 465, 
6913, 41199, 41200, 6087, 6086
16663, 5187, 5188, 189, 188, 6374, 6375, 455, 454, 5714, 5728, 200, 5727, 6901, 6915, 466, 
6914, 41200, 41201, 6088, 6087
16664, 5188, 5189, 190, 189, 6375, 6376, 456, 455, 5716, 5729, 201, 5728, 6903, 6916, 467, 
6915, 41201, 41202, 6089, 6088
16665, 5189, 5190, 191, 190, 6376, 6377, 457, 456, 5718, 5730, 202, 5729, 6905, 6917, 468, 
6916, 41202, 41203, 6090, 6089
16666, 5190, 372, 7, 191, 6377, 493, 11, 457, 5719, 396, 203, 5730, 6906, 517, 469, 
6917, 41203, 6113, 446, 6090
*ELEMENT, type=C3D20, ELSET=Volume3
16667, 10, 518, 6125, 399, 588, 10977, 41204, 6918, 529, 6378, 6379, 422, 11231, 47024, 47025, 
7447, 611, 11230, 47023, 7448
16668, 588, 10977, 41204, 6918, 589, 10978, 41205, 6919, 11231, 47024, 47025, 7447, 11233, 47027, 47028, 
7449, 612, 11232, 47026, 7450
16669, 589, 10978, 41205, 6919, 590, 10979, 41206, 6920, 11233, 47027, 47028, 7449, 11235, 47030, 47031, 
7451, 613, 11234, 47029, 7452
16670, 590, 10979, 41206, 6920, 591, 10980, 41207, 6921, 11235, 47030, 47031, 7451, 11237, 47033, 47034, 
7453, 614, 11236, 47032, 7454
16671, 591, 10980, 41207, 6921, 592, 10981, 41208, 6922, 11237, 47033, 47034, 7453, 11239, 47036, 47037, 
7455, 615, 11238, 47035, 7456
16672, 592, 10981, 41208, 6922, 593, 10982, 41209, 6923, 11239, 47036, 47037, 7455, 11241, 47039, 47040, 
7457, 616, 11240, 47038, 7458
16673, 593, 10982, 41209, 6923, 594, 10983, 41210, 6924, 11241, 47039, 47040, 7457, 11243, 47042, 47043, 
7459, 617, 11242, 47041, 7460
16674, 594, 10983, 41210, 6924, 595, 10984, 41211, 6925, 11243, 47042, 47043, 7459, 11245, 47045, 47046, 
7461, 618, 11244, 47044, 7462
16675, 595, 10984, 41211, 6925, 596, 10985, 41212, 6926, 11245, 47045, 47046, 7461, 11247, 47048, 47049, 
7463, 619, 11246, 47047, 7464
16676, 596, 10985, 41212, 6926, 597, 10986, 41213, 6927, 11247, 47048, 47049, 7463, 11249, 47051, 47052, 
7465, 620, 11248, 47050, 7466
16677, 597, 10986, 41213, 6927, 598, 10987, 41214, 6928, 11249, 47051, 47052, 7465, 11251, 47054, 47055, 
7467, 621, 11250, 47053, 7468
16678, 598, 10987, 41214, 6928, 599, 10988, 41215, 6929, 11251, 47054, 47055, 7467, 11253, 47057, 47058, 
7469, 622, 11252, 47056, 7470
16679, 599, 10988, 41215, 6929, 600, 10989, 41216, 6930, 11253, 47057, 47058, 7469, 11255, 47060, 47061, 
7471, 623, 11254, 47059, 7472
16680, 600, 10989, 41216, 6930, 601, 10990, 41217, 6931, 11255, 47060, 47061, 7471, 11257, 47063, 47064, 
7473, 624, 11256, 47062, 7474
16681, 601, 10990, 41217, 6931, 602, 10991, 41218, 6932, 11257, 47063, 47064, 7473, 11259, 47066, 47067, 
7475, 625, 11258, 47065, 7476
16682, 602, 10991, 41218, 6932, 603, 10992, 41219, 6933, 11259, 47066, 47067, 7475, 11261, 47069, 47070, 
7477, 626, 11260, 47068, 7478
16683, 603, 10992, 41219, 6933, 604, 10993, 41220, 6934, 11261, 47069, 47070, 7477, 11263, 47072, 47073, 
7479, 627, 11262, 47071, 7480
16684, 604, 10993, 41220, 6934, 605, 10994, 41221, 6935, 11263, 47072, 47073, 7479, 11265, 47075, 47076, 
7481, 628, 11264, 47074, 7482
16685, 605, 10994, 41221, 6935, 606, 10995, 41222, 6936, 11265, 47075, 47076, 7481, 11267, 47078, 47079, 
7483, 629, 11266, 47077, 7484
16686, 606, 10995, 41222, 6936, 607, 10996, 41223, 6937, 11267, 47078, 47079, 7483, 11269, 47081, 47082, 
7485, 630, 11268, 47080, 7486
