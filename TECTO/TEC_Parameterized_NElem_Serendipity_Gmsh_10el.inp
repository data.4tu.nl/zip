64143, 0.91666666666667, 0.95, 0.27083333333333
64144, 0.91666666666667, 0.975, 0.29166666666667
64145, 0.89583333333333, 1, 0.29166666666667
64146, 0.91666666666667, 1, 0.27083333333333
64147, 0.91666666666667, 1.025, 0.29166666666667
64148, 0.89583333333333, 1.05, 0.29166666666667
64149, 0.91666666666667, 1.05, 0.27083333333333
64150, 0.91666666666667, 1.075, 0.29166666666667
64151, 0.89583333333333, 1.1, 0.29166666666667
64152, 0.91666666666667, 1.1, 0.27083333333333
64153, 0.91666666666667, 1.125, 0.29166666666667
64154, 0.89583333333333, 1.15, 0.29166666666667
64155, 0.91666666666667, 1.15, 0.27083333333333
64156, 0.91666666666667, 1.175, 0.29166666666667
64157, 0.89583333333333, 1.2, 0.29166666666667
64158, 0.91666666666667, 1.2, 0.27083333333333
64159, 0.91666666666667, 1.225, 0.29166666666667
64160, 0.89583333333333, 1.25, 0.29166666666667
64161, 0.91666666666667, 1.25, 0.27083333333333
64162, 0.91666666666667, 1.275, 0.29166666666667
64163, 0.89583333333333, 1.3, 0.29166666666667
64164, 0.91666666666667, 1.3, 0.27083333333333
64165, 0.91666666666667, 1.325, 0.29166666666667
64166, 0.91666666666667, 0.175, 0.33333333333333
64167, 0.89583333333333, 0.2, 0.33333333333333
64168, 0.91666666666667, 0.2, 0.3125
64169, 0.91666666666667, 0.225, 0.33333333333333
64170, 0.89583333333333, 0.25, 0.33333333333333
64171, 0.91666666666667, 0.25, 0.3125
64172, 0.91666666666667, 0.275, 0.33333333333333
64173, 0.89583333333333, 0.3, 0.33333333333333
64174, 0.91666666666667, 0.3, 0.3125
64175, 0.91666666666667, 0.325, 0.33333333333333
64176, 0.89583333333333, 0.35, 0.33333333333333
64177, 0.91666666666667, 0.35, 0.3125
64178, 0.91666666666667, 0.375, 0.33333333333333
64179, 0.89583333333333, 0.4, 0.33333333333333
64180, 0.91666666666667, 0.4, 0.3125
64181, 0.91666666666667, 0.425, 0.33333333333333
64182, 0.89583333333333, 0.45, 0.33333333333333
64183, 0.91666666666667, 0.45, 0.3125
64184, 0.91666666666667, 0.475, 0.33333333333333
64185, 0.89583333333333, 0.5, 0.33333333333333
64186, 0.91666666666667, 0.5, 0.3125
64187, 0.91666666666667, 0.525, 0.33333333333333
64188, 0.89583333333333, 0.55, 0.33333333333333
64189, 0.91666666666667, 0.55, 0.3125
64190, 0.91666666666667, 0.575, 0.33333333333333
64191, 0.89583333333333, 0.6, 0.33333333333333
64192, 0.91666666666667, 0.6, 0.3125
64193, 0.91666666666667, 0.625, 0.33333333333333
64194, 0.89583333333333, 0.65, 0.33333333333333
64195, 0.91666666666667, 0.65, 0.3125
64196, 0.91666666666667, 0.675, 0.33333333333333
64197, 0.89583333333333, 0.7, 0.33333333333333
64198, 0.91666666666667, 0.7, 0.3125
64199, 0.91666666666667, 0.725, 0.33333333333333
64200, 0.89583333333333, 0.75, 0.33333333333333
64201, 0.91666666666667, 0.75, 0.3125
64202, 0.91666666666667, 0.775, 0.33333333333333
64203, 0.89583333333333, 0.8, 0.33333333333333
64204, 0.91666666666667, 0.8, 0.3125
64205, 0.91666666666667, 0.825, 0.33333333333333
64206, 0.89583333333333, 0.85, 0.33333333333333
64207, 0.91666666666667, 0.85, 0.3125
64208, 0.91666666666667, 0.875, 0.33333333333333
64209, 0.89583333333333, 0.9, 0.33333333333333
64210, 0.91666666666667, 0.9, 0.3125
64211, 0.91666666666667, 0.925, 0.33333333333333
64212, 0.89583333333333, 0.95, 0.33333333333333
64213, 0.91666666666667, 0.95, 0.3125
64214, 0.91666666666667, 0.975, 0.33333333333333
64215, 0.89583333333333, 1, 0.33333333333333
64216, 0.91666666666667, 1, 0.3125
64217, 0.91666666666667, 1.025, 0.33333333333333
64218, 0.89583333333333, 1.05, 0.33333333333333
64219, 0.91666666666667, 1.05, 0.3125
64220, 0.91666666666667, 1.075, 0.33333333333333
64221, 0.89583333333333, 1.1, 0.33333333333333
64222, 0.91666666666667, 1.1, 0.3125
64223, 0.91666666666667, 1.125, 0.33333333333333
64224, 0.89583333333333, 1.15, 0.33333333333333
64225, 0.91666666666667, 1.15, 0.3125
64226, 0.91666666666667, 1.175, 0.33333333333333
64227, 0.89583333333333, 1.2, 0.33333333333333
64228, 0.91666666666667, 1.2, 0.3125
64229, 0.91666666666667, 1.225, 0.33333333333333
64230, 0.89583333333333, 1.25, 0.33333333333333
64231, 0.91666666666667, 1.25, 0.3125
64232, 0.91666666666667, 1.275, 0.33333333333333
64233, 0.89583333333333, 1.3, 0.33333333333333
64234, 0.91666666666667, 1.3, 0.3125
64235, 0.91666666666667, 1.325, 0.33333333333333
64236, 0.91666666666667, 0.175, 0.375
64237, 0.89583333333333, 0.2, 0.375
64238, 0.91666666666667, 0.2, 0.35416666666667
64239, 0.91666666666667, 0.225, 0.375
64240, 0.89583333333333, 0.25, 0.375
64241, 0.91666666666667, 0.25, 0.35416666666667
64242, 0.91666666666667, 0.275, 0.375
64243, 0.89583333333333, 0.3, 0.375
64244, 0.91666666666667, 0.3, 0.35416666666667
64245, 0.91666666666667, 0.325, 0.375
64246, 0.89583333333333, 0.35, 0.375
64247, 0.91666666666667, 0.35, 0.35416666666667
64248, 0.91666666666667, 0.375, 0.375
64249, 0.89583333333333, 0.4, 0.375
64250, 0.91666666666667, 0.4, 0.35416666666667
64251, 0.91666666666667, 0.425, 0.375
64252, 0.89583333333333, 0.45, 0.375
64253, 0.91666666666667, 0.45, 0.35416666666667
64254, 0.91666666666667, 0.475, 0.375
64255, 0.89583333333333, 0.5, 0.375
64256, 0.91666666666667, 0.5, 0.35416666666667
64257, 0.91666666666667, 0.525, 0.375
64258, 0.89583333333333, 0.55, 0.375
64259, 0.91666666666667, 0.55, 0.35416666666667
64260, 0.91666666666667, 0.575, 0.375
64261, 0.89583333333333, 0.6, 0.375
64262, 0.91666666666667, 0.6, 0.35416666666667
64263, 0.91666666666667, 0.625, 0.375
64264, 0.89583333333333, 0.65, 0.375
64265, 0.91666666666667, 0.65, 0.35416666666667
64266, 0.91666666666667, 0.675, 0.375
64267, 0.89583333333333, 0.7, 0.375
64268, 0.91666666666667, 0.7, 0.35416666666667
64269, 0.91666666666667, 0.725, 0.375
64270, 0.89583333333333, 0.75, 0.375
64271, 0.91666666666667, 0.75, 0.35416666666667
64272, 0.91666666666667, 0.775, 0.375
64273, 0.89583333333333, 0.8, 0.375
64274, 0.91666666666667, 0.8, 0.35416666666667
64275, 0.91666666666667, 0.825, 0.375
64276, 0.89583333333333, 0.85, 0.375
64277, 0.91666666666667, 0.85, 0.35416666666667
64278, 0.91666666666667, 0.875, 0.375
64279, 0.89583333333333, 0.9, 0.375
64280, 0.91666666666667, 0.9, 0.35416666666667
64281, 0.91666666666667, 0.925, 0.375
64282, 0.89583333333333, 0.95, 0.375
64283, 0.91666666666667, 0.95, 0.35416666666667
64284, 0.91666666666667, 0.975, 0.375
64285, 0.89583333333333, 1, 0.375
64286, 0.91666666666667, 1, 0.35416666666667
64287, 0.91666666666667, 1.025, 0.375
64288, 0.89583333333333, 1.05, 0.375
64289, 0.91666666666667, 1.05, 0.35416666666667
64290, 0.91666666666667, 1.075, 0.375
64291, 0.89583333333333, 1.1, 0.375
64292, 0.91666666666667, 1.1, 0.35416666666667
64293, 0.91666666666667, 1.125, 0.375
64294, 0.89583333333333, 1.15, 0.375
64295, 0.91666666666667, 1.15, 0.35416666666667
64296, 0.91666666666667, 1.175, 0.375
64297, 0.89583333333333, 1.2, 0.375
64298, 0.91666666666667, 1.2, 0.35416666666667
64299, 0.91666666666667, 1.225, 0.375
64300, 0.89583333333333, 1.25, 0.375
64301, 0.91666666666667, 1.25, 0.35416666666667
64302, 0.91666666666667, 1.275, 0.375
64303, 0.89583333333333, 1.3, 0.375
64304, 0.91666666666667, 1.3, 0.35416666666667
64305, 0.91666666666667, 1.325, 0.375
64306, 0.91666666666667, 0.175, 0.41666666666667
64307, 0.89583333333333, 0.2, 0.41666666666667
64308, 0.91666666666667, 0.2, 0.39583333333333
64309, 0.91666666666667, 0.225, 0.41666666666667
64310, 0.89583333333333, 0.25, 0.41666666666667
64311, 0.91666666666667, 0.25, 0.39583333333333
64312, 0.91666666666667, 0.275, 0.41666666666667
64313, 0.89583333333333, 0.3, 0.41666666666667
64314, 0.91666666666667, 0.3, 0.39583333333333
64315, 0.91666666666667, 0.325, 0.41666666666667
64316, 0.89583333333333, 0.35, 0.41666666666667
64317, 0.91666666666667, 0.35, 0.39583333333333
64318, 0.91666666666667, 0.375, 0.41666666666667
64319, 0.89583333333333, 0.4, 0.41666666666667
64320, 0.91666666666667, 0.4, 0.39583333333333
64321, 0.91666666666667, 0.425, 0.41666666666667
64322, 0.89583333333333, 0.45, 0.41666666666667
64323, 0.91666666666667, 0.45, 0.39583333333333
64324, 0.91666666666667, 0.475, 0.41666666666667
64325, 0.89583333333333, 0.5, 0.41666666666667
64326, 0.91666666666667, 0.5, 0.39583333333333
64327, 0.91666666666667, 0.525, 0.41666666666667
64328, 0.89583333333333, 0.55, 0.41666666666667
64329, 0.91666666666667, 0.55, 0.39583333333333
64330, 0.91666666666667, 0.575, 0.41666666666667
64331, 0.89583333333333, 0.6, 0.41666666666667
64332, 0.91666666666667, 0.6, 0.39583333333333
64333, 0.91666666666667, 0.625, 0.41666666666667
64334, 0.89583333333333, 0.65, 0.41666666666667
64335, 0.91666666666667, 0.65, 0.39583333333333
64336, 0.91666666666667, 0.675, 0.41666666666667
64337, 0.89583333333333, 0.7, 0.41666666666667
64338, 0.91666666666667, 0.7, 0.39583333333333
64339, 0.91666666666667, 0.725, 0.41666666666667
64340, 0.89583333333333, 0.75, 0.41666666666667
64341, 0.91666666666667, 0.75, 0.39583333333333
64342, 0.91666666666667, 0.775, 0.41666666666667
64343, 0.89583333333333, 0.8, 0.41666666666667
64344, 0.91666666666667, 0.8, 0.39583333333333
64345, 0.91666666666667, 0.825, 0.41666666666667
64346, 0.89583333333333, 0.85, 0.41666666666667
64347, 0.91666666666667, 0.85, 0.39583333333333
64348, 0.91666666666667, 0.875, 0.41666666666667
64349, 0.89583333333333, 0.9, 0.41666666666667
64350, 0.91666666666667, 0.9, 0.39583333333333
64351, 0.91666666666667, 0.925, 0.41666666666667
64352, 0.89583333333333, 0.95, 0.41666666666667
64353, 0.91666666666667, 0.95, 0.39583333333333
64354, 0.91666666666667, 0.975, 0.41666666666667
64355, 0.89583333333333, 1, 0.41666666666667
64356, 0.91666666666667, 1, 0.39583333333333
64357, 0.91666666666667, 1.025, 0.41666666666667
64358, 0.89583333333333, 1.05, 0.41666666666667
64359, 0.91666666666667, 1.05, 0.39583333333333
64360, 0.91666666666667, 1.075, 0.41666666666667
64361, 0.89583333333333, 1.1, 0.41666666666667
64362, 0.91666666666667, 1.1, 0.39583333333333
64363, 0.91666666666667, 1.125, 0.41666666666667
64364, 0.89583333333333, 1.15, 0.41666666666667
64365, 0.91666666666667, 1.15, 0.39583333333333
64366, 0.91666666666667, 1.175, 0.41666666666667
64367, 0.89583333333333, 1.2, 0.41666666666667
64368, 0.91666666666667, 1.2, 0.39583333333333
64369, 0.91666666666667, 1.225, 0.41666666666667
64370, 0.89583333333333, 1.25, 0.41666666666667
64371, 0.91666666666667, 1.25, 0.39583333333333
64372, 0.91666666666667, 1.275, 0.41666666666667
64373, 0.89583333333333, 1.3, 0.41666666666667
64374, 0.91666666666667, 1.3, 0.39583333333333
64375, 0.91666666666667, 1.325, 0.41666666666667
64376, 0.91666666666667, 0.175, 0.45833333333333
64377, 0.89583333333333, 0.2, 0.45833333333333
64378, 0.91666666666667, 0.2, 0.4375
64379, 0.91666666666667, 0.225, 0.45833333333333
64380, 0.89583333333333, 0.25, 0.45833333333333
64381, 0.91666666666667, 0.25, 0.4375
64382, 0.91666666666667, 0.275, 0.45833333333333
64383, 0.89583333333333, 0.3, 0.45833333333333
64384, 0.91666666666667, 0.3, 0.4375
64385, 0.91666666666667, 0.325, 0.45833333333333
64386, 0.89583333333333, 0.35, 0.45833333333333
64387, 0.91666666666667, 0.35, 0.4375
64388, 0.91666666666667, 0.375, 0.45833333333333
64389, 0.89583333333333, 0.4, 0.45833333333333
64390, 0.91666666666667, 0.4, 0.4375
64391, 0.91666666666667, 0.425, 0.45833333333333
64392, 0.89583333333333, 0.45, 0.45833333333333
64393, 0.91666666666667, 0.45, 0.4375
64394, 0.91666666666667, 0.475, 0.45833333333333
64395, 0.89583333333333, 0.5, 0.45833333333333
64396, 0.91666666666667, 0.5, 0.4375
64397, 0.91666666666667, 0.525, 0.45833333333333
64398, 0.89583333333333, 0.55, 0.45833333333333
64399, 0.91666666666667, 0.55, 0.4375
64400, 0.91666666666667, 0.575, 0.45833333333333
64401, 0.89583333333333, 0.6, 0.45833333333333
64402, 0.91666666666667, 0.6, 0.4375
64403, 0.91666666666667, 0.625, 0.45833333333333
64404, 0.89583333333333, 0.65, 0.45833333333333
64405, 0.91666666666667, 0.65, 0.4375
64406, 0.91666666666667, 0.675, 0.45833333333333
64407, 0.89583333333333, 0.7, 0.45833333333333
64408, 0.91666666666667, 0.7, 0.4375
64409, 0.91666666666667, 0.725, 0.45833333333333
64410, 0.89583333333333, 0.75, 0.45833333333333
64411, 0.91666666666667, 0.75, 0.4375
64412, 0.91666666666667, 0.775, 0.45833333333333
64413, 0.89583333333333, 0.8, 0.45833333333333
64414, 0.91666666666667, 0.8, 0.4375
64415, 0.91666666666667, 0.825, 0.45833333333333
64416, 0.89583333333333, 0.85, 0.45833333333333
64417, 0.91666666666667, 0.85, 0.4375
64418, 0.91666666666667, 0.875, 0.45833333333333
64419, 0.89583333333333, 0.9, 0.45833333333333
64420, 0.91666666666667, 0.9, 0.4375
64421, 0.91666666666667, 0.925, 0.45833333333333
64422, 0.89583333333333, 0.95, 0.45833333333333
64423, 0.91666666666667, 0.95, 0.4375
64424, 0.91666666666667, 0.975, 0.45833333333333
64425, 0.89583333333333, 1, 0.45833333333333
64426, 0.91666666666667, 1, 0.4375
64427, 0.91666666666667, 1.025, 0.45833333333333
64428, 0.89583333333333, 1.05, 0.45833333333333
64429, 0.91666666666667, 1.05, 0.4375
64430, 0.91666666666667, 1.075, 0.45833333333333
64431, 0.89583333333333, 1.1, 0.45833333333333
64432, 0.91666666666667, 1.1, 0.4375
64433, 0.91666666666667, 1.125, 0.45833333333333
64434, 0.89583333333333, 1.15, 0.45833333333333
64435, 0.91666666666667, 1.15, 0.4375
64436, 0.91666666666667, 1.175, 0.45833333333333
64437, 0.89583333333333, 1.2, 0.45833333333333
64438, 0.91666666666667, 1.2, 0.4375
64439, 0.91666666666667, 1.225, 0.45833333333333
64440, 0.89583333333333, 1.25, 0.45833333333333
64441, 0.91666666666667, 1.25, 0.4375
64442, 0.91666666666667, 1.275, 0.45833333333333
64443, 0.89583333333333, 1.3, 0.45833333333333
64444, 0.91666666666667, 1.3, 0.4375
64445, 0.91666666666667, 1.325, 0.45833333333333
64446, 0.91666666666667, 0.2, 0.47916666666667
64447, 0.91666666666667, 0.25, 0.47916666666667
64448, 0.91666666666667, 0.3, 0.47916666666667
64449, 0.91666666666667, 0.35, 0.47916666666667
64450, 0.91666666666667, 0.4, 0.47916666666667
64451, 0.91666666666667, 0.45, 0.47916666666667
64452, 0.91666666666667, 0.5, 0.47916666666667
64453, 0.91666666666667, 0.55, 0.47916666666667
64454, 0.91666666666667, 0.6, 0.47916666666667
64455, 0.91666666666667, 0.65, 0.47916666666667
64456, 0.91666666666667, 0.7, 0.47916666666667
64457, 0.91666666666667, 0.75, 0.47916666666667
64458, 0.91666666666667, 0.8, 0.47916666666667
64459, 0.91666666666667, 0.85, 0.47916666666667
64460, 0.91666666666667, 0.9, 0.47916666666667
64461, 0.91666666666667, 0.95, 0.47916666666667
64462, 0.91666666666667, 1, 0.47916666666667
64463, 0.91666666666667, 1.05, 0.47916666666667
64464, 0.91666666666667, 1.1, 0.47916666666667
64465, 0.91666666666667, 1.15, 0.47916666666667
64466, 0.91666666666667, 1.2, 0.47916666666667
64467, 0.91666666666667, 1.25, 0.47916666666667
64468, 0.91666666666667, 1.3, 0.47916666666667
64469, 0.95833333333333, 0.175, 0.041666666666667
64470, 0.9375, 0.2, 0.041666666666667
64471, 0.95833333333333, 0.2, 0.020833333333333
64472, 0.95833333333333, 0.225, 0.041666666666667
64473, 0.9375, 0.25, 0.041666666666667
64474, 0.95833333333333, 0.25, 0.020833333333333
64475, 0.95833333333333, 0.275, 0.041666666666667
64476, 0.9375, 0.3, 0.041666666666667
64477, 0.95833333333333, 0.3, 0.020833333333333
64478, 0.95833333333333, 0.325, 0.041666666666667
64479, 0.9375, 0.35, 0.041666666666667
64480, 0.95833333333333, 0.35, 0.020833333333333
64481, 0.95833333333333, 0.375, 0.041666666666667
64482, 0.9375, 0.4, 0.041666666666667
64483, 0.95833333333333, 0.4, 0.020833333333333
64484, 0.95833333333333, 0.425, 0.041666666666667
64485, 0.9375, 0.45, 0.041666666666667
64486, 0.95833333333333, 0.45, 0.020833333333333
64487, 0.95833333333333, 0.475, 0.041666666666667
64488, 0.9375, 0.5, 0.041666666666667
64489, 0.95833333333333, 0.5, 0.020833333333333
64490, 0.95833333333333, 0.525, 0.041666666666667
64491, 0.9375, 0.55, 0.041666666666667
64492, 0.95833333333333, 0.55, 0.020833333333333
64493, 0.95833333333333, 0.575, 0.041666666666667
64494, 0.9375, 0.6, 0.041666666666667
64495, 0.95833333333333, 0.6, 0.020833333333333
64496, 0.95833333333333, 0.625, 0.041666666666667
64497, 0.9375, 0.65, 0.041666666666667
64498, 0.95833333333333, 0.65, 0.020833333333333
64499, 0.95833333333333, 0.675, 0.041666666666667
64500, 0.9375, 0.7, 0.041666666666667
64501, 0.95833333333333, 0.7, 0.020833333333333
64502, 0.95833333333333, 0.725, 0.041666666666667
64503, 0.9375, 0.75, 0.041666666666667
64504, 0.95833333333333, 0.75, 0.020833333333333
64505, 0.95833333333333, 0.775, 0.041666666666667
64506, 0.9375, 0.8, 0.041666666666667
64507, 0.95833333333333, 0.8, 0.020833333333333
64508, 0.95833333333333, 0.825, 0.041666666666667
64509, 0.9375, 0.85, 0.041666666666667
64510, 0.95833333333333, 0.85, 0.020833333333333
64511, 0.95833333333333, 0.875, 0.041666666666667
64512, 0.9375, 0.9, 0.041666666666667
64513, 0.95833333333333, 0.9, 0.020833333333333
64514, 0.95833333333333, 0.925, 0.041666666666667
64515, 0.9375, 0.95, 0.041666666666667
64516, 0.95833333333333, 0.95, 0.020833333333333
64517, 0.95833333333333, 0.975, 0.041666666666667
64518, 0.9375, 1, 0.041666666666667
64519, 0.95833333333333, 1, 0.020833333333333
64520, 0.95833333333333, 1.025, 0.041666666666667
64521, 0.9375, 1.05, 0.041666666666667
64522, 0.95833333333333, 1.05, 0.020833333333333
64523, 0.95833333333333, 1.075, 0.041666666666667
64524, 0.9375, 1.1, 0.041666666666667
64525, 0.95833333333333, 1.1, 0.020833333333333
64526, 0.95833333333333, 1.125, 0.041666666666667
64527, 0.9375, 1.15, 0.041666666666667
64528, 0.95833333333333, 1.15, 0.020833333333333
64529, 0.95833333333333, 1.175, 0.041666666666667
64530, 0.9375, 1.2, 0.041666666666667
64531, 0.95833333333333, 1.2, 0.020833333333333
64532, 0.95833333333333, 1.225, 0.041666666666667
64533, 0.9375, 1.25, 0.041666666666667
64534, 0.95833333333333, 1.25, 0.020833333333333
64535, 0.95833333333333, 1.275, 0.041666666666667
64536, 0.9375, 1.3, 0.041666666666667
64537, 0.95833333333333, 1.3, 0.020833333333333
64538, 0.95833333333333, 1.325, 0.041666666666667
64539, 0.95833333333333, 0.175, 0.083333333333333
64540, 0.9375, 0.2, 0.083333333333333
64541, 0.95833333333333, 0.2, 0.0625
64542, 0.95833333333333, 0.225, 0.083333333333333
64543, 0.9375, 0.25, 0.083333333333333
64544, 0.95833333333333, 0.25, 0.0625
64545, 0.95833333333333, 0.275, 0.083333333333333
64546, 0.9375, 0.3, 0.083333333333333
64547, 0.95833333333333, 0.3, 0.0625
64548, 0.95833333333333, 0.325, 0.083333333333333
64549, 0.9375, 0.35, 0.083333333333333
64550, 0.95833333333333, 0.35, 0.0625
64551, 0.95833333333333, 0.375, 0.083333333333333
64552, 0.9375, 0.4, 0.083333333333333
64553, 0.95833333333333, 0.4, 0.0625
64554, 0.95833333333333, 0.425, 0.083333333333333
64555, 0.9375, 0.45, 0.083333333333333
64556, 0.95833333333333, 0.45, 0.0625
64557, 0.95833333333333, 0.475, 0.083333333333333
64558, 0.9375, 0.5, 0.083333333333333
64559, 0.95833333333333, 0.5, 0.0625
64560, 0.95833333333333, 0.525, 0.083333333333333
64561, 0.9375, 0.55, 0.083333333333333
64562, 0.95833333333333, 0.55, 0.0625
64563, 0.95833333333333, 0.575, 0.083333333333333
64564, 0.9375, 0.6, 0.083333333333333
64565, 0.95833333333333, 0.6, 0.0625
64566, 0.95833333333333, 0.625, 0.083333333333333
64567, 0.9375, 0.65, 0.083333333333333
64568, 0.95833333333333, 0.65, 0.0625
64569, 0.95833333333333, 0.675, 0.083333333333333
64570, 0.9375, 0.7, 0.083333333333333
64571, 0.95833333333333, 0.7, 0.0625
64572, 0.95833333333333, 0.725, 0.083333333333333
64573, 0.9375, 0.75, 0.083333333333333
64574, 0.95833333333333, 0.75, 0.0625
64575, 0.95833333333333, 0.775, 0.083333333333333
64576, 0.9375, 0.8, 0.083333333333333
64577, 0.95833333333333, 0.8, 0.0625
64578, 0.95833333333333, 0.825, 0.083333333333333
64579, 0.9375, 0.85, 0.083333333333333
64580, 0.95833333333333, 0.85, 0.0625
64581, 0.95833333333333, 0.875, 0.083333333333333
64582, 0.9375, 0.9, 0.083333333333333
64583, 0.95833333333333, 0.9, 0.0625
64584, 0.95833333333333, 0.925, 0.083333333333333
64585, 0.9375, 0.95, 0.083333333333333
64586, 0.95833333333333, 0.95, 0.0625
64587, 0.95833333333333, 0.975, 0.083333333333333
64588, 0.9375, 1, 0.083333333333333
64589, 0.95833333333333, 1, 0.0625
64590, 0.95833333333333, 1.025, 0.083333333333333
64591, 0.9375, 1.05, 0.083333333333333
64592, 0.95833333333333, 1.05, 0.0625
64593, 0.95833333333333, 1.075, 0.083333333333333
64594, 0.9375, 1.1, 0.083333333333333
64595, 0.95833333333333, 1.1, 0.0625
64596, 0.95833333333333, 1.125, 0.083333333333333
64597, 0.9375, 1.15, 0.083333333333333
64598, 0.95833333333333, 1.15, 0.0625
64599, 0.95833333333333, 1.175, 0.083333333333333
64600, 0.9375, 1.2, 0.083333333333333
64601, 0.95833333333333, 1.2, 0.0625
64602, 0.95833333333333, 1.225, 0.083333333333333
64603, 0.9375, 1.25, 0.083333333333333
64604, 0.95833333333333, 1.25, 0.0625
64605, 0.95833333333333, 1.275, 0.083333333333333
64606, 0.9375, 1.3, 0.083333333333333
64607, 0.95833333333333, 1.3, 0.0625
64608, 0.95833333333333, 1.325, 0.083333333333333
64609, 0.95833333333333, 0.175, 0.125
64610, 0.9375, 0.2, 0.125
64611, 0.95833333333333, 0.2, 0.10416666666667
64612, 0.95833333333333, 0.225, 0.125
64613, 0.9375, 0.25, 0.125
64614, 0.95833333333333, 0.25, 0.10416666666667
64615, 0.95833333333333, 0.275, 0.125
64616, 0.9375, 0.3, 0.125
64617, 0.95833333333333, 0.3, 0.10416666666667
64618, 0.95833333333333, 0.325, 0.125
64619, 0.9375, 0.35, 0.125
64620, 0.95833333333333, 0.35, 0.10416666666667
64621, 0.95833333333333, 0.375, 0.125
64622, 0.9375, 0.4, 0.125
64623, 0.95833333333333, 0.4, 0.10416666666667
64624, 0.95833333333333, 0.425, 0.125
64625, 0.9375, 0.45, 0.125
64626, 0.95833333333333, 0.45, 0.10416666666667
64627, 0.95833333333333, 0.475, 0.125
64628, 0.9375, 0.5, 0.125
64629, 0.95833333333333, 0.5, 0.10416666666667
64630, 0.95833333333333, 0.525, 0.125
64631, 0.9375, 0.55, 0.125
64632, 0.95833333333333, 0.55, 0.10416666666667
64633, 0.95833333333333, 0.575, 0.125
64634, 0.9375, 0.6, 0.125
64635, 0.95833333333333, 0.6, 0.10416666666667
64636, 0.95833333333333, 0.625, 0.125
64637, 0.9375, 0.65, 0.125
64638, 0.95833333333333, 0.65, 0.10416666666667
64639, 0.95833333333333, 0.675, 0.125
64640, 0.9375, 0.7, 0.125
64641, 0.95833333333333, 0.7, 0.10416666666667
64642, 0.95833333333333, 0.725, 0.125
64643, 0.9375, 0.75, 0.125
64644, 0.95833333333333, 0.75, 0.10416666666667
64645, 0.95833333333333, 0.775, 0.125
64646, 0.9375, 0.8, 0.125
64647, 0.95833333333333, 0.8, 0.10416666666667
64648, 0.95833333333333, 0.825, 0.125
64649, 0.9375, 0.85, 0.125
64650, 0.95833333333333, 0.85, 0.10416666666667
64651, 0.95833333333333, 0.875, 0.125
64652, 0.9375, 0.9, 0.125
64653, 0.95833333333333, 0.9, 0.10416666666667
64654, 0.95833333333333, 0.925, 0.125
64655, 0.9375, 0.95, 0.125
64656, 0.95833333333333, 0.95, 0.10416666666667
64657, 0.95833333333333, 0.975, 0.125
64658, 0.9375, 1, 0.125
64659, 0.95833333333333, 1, 0.10416666666667
64660, 0.95833333333333, 1.025, 0.125
64661, 0.9375, 1.05, 0.125
64662, 0.95833333333333, 1.05, 0.10416666666667
64663, 0.95833333333333, 1.075, 0.125
64664, 0.9375, 1.1, 0.125
64665, 0.95833333333333, 1.1, 0.10416666666667
64666, 0.95833333333333, 1.125, 0.125
64667, 0.9375, 1.15, 0.125
64668, 0.95833333333333, 1.15, 0.10416666666667
64669, 0.95833333333333, 1.175, 0.125
64670, 0.9375, 1.2, 0.125
64671, 0.95833333333333, 1.2, 0.10416666666667
64672, 0.95833333333333, 1.225, 0.125
64673, 0.9375, 1.25, 0.125
64674, 0.95833333333333, 1.25, 0.10416666666667
64675, 0.95833333333333, 1.275, 0.125
64676, 0.9375, 1.3, 0.125
64677, 0.95833333333333, 1.3, 0.10416666666667
64678, 0.95833333333333, 1.325, 0.125
64679, 0.95833333333333, 0.175, 0.16666666666667
64680, 0.9375, 0.2, 0.16666666666667
64681, 0.95833333333333, 0.2, 0.14583333333333
64682, 0.95833333333333, 0.225, 0.16666666666667
64683, 0.9375, 0.25, 0.16666666666667
64684, 0.95833333333333, 0.25, 0.14583333333333
64685, 0.95833333333333, 0.275, 0.16666666666667
64686, 0.9375, 0.3, 0.16666666666667
64687, 0.95833333333333, 0.3, 0.14583333333333
64688, 0.95833333333333, 0.325, 0.16666666666667
64689, 0.9375, 0.35, 0.16666666666667
64690, 0.95833333333333, 0.35, 0.14583333333333
64691, 0.95833333333333, 0.375, 0.16666666666667
64692, 0.9375, 0.4, 0.16666666666667
64693, 0.95833333333333, 0.4, 0.14583333333333
64694, 0.95833333333333, 0.425, 0.16666666666667
64695, 0.9375, 0.45, 0.16666666666667
64696, 0.95833333333333, 0.45, 0.14583333333333
64697, 0.95833333333333, 0.475, 0.16666666666667
64698, 0.9375, 0.5, 0.16666666666667
64699, 0.95833333333333, 0.5, 0.14583333333333
64700, 0.95833333333333, 0.525, 0.16666666666667
64701, 0.9375, 0.55, 0.16666666666667
64702, 0.95833333333333, 0.55, 0.14583333333333
64703, 0.95833333333333, 0.575, 0.16666666666667
64704, 0.9375, 0.6, 0.16666666666667
64705, 0.95833333333333, 0.6, 0.14583333333333
64706, 0.95833333333333, 0.625, 0.16666666666667
64707, 0.9375, 0.65, 0.16666666666667
64708, 0.95833333333333, 0.65, 0.14583333333333
64709, 0.95833333333333, 0.675, 0.16666666666667
64710, 0.9375, 0.7, 0.16666666666667
64711, 0.95833333333333, 0.7, 0.14583333333333
64712, 0.95833333333333, 0.725, 0.16666666666667
64713, 0.9375, 0.75, 0.16666666666667
64714, 0.95833333333333, 0.75, 0.14583333333333
64715, 0.95833333333333, 0.775, 0.16666666666667
64716, 0.9375, 0.8, 0.16666666666667
64717, 0.95833333333333, 0.8, 0.14583333333333
64718, 0.95833333333333, 0.825, 0.16666666666667
64719, 0.9375, 0.85, 0.16666666666667
64720, 0.95833333333333, 0.85, 0.14583333333333
64721, 0.95833333333333, 0.875, 0.16666666666667
64722, 0.9375, 0.9, 0.16666666666667
64723, 0.95833333333333, 0.9, 0.14583333333333
64724, 0.95833333333333, 0.925, 0.16666666666667
64725, 0.9375, 0.95, 0.16666666666667
64726, 0.95833333333333, 0.95, 0.14583333333333
64727, 0.95833333333333, 0.975, 0.16666666666667
64728, 0.9375, 1, 0.16666666666667
64729, 0.95833333333333, 1, 0.14583333333333
64730, 0.95833333333333, 1.025, 0.16666666666667
64731, 0.9375, 1.05, 0.16666666666667
64732, 0.95833333333333, 1.05, 0.14583333333333
64733, 0.95833333333333, 1.075, 0.16666666666667
64734, 0.9375, 1.1, 0.16666666666667
64735, 0.95833333333333, 1.1, 0.14583333333333
64736, 0.95833333333333, 1.125, 0.16666666666667
64737, 0.9375, 1.15, 0.16666666666667
64738, 0.95833333333333, 1.15, 0.14583333333333
64739, 0.95833333333333, 1.175, 0.16666666666667
64740, 0.9375, 1.2, 0.16666666666667
64741, 0.95833333333333, 1.2, 0.14583333333333
64742, 0.95833333333333, 1.225, 0.16666666666667
64743, 0.9375, 1.25, 0.16666666666667
64744, 0.95833333333333, 1.25, 0.14583333333333
64745, 0.95833333333333, 1.275, 0.16666666666667
64746, 0.9375, 1.3, 0.16666666666667
64747, 0.95833333333333, 1.3, 0.14583333333333
64748, 0.95833333333333, 1.325, 0.16666666666667
64749, 0.95833333333333, 0.175, 0.20833333333333
64750, 0.9375, 0.2, 0.20833333333333
64751, 0.95833333333333, 0.2, 0.1875
64752, 0.95833333333333, 0.225, 0.20833333333333
64753, 0.9375, 0.25, 0.20833333333333
64754, 0.95833333333333, 0.25, 0.1875
64755, 0.95833333333333, 0.275, 0.20833333333333
64756, 0.9375, 0.3, 0.20833333333333
64757, 0.95833333333333, 0.3, 0.1875
64758, 0.95833333333333, 0.325, 0.20833333333333
64759, 0.9375, 0.35, 0.20833333333333
64760, 0.95833333333333, 0.35, 0.1875
64761, 0.95833333333333, 0.375, 0.20833333333333
64762, 0.9375, 0.4, 0.20833333333333
64763, 0.95833333333333, 0.4, 0.1875
64764, 0.95833333333333, 0.425, 0.20833333333333
64765, 0.9375, 0.45, 0.20833333333333
64766, 0.95833333333333, 0.45, 0.1875
64767, 0.95833333333333, 0.475, 0.20833333333333
64768, 0.9375, 0.5, 0.20833333333333
64769, 0.95833333333333, 0.5, 0.1875
64770, 0.95833333333333, 0.525, 0.20833333333333
64771, 0.9375, 0.55, 0.20833333333333
64772, 0.95833333333333, 0.55, 0.1875
64773, 0.95833333333333, 0.575, 0.20833333333333
64774, 0.9375, 0.6, 0.20833333333333
64775, 0.95833333333333, 0.6, 0.1875
64776, 0.95833333333333, 0.625, 0.20833333333333
64777, 0.9375, 0.65, 0.20833333333333
64778, 0.95833333333333, 0.65, 0.1875
64779, 0.95833333333333, 0.675, 0.20833333333333
64780, 0.9375, 0.7, 0.20833333333333
64781, 0.95833333333333, 0.7, 0.1875
64782, 0.95833333333333, 0.725, 0.20833333333333
64783, 0.9375, 0.75, 0.20833333333333
64784, 0.95833333333333, 0.75, 0.1875
64785, 0.95833333333333, 0.775, 0.20833333333333
64786, 0.9375, 0.8, 0.20833333333333
64787, 0.95833333333333, 0.8, 0.1875
64788, 0.95833333333333, 0.825, 0.20833333333333
64789, 0.9375, 0.85, 0.20833333333333
64790, 0.95833333333333, 0.85, 0.1875
64791, 0.95833333333333, 0.875, 0.20833333333333
64792, 0.9375, 0.9, 0.20833333333333
64793, 0.95833333333333, 0.9, 0.1875
64794, 0.95833333333333, 0.925, 0.20833333333333
64795, 0.9375, 0.95, 0.20833333333333
64796, 0.95833333333333, 0.95, 0.1875
64797, 0.95833333333333, 0.975, 0.20833333333333
64798, 0.9375, 1, 0.20833333333333
64799, 0.95833333333333, 1, 0.1875
64800, 0.95833333333333, 1.025, 0.20833333333333
64801, 0.9375, 1.05, 0.20833333333333
64802, 0.95833333333333, 1.05, 0.1875
64803, 0.95833333333333, 1.075, 0.20833333333333
64804, 0.9375, 1.1, 0.20833333333333
64805, 0.95833333333333, 1.1, 0.1875
64806, 0.95833333333333, 1.125, 0.20833333333333
64807, 0.9375, 1.15, 0.20833333333333
64808, 0.95833333333333, 1.15, 0.1875
64809, 0.95833333333333, 1.175, 0.20833333333333
64810, 0.9375, 1.2, 0.20833333333333
64811, 0.95833333333333, 1.2, 0.1875
64812, 0.95833333333333, 1.225, 0.20833333333333
64813, 0.9375, 1.25, 0.20833333333333
64814, 0.95833333333333, 1.25, 0.1875
64815, 0.95833333333333, 1.275, 0.20833333333333
64816, 0.9375, 1.3, 0.20833333333333
64817, 0.95833333333333, 1.3, 0.1875
64818, 0.95833333333333, 1.325, 0.20833333333333
64819, 0.95833333333333, 0.175, 0.25
64820, 0.9375, 0.2, 0.25
64821, 0.95833333333333, 0.2, 0.22916666666667
64822, 0.95833333333333, 0.225, 0.25
64823, 0.9375, 0.25, 0.25
64824, 0.95833333333333, 0.25, 0.22916666666667
64825, 0.95833333333333, 0.275, 0.25
64826, 0.9375, 0.3, 0.25
64827, 0.95833333333333, 0.3, 0.22916666666667
64828, 0.95833333333333, 0.325, 0.25
64829, 0.9375, 0.35, 0.25
64830, 0.95833333333333, 0.35, 0.22916666666667
64831, 0.95833333333333, 0.375, 0.25
64832, 0.9375, 0.4, 0.25
64833, 0.95833333333333, 0.4, 0.22916666666667
64834, 0.95833333333333, 0.425, 0.25
64835, 0.9375, 0.45, 0.25
64836, 0.95833333333333, 0.45, 0.22916666666667
64837, 0.95833333333333, 0.475, 0.25
64838, 0.9375, 0.5, 0.25
64839, 0.95833333333333, 0.5, 0.22916666666667
64840, 0.95833333333333, 0.525, 0.25
64841, 0.9375, 0.55, 0.25
64842, 0.95833333333333, 0.55, 0.22916666666667
64843, 0.95833333333333, 0.575, 0.25
64844, 0.9375, 0.6, 0.25
64845, 0.95833333333333, 0.6, 0.22916666666667
64846, 0.95833333333333, 0.625, 0.25
64847, 0.9375, 0.65, 0.25
64848, 0.95833333333333, 0.65, 0.22916666666667
64849, 0.95833333333333, 0.675, 0.25
64850, 0.9375, 0.7, 0.25
64851, 0.95833333333333, 0.7, 0.22916666666667
64852, 0.95833333333333, 0.725, 0.25
64853, 0.9375, 0.75, 0.25
64854, 0.95833333333333, 0.75, 0.22916666666667
64855, 0.95833333333333, 0.775, 0.25
64856, 0.9375, 0.8, 0.25
64857, 0.95833333333333, 0.8, 0.22916666666667
64858, 0.95833333333333, 0.825, 0.25
64859, 0.9375, 0.85, 0.25
64860, 0.95833333333333, 0.85, 0.22916666666667
64861, 0.95833333333333, 0.875, 0.25
64862, 0.9375, 0.9, 0.25
64863, 0.95833333333333, 0.9, 0.22916666666667
64864, 0.95833333333333, 0.925, 0.25
64865, 0.9375, 0.95, 0.25
64866, 0.95833333333333, 0.95, 0.22916666666667
64867, 0.95833333333333, 0.975, 0.25
64868, 0.9375, 1, 0.25
64869, 0.95833333333333, 1, 0.22916666666667
64870, 0.95833333333333, 1.025, 0.25
64871, 0.9375, 1.05, 0.25
64872, 0.95833333333333, 1.05, 0.22916666666667
64873, 0.95833333333333, 1.075, 0.25
64874, 0.9375, 1.1, 0.25
64875, 0.95833333333333, 1.1, 0.22916666666667
64876, 0.95833333333333, 1.125, 0.25
64877, 0.9375, 1.15, 0.25
64878, 0.95833333333333, 1.15, 0.22916666666667
64879, 0.95833333333333, 1.175, 0.25
64880, 0.9375, 1.2, 0.25
64881, 0.95833333333333, 1.2, 0.22916666666667
64882, 0.95833333333333, 1.225, 0.25
64883, 0.9375, 1.25, 0.25
64884, 0.95833333333333, 1.25, 0.22916666666667
64885, 0.95833333333333, 1.275, 0.25
64886, 0.9375, 1.3, 0.25
64887, 0.95833333333333, 1.3, 0.22916666666667
64888, 0.95833333333333, 1.325, 0.25
64889, 0.95833333333333, 0.175, 0.29166666666667
64890, 0.9375, 0.2, 0.29166666666667
64891, 0.95833333333333, 0.2, 0.27083333333333
64892, 0.95833333333333, 0.225, 0.29166666666667
64893, 0.9375, 0.25, 0.29166666666667
64894, 0.95833333333333, 0.25, 0.27083333333333
64895, 0.95833333333333, 0.275, 0.29166666666667
64896, 0.9375, 0.3, 0.29166666666667
64897, 0.95833333333333, 0.3, 0.27083333333333
64898, 0.95833333333333, 0.325, 0.29166666666667
64899, 0.9375, 0.35, 0.29166666666667
64900, 0.95833333333333, 0.35, 0.27083333333333
64901, 0.95833333333333, 0.375, 0.29166666666667
64902, 0.9375, 0.4, 0.29166666666667
64903, 0.95833333333333, 0.4, 0.27083333333333
64904, 0.95833333333333, 0.425, 0.29166666666667
64905, 0.9375, 0.45, 0.29166666666667
64906, 0.95833333333333, 0.45, 0.27083333333333
64907, 0.95833333333333, 0.475, 0.29166666666667
64908, 0.9375, 0.5, 0.29166666666667
64909, 0.95833333333333, 0.5, 0.27083333333333
64910, 0.95833333333333, 0.525, 0.29166666666667
64911, 0.9375, 0.55, 0.29166666666667
64912, 0.95833333333333, 0.55, 0.27083333333333
64913, 0.95833333333333, 0.575, 0.29166666666667
64914, 0.9375, 0.6, 0.29166666666667
64915, 0.95833333333333, 0.6, 0.27083333333333
64916, 0.95833333333333, 0.625, 0.29166666666667
64917, 0.9375, 0.65, 0.29166666666667
64918, 0.95833333333333, 0.65, 0.27083333333333
64919, 0.95833333333333, 0.675, 0.29166666666667
64920, 0.9375, 0.7, 0.29166666666667
64921, 0.95833333333333, 0.7, 0.27083333333333
64922, 0.95833333333333, 0.725, 0.29166666666667
64923, 0.9375, 0.75, 0.29166666666667
64924, 0.95833333333333, 0.75, 0.27083333333333
64925, 0.95833333333333, 0.775, 0.29166666666667
64926, 0.9375, 0.8, 0.29166666666667
64927, 0.95833333333333, 0.8, 0.27083333333333
64928, 0.95833333333333, 0.825, 0.29166666666667
64929, 0.9375, 0.85, 0.29166666666667
64930, 0.95833333333333, 0.85, 0.27083333333333
64931, 0.95833333333333, 0.875, 0.29166666666667
64932, 0.9375, 0.9, 0.29166666666667
64933, 0.95833333333333, 0.9, 0.27083333333333
64934, 0.95833333333333, 0.925, 0.29166666666667
64935, 0.9375, 0.95, 0.29166666666667
64936, 0.95833333333333, 0.95, 0.27083333333333
64937, 0.95833333333333, 0.975, 0.29166666666667
64938, 0.9375, 1, 0.29166666666667
64939, 0.95833333333333, 1, 0.27083333333333
64940, 0.95833333333333, 1.025, 0.29166666666667
64941, 0.9375, 1.05, 0.29166666666667
64942, 0.95833333333333, 1.05, 0.27083333333333
64943, 0.95833333333333, 1.075, 0.29166666666667
64944, 0.9375, 1.1, 0.29166666666667
64945, 0.95833333333333, 1.1, 0.27083333333333
64946, 0.95833333333333, 1.125, 0.29166666666667
64947, 0.9375, 1.15, 0.29166666666667
64948, 0.95833333333333, 1.15, 0.27083333333333
64949, 0.95833333333333, 1.175, 0.29166666666667
64950, 0.9375, 1.2, 0.29166666666667
64951, 0.95833333333333, 1.2, 0.27083333333333
64952, 0.95833333333333, 1.225, 0.29166666666667
64953, 0.9375, 1.25, 0.29166666666667
64954, 0.95833333333333, 1.25, 0.27083333333333
64955, 0.95833333333333, 1.275, 0.29166666666667
64956, 0.9375, 1.3, 0.29166666666667
64957, 0.95833333333333, 1.3, 0.27083333333333
64958, 0.95833333333333, 1.325, 0.29166666666667
64959, 0.95833333333333, 0.175, 0.33333333333333
64960, 0.9375, 0.2, 0.33333333333333
64961, 0.95833333333333, 0.2, 0.3125
64962, 0.95833333333333, 0.225, 0.33333333333333
64963, 0.9375, 0.25, 0.33333333333333
64964, 0.95833333333333, 0.25, 0.3125
64965, 0.95833333333333, 0.275, 0.33333333333333
64966, 0.9375, 0.3, 0.33333333333333
64967, 0.95833333333333, 0.3, 0.3125
64968, 0.95833333333333, 0.325, 0.33333333333333
64969, 0.9375, 0.35, 0.33333333333333
64970, 0.95833333333333, 0.35, 0.3125
64971, 0.95833333333333, 0.375, 0.33333333333333
64972, 0.9375, 0.4, 0.33333333333333
64973, 0.95833333333333, 0.4, 0.3125
64974, 0.95833333333333, 0.425, 0.33333333333333
64975, 0.9375, 0.45, 0.33333333333333
64976, 0.95833333333333, 0.45, 0.3125
64977, 0.95833333333333, 0.475, 0.33333333333333
64978, 0.9375, 0.5, 0.33333333333333
64979, 0.95833333333333, 0.5, 0.3125
64980, 0.95833333333333, 0.525, 0.33333333333333
64981, 0.9375, 0.55, 0.33333333333333
64982, 0.95833333333333, 0.55, 0.3125
64983, 0.95833333333333, 0.575, 0.33333333333333
64984, 0.9375, 0.6, 0.33333333333333
64985, 0.95833333333333, 0.6, 0.3125
64986, 0.95833333333333, 0.625, 0.33333333333333
64987, 0.9375, 0.65, 0.33333333333333
64988, 0.95833333333333, 0.65, 0.3125
64989, 0.95833333333333, 0.675, 0.33333333333333
64990, 0.9375, 0.7, 0.33333333333333
64991, 0.95833333333333, 0.7, 0.3125
64992, 0.95833333333333, 0.725, 0.33333333333333
64993, 0.9375, 0.75, 0.33333333333333
64994, 0.95833333333333, 0.75, 0.3125
64995, 0.95833333333333, 0.775, 0.33333333333333
64996, 0.9375, 0.8, 0.33333333333333
64997, 0.95833333333333, 0.8, 0.3125
64998, 0.95833333333333, 0.825, 0.33333333333333
64999, 0.9375, 0.85, 0.33333333333333
65000, 0.95833333333333, 0.85, 0.3125
65001, 0.95833333333333, 0.875, 0.33333333333333
65002, 0.9375, 0.9, 0.33333333333333
65003, 0.95833333333333, 0.9, 0.3125
65004, 0.95833333333333, 0.925, 0.33333333333333
65005, 0.9375, 0.95, 0.33333333333333
65006, 0.95833333333333, 0.95, 0.3125
65007, 0.95833333333333, 0.975, 0.33333333333333
65008, 0.9375, 1, 0.33333333333333
65009, 0.95833333333333, 1, 0.3125
65010, 0.95833333333333, 1.025, 0.33333333333333
65011, 0.9375, 1.05, 0.33333333333333
65012, 0.95833333333333, 1.05, 0.3125
65013, 0.95833333333333, 1.075, 0.33333333333333
65014, 0.9375, 1.1, 0.33333333333333
65015, 0.95833333333333, 1.1, 0.3125
65016, 0.95833333333333, 1.125, 0.33333333333333
65017, 0.9375, 1.15, 0.33333333333333
65018, 0.95833333333333, 1.15, 0.3125
65019, 0.95833333333333, 1.175, 0.33333333333333
65020, 0.9375, 1.2, 0.33333333333333
65021, 0.95833333333333, 1.2, 0.3125
65022, 0.95833333333333, 1.225, 0.33333333333333
65023, 0.9375, 1.25, 0.33333333333333
65024, 0.95833333333333, 1.25, 0.3125
65025, 0.95833333333333, 1.275, 0.33333333333333
65026, 0.9375, 1.3, 0.33333333333333
65027, 0.95833333333333, 1.3, 0.3125
65028, 0.95833333333333, 1.325, 0.33333333333333
65029, 0.95833333333333, 0.175, 0.375
65030, 0.9375, 0.2, 0.375
65031, 0.95833333333333, 0.2, 0.35416666666667
65032, 0.95833333333333, 0.225, 0.375
65033, 0.9375, 0.25, 0.375
65034, 0.95833333333333, 0.25, 0.35416666666667
65035, 0.95833333333333, 0.275, 0.375
65036, 0.9375, 0.3, 0.375
65037, 0.95833333333333, 0.3, 0.35416666666667
65038, 0.95833333333333, 0.325, 0.375
65039, 0.9375, 0.35, 0.375
65040, 0.95833333333333, 0.35, 0.35416666666667
65041, 0.95833333333333, 0.375, 0.375
65042, 0.9375, 0.4, 0.375
65043, 0.95833333333333, 0.4, 0.35416666666667
65044, 0.95833333333333, 0.425, 0.375
65045, 0.9375, 0.45, 0.375
65046, 0.95833333333333, 0.45, 0.35416666666667
65047, 0.95833333333333, 0.475, 0.375
65048, 0.9375, 0.5, 0.375
65049, 0.95833333333333, 0.5, 0.35416666666667
65050, 0.95833333333333, 0.525, 0.375
65051, 0.9375, 0.55, 0.375
65052, 0.95833333333333, 0.55, 0.35416666666667
65053, 0.95833333333333, 0.575, 0.375
65054, 0.9375, 0.6, 0.375
65055, 0.95833333333333, 0.6, 0.35416666666667
65056, 0.95833333333333, 0.625, 0.375
65057, 0.9375, 0.65, 0.375
65058, 0.95833333333333, 0.65, 0.35416666666667
65059, 0.95833333333333, 0.675, 0.375
65060, 0.9375, 0.7, 0.375
65061, 0.95833333333333, 0.7, 0.35416666666667
65062, 0.95833333333333, 0.725, 0.375
65063, 0.9375, 0.75, 0.375
65064, 0.95833333333333, 0.75, 0.35416666666667
65065, 0.95833333333333, 0.775, 0.375
65066, 0.9375, 0.8, 0.375
65067, 0.95833333333333, 0.8, 0.35416666666667
65068, 0.95833333333333, 0.825, 0.375
65069, 0.9375, 0.85, 0.375
65070, 0.95833333333333, 0.85, 0.35416666666667
65071, 0.95833333333333, 0.875, 0.375
65072, 0.9375, 0.9, 0.375
65073, 0.95833333333333, 0.9, 0.35416666666667
65074, 0.95833333333333, 0.925, 0.375
65075, 0.9375, 0.95, 0.375
65076, 0.95833333333333, 0.95, 0.35416666666667
65077, 0.95833333333333, 0.975, 0.375
65078, 0.9375, 1, 0.375
65079, 0.95833333333333, 1, 0.35416666666667
65080, 0.95833333333333, 1.025, 0.375
65081, 0.9375, 1.05, 0.375
65082, 0.95833333333333, 1.05, 0.35416666666667
65083, 0.95833333333333, 1.075, 0.375
65084, 0.9375, 1.1, 0.375
65085, 0.95833333333333, 1.1, 0.35416666666667
65086, 0.95833333333333, 1.125, 0.375
65087, 0.9375, 1.15, 0.375
65088, 0.95833333333333, 1.15, 0.35416666666667
65089, 0.95833333333333, 1.175, 0.375
65090, 0.9375, 1.2, 0.375
65091, 0.95833333333333, 1.2, 0.35416666666667
65092, 0.95833333333333, 1.225, 0.375
65093, 0.9375, 1.25, 0.375
65094, 0.95833333333333, 1.25, 0.35416666666667
65095, 0.95833333333333, 1.275, 0.375
65096, 0.9375, 1.3, 0.375
65097, 0.95833333333333, 1.3, 0.35416666666667
65098, 0.95833333333333, 1.325, 0.375
65099, 0.95833333333333, 0.175, 0.41666666666667
65100, 0.9375, 0.2, 0.41666666666667
65101, 0.95833333333333, 0.2, 0.39583333333333
65102, 0.95833333333333, 0.225, 0.41666666666667
65103, 0.9375, 0.25, 0.41666666666667
65104, 0.95833333333333, 0.25, 0.39583333333333
65105, 0.95833333333333, 0.275, 0.41666666666667
65106, 0.9375, 0.3, 0.41666666666667
65107, 0.95833333333333, 0.3, 0.39583333333333
65108, 0.95833333333333, 0.325, 0.41666666666667
65109, 0.9375, 0.35, 0.41666666666667
65110, 0.95833333333333, 0.35, 0.39583333333333
65111, 0.95833333333333, 0.375, 0.41666666666667
65112, 0.9375, 0.4, 0.41666666666667
65113, 0.95833333333333, 0.4, 0.39583333333333
65114, 0.95833333333333, 0.425, 0.41666666666667
65115, 0.9375, 0.45, 0.41666666666667
65116, 0.95833333333333, 0.45, 0.39583333333333
65117, 0.95833333333333, 0.475, 0.41666666666667
65118, 0.9375, 0.5, 0.41666666666667
65119, 0.95833333333333, 0.5, 0.39583333333333
65120, 0.95833333333333, 0.525, 0.41666666666667
65121, 0.9375, 0.55, 0.41666666666667
65122, 0.95833333333333, 0.55, 0.39583333333333
65123, 0.95833333333333, 0.575, 0.41666666666667
65124, 0.9375, 0.6, 0.41666666666667
65125, 0.95833333333333, 0.6, 0.39583333333333
65126, 0.95833333333333, 0.625, 0.41666666666667
65127, 0.9375, 0.65, 0.41666666666667
65128, 0.95833333333333, 0.65, 0.39583333333333
65129, 0.95833333333333, 0.675, 0.41666666666667
65130, 0.9375, 0.7, 0.41666666666667
65131, 0.95833333333333, 0.7, 0.39583333333333
65132, 0.95833333333333, 0.725, 0.41666666666667
65133, 0.9375, 0.75, 0.41666666666667
65134, 0.95833333333333, 0.75, 0.39583333333333
65135, 0.95833333333333, 0.775, 0.41666666666667
65136, 0.9375, 0.8, 0.41666666666667
65137, 0.95833333333333, 0.8, 0.39583333333333
65138, 0.95833333333333, 0.825, 0.41666666666667
65139, 0.9375, 0.85, 0.41666666666667
65140, 0.95833333333333, 0.85, 0.39583333333333
65141, 0.95833333333333, 0.875, 0.41666666666667
65142, 0.9375, 0.9, 0.41666666666667
65143, 0.95833333333333, 0.9, 0.39583333333333
65144, 0.95833333333333, 0.925, 0.41666666666667
65145, 0.9375, 0.95, 0.41666666666667
65146, 0.95833333333333, 0.95, 0.39583333333333
65147, 0.95833333333333, 0.975, 0.41666666666667
65148, 0.9375, 1, 0.41666666666667
65149, 0.95833333333333, 1, 0.39583333333333
65150, 0.95833333333333, 1.025, 0.41666666666667
65151, 0.9375, 1.05, 0.41666666666667
65152, 0.95833333333333, 1.05, 0.39583333333333
65153, 0.95833333333333, 1.075, 0.41666666666667
65154, 0.9375, 1.1, 0.41666666666667
65155, 0.95833333333333, 1.1, 0.39583333333333
65156, 0.95833333333333, 1.125, 0.41666666666667
65157, 0.9375, 1.15, 0.41666666666667
65158, 0.95833333333333, 1.15, 0.39583333333333
65159, 0.95833333333333, 1.175, 0.41666666666667
65160, 0.9375, 1.2, 0.41666666666667
65161, 0.95833333333333, 1.2, 0.39583333333333
65162, 0.95833333333333, 1.225, 0.41666666666667
65163, 0.9375, 1.25, 0.41666666666667
65164, 0.95833333333333, 1.25, 0.39583333333333
65165, 0.95833333333333, 1.275, 0.41666666666667
65166, 0.9375, 1.3, 0.41666666666667
65167, 0.95833333333333, 1.3, 0.39583333333333
65168, 0.95833333333333, 1.325, 0.41666666666667
65169, 0.95833333333333, 0.175, 0.45833333333333
65170, 0.9375, 0.2, 0.45833333333333
65171, 0.95833333333333, 0.2, 0.4375
65172, 0.95833333333333, 0.225, 0.45833333333333
65173, 0.9375, 0.25, 0.45833333333333
65174, 0.95833333333333, 0.25, 0.4375
65175, 0.95833333333333, 0.275, 0.45833333333333
65176, 0.9375, 0.3, 0.45833333333333
65177, 0.95833333333333, 0.3, 0.4375
65178, 0.95833333333333, 0.325, 0.45833333333333
65179, 0.9375, 0.35, 0.45833333333333
65180, 0.95833333333333, 0.35, 0.4375
65181, 0.95833333333333, 0.375, 0.45833333333333
65182, 0.9375, 0.4, 0.45833333333333
65183, 0.95833333333333, 0.4, 0.4375
65184, 0.95833333333333, 0.425, 0.45833333333333
65185, 0.9375, 0.45, 0.45833333333333
65186, 0.95833333333333, 0.45, 0.4375
65187, 0.95833333333333, 0.475, 0.45833333333333
65188, 0.9375, 0.5, 0.45833333333333
65189, 0.95833333333333, 0.5, 0.4375
65190, 0.95833333333333, 0.525, 0.45833333333333
65191, 0.9375, 0.55, 0.45833333333333
65192, 0.95833333333333, 0.55, 0.4375
65193, 0.95833333333333, 0.575, 0.45833333333333
65194, 0.9375, 0.6, 0.45833333333333
65195, 0.95833333333333, 0.6, 0.4375
65196, 0.95833333333333, 0.625, 0.45833333333333
65197, 0.9375, 0.65, 0.45833333333333
65198, 0.95833333333333, 0.65, 0.4375
65199, 0.95833333333333, 0.675, 0.45833333333333
65200, 0.9375, 0.7, 0.45833333333333
65201, 0.95833333333333, 0.7, 0.4375
65202, 0.95833333333333, 0.725, 0.45833333333333
65203, 0.9375, 0.75, 0.45833333333333
65204, 0.95833333333333, 0.75, 0.4375
65205, 0.95833333333333, 0.775, 0.45833333333333
65206, 0.9375, 0.8, 0.45833333333333
65207, 0.95833333333333, 0.8, 0.4375
65208, 0.95833333333333, 0.825, 0.45833333333333
65209, 0.9375, 0.85, 0.45833333333333
65210, 0.95833333333333, 0.85, 0.4375
65211, 0.95833333333333, 0.875, 0.45833333333333
65212, 0.9375, 0.9, 0.45833333333333
65213, 0.95833333333333, 0.9, 0.4375
65214, 0.95833333333333, 0.925, 0.45833333333333
65215, 0.9375, 0.95, 0.45833333333333
65216, 0.95833333333333, 0.95, 0.4375
65217, 0.95833333333333, 0.975, 0.45833333333333
65218, 0.9375, 1, 0.45833333333333
65219, 0.95833333333333, 1, 0.4375
65220, 0.95833333333333, 1.025, 0.45833333333333
65221, 0.9375, 1.05, 0.45833333333333
65222, 0.95833333333333, 1.05, 0.4375
65223, 0.95833333333333, 1.075, 0.45833333333333
65224, 0.9375, 1.1, 0.45833333333333
65225, 0.95833333333333, 1.1, 0.4375
65226, 0.95833333333333, 1.125, 0.45833333333333
65227, 0.9375, 1.15, 0.45833333333333
65228, 0.95833333333333, 1.15, 0.4375
65229, 0.95833333333333, 1.175, 0.45833333333333
65230, 0.9375, 1.2, 0.45833333333333
65231, 0.95833333333333, 1.2, 0.4375
65232, 0.95833333333333, 1.225, 0.45833333333333
65233, 0.9375, 1.25, 0.45833333333333
65234, 0.95833333333333, 1.25, 0.4375
65235, 0.95833333333333, 1.275, 0.45833333333333
65236, 0.9375, 1.3, 0.45833333333333
65237, 0.95833333333333, 1.3, 0.4375
65238, 0.95833333333333, 1.325, 0.45833333333333
65239, 0.95833333333333, 0.2, 0.47916666666667
65240, 0.95833333333333, 0.25, 0.47916666666667
65241, 0.95833333333333, 0.3, 0.47916666666667
65242, 0.95833333333333, 0.35, 0.47916666666667
65243, 0.95833333333333, 0.4, 0.47916666666667
65244, 0.95833333333333, 0.45, 0.47916666666667
65245, 0.95833333333333, 0.5, 0.47916666666667
65246, 0.95833333333333, 0.55, 0.47916666666667
65247, 0.95833333333333, 0.6, 0.47916666666667
65248, 0.95833333333333, 0.65, 0.47916666666667
65249, 0.95833333333333, 0.7, 0.47916666666667
65250, 0.95833333333333, 0.75, 0.47916666666667
65251, 0.95833333333333, 0.8, 0.47916666666667
65252, 0.95833333333333, 0.85, 0.47916666666667
65253, 0.95833333333333, 0.9, 0.47916666666667
65254, 0.95833333333333, 0.95, 0.47916666666667
65255, 0.95833333333333, 1, 0.47916666666667
65256, 0.95833333333333, 1.05, 0.47916666666667
65257, 0.95833333333333, 1.1, 0.47916666666667
65258, 0.95833333333333, 1.15, 0.47916666666667
65259, 0.95833333333333, 1.2, 0.47916666666667
65260, 0.95833333333333, 1.25, 0.47916666666667
65261, 0.95833333333333, 1.3, 0.47916666666667
65262, 0.97916666666667, 0.2, 0.041666666666667
65263, 0.97916666666667, 0.25, 0.041666666666667
65264, 0.97916666666667, 0.3, 0.041666666666667
65265, 0.97916666666667, 0.35, 0.041666666666667
65266, 0.97916666666667, 0.4, 0.041666666666667
65267, 0.97916666666667, 0.45, 0.041666666666667
65268, 0.97916666666667, 0.5, 0.041666666666667
65269, 0.97916666666667, 0.55, 0.041666666666667
65270, 0.97916666666667, 0.6, 0.041666666666667
65271, 0.97916666666667, 0.65, 0.041666666666667
65272, 0.97916666666667, 0.7, 0.041666666666667
65273, 0.97916666666667, 0.75, 0.041666666666667
65274, 0.97916666666667, 0.8, 0.041666666666667
65275, 0.97916666666667, 0.85, 0.041666666666667
65276, 0.97916666666667, 0.9, 0.041666666666667
65277, 0.97916666666667, 0.95, 0.041666666666667
65278, 0.97916666666667, 1, 0.041666666666667
65279, 0.97916666666667, 1.05, 0.041666666666667
65280, 0.97916666666667, 1.1, 0.041666666666667
65281, 0.97916666666667, 1.15, 0.041666666666667
65282, 0.97916666666667, 1.2, 0.041666666666667
65283, 0.97916666666667, 1.25, 0.041666666666667
65284, 0.97916666666667, 1.3, 0.041666666666667
65285, 0.97916666666667, 0.2, 0.083333333333333
65286, 0.97916666666667, 0.25, 0.083333333333333
65287, 0.97916666666667, 0.3, 0.083333333333333
65288, 0.97916666666667, 0.35, 0.083333333333333
65289, 0.97916666666667, 0.4, 0.083333333333333
65290, 0.97916666666667, 0.45, 0.083333333333333
65291, 0.97916666666667, 0.5, 0.083333333333333
65292, 0.97916666666667, 0.55, 0.083333333333333
65293, 0.97916666666667, 0.6, 0.083333333333333
65294, 0.97916666666667, 0.65, 0.083333333333333
65295, 0.97916666666667, 0.7, 0.083333333333333
65296, 0.97916666666667, 0.75, 0.083333333333333
65297, 0.97916666666667, 0.8, 0.083333333333333
65298, 0.97916666666667, 0.85, 0.083333333333333
65299, 0.97916666666667, 0.9, 0.083333333333333
65300, 0.97916666666667, 0.95, 0.083333333333333
65301, 0.97916666666667, 1, 0.083333333333333
65302, 0.97916666666667, 1.05, 0.083333333333333
65303, 0.97916666666667, 1.1, 0.083333333333333
65304, 0.97916666666667, 1.15, 0.083333333333333
65305, 0.97916666666667, 1.2, 0.083333333333333
65306, 0.97916666666667, 1.25, 0.083333333333333
65307, 0.97916666666667, 1.3, 0.083333333333333
65308, 0.97916666666667, 0.2, 0.125
65309, 0.97916666666667, 0.25, 0.125
65310, 0.97916666666667, 0.3, 0.125
65311, 0.97916666666667, 0.35, 0.125
65312, 0.97916666666667, 0.4, 0.125
65313, 0.97916666666667, 0.45, 0.125
65314, 0.97916666666667, 0.5, 0.125
65315, 0.97916666666667, 0.55, 0.125
65316, 0.97916666666667, 0.6, 0.125
65317, 0.97916666666667, 0.65, 0.125
65318, 0.97916666666667, 0.7, 0.125
65319, 0.97916666666667, 0.75, 0.125
65320, 0.97916666666667, 0.8, 0.125
65321, 0.97916666666667, 0.85, 0.125
65322, 0.97916666666667, 0.9, 0.125
65323, 0.97916666666667, 0.95, 0.125
65324, 0.97916666666667, 1, 0.125
65325, 0.97916666666667, 1.05, 0.125
65326, 0.97916666666667, 1.1, 0.125
65327, 0.97916666666667, 1.15, 0.125
65328, 0.97916666666667, 1.2, 0.125
65329, 0.97916666666667, 1.25, 0.125
65330, 0.97916666666667, 1.3, 0.125
65331, 0.97916666666667, 0.2, 0.16666666666667
65332, 0.97916666666667, 0.25, 0.16666666666667
65333, 0.97916666666667, 0.3, 0.16666666666667
65334, 0.97916666666667, 0.35, 0.16666666666667
65335, 0.97916666666667, 0.4, 0.16666666666667
65336, 0.97916666666667, 0.45, 0.16666666666667
65337, 0.97916666666667, 0.5, 0.16666666666667
65338, 0.97916666666667, 0.55, 0.16666666666667
65339, 0.97916666666667, 0.6, 0.16666666666667
65340, 0.97916666666667, 0.65, 0.16666666666667
65341, 0.97916666666667, 0.7, 0.16666666666667
65342, 0.97916666666667, 0.75, 0.16666666666667
65343, 0.97916666666667, 0.8, 0.16666666666667
65344, 0.97916666666667, 0.85, 0.16666666666667
65345, 0.97916666666667, 0.9, 0.16666666666667
65346, 0.97916666666667, 0.95, 0.16666666666667
65347, 0.97916666666667, 1, 0.16666666666667
65348, 0.97916666666667, 1.05, 0.16666666666667
65349, 0.97916666666667, 1.1, 0.16666666666667
65350, 0.97916666666667, 1.15, 0.16666666666667
65351, 0.97916666666667, 1.2, 0.16666666666667
65352, 0.97916666666667, 1.25, 0.16666666666667
65353, 0.97916666666667, 1.3, 0.16666666666667
65354, 0.97916666666667, 0.2, 0.20833333333333
65355, 0.97916666666667, 0.25, 0.20833333333333
65356, 0.97916666666667, 0.3, 0.20833333333333
65357, 0.97916666666667, 0.35, 0.20833333333333
65358, 0.97916666666667, 0.4, 0.20833333333333
65359, 0.97916666666667, 0.45, 0.20833333333333
65360, 0.97916666666667, 0.5, 0.20833333333333
65361, 0.97916666666667, 0.55, 0.20833333333333
65362, 0.97916666666667, 0.6, 0.20833333333333
65363, 0.97916666666667, 0.65, 0.20833333333333
65364, 0.97916666666667, 0.7, 0.20833333333333
65365, 0.97916666666667, 0.75, 0.20833333333333
65366, 0.97916666666667, 0.8, 0.20833333333333
65367, 0.97916666666667, 0.85, 0.20833333333333
65368, 0.97916666666667, 0.9, 0.20833333333333
65369, 0.97916666666667, 0.95, 0.20833333333333
65370, 0.97916666666667, 1, 0.20833333333333
65371, 0.97916666666667, 1.05, 0.20833333333333
65372, 0.97916666666667, 1.1, 0.20833333333333
65373, 0.97916666666667, 1.15, 0.20833333333333
65374, 0.97916666666667, 1.2, 0.20833333333333
65375, 0.97916666666667, 1.25, 0.20833333333333
65376, 0.97916666666667, 1.3, 0.20833333333333
65377, 0.97916666666667, 0.2, 0.25
65378, 0.97916666666667, 0.25, 0.25
65379, 0.97916666666667, 0.3, 0.25
65380, 0.97916666666667, 0.35, 0.25
65381, 0.97916666666667, 0.4, 0.25
65382, 0.97916666666667, 0.45, 0.25
65383, 0.97916666666667, 0.5, 0.25
65384, 0.97916666666667, 0.55, 0.25
65385, 0.97916666666667, 0.6, 0.25
65386, 0.97916666666667, 0.65, 0.25
65387, 0.97916666666667, 0.7, 0.25
65388, 0.97916666666667, 0.75, 0.25
65389, 0.97916666666667, 0.8, 0.25
65390, 0.97916666666667, 0.85, 0.25
65391, 0.97916666666667, 0.9, 0.25
65392, 0.97916666666667, 0.95, 0.25
65393, 0.97916666666667, 1, 0.25
65394, 0.97916666666667, 1.05, 0.25
65395, 0.97916666666667, 1.1, 0.25
65396, 0.97916666666667, 1.15, 0.25
65397, 0.97916666666667, 1.2, 0.25
65398, 0.97916666666667, 1.25, 0.25
65399, 0.97916666666667, 1.3, 0.25
65400, 0.97916666666667, 0.2, 0.29166666666667
65401, 0.97916666666667, 0.25, 0.29166666666667
65402, 0.97916666666667, 0.3, 0.29166666666667
65403, 0.97916666666667, 0.35, 0.29166666666667
65404, 0.97916666666667, 0.4, 0.29166666666667
65405, 0.97916666666667, 0.45, 0.29166666666667
65406, 0.97916666666667, 0.5, 0.29166666666667
65407, 0.97916666666667, 0.55, 0.29166666666667
65408, 0.97916666666667, 0.6, 0.29166666666667
65409, 0.97916666666667, 0.65, 0.29166666666667
65410, 0.97916666666667, 0.7, 0.29166666666667
65411, 0.97916666666667, 0.75, 0.29166666666667
65412, 0.97916666666667, 0.8, 0.29166666666667
65413, 0.97916666666667, 0.85, 0.29166666666667
65414, 0.97916666666667, 0.9, 0.29166666666667
65415, 0.97916666666667, 0.95, 0.29166666666667
65416, 0.97916666666667, 1, 0.29166666666667
65417, 0.97916666666667, 1.05, 0.29166666666667
65418, 0.97916666666667, 1.1, 0.29166666666667
65419, 0.97916666666667, 1.15, 0.29166666666667
65420, 0.97916666666667, 1.2, 0.29166666666667
65421, 0.97916666666667, 1.25, 0.29166666666667
65422, 0.97916666666667, 1.3, 0.29166666666667
65423, 0.97916666666667, 0.2, 0.33333333333333
65424, 0.97916666666667, 0.25, 0.33333333333333
65425, 0.97916666666667, 0.3, 0.33333333333333
65426, 0.97916666666667, 0.35, 0.33333333333333
65427, 0.97916666666667, 0.4, 0.33333333333333
65428, 0.97916666666667, 0.45, 0.33333333333333
65429, 0.97916666666667, 0.5, 0.33333333333333
65430, 0.97916666666667, 0.55, 0.33333333333333
65431, 0.97916666666667, 0.6, 0.33333333333333
65432, 0.97916666666667, 0.65, 0.33333333333333
65433, 0.97916666666667, 0.7, 0.33333333333333
65434, 0.97916666666667, 0.75, 0.33333333333333
65435, 0.97916666666667, 0.8, 0.33333333333333
65436, 0.97916666666667, 0.85, 0.33333333333333
65437, 0.97916666666667, 0.9, 0.33333333333333
65438, 0.97916666666667, 0.95, 0.33333333333333
65439, 0.97916666666667, 1, 0.33333333333333
65440, 0.97916666666667, 1.05, 0.33333333333333
65441, 0.97916666666667, 1.1, 0.33333333333333
65442, 0.97916666666667, 1.15, 0.33333333333333
65443, 0.97916666666667, 1.2, 0.33333333333333
65444, 0.97916666666667, 1.25, 0.33333333333333
65445, 0.97916666666667, 1.3, 0.33333333333333
65446, 0.97916666666667, 0.2, 0.375
65447, 0.97916666666667, 0.25, 0.375
65448, 0.97916666666667, 0.3, 0.375
65449, 0.97916666666667, 0.35, 0.375
65450, 0.97916666666667, 0.4, 0.375
65451, 0.97916666666667, 0.45, 0.375
65452, 0.97916666666667, 0.5, 0.375
65453, 0.97916666666667, 0.55, 0.375
65454, 0.97916666666667, 0.6, 0.375
65455, 0.97916666666667, 0.65, 0.375
65456, 0.97916666666667, 0.7, 0.375
65457, 0.97916666666667, 0.75, 0.375
65458, 0.97916666666667, 0.8, 0.375
65459, 0.97916666666667, 0.85, 0.375
65460, 0.97916666666667, 0.9, 0.375
65461, 0.97916666666667, 0.95, 0.375
65462, 0.97916666666667, 1, 0.375
65463, 0.97916666666667, 1.05, 0.375
65464, 0.97916666666667, 1.1, 0.375
65465, 0.97916666666667, 1.15, 0.375
65466, 0.97916666666667, 1.2, 0.375
65467, 0.97916666666667, 1.25, 0.375
65468, 0.97916666666667, 1.3, 0.375
65469, 0.97916666666667, 0.2, 0.41666666666667
65470, 0.97916666666667, 0.25, 0.41666666666667
65471, 0.97916666666667, 0.3, 0.41666666666667
65472, 0.97916666666667, 0.35, 0.41666666666667
65473, 0.97916666666667, 0.4, 0.41666666666667
65474, 0.97916666666667, 0.45, 0.41666666666667
65475, 0.97916666666667, 0.5, 0.41666666666667
65476, 0.97916666666667, 0.55, 0.41666666666667
65477, 0.97916666666667, 0.6, 0.41666666666667
65478, 0.97916666666667, 0.65, 0.41666666666667
65479, 0.97916666666667, 0.7, 0.41666666666667
65480, 0.97916666666667, 0.75, 0.41666666666667
65481, 0.97916666666667, 0.8, 0.41666666666667
65482, 0.97916666666667, 0.85, 0.41666666666667
65483, 0.97916666666667, 0.9, 0.41666666666667
65484, 0.97916666666667, 0.95, 0.41666666666667
65485, 0.97916666666667, 1, 0.41666666666667
65486, 0.97916666666667, 1.05, 0.41666666666667
65487, 0.97916666666667, 1.1, 0.41666666666667
65488, 0.97916666666667, 1.15, 0.41666666666667
65489, 0.97916666666667, 1.2, 0.41666666666667
65490, 0.97916666666667, 1.25, 0.41666666666667
65491, 0.97916666666667, 1.3, 0.41666666666667
65492, 0.97916666666667, 0.2, 0.45833333333333
65493, 0.97916666666667, 0.25, 0.45833333333333
65494, 0.97916666666667, 0.3, 0.45833333333333
65495, 0.97916666666667, 0.35, 0.45833333333333
65496, 0.97916666666667, 0.4, 0.45833333333333
65497, 0.97916666666667, 0.45, 0.45833333333333
65498, 0.97916666666667, 0.5, 0.45833333333333
65499, 0.97916666666667, 0.55, 0.45833333333333
65500, 0.97916666666667, 0.6, 0.45833333333333
65501, 0.97916666666667, 0.65, 0.45833333333333
65502, 0.97916666666667, 0.7, 0.45833333333333
65503, 0.97916666666667, 0.75, 0.45833333333333
65504, 0.97916666666667, 0.8, 0.45833333333333
65505, 0.97916666666667, 0.85, 0.45833333333333
65506, 0.97916666666667, 0.9, 0.45833333333333
65507, 0.97916666666667, 0.95, 0.45833333333333
65508, 0.97916666666667, 1, 0.45833333333333
65509, 0.97916666666667, 1.05, 0.45833333333333
65510, 0.97916666666667, 1.1, 0.45833333333333
65511, 0.97916666666667, 1.15, 0.45833333333333
65512, 0.97916666666667, 1.2, 0.45833333333333
65513, 0.97916666666667, 1.25, 0.45833333333333
65514, 0.97916666666667, 1.3, 0.45833333333333
65515, 0.041666666666667, 1.375, 0.041666666666667
65516, 0.041666666666667, 1.375, 0.083333333333333
65517, 0.041666666666667, 1.375, 0.125
65518, 0.041666666666667, 1.375, 0.16666666666667
65519, 0.041666666666667, 1.375, 0.20833333333333
65520, 0.041666666666667, 1.375, 0.25
65521, 0.041666666666667, 1.375, 0.29166666666667
65522, 0.041666666666667, 1.375, 0.33333333333333
65523, 0.041666666666667, 1.375, 0.375
65524, 0.041666666666667, 1.375, 0.41666666666667
65525, 0.041666666666667, 1.375, 0.45833333333333
65526, 0.083333333333333, 1.375, 0.041666666666667
65527, 0.083333333333333, 1.375, 0.083333333333333
65528, 0.083333333333333, 1.375, 0.125
65529, 0.083333333333333, 1.375, 0.16666666666667
65530, 0.083333333333333, 1.375, 0.20833333333333
65531, 0.083333333333333, 1.375, 0.25
65532, 0.083333333333333, 1.375, 0.29166666666667
65533, 0.083333333333333, 1.375, 0.33333333333333
65534, 0.083333333333333, 1.375, 0.375
65535, 0.083333333333333, 1.375, 0.41666666666667
65536, 0.083333333333333, 1.375, 0.45833333333333
65537, 0.125, 1.375, 0.041666666666667
65538, 0.125, 1.375, 0.083333333333333
65539, 0.125, 1.375, 0.125
65540, 0.125, 1.375, 0.16666666666667
65541, 0.125, 1.375, 0.20833333333333
65542, 0.125, 1.375, 0.25
65543, 0.125, 1.375, 0.29166666666667
65544, 0.125, 1.375, 0.33333333333333
65545, 0.125, 1.375, 0.375
65546, 0.125, 1.375, 0.41666666666667
65547, 0.125, 1.375, 0.45833333333333
65548, 0.16666666666667, 1.375, 0.041666666666667
65549, 0.16666666666667, 1.375, 0.083333333333333
65550, 0.16666666666667, 1.375, 0.125
65551, 0.16666666666667, 1.375, 0.16666666666667
65552, 0.16666666666667, 1.375, 0.20833333333333
65553, 0.16666666666667, 1.375, 0.25
65554, 0.16666666666667, 1.375, 0.29166666666667
65555, 0.16666666666667, 1.375, 0.33333333333333
65556, 0.16666666666667, 1.375, 0.375
65557, 0.16666666666667, 1.375, 0.41666666666667
65558, 0.16666666666667, 1.375, 0.45833333333333
65559, 0.20833333333333, 1.375, 0.041666666666667
65560, 0.20833333333333, 1.375, 0.083333333333333
65561, 0.20833333333333, 1.375, 0.125
65562, 0.20833333333333, 1.375, 0.16666666666667
65563, 0.20833333333333, 1.375, 0.20833333333333
65564, 0.20833333333333, 1.375, 0.25
65565, 0.20833333333333, 1.375, 0.29166666666667
65566, 0.20833333333333, 1.375, 0.33333333333333
65567, 0.20833333333333, 1.375, 0.375
65568, 0.20833333333333, 1.375, 0.41666666666667
65569, 0.20833333333333, 1.375, 0.45833333333333
65570, 0.25, 1.375, 0.041666666666667
65571, 0.25, 1.375, 0.083333333333333
65572, 0.25, 1.375, 0.125
65573, 0.25, 1.375, 0.16666666666667
65574, 0.25, 1.375, 0.20833333333333
65575, 0.25, 1.375, 0.25
65576, 0.25, 1.375, 0.29166666666667
65577, 0.25, 1.375, 0.33333333333333
65578, 0.25, 1.375, 0.375
65579, 0.25, 1.375, 0.41666666666667
65580, 0.25, 1.375, 0.45833333333333
65581, 0.29166666666667, 1.375, 0.041666666666667
65582, 0.29166666666667, 1.375, 0.083333333333333
65583, 0.29166666666667, 1.375, 0.125
65584, 0.29166666666667, 1.375, 0.16666666666667
65585, 0.29166666666667, 1.375, 0.20833333333333
65586, 0.29166666666667, 1.375, 0.25
65587, 0.29166666666667, 1.375, 0.29166666666667
65588, 0.29166666666667, 1.375, 0.33333333333333
65589, 0.29166666666667, 1.375, 0.375
65590, 0.29166666666667, 1.375, 0.41666666666667
65591, 0.29166666666667, 1.375, 0.45833333333333
65592, 0.33333333333333, 1.375, 0.041666666666667
65593, 0.33333333333333, 1.375, 0.083333333333333
65594, 0.33333333333333, 1.375, 0.125
65595, 0.33333333333333, 1.375, 0.16666666666667
65596, 0.33333333333333, 1.375, 0.20833333333333
65597, 0.33333333333333, 1.375, 0.25
65598, 0.33333333333333, 1.375, 0.29166666666667
65599, 0.33333333333333, 1.375, 0.33333333333333
65600, 0.33333333333333, 1.375, 0.375
65601, 0.33333333333333, 1.375, 0.41666666666667
65602, 0.33333333333333, 1.375, 0.45833333333333
65603, 0.375, 1.375, 0.041666666666667
65604, 0.375, 1.375, 0.083333333333333
65605, 0.375, 1.375, 0.125
65606, 0.375, 1.375, 0.16666666666667
65607, 0.375, 1.375, 0.20833333333333
65608, 0.375, 1.375, 0.25
65609, 0.375, 1.375, 0.29166666666667
65610, 0.375, 1.375, 0.33333333333333
65611, 0.375, 1.375, 0.375
65612, 0.375, 1.375, 0.41666666666667
65613, 0.375, 1.375, 0.45833333333333
65614, 0.41666666666667, 1.375, 0.041666666666667
65615, 0.41666666666667, 1.375, 0.083333333333333
65616, 0.41666666666667, 1.375, 0.125
65617, 0.41666666666667, 1.375, 0.16666666666667
65618, 0.41666666666667, 1.375, 0.20833333333333
65619, 0.41666666666667, 1.375, 0.25
65620, 0.41666666666667, 1.375, 0.29166666666667
65621, 0.41666666666667, 1.375, 0.33333333333333
65622, 0.41666666666667, 1.375, 0.375
65623, 0.41666666666667, 1.375, 0.41666666666667
65624, 0.41666666666667, 1.375, 0.45833333333333
65625, 0.45833333333333, 1.375, 0.041666666666667
65626, 0.45833333333333, 1.375, 0.083333333333333
65627, 0.45833333333333, 1.375, 0.125
65628, 0.45833333333333, 1.375, 0.16666666666667
65629, 0.45833333333333, 1.375, 0.20833333333333
65630, 0.45833333333333, 1.375, 0.25
65631, 0.45833333333333, 1.375, 0.29166666666667
65632, 0.45833333333333, 1.375, 0.33333333333333
65633, 0.45833333333333, 1.375, 0.375
65634, 0.45833333333333, 1.375, 0.41666666666667
65635, 0.45833333333333, 1.375, 0.45833333333333
65636, 0.5, 1.375, 0.041666666666667
65637, 0.5, 1.375, 0.083333333333333
65638, 0.5, 1.375, 0.125
65639, 0.5, 1.375, 0.16666666666667
65640, 0.5, 1.375, 0.20833333333333
65641, 0.5, 1.375, 0.25
65642, 0.5, 1.375, 0.29166666666667
65643, 0.5, 1.375, 0.33333333333333
65644, 0.5, 1.375, 0.375
65645, 0.5, 1.375, 0.41666666666667
65646, 0.5, 1.375, 0.45833333333333
65647, 0.54166666666667, 1.375, 0.041666666666667
65648, 0.54166666666667, 1.375, 0.083333333333333
65649, 0.54166666666667, 1.375, 0.125
65650, 0.54166666666667, 1.375, 0.16666666666667
65651, 0.54166666666667, 1.375, 0.20833333333333
65652, 0.54166666666667, 1.375, 0.25
65653, 0.54166666666667, 1.375, 0.29166666666667
65654, 0.54166666666667, 1.375, 0.33333333333333
65655, 0.54166666666667, 1.375, 0.375
65656, 0.54166666666667, 1.375, 0.41666666666667
65657, 0.54166666666667, 1.375, 0.45833333333333
65658, 0.58333333333333, 1.375, 0.041666666666667
65659, 0.58333333333333, 1.375, 0.083333333333333
65660, 0.58333333333333, 1.375, 0.125
65661, 0.58333333333333, 1.375, 0.16666666666667
65662, 0.58333333333333, 1.375, 0.20833333333333
65663, 0.58333333333333, 1.375, 0.25
65664, 0.58333333333333, 1.375, 0.29166666666667
65665, 0.58333333333333, 1.375, 0.33333333333333
65666, 0.58333333333333, 1.375, 0.375
65667, 0.58333333333333, 1.375, 0.41666666666667
65668, 0.58333333333333, 1.375, 0.45833333333333
65669, 0.625, 1.375, 0.041666666666667
65670, 0.625, 1.375, 0.083333333333333
65671, 0.625, 1.375, 0.125
65672, 0.625, 1.375, 0.16666666666667
65673, 0.625, 1.375, 0.20833333333333
65674, 0.625, 1.375, 0.25
65675, 0.625, 1.375, 0.29166666666667
65676, 0.625, 1.375, 0.33333333333333
65677, 0.625, 1.375, 0.375
65678, 0.625, 1.375, 0.41666666666667
65679, 0.625, 1.375, 0.45833333333333
65680, 0.66666666666667, 1.375, 0.041666666666667
65681, 0.66666666666667, 1.375, 0.083333333333333
65682, 0.66666666666667, 1.375, 0.125
65683, 0.66666666666667, 1.375, 0.16666666666667
65684, 0.66666666666667, 1.375, 0.20833333333333
65685, 0.66666666666667, 1.375, 0.25
65686, 0.66666666666667, 1.375, 0.29166666666667
65687, 0.66666666666667, 1.375, 0.33333333333333
65688, 0.66666666666667, 1.375, 0.375
65689, 0.66666666666667, 1.375, 0.41666666666667
65690, 0.66666666666667, 1.375, 0.45833333333333
65691, 0.70833333333333, 1.375, 0.041666666666667
65692, 0.70833333333333, 1.375, 0.083333333333333
65693, 0.70833333333333, 1.375, 0.125
65694, 0.70833333333333, 1.375, 0.16666666666667
65695, 0.70833333333333, 1.375, 0.20833333333333
65696, 0.70833333333333, 1.375, 0.25
65697, 0.70833333333333, 1.375, 0.29166666666667
65698, 0.70833333333333, 1.375, 0.33333333333333
65699, 0.70833333333333, 1.375, 0.375
65700, 0.70833333333333, 1.375, 0.41666666666667
65701, 0.70833333333333, 1.375, 0.45833333333333
65702, 0.75, 1.375, 0.041666666666667
65703, 0.75, 1.375, 0.083333333333333
65704, 0.75, 1.375, 0.125
65705, 0.75, 1.375, 0.16666666666667
65706, 0.75, 1.375, 0.20833333333333
65707, 0.75, 1.375, 0.25
65708, 0.75, 1.375, 0.29166666666667
65709, 0.75, 1.375, 0.33333333333333
65710, 0.75, 1.375, 0.375
65711, 0.75, 1.375, 0.41666666666667
65712, 0.75, 1.375, 0.45833333333333
65713, 0.79166666666667, 1.375, 0.041666666666667
65714, 0.79166666666667, 1.375, 0.083333333333333
65715, 0.79166666666667, 1.375, 0.125
65716, 0.79166666666667, 1.375, 0.16666666666667
65717, 0.79166666666667, 1.375, 0.20833333333333
65718, 0.79166666666667, 1.375, 0.25
65719, 0.79166666666667, 1.375, 0.29166666666667
65720, 0.79166666666667, 1.375, 0.33333333333333
65721, 0.79166666666667, 1.375, 0.375
65722, 0.79166666666667, 1.375, 0.41666666666667
65723, 0.79166666666667, 1.375, 0.45833333333333
65724, 0.83333333333333, 1.375, 0.041666666666667
65725, 0.83333333333333, 1.375, 0.083333333333333
65726, 0.83333333333333, 1.375, 0.125
65727, 0.83333333333333, 1.375, 0.16666666666667
65728, 0.83333333333333, 1.375, 0.20833333333333
65729, 0.83333333333333, 1.375, 0.25
65730, 0.83333333333333, 1.375, 0.29166666666667
65731, 0.83333333333333, 1.375, 0.33333333333333
65732, 0.83333333333333, 1.375, 0.375
65733, 0.83333333333333, 1.375, 0.41666666666667
65734, 0.83333333333333, 1.375, 0.45833333333333
65735, 0.875, 1.375, 0.041666666666667
65736, 0.875, 1.375, 0.083333333333333
65737, 0.875, 1.375, 0.125
65738, 0.875, 1.375, 0.16666666666667
65739, 0.875, 1.375, 0.20833333333333
65740, 0.875, 1.375, 0.25
65741, 0.875, 1.375, 0.29166666666667
65742, 0.875, 1.375, 0.33333333333333
65743, 0.875, 1.375, 0.375
65744, 0.875, 1.375, 0.41666666666667
65745, 0.875, 1.375, 0.45833333333333
65746, 0.91666666666667, 1.375, 0.041666666666667
65747, 0.91666666666667, 1.375, 0.083333333333333
65748, 0.91666666666667, 1.375, 0.125
65749, 0.91666666666667, 1.375, 0.16666666666667
65750, 0.91666666666667, 1.375, 0.20833333333333
65751, 0.91666666666667, 1.375, 0.25
65752, 0.91666666666667, 1.375, 0.29166666666667
65753, 0.91666666666667, 1.375, 0.33333333333333
65754, 0.91666666666667, 1.375, 0.375
65755, 0.91666666666667, 1.375, 0.41666666666667
65756, 0.91666666666667, 1.375, 0.45833333333333
65757, 0.95833333333333, 1.375, 0.041666666666667
65758, 0.95833333333333, 1.375, 0.083333333333333
65759, 0.95833333333333, 1.375, 0.125
65760, 0.95833333333333, 1.375, 0.16666666666667
65761, 0.95833333333333, 1.375, 0.20833333333333
65762, 0.95833333333333, 1.375, 0.25
65763, 0.95833333333333, 1.375, 0.29166666666667
65764, 0.95833333333333, 1.375, 0.33333333333333
65765, 0.95833333333333, 1.375, 0.375
65766, 0.95833333333333, 1.375, 0.41666666666667
65767, 0.95833333333333, 1.375, 0.45833333333333
65768, 0.041666666666667, 1.4333333333333, 0.041666666666667
65769, 0.041666666666667, 1.4666666666667, 0.041666666666667
65770, 0.041666666666667, 1.4333333333333, 0.083333333333333
65771, 0.041666666666667, 1.4666666666667, 0.083333333333333
65772, 0.041666666666667, 1.4333333333333, 0.125
65773, 0.041666666666667, 1.4666666666667, 0.125
65774, 0.041666666666667, 1.4333333333333, 0.16666666666667
65775, 0.041666666666667, 1.4666666666667, 0.16666666666667
65776, 0.041666666666667, 1.4333333333333, 0.20833333333333
65777, 0.041666666666667, 1.4666666666667, 0.20833333333333
65778, 0.041666666666667, 1.4333333333333, 0.25
65779, 0.041666666666667, 1.4666666666667, 0.25
65780, 0.041666666666667, 1.4333333333333, 0.29166666666667
65781, 0.041666666666667, 1.4666666666667, 0.29166666666667
65782, 0.041666666666667, 1.4333333333333, 0.33333333333333
65783, 0.041666666666667, 1.4666666666667, 0.33333333333333
65784, 0.041666666666667, 1.4333333333333, 0.375
65785, 0.041666666666667, 1.4666666666667, 0.375
65786, 0.041666666666667, 1.4333333333333, 0.41666666666667
65787, 0.041666666666667, 1.4666666666667, 0.41666666666667
65788, 0.041666666666667, 1.4333333333333, 0.45833333333333
65789, 0.041666666666667, 1.4666666666667, 0.45833333333333
65790, 0.083333333333333, 1.4333333333333, 0.041666666666667
65791, 0.083333333333333, 1.4666666666667, 0.041666666666667
65792, 0.083333333333333, 1.4333333333333, 0.083333333333333
65793, 0.083333333333333, 1.4666666666667, 0.083333333333333
65794, 0.083333333333333, 1.4333333333333, 0.125
65795, 0.083333333333333, 1.4666666666667, 0.125
65796, 0.083333333333333, 1.4333333333333, 0.16666666666667
65797, 0.083333333333333, 1.4666666666667, 0.16666666666667
65798, 0.083333333333333, 1.4333333333333, 0.20833333333333
65799, 0.083333333333333, 1.4666666666667, 0.20833333333333
65800, 0.083333333333333, 1.4333333333333, 0.25
65801, 0.083333333333333, 1.4666666666667, 0.25
65802, 0.083333333333333, 1.4333333333333, 0.29166666666667
65803, 0.083333333333333, 1.4666666666667, 0.29166666666667
65804, 0.083333333333333, 1.4333333333333, 0.33333333333333
65805, 0.083333333333333, 1.4666666666667, 0.33333333333333
65806, 0.083333333333333, 1.4333333333333, 0.375
65807, 0.083333333333333, 1.4666666666667, 0.375
65808, 0.083333333333333, 1.4333333333333, 0.41666666666667
65809, 0.083333333333333, 1.4666666666667, 0.41666666666667
65810, 0.083333333333333, 1.4333333333333, 0.45833333333333
65811, 0.083333333333333, 1.4666666666667, 0.45833333333333
65812, 0.125, 1.4333333333333, 0.041666666666667
65813, 0.125, 1.4666666666667, 0.041666666666667
65814, 0.125, 1.4333333333333, 0.083333333333333
65815, 0.125, 1.4666666666667, 0.083333333333333
65816, 0.125, 1.4333333333333, 0.125
65817, 0.125, 1.4666666666667, 0.125
65818, 0.125, 1.4333333333333, 0.16666666666667
65819, 0.125, 1.4666666666667, 0.16666666666667
65820, 0.125, 1.4333333333333, 0.20833333333333
65821, 0.125, 1.4666666666667, 0.20833333333333
65822, 0.125, 1.4333333333333, 0.25
65823, 0.125, 1.4666666666667, 0.25
65824, 0.125, 1.4333333333333, 0.29166666666667
65825, 0.125, 1.4666666666667, 0.29166666666667
65826, 0.125, 1.4333333333333, 0.33333333333333
65827, 0.125, 1.4666666666667, 0.33333333333333
65828, 0.125, 1.4333333333333, 0.375
65829, 0.125, 1.4666666666667, 0.375
65830, 0.125, 1.4333333333333, 0.41666666666667
65831, 0.125, 1.4666666666667, 0.41666666666667
65832, 0.125, 1.4333333333333, 0.45833333333333
65833, 0.125, 1.4666666666667, 0.45833333333333
65834, 0.16666666666667, 1.4333333333333, 0.041666666666667
65835, 0.16666666666667, 1.4666666666667, 0.041666666666667
65836, 0.16666666666667, 1.4333333333333, 0.083333333333333
65837, 0.16666666666667, 1.4666666666667, 0.083333333333333
65838, 0.16666666666667, 1.4333333333333, 0.125
65839, 0.16666666666667, 1.4666666666667, 0.125
65840, 0.16666666666667, 1.4333333333333, 0.16666666666667
65841, 0.16666666666667, 1.4666666666667, 0.16666666666667
65842, 0.16666666666667, 1.4333333333333, 0.20833333333333
65843, 0.16666666666667, 1.4666666666667, 0.20833333333333
65844, 0.16666666666667, 1.4333333333333, 0.25
65845, 0.16666666666667, 1.4666666666667, 0.25
65846, 0.16666666666667, 1.4333333333333, 0.29166666666667
65847, 0.16666666666667, 1.4666666666667, 0.29166666666667
65848, 0.16666666666667, 1.4333333333333, 0.33333333333333
65849, 0.16666666666667, 1.4666666666667, 0.33333333333333
65850, 0.16666666666667, 1.4333333333333, 0.375
65851, 0.16666666666667, 1.4666666666667, 0.375
65852, 0.16666666666667, 1.4333333333333, 0.41666666666667
65853, 0.16666666666667, 1.4666666666667, 0.41666666666667
65854, 0.16666666666667, 1.4333333333333, 0.45833333333333
65855, 0.16666666666667, 1.4666666666667, 0.45833333333333
65856, 0.20833333333333, 1.4333333333333, 0.041666666666667
65857, 0.20833333333333, 1.4666666666667, 0.041666666666667
65858, 0.20833333333333, 1.4333333333333, 0.083333333333333
65859, 0.20833333333333, 1.4666666666667, 0.083333333333333
65860, 0.20833333333333, 1.4333333333333, 0.125
65861, 0.20833333333333, 1.4666666666667, 0.125
65862, 0.20833333333333, 1.4333333333333, 0.16666666666667
65863, 0.20833333333333, 1.4666666666667, 0.16666666666667
65864, 0.20833333333333, 1.4333333333333, 0.20833333333333
65865, 0.20833333333333, 1.4666666666667, 0.20833333333333
65866, 0.20833333333333, 1.4333333333333, 0.25
65867, 0.20833333333333, 1.4666666666667, 0.25
65868, 0.20833333333333, 1.4333333333333, 0.29166666666667
65869, 0.20833333333333, 1.4666666666667, 0.29166666666667
65870, 0.20833333333333, 1.4333333333333, 0.33333333333333
65871, 0.20833333333333, 1.4666666666667, 0.33333333333333
65872, 0.20833333333333, 1.4333333333333, 0.375
65873, 0.20833333333333, 1.4666666666667, 0.375
65874, 0.20833333333333, 1.4333333333333, 0.41666666666667
65875, 0.20833333333333, 1.4666666666667, 0.41666666666667
65876, 0.20833333333333, 1.4333333333333, 0.45833333333333
65877, 0.20833333333333, 1.4666666666667, 0.45833333333333
65878, 0.25, 1.4333333333333, 0.041666666666667
65879, 0.25, 1.4666666666667, 0.041666666666667
65880, 0.25, 1.4333333333333, 0.083333333333333
65881, 0.25, 1.4666666666667, 0.083333333333333
65882, 0.25, 1.4333333333333, 0.125
65883, 0.25, 1.4666666666667, 0.125
65884, 0.25, 1.4333333333333, 0.16666666666667
65885, 0.25, 1.4666666666667, 0.16666666666667
65886, 0.25, 1.4333333333333, 0.20833333333333
65887, 0.25, 1.4666666666667, 0.20833333333333
65888, 0.25, 1.4333333333333, 0.25
65889, 0.25, 1.4666666666667, 0.25
65890, 0.25, 1.4333333333333, 0.29166666666667
65891, 0.25, 1.4666666666667, 0.29166666666667
65892, 0.25, 1.4333333333333, 0.33333333333333
65893, 0.25, 1.4666666666667, 0.33333333333333
65894, 0.25, 1.4333333333333, 0.375
65895, 0.25, 1.4666666666667, 0.375
65896, 0.25, 1.4333333333333, 0.41666666666667
65897, 0.25, 1.4666666666667, 0.41666666666667
65898, 0.25, 1.4333333333333, 0.45833333333333
65899, 0.25, 1.4666666666667, 0.45833333333333
65900, 0.29166666666667, 1.4333333333333, 0.041666666666667
65901, 0.29166666666667, 1.4666666666667, 0.041666666666667
65902, 0.29166666666667, 1.4333333333333, 0.083333333333333
65903, 0.29166666666667, 1.4666666666667, 0.083333333333333
65904, 0.29166666666667, 1.4333333333333, 0.125
65905, 0.29166666666667, 1.4666666666667, 0.125
65906, 0.29166666666667, 1.4333333333333, 0.16666666666667
65907, 0.29166666666667, 1.4666666666667, 0.16666666666667
65908, 0.29166666666667, 1.4333333333333, 0.20833333333333
65909, 0.29166666666667, 1.4666666666667, 0.20833333333333
65910, 0.29166666666667, 1.4333333333333, 0.25
65911, 0.29166666666667, 1.4666666666667, 0.25
65912, 0.29166666666667, 1.4333333333333, 0.29166666666667
65913, 0.29166666666667, 1.4666666666667, 0.29166666666667
65914, 0.29166666666667, 1.4333333333333, 0.33333333333333
65915, 0.29166666666667, 1.4666666666667, 0.33333333333333
65916, 0.29166666666667, 1.4333333333333, 0.375
65917, 0.29166666666667, 1.4666666666667, 0.375
65918, 0.29166666666667, 1.4333333333333, 0.41666666666667
65919, 0.29166666666667, 1.4666666666667, 0.41666666666667
65920, 0.29166666666667, 1.4333333333333, 0.45833333333333
65921, 0.29166666666667, 1.4666666666667, 0.45833333333333
65922, 0.33333333333333, 1.4333333333333, 0.041666666666667
65923, 0.33333333333333, 1.4666666666667, 0.041666666666667
65924, 0.33333333333333, 1.4333333333333, 0.083333333333333
65925, 0.33333333333333, 1.4666666666667, 0.083333333333333
65926, 0.33333333333333, 1.4333333333333, 0.125
65927, 0.33333333333333, 1.4666666666667, 0.125
65928, 0.33333333333333, 1.4333333333333, 0.16666666666667
65929, 0.33333333333333, 1.4666666666667, 0.16666666666667
65930, 0.33333333333333, 1.4333333333333, 0.20833333333333
65931, 0.33333333333333, 1.4666666666667, 0.20833333333333
65932, 0.33333333333333, 1.4333333333333, 0.25
65933, 0.33333333333333, 1.4666666666667, 0.25
65934, 0.33333333333333, 1.4333333333333, 0.29166666666667
65935, 0.33333333333333, 1.4666666666667, 0.29166666666667
65936, 0.33333333333333, 1.4333333333333, 0.33333333333333
65937, 0.33333333333333, 1.4666666666667, 0.33333333333333
65938, 0.33333333333333, 1.4333333333333, 0.375
65939, 0.33333333333333, 1.4666666666667, 0.375
65940, 0.33333333333333, 1.4333333333333, 0.41666666666667
65941, 0.33333333333333, 1.4666666666667, 0.41666666666667
65942, 0.33333333333333, 1.4333333333333, 0.45833333333333
65943, 0.33333333333333, 1.4666666666667, 0.45833333333333
65944, 0.375, 1.4333333333333, 0.041666666666667
65945, 0.375, 1.4666666666667, 0.041666666666667
65946, 0.375, 1.4333333333333, 0.083333333333333
65947, 0.375, 1.4666666666667, 0.083333333333333
65948, 0.375, 1.4333333333333, 0.125
65949, 0.375, 1.4666666666667, 0.125
65950, 0.375, 1.4333333333333, 0.16666666666667
65951, 0.375, 1.4666666666667, 0.16666666666667
65952, 0.375, 1.4333333333333, 0.20833333333333
65953, 0.375, 1.4666666666667, 0.20833333333333
65954, 0.375, 1.4333333333333, 0.25
65955, 0.375, 1.4666666666667, 0.25
65956, 0.375, 1.4333333333333, 0.29166666666667
65957, 0.375, 1.4666666666667, 0.29166666666667
65958, 0.375, 1.4333333333333, 0.33333333333333
65959, 0.375, 1.4666666666667, 0.33333333333333
65960, 0.375, 1.4333333333333, 0.375
65961, 0.375, 1.4666666666667, 0.375
65962, 0.375, 1.4333333333333, 0.41666666666667
65963, 0.375, 1.4666666666667, 0.41666666666667
65964, 0.375, 1.4333333333333, 0.45833333333333
65965, 0.375, 1.4666666666667, 0.45833333333333
65966, 0.41666666666667, 1.4333333333333, 0.041666666666667
65967, 0.41666666666667, 1.4666666666667, 0.041666666666667
65968, 0.41666666666667, 1.4333333333333, 0.083333333333333
65969, 0.41666666666667, 1.4666666666667, 0.083333333333333
65970, 0.41666666666667, 1.4333333333333, 0.125
65971, 0.41666666666667, 1.4666666666667, 0.125
65972, 0.41666666666667, 1.4333333333333, 0.16666666666667
65973, 0.41666666666667, 1.4666666666667, 0.16666666666667
65974, 0.41666666666667, 1.4333333333333, 0.20833333333333
65975, 0.41666666666667, 1.4666666666667, 0.20833333333333
65976, 0.41666666666667, 1.4333333333333, 0.25
65977, 0.41666666666667, 1.4666666666667, 0.25
65978, 0.41666666666667, 1.4333333333333, 0.29166666666667
65979, 0.41666666666667, 1.4666666666667, 0.29166666666667
65980, 0.41666666666667, 1.4333333333333, 0.33333333333333
65981, 0.41666666666667, 1.4666666666667, 0.33333333333333
65982, 0.41666666666667, 1.4333333333333, 0.375
65983, 0.41666666666667, 1.4666666666667, 0.375
65984, 0.41666666666667, 1.4333333333333, 0.41666666666667
65985, 0.41666666666667, 1.4666666666667, 0.41666666666667
65986, 0.41666666666667, 1.4333333333333, 0.45833333333333
65987, 0.41666666666667, 1.4666666666667, 0.45833333333333
65988, 0.45833333333333, 1.4333333333333, 0.041666666666667
65989, 0.45833333333333, 1.4666666666667, 0.041666666666667
65990, 0.45833333333333, 1.4333333333333, 0.083333333333333
65991, 0.45833333333333, 1.4666666666667, 0.083333333333333
65992, 0.45833333333333, 1.4333333333333, 0.125
65993, 0.45833333333333, 1.4666666666667, 0.125
65994, 0.45833333333333, 1.4333333333333, 0.16666666666667
65995, 0.45833333333333, 1.4666666666667, 0.16666666666667
65996, 0.45833333333333, 1.4333333333333, 0.20833333333333
65997, 0.45833333333333, 1.4666666666667, 0.20833333333333
65998, 0.45833333333333, 1.4333333333333, 0.25
65999, 0.45833333333333, 1.4666666666667, 0.25
66000, 0.45833333333333, 1.4333333333333, 0.29166666666667
66001, 0.45833333333333, 1.4666666666667, 0.29166666666667
66002, 0.45833333333333, 1.4333333333333, 0.33333333333333
66003, 0.45833333333333, 1.4666666666667, 0.33333333333333
66004, 0.45833333333333, 1.4333333333333, 0.375
66005, 0.45833333333333, 1.4666666666667, 0.375
66006, 0.45833333333333, 1.4333333333333, 0.41666666666667
66007, 0.45833333333333, 1.4666666666667, 0.41666666666667
66008, 0.45833333333333, 1.4333333333333, 0.45833333333333
66009, 0.45833333333333, 1.4666666666667, 0.45833333333333
66010, 0.5, 1.4333333333333, 0.041666666666667
66011, 0.5, 1.4666666666667, 0.041666666666667
66012, 0.5, 1.4333333333333, 0.083333333333333
66013, 0.5, 1.4666666666667, 0.083333333333333
66014, 0.5, 1.4333333333333, 0.125
66015, 0.5, 1.4666666666667, 0.125
66016, 0.5, 1.4333333333333, 0.16666666666667
66017, 0.5, 1.4666666666667, 0.16666666666667
66018, 0.5, 1.4333333333333, 0.20833333333333
66019, 0.5, 1.4666666666667, 0.20833333333333
66020, 0.5, 1.4333333333333, 0.25
66021, 0.5, 1.4666666666667, 0.25
66022, 0.5, 1.4333333333333, 0.29166666666667
66023, 0.5, 1.4666666666667, 0.29166666666667
66024, 0.5, 1.4333333333333, 0.33333333333333
66025, 0.5, 1.4666666666667, 0.33333333333333
66026, 0.5, 1.4333333333333, 0.375
66027, 0.5, 1.4666666666667, 0.375
66028, 0.5, 1.4333333333333, 0.41666666666667
66029, 0.5, 1.4666666666667, 0.41666666666667
66030, 0.5, 1.4333333333333, 0.45833333333333
66031, 0.5, 1.4666666666667, 0.45833333333333
66032, 0.54166666666667, 1.4333333333333, 0.041666666666667
66033, 0.54166666666667, 1.4666666666667, 0.041666666666667
66034, 0.54166666666667, 1.4333333333333, 0.083333333333333
66035, 0.54166666666667, 1.4666666666667, 0.083333333333333
66036, 0.54166666666667, 1.4333333333333, 0.125
66037, 0.54166666666667, 1.4666666666667, 0.125
66038, 0.54166666666667, 1.4333333333333, 0.16666666666667
66039, 0.54166666666667, 1.4666666666667, 0.16666666666667
66040, 0.54166666666667, 1.4333333333333, 0.20833333333333
66041, 0.54166666666667, 1.4666666666667, 0.20833333333333
66042, 0.54166666666667, 1.4333333333333, 0.25
66043, 0.54166666666667, 1.4666666666667, 0.25
66044, 0.54166666666667, 1.4333333333333, 0.29166666666667
66045, 0.54166666666667, 1.4666666666667, 0.29166666666667
66046, 0.54166666666667, 1.4333333333333, 0.33333333333333
66047, 0.54166666666667, 1.4666666666667, 0.33333333333333
66048, 0.54166666666667, 1.4333333333333, 0.375
66049, 0.54166666666667, 1.4666666666667, 0.375
66050, 0.54166666666667, 1.4333333333333, 0.41666666666667
66051, 0.54166666666667, 1.4666666666667, 0.41666666666667
66052, 0.54166666666667, 1.4333333333333, 0.45833333333333
66053, 0.54166666666667, 1.4666666666667, 0.45833333333333
66054, 0.58333333333333, 1.4333333333333, 0.041666666666667
66055, 0.58333333333333, 1.4666666666667, 0.041666666666667
66056, 0.58333333333333, 1.4333333333333, 0.083333333333333
66057, 0.58333333333333, 1.4666666666667, 0.083333333333333
66058, 0.58333333333333, 1.4333333333333, 0.125
66059, 0.58333333333333, 1.4666666666667, 0.125
66060, 0.58333333333333, 1.4333333333333, 0.16666666666667
66061, 0.58333333333333, 1.4666666666667, 0.16666666666667
66062, 0.58333333333333, 1.4333333333333, 0.20833333333333
66063, 0.58333333333333, 1.4666666666667, 0.20833333333333
66064, 0.58333333333333, 1.4333333333333, 0.25
66065, 0.58333333333333, 1.4666666666667, 0.25
66066, 0.58333333333333, 1.4333333333333, 0.29166666666667
66067, 0.58333333333333, 1.4666666666667, 0.29166666666667
66068, 0.58333333333333, 1.4333333333333, 0.33333333333333
66069, 0.58333333333333, 1.4666666666667, 0.33333333333333
66070, 0.58333333333333, 1.4333333333333, 0.375
66071, 0.58333333333333, 1.4666666666667, 0.375
66072, 0.58333333333333, 1.4333333333333, 0.41666666666667
66073, 0.58333333333333, 1.4666666666667, 0.41666666666667
66074, 0.58333333333333, 1.4333333333333, 0.45833333333333
66075, 0.58333333333333, 1.4666666666667, 0.45833333333333
66076, 0.625, 1.4333333333333, 0.041666666666667
66077, 0.625, 1.4666666666667, 0.041666666666667
66078, 0.625, 1.4333333333333, 0.083333333333333
66079, 0.625, 1.4666666666667, 0.083333333333333
66080, 0.625, 1.4333333333333, 0.125
66081, 0.625, 1.4666666666667, 0.125
66082, 0.625, 1.4333333333333, 0.16666666666667
66083, 0.625, 1.4666666666667, 0.16666666666667
66084, 0.625, 1.4333333333333, 0.20833333333333
66085, 0.625, 1.4666666666667, 0.20833333333333
66086, 0.625, 1.4333333333333, 0.25
66087, 0.625, 1.4666666666667, 0.25
66088, 0.625, 1.4333333333333, 0.29166666666667
66089, 0.625, 1.4666666666667, 0.29166666666667
66090, 0.625, 1.4333333333333, 0.33333333333333
66091, 0.625, 1.4666666666667, 0.33333333333333
66092, 0.625, 1.4333333333333, 0.375
66093, 0.625, 1.4666666666667, 0.375
66094, 0.625, 1.4333333333333, 0.41666666666667
66095, 0.625, 1.4666666666667, 0.41666666666667
66096, 0.625, 1.4333333333333, 0.45833333333333
66097, 0.625, 1.4666666666667, 0.45833333333333
66098, 0.66666666666667, 1.4333333333333, 0.041666666666667
66099, 0.66666666666667, 1.4666666666667, 0.041666666666667
66100, 0.66666666666667, 1.4333333333333, 0.083333333333333
66101, 0.66666666666667, 1.4666666666667, 0.083333333333333
66102, 0.66666666666667, 1.4333333333333, 0.125
66103, 0.66666666666667, 1.4666666666667, 0.125
66104, 0.66666666666667, 1.4333333333333, 0.16666666666667
66105, 0.66666666666667, 1.4666666666667, 0.16666666666667
66106, 0.66666666666667, 1.4333333333333, 0.20833333333333
66107, 0.66666666666667, 1.4666666666667, 0.20833333333333
66108, 0.66666666666667, 1.4333333333333, 0.25
66109, 0.66666666666667, 1.4666666666667, 0.25
66110, 0.66666666666667, 1.4333333333333, 0.29166666666667
66111, 0.66666666666667, 1.4666666666667, 0.29166666666667
66112, 0.66666666666667, 1.4333333333333, 0.33333333333333
66113, 0.66666666666667, 1.4666666666667, 0.33333333333333
66114, 0.66666666666667, 1.4333333333333, 0.375
66115, 0.66666666666667, 1.4666666666667, 0.375
66116, 0.66666666666667, 1.4333333333333, 0.41666666666667
66117, 0.66666666666667, 1.4666666666667, 0.41666666666667
66118, 0.66666666666667, 1.4333333333333, 0.45833333333333
66119, 0.66666666666667, 1.4666666666667, 0.45833333333333
66120, 0.70833333333333, 1.4333333333333, 0.041666666666667
66121, 0.70833333333333, 1.4666666666667, 0.041666666666667
66122, 0.70833333333333, 1.4333333333333, 0.083333333333333
66123, 0.70833333333333, 1.4666666666667, 0.083333333333333
66124, 0.70833333333333, 1.4333333333333, 0.125
66125, 0.70833333333333, 1.4666666666667, 0.125
66126, 0.70833333333333, 1.4333333333333, 0.16666666666667
66127, 0.70833333333333, 1.4666666666667, 0.16666666666667
66128, 0.70833333333333, 1.4333333333333, 0.20833333333333
66129, 0.70833333333333, 1.4666666666667, 0.20833333333333
66130, 0.70833333333333, 1.4333333333333, 0.25
66131, 0.70833333333333, 1.4666666666667, 0.25
66132, 0.70833333333333, 1.4333333333333, 0.29166666666667
66133, 0.70833333333333, 1.4666666666667, 0.29166666666667
66134, 0.70833333333333, 1.4333333333333, 0.33333333333333
66135, 0.70833333333333, 1.4666666666667, 0.33333333333333
66136, 0.70833333333333, 1.4333333333333, 0.375
66137, 0.70833333333333, 1.4666666666667, 0.375
66138, 0.70833333333333, 1.4333333333333, 0.41666666666667
66139, 0.70833333333333, 1.4666666666667, 0.41666666666667
66140, 0.70833333333333, 1.4333333333333, 0.45833333333333
66141, 0.70833333333333, 1.4666666666667, 0.45833333333333
66142, 0.75, 1.4333333333333, 0.041666666666667
66143, 0.75, 1.4666666666667, 0.041666666666667
66144, 0.75, 1.4333333333333, 0.083333333333333
66145, 0.75, 1.4666666666667, 0.083333333333333
66146, 0.75, 1.4333333333333, 0.125
66147, 0.75, 1.4666666666667, 0.125
66148, 0.75, 1.4333333333333, 0.16666666666667
66149, 0.75, 1.4666666666667, 0.16666666666667
66150, 0.75, 1.4333333333333, 0.20833333333333
66151, 0.75, 1.4666666666667, 0.20833333333333
66152, 0.75, 1.4333333333333, 0.25
66153, 0.75, 1.4666666666667, 0.25
66154, 0.75, 1.4333333333333, 0.29166666666667
66155, 0.75, 1.4666666666667, 0.29166666666667
66156, 0.75, 1.4333333333333, 0.33333333333333
66157, 0.75, 1.4666666666667, 0.33333333333333
66158, 0.75, 1.4333333333333, 0.375
66159, 0.75, 1.4666666666667, 0.375
66160, 0.75, 1.4333333333333, 0.41666666666667
66161, 0.75, 1.4666666666667, 0.41666666666667
66162, 0.75, 1.4333333333333, 0.45833333333333
66163, 0.75, 1.4666666666667, 0.45833333333333
66164, 0.79166666666667, 1.4333333333333, 0.041666666666667
66165, 0.79166666666667, 1.4666666666667, 0.041666666666667
66166, 0.79166666666667, 1.4333333333333, 0.083333333333333
66167, 0.79166666666667, 1.4666666666667, 0.083333333333333
66168, 0.79166666666667, 1.4333333333333, 0.125
66169, 0.79166666666667, 1.4666666666667, 0.125
66170, 0.79166666666667, 1.4333333333333, 0.16666666666667
66171, 0.79166666666667, 1.4666666666667, 0.16666666666667
66172, 0.79166666666667, 1.4333333333333, 0.20833333333333
66173, 0.79166666666667, 1.4666666666667, 0.20833333333333
66174, 0.79166666666667, 1.4333333333333, 0.25
66175, 0.79166666666667, 1.4666666666667, 0.25
66176, 0.79166666666667, 1.4333333333333, 0.29166666666667
66177, 0.79166666666667, 1.4666666666667, 0.29166666666667
66178, 0.79166666666667, 1.4333333333333, 0.33333333333333
66179, 0.79166666666667, 1.4666666666667, 0.33333333333333
66180, 0.79166666666667, 1.4333333333333, 0.375
66181, 0.79166666666667, 1.4666666666667, 0.375
66182, 0.79166666666667, 1.4333333333333, 0.41666666666667
66183, 0.79166666666667, 1.4666666666667, 0.41666666666667
66184, 0.79166666666667, 1.4333333333333, 0.45833333333333
66185, 0.79166666666667, 1.4666666666667, 0.45833333333333
66186, 0.83333333333333, 1.4333333333333, 0.041666666666667
66187, 0.83333333333333, 1.4666666666667, 0.041666666666667
66188, 0.83333333333333, 1.4333333333333, 0.083333333333333
66189, 0.83333333333333, 1.4666666666667, 0.083333333333333
66190, 0.83333333333333, 1.4333333333333, 0.125
66191, 0.83333333333333, 1.4666666666667, 0.125
66192, 0.83333333333333, 1.4333333333333, 0.16666666666667
66193, 0.83333333333333, 1.4666666666667, 0.16666666666667
66194, 0.83333333333333, 1.4333333333333, 0.20833333333333
66195, 0.83333333333333, 1.4666666666667, 0.20833333333333
66196, 0.83333333333333, 1.4333333333333, 0.25
66197, 0.83333333333333, 1.4666666666667, 0.25
66198, 0.83333333333333, 1.4333333333333, 0.29166666666667
66199, 0.83333333333333, 1.4666666666667, 0.29166666666667
66200, 0.83333333333333, 1.4333333333333, 0.33333333333333
66201, 0.83333333333333, 1.4666666666667, 0.33333333333333
66202, 0.83333333333333, 1.4333333333333, 0.375
66203, 0.83333333333333, 1.4666666666667, 0.375
66204, 0.83333333333333, 1.4333333333333, 0.41666666666667
66205, 0.83333333333333, 1.4666666666667, 0.41666666666667
66206, 0.83333333333333, 1.4333333333333, 0.45833333333333
66207, 0.83333333333333, 1.4666666666667, 0.45833333333333
66208, 0.875, 1.4333333333333, 0.041666666666667
66209, 0.875, 1.4666666666667, 0.041666666666667
66210, 0.875, 1.4333333333333, 0.083333333333333
66211, 0.875, 1.4666666666667, 0.083333333333333
66212, 0.875, 1.4333333333333, 0.125
66213, 0.875, 1.4666666666667, 0.125
66214, 0.875, 1.4333333333333, 0.16666666666667
66215, 0.875, 1.4666666666667, 0.16666666666667
66216, 0.875, 1.4333333333333, 0.20833333333333
66217, 0.875, 1.4666666666667, 0.20833333333333
66218, 0.875, 1.4333333333333, 0.25
66219, 0.875, 1.4666666666667, 0.25
66220, 0.875, 1.4333333333333, 0.29166666666667
66221, 0.875, 1.4666666666667, 0.29166666666667
66222, 0.875, 1.4333333333333, 0.33333333333333
66223, 0.875, 1.4666666666667, 0.33333333333333
66224, 0.875, 1.4333333333333, 0.375
66225, 0.875, 1.4666666666667, 0.375
66226, 0.875, 1.4333333333333, 0.41666666666667
66227, 0.875, 1.4666666666667, 0.41666666666667
66228, 0.875, 1.4333333333333, 0.45833333333333
66229, 0.875, 1.4666666666667, 0.45833333333333
66230, 0.91666666666667, 1.4333333333333, 0.041666666666667
66231, 0.91666666666667, 1.4666666666667, 0.041666666666667
66232, 0.91666666666667, 1.4333333333333, 0.083333333333333
66233, 0.91666666666667, 1.4666666666667, 0.083333333333333
66234, 0.91666666666667, 1.4333333333333, 0.125
66235, 0.91666666666667, 1.4666666666667, 0.125
66236, 0.91666666666667, 1.4333333333333, 0.16666666666667
66237, 0.91666666666667, 1.4666666666667, 0.16666666666667
66238, 0.91666666666667, 1.4333333333333, 0.20833333333333
66239, 0.91666666666667, 1.4666666666667, 0.20833333333333
66240, 0.91666666666667, 1.4333333333333, 0.25
66241, 0.91666666666667, 1.4666666666667, 0.25
66242, 0.91666666666667, 1.4333333333333, 0.29166666666667
66243, 0.91666666666667, 1.4666666666667, 0.29166666666667
66244, 0.91666666666667, 1.4333333333333, 0.33333333333333
66245, 0.91666666666667, 1.4666666666667, 0.33333333333333
66246, 0.91666666666667, 1.4333333333333, 0.375
66247, 0.91666666666667, 1.4666666666667, 0.375
66248, 0.91666666666667, 1.4333333333333, 0.41666666666667
66249, 0.91666666666667, 1.4666666666667, 0.41666666666667
66250, 0.91666666666667, 1.4333333333333, 0.45833333333333
66251, 0.91666666666667, 1.4666666666667, 0.45833333333333
66252, 0.95833333333333, 1.4333333333333, 0.041666666666667
66253, 0.95833333333333, 1.4666666666667, 0.041666666666667
66254, 0.95833333333333, 1.4333333333333, 0.083333333333333
66255, 0.95833333333333, 1.4666666666667, 0.083333333333333
66256, 0.95833333333333, 1.4333333333333, 0.125
66257, 0.95833333333333, 1.4666666666667, 0.125
66258, 0.95833333333333, 1.4333333333333, 0.16666666666667
66259, 0.95833333333333, 1.4666666666667, 0.16666666666667
66260, 0.95833333333333, 1.4333333333333, 0.20833333333333
66261, 0.95833333333333, 1.4666666666667, 0.20833333333333
66262, 0.95833333333333, 1.4333333333333, 0.25
66263, 0.95833333333333, 1.4666666666667, 0.25
66264, 0.95833333333333, 1.4333333333333, 0.29166666666667
66265, 0.95833333333333, 1.4666666666667, 0.29166666666667
66266, 0.95833333333333, 1.4333333333333, 0.33333333333333
66267, 0.95833333333333, 1.4666666666667, 0.33333333333333
66268, 0.95833333333333, 1.4333333333333, 0.375
66269, 0.95833333333333, 1.4666666666667, 0.375
66270, 0.95833333333333, 1.4333333333333, 0.41666666666667
66271, 0.95833333333333, 1.4666666666667, 0.41666666666667
66272, 0.95833333333333, 1.4333333333333, 0.45833333333333
66273, 0.95833333333333, 1.4666666666667, 0.45833333333333
66274, 0.041666666666667, 1.4166666666667, 0.041666666666667
66275, 0.020833333333333, 1.4333333333333, 0.041666666666667
66276, 0.041666666666667, 1.4333333333333, 0.020833333333333
66277, 0.041666666666667, 1.45, 0.041666666666667
66278, 0.020833333333333, 1.4666666666667, 0.041666666666667
66279, 0.041666666666667, 1.4666666666667, 0.020833333333333
66280, 0.041666666666667, 1.4833333333333, 0.041666666666667
66281, 0.041666666666667, 1.4166666666667, 0.083333333333333
66282, 0.020833333333333, 1.4333333333333, 0.083333333333333
66283, 0.041666666666667, 1.4333333333333, 0.0625
66284, 0.041666666666667, 1.45, 0.083333333333333
66285, 0.020833333333333, 1.4666666666667, 0.083333333333333
66286, 0.041666666666667, 1.4666666666667, 0.0625
66287, 0.041666666666667, 1.4833333333333, 0.083333333333333
66288, 0.041666666666667, 1.4166666666667, 0.125
66289, 0.020833333333333, 1.4333333333333, 0.125
66290, 0.041666666666667, 1.4333333333333, 0.10416666666667
66291, 0.041666666666667, 1.45, 0.125
66292, 0.020833333333333, 1.4666666666667, 0.125
66293, 0.041666666666667, 1.4666666666667, 0.10416666666667
66294, 0.041666666666667, 1.4833333333333, 0.125
66295, 0.041666666666667, 1.4166666666667, 0.16666666666667
66296, 0.020833333333333, 1.4333333333333, 0.16666666666667
66297, 0.041666666666667, 1.4333333333333, 0.14583333333333
66298, 0.041666666666667, 1.45, 0.16666666666667
66299, 0.020833333333333, 1.4666666666667, 0.16666666666667
66300, 0.041666666666667, 1.4666666666667, 0.14583333333333
66301, 0.041666666666667, 1.4833333333333, 0.16666666666667
66302, 0.041666666666667, 1.4166666666667, 0.20833333333333
66303, 0.020833333333333, 1.4333333333333, 0.20833333333333
66304, 0.041666666666667, 1.4333333333333, 0.1875
66305, 0.041666666666667, 1.45, 0.20833333333333
66306, 0.020833333333333, 1.4666666666667, 0.20833333333333
66307, 0.041666666666667, 1.4666666666667, 0.1875
66308, 0.041666666666667, 1.4833333333333, 0.20833333333333
66309, 0.041666666666667, 1.4166666666667, 0.25
66310, 0.020833333333333, 1.4333333333333, 0.25
66311, 0.041666666666667, 1.4333333333333, 0.22916666666667
66312, 0.041666666666667, 1.45, 0.25
66313, 0.020833333333333, 1.4666666666667, 0.25
66314, 0.041666666666667, 1.4666666666667, 0.22916666666667
66315, 0.041666666666667, 1.4833333333333, 0.25
66316, 0.041666666666667, 1.4166666666667, 0.29166666666667
66317, 0.020833333333333, 1.4333333333333, 0.29166666666667
66318, 0.041666666666667, 1.4333333333333, 0.27083333333333
66319, 0.041666666666667, 1.45, 0.29166666666667
66320, 0.020833333333333, 1.4666666666667, 0.29166666666667
66321, 0.041666666666667, 1.4666666666667, 0.27083333333333
66322, 0.041666666666667, 1.4833333333333, 0.29166666666667
66323, 0.041666666666667, 1.4166666666667, 0.33333333333333
66324, 0.020833333333333, 1.4333333333333, 0.33333333333333
66325, 0.041666666666667, 1.4333333333333, 0.3125
66326, 0.041666666666667, 1.45, 0.33333333333333
66327, 0.020833333333333, 1.4666666666667, 0.33333333333333
66328, 0.041666666666667, 1.4666666666667, 0.3125
66329, 0.041666666666667, 1.4833333333333, 0.33333333333333
66330, 0.041666666666667, 1.4166666666667, 0.375
66331, 0.020833333333333, 1.4333333333333, 0.375
66332, 0.041666666666667, 1.4333333333333, 0.35416666666667
66333, 0.041666666666667, 1.45, 0.375
66334, 0.020833333333333, 1.4666666666667, 0.375
66335, 0.041666666666667, 1.4666666666667, 0.35416666666667
66336, 0.041666666666667, 1.4833333333333, 0.375
66337, 0.041666666666667, 1.4166666666667, 0.41666666666667
66338, 0.020833333333333, 1.4333333333333, 0.41666666666667
