59299, 0.64583333333333, 0.7, 0.25
59300, 0.66666666666667, 0.7, 0.22916666666667
59301, 0.66666666666667, 0.725, 0.25
59302, 0.64583333333333, 0.75, 0.25
59303, 0.66666666666667, 0.75, 0.22916666666667
59304, 0.66666666666667, 0.775, 0.25
59305, 0.64583333333333, 0.8, 0.25
59306, 0.66666666666667, 0.8, 0.22916666666667
59307, 0.66666666666667, 0.825, 0.25
59308, 0.64583333333333, 0.85, 0.25
59309, 0.66666666666667, 0.85, 0.22916666666667
59310, 0.66666666666667, 0.875, 0.25
59311, 0.64583333333333, 0.9, 0.25
59312, 0.66666666666667, 0.9, 0.22916666666667
59313, 0.66666666666667, 0.925, 0.25
59314, 0.64583333333333, 0.95, 0.25
59315, 0.66666666666667, 0.95, 0.22916666666667
59316, 0.66666666666667, 0.975, 0.25
59317, 0.64583333333333, 1, 0.25
59318, 0.66666666666667, 1, 0.22916666666667
59319, 0.66666666666667, 1.025, 0.25
59320, 0.64583333333333, 1.05, 0.25
59321, 0.66666666666667, 1.05, 0.22916666666667
59322, 0.66666666666667, 1.075, 0.25
59323, 0.64583333333333, 1.1, 0.25
59324, 0.66666666666667, 1.1, 0.22916666666667
59325, 0.66666666666667, 1.125, 0.25
59326, 0.64583333333333, 1.15, 0.25
59327, 0.66666666666667, 1.15, 0.22916666666667
59328, 0.66666666666667, 1.175, 0.25
59329, 0.64583333333333, 1.2, 0.25
59330, 0.66666666666667, 1.2, 0.22916666666667
59331, 0.66666666666667, 1.225, 0.25
59332, 0.64583333333333, 1.25, 0.25
59333, 0.66666666666667, 1.25, 0.22916666666667
59334, 0.66666666666667, 1.275, 0.25
59335, 0.64583333333333, 1.3, 0.25
59336, 0.66666666666667, 1.3, 0.22916666666667
59337, 0.66666666666667, 1.325, 0.25
59338, 0.66666666666667, 0.175, 0.29166666666667
59339, 0.64583333333333, 0.2, 0.29166666666667
59340, 0.66666666666667, 0.2, 0.27083333333333
59341, 0.66666666666667, 0.225, 0.29166666666667
59342, 0.64583333333333, 0.25, 0.29166666666667
59343, 0.66666666666667, 0.25, 0.27083333333333
59344, 0.66666666666667, 0.275, 0.29166666666667
59345, 0.64583333333333, 0.3, 0.29166666666667
59346, 0.66666666666667, 0.3, 0.27083333333333
59347, 0.66666666666667, 0.325, 0.29166666666667
59348, 0.64583333333333, 0.35, 0.29166666666667
59349, 0.66666666666667, 0.35, 0.27083333333333
59350, 0.66666666666667, 0.375, 0.29166666666667
59351, 0.64583333333333, 0.4, 0.29166666666667
59352, 0.66666666666667, 0.4, 0.27083333333333
59353, 0.66666666666667, 0.425, 0.29166666666667
59354, 0.64583333333333, 0.45, 0.29166666666667
59355, 0.66666666666667, 0.45, 0.27083333333333
59356, 0.66666666666667, 0.475, 0.29166666666667
59357, 0.64583333333333, 0.5, 0.29166666666667
59358, 0.66666666666667, 0.5, 0.27083333333333
59359, 0.66666666666667, 0.525, 0.29166666666667
59360, 0.64583333333333, 0.55, 0.29166666666667
59361, 0.66666666666667, 0.55, 0.27083333333333
59362, 0.66666666666667, 0.575, 0.29166666666667
59363, 0.64583333333333, 0.6, 0.29166666666667
59364, 0.66666666666667, 0.6, 0.27083333333333
59365, 0.66666666666667, 0.625, 0.29166666666667
59366, 0.64583333333333, 0.65, 0.29166666666667
59367, 0.66666666666667, 0.65, 0.27083333333333
59368, 0.66666666666667, 0.675, 0.29166666666667
59369, 0.64583333333333, 0.7, 0.29166666666667
59370, 0.66666666666667, 0.7, 0.27083333333333
59371, 0.66666666666667, 0.725, 0.29166666666667
59372, 0.64583333333333, 0.75, 0.29166666666667
59373, 0.66666666666667, 0.75, 0.27083333333333
59374, 0.66666666666667, 0.775, 0.29166666666667
59375, 0.64583333333333, 0.8, 0.29166666666667
59376, 0.66666666666667, 0.8, 0.27083333333333
59377, 0.66666666666667, 0.825, 0.29166666666667
59378, 0.64583333333333, 0.85, 0.29166666666667
59379, 0.66666666666667, 0.85, 0.27083333333333
59380, 0.66666666666667, 0.875, 0.29166666666667
59381, 0.64583333333333, 0.9, 0.29166666666667
59382, 0.66666666666667, 0.9, 0.27083333333333
59383, 0.66666666666667, 0.925, 0.29166666666667
59384, 0.64583333333333, 0.95, 0.29166666666667
59385, 0.66666666666667, 0.95, 0.27083333333333
59386, 0.66666666666667, 0.975, 0.29166666666667
59387, 0.64583333333333, 1, 0.29166666666667
59388, 0.66666666666667, 1, 0.27083333333333
59389, 0.66666666666667, 1.025, 0.29166666666667
59390, 0.64583333333333, 1.05, 0.29166666666667
59391, 0.66666666666667, 1.05, 0.27083333333333
59392, 0.66666666666667, 1.075, 0.29166666666667
59393, 0.64583333333333, 1.1, 0.29166666666667
59394, 0.66666666666667, 1.1, 0.27083333333333
59395, 0.66666666666667, 1.125, 0.29166666666667
59396, 0.64583333333333, 1.15, 0.29166666666667
59397, 0.66666666666667, 1.15, 0.27083333333333
59398, 0.66666666666667, 1.175, 0.29166666666667
59399, 0.64583333333333, 1.2, 0.29166666666667
59400, 0.66666666666667, 1.2, 0.27083333333333
59401, 0.66666666666667, 1.225, 0.29166666666667
59402, 0.64583333333333, 1.25, 0.29166666666667
59403, 0.66666666666667, 1.25, 0.27083333333333
59404, 0.66666666666667, 1.275, 0.29166666666667
59405, 0.64583333333333, 1.3, 0.29166666666667
59406, 0.66666666666667, 1.3, 0.27083333333333
59407, 0.66666666666667, 1.325, 0.29166666666667
59408, 0.66666666666667, 0.175, 0.33333333333333
59409, 0.64583333333333, 0.2, 0.33333333333333
59410, 0.66666666666667, 0.2, 0.3125
59411, 0.66666666666667, 0.225, 0.33333333333333
59412, 0.64583333333333, 0.25, 0.33333333333333
59413, 0.66666666666667, 0.25, 0.3125
59414, 0.66666666666667, 0.275, 0.33333333333333
59415, 0.64583333333333, 0.3, 0.33333333333333
59416, 0.66666666666667, 0.3, 0.3125
59417, 0.66666666666667, 0.325, 0.33333333333333
59418, 0.64583333333333, 0.35, 0.33333333333333
59419, 0.66666666666667, 0.35, 0.3125
59420, 0.66666666666667, 0.375, 0.33333333333333
59421, 0.64583333333333, 0.4, 0.33333333333333
59422, 0.66666666666667, 0.4, 0.3125
59423, 0.66666666666667, 0.425, 0.33333333333333
59424, 0.64583333333333, 0.45, 0.33333333333333
59425, 0.66666666666667, 0.45, 0.3125
59426, 0.66666666666667, 0.475, 0.33333333333333
59427, 0.64583333333333, 0.5, 0.33333333333333
59428, 0.66666666666667, 0.5, 0.3125
59429, 0.66666666666667, 0.525, 0.33333333333333
59430, 0.64583333333333, 0.55, 0.33333333333333
59431, 0.66666666666667, 0.55, 0.3125
59432, 0.66666666666667, 0.575, 0.33333333333333
59433, 0.64583333333333, 0.6, 0.33333333333333
59434, 0.66666666666667, 0.6, 0.3125
59435, 0.66666666666667, 0.625, 0.33333333333333
59436, 0.64583333333333, 0.65, 0.33333333333333
59437, 0.66666666666667, 0.65, 0.3125
59438, 0.66666666666667, 0.675, 0.33333333333333
59439, 0.64583333333333, 0.7, 0.33333333333333
59440, 0.66666666666667, 0.7, 0.3125
59441, 0.66666666666667, 0.725, 0.33333333333333
59442, 0.64583333333333, 0.75, 0.33333333333333
59443, 0.66666666666667, 0.75, 0.3125
59444, 0.66666666666667, 0.775, 0.33333333333333
59445, 0.64583333333333, 0.8, 0.33333333333333
59446, 0.66666666666667, 0.8, 0.3125
59447, 0.66666666666667, 0.825, 0.33333333333333
59448, 0.64583333333333, 0.85, 0.33333333333333
59449, 0.66666666666667, 0.85, 0.3125
59450, 0.66666666666667, 0.875, 0.33333333333333
59451, 0.64583333333333, 0.9, 0.33333333333333
59452, 0.66666666666667, 0.9, 0.3125
59453, 0.66666666666667, 0.925, 0.33333333333333
59454, 0.64583333333333, 0.95, 0.33333333333333
59455, 0.66666666666667, 0.95, 0.3125
59456, 0.66666666666667, 0.975, 0.33333333333333
59457, 0.64583333333333, 1, 0.33333333333333
59458, 0.66666666666667, 1, 0.3125
59459, 0.66666666666667, 1.025, 0.33333333333333
59460, 0.64583333333333, 1.05, 0.33333333333333
59461, 0.66666666666667, 1.05, 0.3125
59462, 0.66666666666667, 1.075, 0.33333333333333
59463, 0.64583333333333, 1.1, 0.33333333333333
59464, 0.66666666666667, 1.1, 0.3125
59465, 0.66666666666667, 1.125, 0.33333333333333
59466, 0.64583333333333, 1.15, 0.33333333333333
59467, 0.66666666666667, 1.15, 0.3125
59468, 0.66666666666667, 1.175, 0.33333333333333
59469, 0.64583333333333, 1.2, 0.33333333333333
59470, 0.66666666666667, 1.2, 0.3125
59471, 0.66666666666667, 1.225, 0.33333333333333
59472, 0.64583333333333, 1.25, 0.33333333333333
59473, 0.66666666666667, 1.25, 0.3125
59474, 0.66666666666667, 1.275, 0.33333333333333
59475, 0.64583333333333, 1.3, 0.33333333333333
59476, 0.66666666666667, 1.3, 0.3125
59477, 0.66666666666667, 1.325, 0.33333333333333
59478, 0.66666666666667, 0.175, 0.375
59479, 0.64583333333333, 0.2, 0.375
59480, 0.66666666666667, 0.2, 0.35416666666667
59481, 0.66666666666667, 0.225, 0.375
59482, 0.64583333333333, 0.25, 0.375
59483, 0.66666666666667, 0.25, 0.35416666666667
59484, 0.66666666666667, 0.275, 0.375
59485, 0.64583333333333, 0.3, 0.375
59486, 0.66666666666667, 0.3, 0.35416666666667
59487, 0.66666666666667, 0.325, 0.375
59488, 0.64583333333333, 0.35, 0.375
59489, 0.66666666666667, 0.35, 0.35416666666667
59490, 0.66666666666667, 0.375, 0.375
59491, 0.64583333333333, 0.4, 0.375
59492, 0.66666666666667, 0.4, 0.35416666666667
59493, 0.66666666666667, 0.425, 0.375
59494, 0.64583333333333, 0.45, 0.375
59495, 0.66666666666667, 0.45, 0.35416666666667
59496, 0.66666666666667, 0.475, 0.375
59497, 0.64583333333333, 0.5, 0.375
59498, 0.66666666666667, 0.5, 0.35416666666667
59499, 0.66666666666667, 0.525, 0.375
59500, 0.64583333333333, 0.55, 0.375
59501, 0.66666666666667, 0.55, 0.35416666666667
59502, 0.66666666666667, 0.575, 0.375
59503, 0.64583333333333, 0.6, 0.375
59504, 0.66666666666667, 0.6, 0.35416666666667
59505, 0.66666666666667, 0.625, 0.375
59506, 0.64583333333333, 0.65, 0.375
59507, 0.66666666666667, 0.65, 0.35416666666667
59508, 0.66666666666667, 0.675, 0.375
59509, 0.64583333333333, 0.7, 0.375
59510, 0.66666666666667, 0.7, 0.35416666666667
59511, 0.66666666666667, 0.725, 0.375
59512, 0.64583333333333, 0.75, 0.375
59513, 0.66666666666667, 0.75, 0.35416666666667
59514, 0.66666666666667, 0.775, 0.375
59515, 0.64583333333333, 0.8, 0.375
59516, 0.66666666666667, 0.8, 0.35416666666667
59517, 0.66666666666667, 0.825, 0.375
59518, 0.64583333333333, 0.85, 0.375
59519, 0.66666666666667, 0.85, 0.35416666666667
59520, 0.66666666666667, 0.875, 0.375
59521, 0.64583333333333, 0.9, 0.375
59522, 0.66666666666667, 0.9, 0.35416666666667
59523, 0.66666666666667, 0.925, 0.375
59524, 0.64583333333333, 0.95, 0.375
59525, 0.66666666666667, 0.95, 0.35416666666667
59526, 0.66666666666667, 0.975, 0.375
59527, 0.64583333333333, 1, 0.375
59528, 0.66666666666667, 1, 0.35416666666667
59529, 0.66666666666667, 1.025, 0.375
59530, 0.64583333333333, 1.05, 0.375
59531, 0.66666666666667, 1.05, 0.35416666666667
59532, 0.66666666666667, 1.075, 0.375
59533, 0.64583333333333, 1.1, 0.375
59534, 0.66666666666667, 1.1, 0.35416666666667
59535, 0.66666666666667, 1.125, 0.375
59536, 0.64583333333333, 1.15, 0.375
59537, 0.66666666666667, 1.15, 0.35416666666667
59538, 0.66666666666667, 1.175, 0.375
59539, 0.64583333333333, 1.2, 0.375
59540, 0.66666666666667, 1.2, 0.35416666666667
59541, 0.66666666666667, 1.225, 0.375
59542, 0.64583333333333, 1.25, 0.375
59543, 0.66666666666667, 1.25, 0.35416666666667
59544, 0.66666666666667, 1.275, 0.375
59545, 0.64583333333333, 1.3, 0.375
59546, 0.66666666666667, 1.3, 0.35416666666667
59547, 0.66666666666667, 1.325, 0.375
59548, 0.66666666666667, 0.175, 0.41666666666667
59549, 0.64583333333333, 0.2, 0.41666666666667
59550, 0.66666666666667, 0.2, 0.39583333333333
59551, 0.66666666666667, 0.225, 0.41666666666667
59552, 0.64583333333333, 0.25, 0.41666666666667
59553, 0.66666666666667, 0.25, 0.39583333333333
59554, 0.66666666666667, 0.275, 0.41666666666667
59555, 0.64583333333333, 0.3, 0.41666666666667
59556, 0.66666666666667, 0.3, 0.39583333333333
59557, 0.66666666666667, 0.325, 0.41666666666667
59558, 0.64583333333333, 0.35, 0.41666666666667
59559, 0.66666666666667, 0.35, 0.39583333333333
59560, 0.66666666666667, 0.375, 0.41666666666667
59561, 0.64583333333333, 0.4, 0.41666666666667
59562, 0.66666666666667, 0.4, 0.39583333333333
59563, 0.66666666666667, 0.425, 0.41666666666667
59564, 0.64583333333333, 0.45, 0.41666666666667
59565, 0.66666666666667, 0.45, 0.39583333333333
59566, 0.66666666666667, 0.475, 0.41666666666667
59567, 0.64583333333333, 0.5, 0.41666666666667
59568, 0.66666666666667, 0.5, 0.39583333333333
59569, 0.66666666666667, 0.525, 0.41666666666667
59570, 0.64583333333333, 0.55, 0.41666666666667
59571, 0.66666666666667, 0.55, 0.39583333333333
59572, 0.66666666666667, 0.575, 0.41666666666667
59573, 0.64583333333333, 0.6, 0.41666666666667
59574, 0.66666666666667, 0.6, 0.39583333333333
59575, 0.66666666666667, 0.625, 0.41666666666667
59576, 0.64583333333333, 0.65, 0.41666666666667
59577, 0.66666666666667, 0.65, 0.39583333333333
59578, 0.66666666666667, 0.675, 0.41666666666667
59579, 0.64583333333333, 0.7, 0.41666666666667
59580, 0.66666666666667, 0.7, 0.39583333333333
59581, 0.66666666666667, 0.725, 0.41666666666667
59582, 0.64583333333333, 0.75, 0.41666666666667
59583, 0.66666666666667, 0.75, 0.39583333333333
59584, 0.66666666666667, 0.775, 0.41666666666667
59585, 0.64583333333333, 0.8, 0.41666666666667
59586, 0.66666666666667, 0.8, 0.39583333333333
59587, 0.66666666666667, 0.825, 0.41666666666667
59588, 0.64583333333333, 0.85, 0.41666666666667
59589, 0.66666666666667, 0.85, 0.39583333333333
59590, 0.66666666666667, 0.875, 0.41666666666667
59591, 0.64583333333333, 0.9, 0.41666666666667
59592, 0.66666666666667, 0.9, 0.39583333333333
59593, 0.66666666666667, 0.925, 0.41666666666667
59594, 0.64583333333333, 0.95, 0.41666666666667
59595, 0.66666666666667, 0.95, 0.39583333333333
59596, 0.66666666666667, 0.975, 0.41666666666667
59597, 0.64583333333333, 1, 0.41666666666667
59598, 0.66666666666667, 1, 0.39583333333333
59599, 0.66666666666667, 1.025, 0.41666666666667
59600, 0.64583333333333, 1.05, 0.41666666666667
59601, 0.66666666666667, 1.05, 0.39583333333333
59602, 0.66666666666667, 1.075, 0.41666666666667
59603, 0.64583333333333, 1.1, 0.41666666666667
59604, 0.66666666666667, 1.1, 0.39583333333333
59605, 0.66666666666667, 1.125, 0.41666666666667
59606, 0.64583333333333, 1.15, 0.41666666666667
59607, 0.66666666666667, 1.15, 0.39583333333333
59608, 0.66666666666667, 1.175, 0.41666666666667
59609, 0.64583333333333, 1.2, 0.41666666666667
59610, 0.66666666666667, 1.2, 0.39583333333333
59611, 0.66666666666667, 1.225, 0.41666666666667
59612, 0.64583333333333, 1.25, 0.41666666666667
59613, 0.66666666666667, 1.25, 0.39583333333333
59614, 0.66666666666667, 1.275, 0.41666666666667
59615, 0.64583333333333, 1.3, 0.41666666666667
59616, 0.66666666666667, 1.3, 0.39583333333333
59617, 0.66666666666667, 1.325, 0.41666666666667
59618, 0.66666666666667, 0.175, 0.45833333333333
59619, 0.64583333333333, 0.2, 0.45833333333333
59620, 0.66666666666667, 0.2, 0.4375
59621, 0.66666666666667, 0.225, 0.45833333333333
59622, 0.64583333333333, 0.25, 0.45833333333333
59623, 0.66666666666667, 0.25, 0.4375
59624, 0.66666666666667, 0.275, 0.45833333333333
59625, 0.64583333333333, 0.3, 0.45833333333333
59626, 0.66666666666667, 0.3, 0.4375
59627, 0.66666666666667, 0.325, 0.45833333333333
59628, 0.64583333333333, 0.35, 0.45833333333333
59629, 0.66666666666667, 0.35, 0.4375
59630, 0.66666666666667, 0.375, 0.45833333333333
59631, 0.64583333333333, 0.4, 0.45833333333333
59632, 0.66666666666667, 0.4, 0.4375
59633, 0.66666666666667, 0.425, 0.45833333333333
59634, 0.64583333333333, 0.45, 0.45833333333333
59635, 0.66666666666667, 0.45, 0.4375
59636, 0.66666666666667, 0.475, 0.45833333333333
59637, 0.64583333333333, 0.5, 0.45833333333333
59638, 0.66666666666667, 0.5, 0.4375
59639, 0.66666666666667, 0.525, 0.45833333333333
59640, 0.64583333333333, 0.55, 0.45833333333333
59641, 0.66666666666667, 0.55, 0.4375
59642, 0.66666666666667, 0.575, 0.45833333333333
59643, 0.64583333333333, 0.6, 0.45833333333333
59644, 0.66666666666667, 0.6, 0.4375
59645, 0.66666666666667, 0.625, 0.45833333333333
59646, 0.64583333333333, 0.65, 0.45833333333333
59647, 0.66666666666667, 0.65, 0.4375
59648, 0.66666666666667, 0.675, 0.45833333333333
59649, 0.64583333333333, 0.7, 0.45833333333333
59650, 0.66666666666667, 0.7, 0.4375
59651, 0.66666666666667, 0.725, 0.45833333333333
59652, 0.64583333333333, 0.75, 0.45833333333333
59653, 0.66666666666667, 0.75, 0.4375
59654, 0.66666666666667, 0.775, 0.45833333333333
59655, 0.64583333333333, 0.8, 0.45833333333333
59656, 0.66666666666667, 0.8, 0.4375
59657, 0.66666666666667, 0.825, 0.45833333333333
59658, 0.64583333333333, 0.85, 0.45833333333333
59659, 0.66666666666667, 0.85, 0.4375
59660, 0.66666666666667, 0.875, 0.45833333333333
59661, 0.64583333333333, 0.9, 0.45833333333333
59662, 0.66666666666667, 0.9, 0.4375
59663, 0.66666666666667, 0.925, 0.45833333333333
59664, 0.64583333333333, 0.95, 0.45833333333333
59665, 0.66666666666667, 0.95, 0.4375
59666, 0.66666666666667, 0.975, 0.45833333333333
59667, 0.64583333333333, 1, 0.45833333333333
59668, 0.66666666666667, 1, 0.4375
59669, 0.66666666666667, 1.025, 0.45833333333333
59670, 0.64583333333333, 1.05, 0.45833333333333
59671, 0.66666666666667, 1.05, 0.4375
59672, 0.66666666666667, 1.075, 0.45833333333333
59673, 0.64583333333333, 1.1, 0.45833333333333
59674, 0.66666666666667, 1.1, 0.4375
59675, 0.66666666666667, 1.125, 0.45833333333333
59676, 0.64583333333333, 1.15, 0.45833333333333
59677, 0.66666666666667, 1.15, 0.4375
59678, 0.66666666666667, 1.175, 0.45833333333333
59679, 0.64583333333333, 1.2, 0.45833333333333
59680, 0.66666666666667, 1.2, 0.4375
59681, 0.66666666666667, 1.225, 0.45833333333333
59682, 0.64583333333333, 1.25, 0.45833333333333
59683, 0.66666666666667, 1.25, 0.4375
59684, 0.66666666666667, 1.275, 0.45833333333333
59685, 0.64583333333333, 1.3, 0.45833333333333
59686, 0.66666666666667, 1.3, 0.4375
59687, 0.66666666666667, 1.325, 0.45833333333333
59688, 0.66666666666667, 0.2, 0.47916666666667
59689, 0.66666666666667, 0.25, 0.47916666666667
59690, 0.66666666666667, 0.3, 0.47916666666667
59691, 0.66666666666667, 0.35, 0.47916666666667
59692, 0.66666666666667, 0.4, 0.47916666666667
59693, 0.66666666666667, 0.45, 0.47916666666667
59694, 0.66666666666667, 0.5, 0.47916666666667
59695, 0.66666666666667, 0.55, 0.47916666666667
59696, 0.66666666666667, 0.6, 0.47916666666667
59697, 0.66666666666667, 0.65, 0.47916666666667
59698, 0.66666666666667, 0.7, 0.47916666666667
59699, 0.66666666666667, 0.75, 0.47916666666667
59700, 0.66666666666667, 0.8, 0.47916666666667
59701, 0.66666666666667, 0.85, 0.47916666666667
59702, 0.66666666666667, 0.9, 0.47916666666667
59703, 0.66666666666667, 0.95, 0.47916666666667
59704, 0.66666666666667, 1, 0.47916666666667
59705, 0.66666666666667, 1.05, 0.47916666666667
59706, 0.66666666666667, 1.1, 0.47916666666667
59707, 0.66666666666667, 1.15, 0.47916666666667
59708, 0.66666666666667, 1.2, 0.47916666666667
59709, 0.66666666666667, 1.25, 0.47916666666667
59710, 0.66666666666667, 1.3, 0.47916666666667
59711, 0.70833333333333, 0.175, 0.041666666666667
59712, 0.6875, 0.2, 0.041666666666667
59713, 0.70833333333333, 0.2, 0.020833333333333
59714, 0.70833333333333, 0.225, 0.041666666666667
59715, 0.6875, 0.25, 0.041666666666667
59716, 0.70833333333333, 0.25, 0.020833333333333
59717, 0.70833333333333, 0.275, 0.041666666666667
59718, 0.6875, 0.3, 0.041666666666667
59719, 0.70833333333333, 0.3, 0.020833333333333
59720, 0.70833333333333, 0.325, 0.041666666666667
59721, 0.6875, 0.35, 0.041666666666667
59722, 0.70833333333333, 0.35, 0.020833333333333
59723, 0.70833333333333, 0.375, 0.041666666666667
59724, 0.6875, 0.4, 0.041666666666667
59725, 0.70833333333333, 0.4, 0.020833333333333
59726, 0.70833333333333, 0.425, 0.041666666666667
59727, 0.6875, 0.45, 0.041666666666667
59728, 0.70833333333333, 0.45, 0.020833333333333
59729, 0.70833333333333, 0.475, 0.041666666666667
59730, 0.6875, 0.5, 0.041666666666667
59731, 0.70833333333333, 0.5, 0.020833333333333
59732, 0.70833333333333, 0.525, 0.041666666666667
59733, 0.6875, 0.55, 0.041666666666667
59734, 0.70833333333333, 0.55, 0.020833333333333
59735, 0.70833333333333, 0.575, 0.041666666666667
59736, 0.6875, 0.6, 0.041666666666667
59737, 0.70833333333333, 0.6, 0.020833333333333
59738, 0.70833333333333, 0.625, 0.041666666666667
59739, 0.6875, 0.65, 0.041666666666667
59740, 0.70833333333333, 0.65, 0.020833333333333
59741, 0.70833333333333, 0.675, 0.041666666666667
59742, 0.6875, 0.7, 0.041666666666667
59743, 0.70833333333333, 0.7, 0.020833333333333
59744, 0.70833333333333, 0.725, 0.041666666666667
59745, 0.6875, 0.75, 0.041666666666667
59746, 0.70833333333333, 0.75, 0.020833333333333
59747, 0.70833333333333, 0.775, 0.041666666666667
59748, 0.6875, 0.8, 0.041666666666667
59749, 0.70833333333333, 0.8, 0.020833333333333
59750, 0.70833333333333, 0.825, 0.041666666666667
59751, 0.6875, 0.85, 0.041666666666667
59752, 0.70833333333333, 0.85, 0.020833333333333
59753, 0.70833333333333, 0.875, 0.041666666666667
59754, 0.6875, 0.9, 0.041666666666667
59755, 0.70833333333333, 0.9, 0.020833333333333
59756, 0.70833333333333, 0.925, 0.041666666666667
59757, 0.6875, 0.95, 0.041666666666667
59758, 0.70833333333333, 0.95, 0.020833333333333
59759, 0.70833333333333, 0.975, 0.041666666666667
59760, 0.6875, 1, 0.041666666666667
59761, 0.70833333333333, 1, 0.020833333333333
59762, 0.70833333333333, 1.025, 0.041666666666667
59763, 0.6875, 1.05, 0.041666666666667
59764, 0.70833333333333, 1.05, 0.020833333333333
59765, 0.70833333333333, 1.075, 0.041666666666667
59766, 0.6875, 1.1, 0.041666666666667
59767, 0.70833333333333, 1.1, 0.020833333333333
59768, 0.70833333333333, 1.125, 0.041666666666667
59769, 0.6875, 1.15, 0.041666666666667
59770, 0.70833333333333, 1.15, 0.020833333333333
59771, 0.70833333333333, 1.175, 0.041666666666667
59772, 0.6875, 1.2, 0.041666666666667
59773, 0.70833333333333, 1.2, 0.020833333333333
59774, 0.70833333333333, 1.225, 0.041666666666667
59775, 0.6875, 1.25, 0.041666666666667
59776, 0.70833333333333, 1.25, 0.020833333333333
59777, 0.70833333333333, 1.275, 0.041666666666667
59778, 0.6875, 1.3, 0.041666666666667
59779, 0.70833333333333, 1.3, 0.020833333333333
59780, 0.70833333333333, 1.325, 0.041666666666667
59781, 0.70833333333333, 0.175, 0.083333333333333
59782, 0.6875, 0.2, 0.083333333333333
59783, 0.70833333333333, 0.2, 0.0625
59784, 0.70833333333333, 0.225, 0.083333333333333
59785, 0.6875, 0.25, 0.083333333333333
59786, 0.70833333333333, 0.25, 0.0625
59787, 0.70833333333333, 0.275, 0.083333333333333
59788, 0.6875, 0.3, 0.083333333333333
59789, 0.70833333333333, 0.3, 0.0625
59790, 0.70833333333333, 0.325, 0.083333333333333
59791, 0.6875, 0.35, 0.083333333333333
59792, 0.70833333333333, 0.35, 0.0625
59793, 0.70833333333333, 0.375, 0.083333333333333
59794, 0.6875, 0.4, 0.083333333333333
59795, 0.70833333333333, 0.4, 0.0625
59796, 0.70833333333333, 0.425, 0.083333333333333
59797, 0.6875, 0.45, 0.083333333333333
59798, 0.70833333333333, 0.45, 0.0625
59799, 0.70833333333333, 0.475, 0.083333333333333
59800, 0.6875, 0.5, 0.083333333333333
59801, 0.70833333333333, 0.5, 0.0625
59802, 0.70833333333333, 0.525, 0.083333333333333
59803, 0.6875, 0.55, 0.083333333333333
59804, 0.70833333333333, 0.55, 0.0625
59805, 0.70833333333333, 0.575, 0.083333333333333
59806, 0.6875, 0.6, 0.083333333333333
59807, 0.70833333333333, 0.6, 0.0625
59808, 0.70833333333333, 0.625, 0.083333333333333
59809, 0.6875, 0.65, 0.083333333333333
59810, 0.70833333333333, 0.65, 0.0625
59811, 0.70833333333333, 0.675, 0.083333333333333
59812, 0.6875, 0.7, 0.083333333333333
59813, 0.70833333333333, 0.7, 0.0625
59814, 0.70833333333333, 0.725, 0.083333333333333
59815, 0.6875, 0.75, 0.083333333333333
59816, 0.70833333333333, 0.75, 0.0625
59817, 0.70833333333333, 0.775, 0.083333333333333
59818, 0.6875, 0.8, 0.083333333333333
59819, 0.70833333333333, 0.8, 0.0625
59820, 0.70833333333333, 0.825, 0.083333333333333
59821, 0.6875, 0.85, 0.083333333333333
59822, 0.70833333333333, 0.85, 0.0625
59823, 0.70833333333333, 0.875, 0.083333333333333
59824, 0.6875, 0.9, 0.083333333333333
59825, 0.70833333333333, 0.9, 0.0625
59826, 0.70833333333333, 0.925, 0.083333333333333
59827, 0.6875, 0.95, 0.083333333333333
59828, 0.70833333333333, 0.95, 0.0625
59829, 0.70833333333333, 0.975, 0.083333333333333
59830, 0.6875, 1, 0.083333333333333
59831, 0.70833333333333, 1, 0.0625
59832, 0.70833333333333, 1.025, 0.083333333333333
59833, 0.6875, 1.05, 0.083333333333333
59834, 0.70833333333333, 1.05, 0.0625
59835, 0.70833333333333, 1.075, 0.083333333333333
59836, 0.6875, 1.1, 0.083333333333333
59837, 0.70833333333333, 1.1, 0.0625
59838, 0.70833333333333, 1.125, 0.083333333333333
59839, 0.6875, 1.15, 0.083333333333333
59840, 0.70833333333333, 1.15, 0.0625
59841, 0.70833333333333, 1.175, 0.083333333333333
59842, 0.6875, 1.2, 0.083333333333333
59843, 0.70833333333333, 1.2, 0.0625
59844, 0.70833333333333, 1.225, 0.083333333333333
59845, 0.6875, 1.25, 0.083333333333333
59846, 0.70833333333333, 1.25, 0.0625
59847, 0.70833333333333, 1.275, 0.083333333333333
59848, 0.6875, 1.3, 0.083333333333333
59849, 0.70833333333333, 1.3, 0.0625
59850, 0.70833333333333, 1.325, 0.083333333333333
59851, 0.70833333333333, 0.175, 0.125
59852, 0.6875, 0.2, 0.125
59853, 0.70833333333333, 0.2, 0.10416666666667
59854, 0.70833333333333, 0.225, 0.125
59855, 0.6875, 0.25, 0.125
59856, 0.70833333333333, 0.25, 0.10416666666667
59857, 0.70833333333333, 0.275, 0.125
59858, 0.6875, 0.3, 0.125
59859, 0.70833333333333, 0.3, 0.10416666666667
59860, 0.70833333333333, 0.325, 0.125
59861, 0.6875, 0.35, 0.125
59862, 0.70833333333333, 0.35, 0.10416666666667
59863, 0.70833333333333, 0.375, 0.125
59864, 0.6875, 0.4, 0.125
59865, 0.70833333333333, 0.4, 0.10416666666667
59866, 0.70833333333333, 0.425, 0.125
59867, 0.6875, 0.45, 0.125
59868, 0.70833333333333, 0.45, 0.10416666666667
59869, 0.70833333333333, 0.475, 0.125
59870, 0.6875, 0.5, 0.125
59871, 0.70833333333333, 0.5, 0.10416666666667
59872, 0.70833333333333, 0.525, 0.125
59873, 0.6875, 0.55, 0.125
59874, 0.70833333333333, 0.55, 0.10416666666667
59875, 0.70833333333333, 0.575, 0.125
59876, 0.6875, 0.6, 0.125
59877, 0.70833333333333, 0.6, 0.10416666666667
59878, 0.70833333333333, 0.625, 0.125
59879, 0.6875, 0.65, 0.125
59880, 0.70833333333333, 0.65, 0.10416666666667
59881, 0.70833333333333, 0.675, 0.125
59882, 0.6875, 0.7, 0.125
59883, 0.70833333333333, 0.7, 0.10416666666667
59884, 0.70833333333333, 0.725, 0.125
59885, 0.6875, 0.75, 0.125
59886, 0.70833333333333, 0.75, 0.10416666666667
59887, 0.70833333333333, 0.775, 0.125
59888, 0.6875, 0.8, 0.125
59889, 0.70833333333333, 0.8, 0.10416666666667
59890, 0.70833333333333, 0.825, 0.125
59891, 0.6875, 0.85, 0.125
59892, 0.70833333333333, 0.85, 0.10416666666667
59893, 0.70833333333333, 0.875, 0.125
59894, 0.6875, 0.9, 0.125
59895, 0.70833333333333, 0.9, 0.10416666666667
59896, 0.70833333333333, 0.925, 0.125
59897, 0.6875, 0.95, 0.125
59898, 0.70833333333333, 0.95, 0.10416666666667
59899, 0.70833333333333, 0.975, 0.125
59900, 0.6875, 1, 0.125
59901, 0.70833333333333, 1, 0.10416666666667
59902, 0.70833333333333, 1.025, 0.125
59903, 0.6875, 1.05, 0.125
59904, 0.70833333333333, 1.05, 0.10416666666667
59905, 0.70833333333333, 1.075, 0.125
59906, 0.6875, 1.1, 0.125
59907, 0.70833333333333, 1.1, 0.10416666666667
59908, 0.70833333333333, 1.125, 0.125
59909, 0.6875, 1.15, 0.125
59910, 0.70833333333333, 1.15, 0.10416666666667
59911, 0.70833333333333, 1.175, 0.125
59912, 0.6875, 1.2, 0.125
59913, 0.70833333333333, 1.2, 0.10416666666667
59914, 0.70833333333333, 1.225, 0.125
59915, 0.6875, 1.25, 0.125
59916, 0.70833333333333, 1.25, 0.10416666666667
59917, 0.70833333333333, 1.275, 0.125
59918, 0.6875, 1.3, 0.125
59919, 0.70833333333333, 1.3, 0.10416666666667
59920, 0.70833333333333, 1.325, 0.125
59921, 0.70833333333333, 0.175, 0.16666666666667
59922, 0.6875, 0.2, 0.16666666666667
59923, 0.70833333333333, 0.2, 0.14583333333333
59924, 0.70833333333333, 0.225, 0.16666666666667
59925, 0.6875, 0.25, 0.16666666666667
59926, 0.70833333333333, 0.25, 0.14583333333333
59927, 0.70833333333333, 0.275, 0.16666666666667
59928, 0.6875, 0.3, 0.16666666666667
59929, 0.70833333333333, 0.3, 0.14583333333333
59930, 0.70833333333333, 0.325, 0.16666666666667
59931, 0.6875, 0.35, 0.16666666666667
59932, 0.70833333333333, 0.35, 0.14583333333333
59933, 0.70833333333333, 0.375, 0.16666666666667
59934, 0.6875, 0.4, 0.16666666666667
59935, 0.70833333333333, 0.4, 0.14583333333333
59936, 0.70833333333333, 0.425, 0.16666666666667
59937, 0.6875, 0.45, 0.16666666666667
59938, 0.70833333333333, 0.45, 0.14583333333333
59939, 0.70833333333333, 0.475, 0.16666666666667
59940, 0.6875, 0.5, 0.16666666666667
59941, 0.70833333333333, 0.5, 0.14583333333333
59942, 0.70833333333333, 0.525, 0.16666666666667
59943, 0.6875, 0.55, 0.16666666666667
59944, 0.70833333333333, 0.55, 0.14583333333333
59945, 0.70833333333333, 0.575, 0.16666666666667
59946, 0.6875, 0.6, 0.16666666666667
59947, 0.70833333333333, 0.6, 0.14583333333333
59948, 0.70833333333333, 0.625, 0.16666666666667
59949, 0.6875, 0.65, 0.16666666666667
59950, 0.70833333333333, 0.65, 0.14583333333333
59951, 0.70833333333333, 0.675, 0.16666666666667
59952, 0.6875, 0.7, 0.16666666666667
59953, 0.70833333333333, 0.7, 0.14583333333333
59954, 0.70833333333333, 0.725, 0.16666666666667
59955, 0.6875, 0.75, 0.16666666666667
59956, 0.70833333333333, 0.75, 0.14583333333333
59957, 0.70833333333333, 0.775, 0.16666666666667
59958, 0.6875, 0.8, 0.16666666666667
59959, 0.70833333333333, 0.8, 0.14583333333333
59960, 0.70833333333333, 0.825, 0.16666666666667
59961, 0.6875, 0.85, 0.16666666666667
59962, 0.70833333333333, 0.85, 0.14583333333333
59963, 0.70833333333333, 0.875, 0.16666666666667
59964, 0.6875, 0.9, 0.16666666666667
59965, 0.70833333333333, 0.9, 0.14583333333333
59966, 0.70833333333333, 0.925, 0.16666666666667
59967, 0.6875, 0.95, 0.16666666666667
59968, 0.70833333333333, 0.95, 0.14583333333333
59969, 0.70833333333333, 0.975, 0.16666666666667
59970, 0.6875, 1, 0.16666666666667
59971, 0.70833333333333, 1, 0.14583333333333
59972, 0.70833333333333, 1.025, 0.16666666666667
59973, 0.6875, 1.05, 0.16666666666667
59974, 0.70833333333333, 1.05, 0.14583333333333
59975, 0.70833333333333, 1.075, 0.16666666666667
59976, 0.6875, 1.1, 0.16666666666667
59977, 0.70833333333333, 1.1, 0.14583333333333
59978, 0.70833333333333, 1.125, 0.16666666666667
59979, 0.6875, 1.15, 0.16666666666667
59980, 0.70833333333333, 1.15, 0.14583333333333
59981, 0.70833333333333, 1.175, 0.16666666666667
59982, 0.6875, 1.2, 0.16666666666667
59983, 0.70833333333333, 1.2, 0.14583333333333
59984, 0.70833333333333, 1.225, 0.16666666666667
59985, 0.6875, 1.25, 0.16666666666667
59986, 0.70833333333333, 1.25, 0.14583333333333
59987, 0.70833333333333, 1.275, 0.16666666666667
59988, 0.6875, 1.3, 0.16666666666667
59989, 0.70833333333333, 1.3, 0.14583333333333
59990, 0.70833333333333, 1.325, 0.16666666666667
59991, 0.70833333333333, 0.175, 0.20833333333333
59992, 0.6875, 0.2, 0.20833333333333
59993, 0.70833333333333, 0.2, 0.1875
59994, 0.70833333333333, 0.225, 0.20833333333333
59995, 0.6875, 0.25, 0.20833333333333
59996, 0.70833333333333, 0.25, 0.1875
59997, 0.70833333333333, 0.275, 0.20833333333333
59998, 0.6875, 0.3, 0.20833333333333
59999, 0.70833333333333, 0.3, 0.1875
60000, 0.70833333333333, 0.325, 0.20833333333333
60001, 0.6875, 0.35, 0.20833333333333
60002, 0.70833333333333, 0.35, 0.1875
60003, 0.70833333333333, 0.375, 0.20833333333333
60004, 0.6875, 0.4, 0.20833333333333
60005, 0.70833333333333, 0.4, 0.1875
60006, 0.70833333333333, 0.425, 0.20833333333333
60007, 0.6875, 0.45, 0.20833333333333
60008, 0.70833333333333, 0.45, 0.1875
60009, 0.70833333333333, 0.475, 0.20833333333333
60010, 0.6875, 0.5, 0.20833333333333
60011, 0.70833333333333, 0.5, 0.1875
60012, 0.70833333333333, 0.525, 0.20833333333333
60013, 0.6875, 0.55, 0.20833333333333
60014, 0.70833333333333, 0.55, 0.1875
60015, 0.70833333333333, 0.575, 0.20833333333333
60016, 0.6875, 0.6, 0.20833333333333
60017, 0.70833333333333, 0.6, 0.1875
60018, 0.70833333333333, 0.625, 0.20833333333333
60019, 0.6875, 0.65, 0.20833333333333
60020, 0.70833333333333, 0.65, 0.1875
60021, 0.70833333333333, 0.675, 0.20833333333333
60022, 0.6875, 0.7, 0.20833333333333
60023, 0.70833333333333, 0.7, 0.1875
60024, 0.70833333333333, 0.725, 0.20833333333333
60025, 0.6875, 0.75, 0.20833333333333
60026, 0.70833333333333, 0.75, 0.1875
60027, 0.70833333333333, 0.775, 0.20833333333333
60028, 0.6875, 0.8, 0.20833333333333
60029, 0.70833333333333, 0.8, 0.1875
60030, 0.70833333333333, 0.825, 0.20833333333333
60031, 0.6875, 0.85, 0.20833333333333
60032, 0.70833333333333, 0.85, 0.1875
60033, 0.70833333333333, 0.875, 0.20833333333333
60034, 0.6875, 0.9, 0.20833333333333
60035, 0.70833333333333, 0.9, 0.1875
60036, 0.70833333333333, 0.925, 0.20833333333333
60037, 0.6875, 0.95, 0.20833333333333
60038, 0.70833333333333, 0.95, 0.1875
60039, 0.70833333333333, 0.975, 0.20833333333333
60040, 0.6875, 1, 0.20833333333333
60041, 0.70833333333333, 1, 0.1875
60042, 0.70833333333333, 1.025, 0.20833333333333
60043, 0.6875, 1.05, 0.20833333333333
60044, 0.70833333333333, 1.05, 0.1875
60045, 0.70833333333333, 1.075, 0.20833333333333
60046, 0.6875, 1.1, 0.20833333333333
60047, 0.70833333333333, 1.1, 0.1875
60048, 0.70833333333333, 1.125, 0.20833333333333
60049, 0.6875, 1.15, 0.20833333333333
60050, 0.70833333333333, 1.15, 0.1875
60051, 0.70833333333333, 1.175, 0.20833333333333
60052, 0.6875, 1.2, 0.20833333333333
60053, 0.70833333333333, 1.2, 0.1875
60054, 0.70833333333333, 1.225, 0.20833333333333
60055, 0.6875, 1.25, 0.20833333333333
60056, 0.70833333333333, 1.25, 0.1875
60057, 0.70833333333333, 1.275, 0.20833333333333
60058, 0.6875, 1.3, 0.20833333333333
60059, 0.70833333333333, 1.3, 0.1875
60060, 0.70833333333333, 1.325, 0.20833333333333
60061, 0.70833333333333, 0.175, 0.25
60062, 0.6875, 0.2, 0.25
60063, 0.70833333333333, 0.2, 0.22916666666667
60064, 0.70833333333333, 0.225, 0.25
60065, 0.6875, 0.25, 0.25
60066, 0.70833333333333, 0.25, 0.22916666666667
60067, 0.70833333333333, 0.275, 0.25
60068, 0.6875, 0.3, 0.25
60069, 0.70833333333333, 0.3, 0.22916666666667
60070, 0.70833333333333, 0.325, 0.25
60071, 0.6875, 0.35, 0.25
60072, 0.70833333333333, 0.35, 0.22916666666667
60073, 0.70833333333333, 0.375, 0.25
60074, 0.6875, 0.4, 0.25
60075, 0.70833333333333, 0.4, 0.22916666666667
60076, 0.70833333333333, 0.425, 0.25
60077, 0.6875, 0.45, 0.25
60078, 0.70833333333333, 0.45, 0.22916666666667
60079, 0.70833333333333, 0.475, 0.25
60080, 0.6875, 0.5, 0.25
60081, 0.70833333333333, 0.5, 0.22916666666667
60082, 0.70833333333333, 0.525, 0.25
60083, 0.6875, 0.55, 0.25
60084, 0.70833333333333, 0.55, 0.22916666666667
60085, 0.70833333333333, 0.575, 0.25
60086, 0.6875, 0.6, 0.25
60087, 0.70833333333333, 0.6, 0.22916666666667
60088, 0.70833333333333, 0.625, 0.25
60089, 0.6875, 0.65, 0.25
60090, 0.70833333333333, 0.65, 0.22916666666667
60091, 0.70833333333333, 0.675, 0.25
60092, 0.6875, 0.7, 0.25
60093, 0.70833333333333, 0.7, 0.22916666666667
60094, 0.70833333333333, 0.725, 0.25
60095, 0.6875, 0.75, 0.25
60096, 0.70833333333333, 0.75, 0.22916666666667
60097, 0.70833333333333, 0.775, 0.25
60098, 0.6875, 0.8, 0.25
60099, 0.70833333333333, 0.8, 0.22916666666667
60100, 0.70833333333333, 0.825, 0.25
60101, 0.6875, 0.85, 0.25
60102, 0.70833333333333, 0.85, 0.22916666666667
60103, 0.70833333333333, 0.875, 0.25
60104, 0.6875, 0.9, 0.25
60105, 0.70833333333333, 0.9, 0.22916666666667
60106, 0.70833333333333, 0.925, 0.25
60107, 0.6875, 0.95, 0.25
60108, 0.70833333333333, 0.95, 0.22916666666667
60109, 0.70833333333333, 0.975, 0.25
60110, 0.6875, 1, 0.25
60111, 0.70833333333333, 1, 0.22916666666667
60112, 0.70833333333333, 1.025, 0.25
60113, 0.6875, 1.05, 0.25
60114, 0.70833333333333, 1.05, 0.22916666666667
60115, 0.70833333333333, 1.075, 0.25
60116, 0.6875, 1.1, 0.25
60117, 0.70833333333333, 1.1, 0.22916666666667
60118, 0.70833333333333, 1.125, 0.25
60119, 0.6875, 1.15, 0.25
60120, 0.70833333333333, 1.15, 0.22916666666667
60121, 0.70833333333333, 1.175, 0.25
60122, 0.6875, 1.2, 0.25
60123, 0.70833333333333, 1.2, 0.22916666666667
60124, 0.70833333333333, 1.225, 0.25
60125, 0.6875, 1.25, 0.25
60126, 0.70833333333333, 1.25, 0.22916666666667
60127, 0.70833333333333, 1.275, 0.25
60128, 0.6875, 1.3, 0.25
60129, 0.70833333333333, 1.3, 0.22916666666667
60130, 0.70833333333333, 1.325, 0.25
60131, 0.70833333333333, 0.175, 0.29166666666667
60132, 0.6875, 0.2, 0.29166666666667
60133, 0.70833333333333, 0.2, 0.27083333333333
60134, 0.70833333333333, 0.225, 0.29166666666667
60135, 0.6875, 0.25, 0.29166666666667
60136, 0.70833333333333, 0.25, 0.27083333333333
60137, 0.70833333333333, 0.275, 0.29166666666667
60138, 0.6875, 0.3, 0.29166666666667
60139, 0.70833333333333, 0.3, 0.27083333333333
60140, 0.70833333333333, 0.325, 0.29166666666667
60141, 0.6875, 0.35, 0.29166666666667
60142, 0.70833333333333, 0.35, 0.27083333333333
60143, 0.70833333333333, 0.375, 0.29166666666667
60144, 0.6875, 0.4, 0.29166666666667
60145, 0.70833333333333, 0.4, 0.27083333333333
60146, 0.70833333333333, 0.425, 0.29166666666667
60147, 0.6875, 0.45, 0.29166666666667
60148, 0.70833333333333, 0.45, 0.27083333333333
60149, 0.70833333333333, 0.475, 0.29166666666667
60150, 0.6875, 0.5, 0.29166666666667
60151, 0.70833333333333, 0.5, 0.27083333333333
60152, 0.70833333333333, 0.525, 0.29166666666667
60153, 0.6875, 0.55, 0.29166666666667
60154, 0.70833333333333, 0.55, 0.27083333333333
60155, 0.70833333333333, 0.575, 0.29166666666667
60156, 0.6875, 0.6, 0.29166666666667
60157, 0.70833333333333, 0.6, 0.27083333333333
60158, 0.70833333333333, 0.625, 0.29166666666667
60159, 0.6875, 0.65, 0.29166666666667
60160, 0.70833333333333, 0.65, 0.27083333333333
60161, 0.70833333333333, 0.675, 0.29166666666667
60162, 0.6875, 0.7, 0.29166666666667
60163, 0.70833333333333, 0.7, 0.27083333333333
60164, 0.70833333333333, 0.725, 0.29166666666667
60165, 0.6875, 0.75, 0.29166666666667
60166, 0.70833333333333, 0.75, 0.27083333333333
60167, 0.70833333333333, 0.775, 0.29166666666667
60168, 0.6875, 0.8, 0.29166666666667
60169, 0.70833333333333, 0.8, 0.27083333333333
60170, 0.70833333333333, 0.825, 0.29166666666667
60171, 0.6875, 0.85, 0.29166666666667
60172, 0.70833333333333, 0.85, 0.27083333333333
60173, 0.70833333333333, 0.875, 0.29166666666667
60174, 0.6875, 0.9, 0.29166666666667
60175, 0.70833333333333, 0.9, 0.27083333333333
60176, 0.70833333333333, 0.925, 0.29166666666667
60177, 0.6875, 0.95, 0.29166666666667
60178, 0.70833333333333, 0.95, 0.27083333333333
60179, 0.70833333333333, 0.975, 0.29166666666667
60180, 0.6875, 1, 0.29166666666667
60181, 0.70833333333333, 1, 0.27083333333333
60182, 0.70833333333333, 1.025, 0.29166666666667
60183, 0.6875, 1.05, 0.29166666666667
60184, 0.70833333333333, 1.05, 0.27083333333333
60185, 0.70833333333333, 1.075, 0.29166666666667
60186, 0.6875, 1.1, 0.29166666666667
60187, 0.70833333333333, 1.1, 0.27083333333333
60188, 0.70833333333333, 1.125, 0.29166666666667
60189, 0.6875, 1.15, 0.29166666666667
60190, 0.70833333333333, 1.15, 0.27083333333333
60191, 0.70833333333333, 1.175, 0.29166666666667
60192, 0.6875, 1.2, 0.29166666666667
60193, 0.70833333333333, 1.2, 0.27083333333333
60194, 0.70833333333333, 1.225, 0.29166666666667
60195, 0.6875, 1.25, 0.29166666666667
60196, 0.70833333333333, 1.25, 0.27083333333333
60197, 0.70833333333333, 1.275, 0.29166666666667
60198, 0.6875, 1.3, 0.29166666666667
60199, 0.70833333333333, 1.3, 0.27083333333333
60200, 0.70833333333333, 1.325, 0.29166666666667
60201, 0.70833333333333, 0.175, 0.33333333333333
60202, 0.6875, 0.2, 0.33333333333333
60203, 0.70833333333333, 0.2, 0.3125
60204, 0.70833333333333, 0.225, 0.33333333333333
60205, 0.6875, 0.25, 0.33333333333333
60206, 0.70833333333333, 0.25, 0.3125
60207, 0.70833333333333, 0.275, 0.33333333333333
60208, 0.6875, 0.3, 0.33333333333333
60209, 0.70833333333333, 0.3, 0.3125
60210, 0.70833333333333, 0.325, 0.33333333333333
60211, 0.6875, 0.35, 0.33333333333333
60212, 0.70833333333333, 0.35, 0.3125
60213, 0.70833333333333, 0.375, 0.33333333333333
60214, 0.6875, 0.4, 0.33333333333333
60215, 0.70833333333333, 0.4, 0.3125
60216, 0.70833333333333, 0.425, 0.33333333333333
60217, 0.6875, 0.45, 0.33333333333333
60218, 0.70833333333333, 0.45, 0.3125
60219, 0.70833333333333, 0.475, 0.33333333333333
60220, 0.6875, 0.5, 0.33333333333333
60221, 0.70833333333333, 0.5, 0.3125
60222, 0.70833333333333, 0.525, 0.33333333333333
60223, 0.6875, 0.55, 0.33333333333333
60224, 0.70833333333333, 0.55, 0.3125
60225, 0.70833333333333, 0.575, 0.33333333333333
60226, 0.6875, 0.6, 0.33333333333333
60227, 0.70833333333333, 0.6, 0.3125
60228, 0.70833333333333, 0.625, 0.33333333333333
60229, 0.6875, 0.65, 0.33333333333333
60230, 0.70833333333333, 0.65, 0.3125
60231, 0.70833333333333, 0.675, 0.33333333333333
60232, 0.6875, 0.7, 0.33333333333333
60233, 0.70833333333333, 0.7, 0.3125
60234, 0.70833333333333, 0.725, 0.33333333333333
60235, 0.6875, 0.75, 0.33333333333333
60236, 0.70833333333333, 0.75, 0.3125
60237, 0.70833333333333, 0.775, 0.33333333333333
60238, 0.6875, 0.8, 0.33333333333333
60239, 0.70833333333333, 0.8, 0.3125
60240, 0.70833333333333, 0.825, 0.33333333333333
60241, 0.6875, 0.85, 0.33333333333333
60242, 0.70833333333333, 0.85, 0.3125
60243, 0.70833333333333, 0.875, 0.33333333333333
60244, 0.6875, 0.9, 0.33333333333333
60245, 0.70833333333333, 0.9, 0.3125
60246, 0.70833333333333, 0.925, 0.33333333333333
60247, 0.6875, 0.95, 0.33333333333333
60248, 0.70833333333333, 0.95, 0.3125
60249, 0.70833333333333, 0.975, 0.33333333333333
60250, 0.6875, 1, 0.33333333333333
60251, 0.70833333333333, 1, 0.3125
60252, 0.70833333333333, 1.025, 0.33333333333333
60253, 0.6875, 1.05, 0.33333333333333
60254, 0.70833333333333, 1.05, 0.3125
60255, 0.70833333333333, 1.075, 0.33333333333333
60256, 0.6875, 1.1, 0.33333333333333
60257, 0.70833333333333, 1.1, 0.3125
60258, 0.70833333333333, 1.125, 0.33333333333333
60259, 0.6875, 1.15, 0.33333333333333
60260, 0.70833333333333, 1.15, 0.3125
60261, 0.70833333333333, 1.175, 0.33333333333333
60262, 0.6875, 1.2, 0.33333333333333
60263, 0.70833333333333, 1.2, 0.3125
60264, 0.70833333333333, 1.225, 0.33333333333333
60265, 0.6875, 1.25, 0.33333333333333
60266, 0.70833333333333, 1.25, 0.3125
60267, 0.70833333333333, 1.275, 0.33333333333333
60268, 0.6875, 1.3, 0.33333333333333
60269, 0.70833333333333, 1.3, 0.3125
60270, 0.70833333333333, 1.325, 0.33333333333333
60271, 0.70833333333333, 0.175, 0.375
60272, 0.6875, 0.2, 0.375
60273, 0.70833333333333, 0.2, 0.35416666666667
60274, 0.70833333333333, 0.225, 0.375
60275, 0.6875, 0.25, 0.375
60276, 0.70833333333333, 0.25, 0.35416666666667
60277, 0.70833333333333, 0.275, 0.375
60278, 0.6875, 0.3, 0.375
60279, 0.70833333333333, 0.3, 0.35416666666667
60280, 0.70833333333333, 0.325, 0.375
60281, 0.6875, 0.35, 0.375
60282, 0.70833333333333, 0.35, 0.35416666666667
60283, 0.70833333333333, 0.375, 0.375
60284, 0.6875, 0.4, 0.375
60285, 0.70833333333333, 0.4, 0.35416666666667
60286, 0.70833333333333, 0.425, 0.375
60287, 0.6875, 0.45, 0.375
60288, 0.70833333333333, 0.45, 0.35416666666667
60289, 0.70833333333333, 0.475, 0.375
60290, 0.6875, 0.5, 0.375
60291, 0.70833333333333, 0.5, 0.35416666666667
60292, 0.70833333333333, 0.525, 0.375
60293, 0.6875, 0.55, 0.375
60294, 0.70833333333333, 0.55, 0.35416666666667
60295, 0.70833333333333, 0.575, 0.375
60296, 0.6875, 0.6, 0.375
60297, 0.70833333333333, 0.6, 0.35416666666667
60298, 0.70833333333333, 0.625, 0.375
60299, 0.6875, 0.65, 0.375
60300, 0.70833333333333, 0.65, 0.35416666666667
60301, 0.70833333333333, 0.675, 0.375
60302, 0.6875, 0.7, 0.375
60303, 0.70833333333333, 0.7, 0.35416666666667
60304, 0.70833333333333, 0.725, 0.375
60305, 0.6875, 0.75, 0.375
60306, 0.70833333333333, 0.75, 0.35416666666667
60307, 0.70833333333333, 0.775, 0.375
60308, 0.6875, 0.8, 0.375
60309, 0.70833333333333, 0.8, 0.35416666666667
60310, 0.70833333333333, 0.825, 0.375
60311, 0.6875, 0.85, 0.375
60312, 0.70833333333333, 0.85, 0.35416666666667
60313, 0.70833333333333, 0.875, 0.375
60314, 0.6875, 0.9, 0.375
60315, 0.70833333333333, 0.9, 0.35416666666667
60316, 0.70833333333333, 0.925, 0.375
60317, 0.6875, 0.95, 0.375
60318, 0.70833333333333, 0.95, 0.35416666666667
60319, 0.70833333333333, 0.975, 0.375
60320, 0.6875, 1, 0.375
60321, 0.70833333333333, 1, 0.35416666666667
60322, 0.70833333333333, 1.025, 0.375
60323, 0.6875, 1.05, 0.375
60324, 0.70833333333333, 1.05, 0.35416666666667
60325, 0.70833333333333, 1.075, 0.375
60326, 0.6875, 1.1, 0.375
60327, 0.70833333333333, 1.1, 0.35416666666667
60328, 0.70833333333333, 1.125, 0.375
60329, 0.6875, 1.15, 0.375
60330, 0.70833333333333, 1.15, 0.35416666666667
60331, 0.70833333333333, 1.175, 0.375
60332, 0.6875, 1.2, 0.375
60333, 0.70833333333333, 1.2, 0.35416666666667
60334, 0.70833333333333, 1.225, 0.375
60335, 0.6875, 1.25, 0.375
60336, 0.70833333333333, 1.25, 0.35416666666667
60337, 0.70833333333333, 1.275, 0.375
60338, 0.6875, 1.3, 0.375
60339, 0.70833333333333, 1.3, 0.35416666666667
60340, 0.70833333333333, 1.325, 0.375
60341, 0.70833333333333, 0.175, 0.41666666666667
60342, 0.6875, 0.2, 0.41666666666667
60343, 0.70833333333333, 0.2, 0.39583333333333
60344, 0.70833333333333, 0.225, 0.41666666666667
60345, 0.6875, 0.25, 0.41666666666667
60346, 0.70833333333333, 0.25, 0.39583333333333
60347, 0.70833333333333, 0.275, 0.41666666666667
60348, 0.6875, 0.3, 0.41666666666667
60349, 0.70833333333333, 0.3, 0.39583333333333
60350, 0.70833333333333, 0.325, 0.41666666666667
60351, 0.6875, 0.35, 0.41666666666667
60352, 0.70833333333333, 0.35, 0.39583333333333
60353, 0.70833333333333, 0.375, 0.41666666666667
60354, 0.6875, 0.4, 0.41666666666667
60355, 0.70833333333333, 0.4, 0.39583333333333
60356, 0.70833333333333, 0.425, 0.41666666666667
60357, 0.6875, 0.45, 0.41666666666667
60358, 0.70833333333333, 0.45, 0.39583333333333
60359, 0.70833333333333, 0.475, 0.41666666666667
60360, 0.6875, 0.5, 0.41666666666667
60361, 0.70833333333333, 0.5, 0.39583333333333
60362, 0.70833333333333, 0.525, 0.41666666666667
60363, 0.6875, 0.55, 0.41666666666667
60364, 0.70833333333333, 0.55, 0.39583333333333
60365, 0.70833333333333, 0.575, 0.41666666666667
60366, 0.6875, 0.6, 0.41666666666667
60367, 0.70833333333333, 0.6, 0.39583333333333
60368, 0.70833333333333, 0.625, 0.41666666666667
60369, 0.6875, 0.65, 0.41666666666667
60370, 0.70833333333333, 0.65, 0.39583333333333
60371, 0.70833333333333, 0.675, 0.41666666666667
60372, 0.6875, 0.7, 0.41666666666667
60373, 0.70833333333333, 0.7, 0.39583333333333
60374, 0.70833333333333, 0.725, 0.41666666666667
60375, 0.6875, 0.75, 0.41666666666667
60376, 0.70833333333333, 0.75, 0.39583333333333
60377, 0.70833333333333, 0.775, 0.41666666666667
60378, 0.6875, 0.8, 0.41666666666667
60379, 0.70833333333333, 0.8, 0.39583333333333
60380, 0.70833333333333, 0.825, 0.41666666666667
60381, 0.6875, 0.85, 0.41666666666667
60382, 0.70833333333333, 0.85, 0.39583333333333
60383, 0.70833333333333, 0.875, 0.41666666666667
60384, 0.6875, 0.9, 0.41666666666667
60385, 0.70833333333333, 0.9, 0.39583333333333
60386, 0.70833333333333, 0.925, 0.41666666666667
60387, 0.6875, 0.95, 0.41666666666667
60388, 0.70833333333333, 0.95, 0.39583333333333
60389, 0.70833333333333, 0.975, 0.41666666666667
60390, 0.6875, 1, 0.41666666666667
60391, 0.70833333333333, 1, 0.39583333333333
60392, 0.70833333333333, 1.025, 0.41666666666667
60393, 0.6875, 1.05, 0.41666666666667
60394, 0.70833333333333, 1.05, 0.39583333333333
60395, 0.70833333333333, 1.075, 0.41666666666667
60396, 0.6875, 1.1, 0.41666666666667
60397, 0.70833333333333, 1.1, 0.39583333333333
60398, 0.70833333333333, 1.125, 0.41666666666667
60399, 0.6875, 1.15, 0.41666666666667
60400, 0.70833333333333, 1.15, 0.39583333333333
60401, 0.70833333333333, 1.175, 0.41666666666667
60402, 0.6875, 1.2, 0.41666666666667
60403, 0.70833333333333, 1.2, 0.39583333333333
60404, 0.70833333333333, 1.225, 0.41666666666667
60405, 0.6875, 1.25, 0.41666666666667
60406, 0.70833333333333, 1.25, 0.39583333333333
60407, 0.70833333333333, 1.275, 0.41666666666667
60408, 0.6875, 1.3, 0.41666666666667
60409, 0.70833333333333, 1.3, 0.39583333333333
60410, 0.70833333333333, 1.325, 0.41666666666667
60411, 0.70833333333333, 0.175, 0.45833333333333
60412, 0.6875, 0.2, 0.45833333333333
60413, 0.70833333333333, 0.2, 0.4375
60414, 0.70833333333333, 0.225, 0.45833333333333
60415, 0.6875, 0.25, 0.45833333333333
60416, 0.70833333333333, 0.25, 0.4375
60417, 0.70833333333333, 0.275, 0.45833333333333
60418, 0.6875, 0.3, 0.45833333333333
60419, 0.70833333333333, 0.3, 0.4375
60420, 0.70833333333333, 0.325, 0.45833333333333
60421, 0.6875, 0.35, 0.45833333333333
60422, 0.70833333333333, 0.35, 0.4375
60423, 0.70833333333333, 0.375, 0.45833333333333
60424, 0.6875, 0.4, 0.45833333333333
60425, 0.70833333333333, 0.4, 0.4375
60426, 0.70833333333333, 0.425, 0.45833333333333
60427, 0.6875, 0.45, 0.45833333333333
60428, 0.70833333333333, 0.45, 0.4375
60429, 0.70833333333333, 0.475, 0.45833333333333
60430, 0.6875, 0.5, 0.45833333333333
60431, 0.70833333333333, 0.5, 0.4375
60432, 0.70833333333333, 0.525, 0.45833333333333
60433, 0.6875, 0.55, 0.45833333333333
60434, 0.70833333333333, 0.55, 0.4375
60435, 0.70833333333333, 0.575, 0.45833333333333
60436, 0.6875, 0.6, 0.45833333333333
60437, 0.70833333333333, 0.6, 0.4375
60438, 0.70833333333333, 0.625, 0.45833333333333
60439, 0.6875, 0.65, 0.45833333333333
60440, 0.70833333333333, 0.65, 0.4375
60441, 0.70833333333333, 0.675, 0.45833333333333
60442, 0.6875, 0.7, 0.45833333333333
60443, 0.70833333333333, 0.7, 0.4375
60444, 0.70833333333333, 0.725, 0.45833333333333
60445, 0.6875, 0.75, 0.45833333333333
60446, 0.70833333333333, 0.75, 0.4375
60447, 0.70833333333333, 0.775, 0.45833333333333
60448, 0.6875, 0.8, 0.45833333333333
60449, 0.70833333333333, 0.8, 0.4375
60450, 0.70833333333333, 0.825, 0.45833333333333
60451, 0.6875, 0.85, 0.45833333333333
60452, 0.70833333333333, 0.85, 0.4375
60453, 0.70833333333333, 0.875, 0.45833333333333
60454, 0.6875, 0.9, 0.45833333333333
60455, 0.70833333333333, 0.9, 0.4375
60456, 0.70833333333333, 0.925, 0.45833333333333
60457, 0.6875, 0.95, 0.45833333333333
60458, 0.70833333333333, 0.95, 0.4375
60459, 0.70833333333333, 0.975, 0.45833333333333
60460, 0.6875, 1, 0.45833333333333
60461, 0.70833333333333, 1, 0.4375
60462, 0.70833333333333, 1.025, 0.45833333333333
60463, 0.6875, 1.05, 0.45833333333333
60464, 0.70833333333333, 1.05, 0.4375
60465, 0.70833333333333, 1.075, 0.45833333333333
60466, 0.6875, 1.1, 0.45833333333333
60467, 0.70833333333333, 1.1, 0.4375
60468, 0.70833333333333, 1.125, 0.45833333333333
60469, 0.6875, 1.15, 0.45833333333333
60470, 0.70833333333333, 1.15, 0.4375
60471, 0.70833333333333, 1.175, 0.45833333333333
60472, 0.6875, 1.2, 0.45833333333333
60473, 0.70833333333333, 1.2, 0.4375
60474, 0.70833333333333, 1.225, 0.45833333333333
60475, 0.6875, 1.25, 0.45833333333333
60476, 0.70833333333333, 1.25, 0.4375
60477, 0.70833333333333, 1.275, 0.45833333333333
60478, 0.6875, 1.3, 0.45833333333333
60479, 0.70833333333333, 1.3, 0.4375
60480, 0.70833333333333, 1.325, 0.45833333333333
60481, 0.70833333333333, 0.2, 0.47916666666667
60482, 0.70833333333333, 0.25, 0.47916666666667
60483, 0.70833333333333, 0.3, 0.47916666666667
60484, 0.70833333333333, 0.35, 0.47916666666667
60485, 0.70833333333333, 0.4, 0.47916666666667
60486, 0.70833333333333, 0.45, 0.47916666666667
60487, 0.70833333333333, 0.5, 0.47916666666667
60488, 0.70833333333333, 0.55, 0.47916666666667
60489, 0.70833333333333, 0.6, 0.47916666666667
60490, 0.70833333333333, 0.65, 0.47916666666667
60491, 0.70833333333333, 0.7, 0.47916666666667
60492, 0.70833333333333, 0.75, 0.47916666666667
60493, 0.70833333333333, 0.8, 0.47916666666667
60494, 0.70833333333333, 0.85, 0.47916666666667
60495, 0.70833333333333, 0.9, 0.47916666666667
60496, 0.70833333333333, 0.95, 0.47916666666667
60497, 0.70833333333333, 1, 0.47916666666667
60498, 0.70833333333333, 1.05, 0.47916666666667
60499, 0.70833333333333, 1.1, 0.47916666666667
60500, 0.70833333333333, 1.15, 0.47916666666667
60501, 0.70833333333333, 1.2, 0.47916666666667
60502, 0.70833333333333, 1.25, 0.47916666666667
60503, 0.70833333333333, 1.3, 0.47916666666667
60504, 0.75, 0.175, 0.041666666666667
60505, 0.72916666666667, 0.2, 0.041666666666667
60506, 0.75, 0.2, 0.020833333333333
60507, 0.75, 0.225, 0.041666666666667
60508, 0.72916666666667, 0.25, 0.041666666666667
60509, 0.75, 0.25, 0.020833333333333
60510, 0.75, 0.275, 0.041666666666667
60511, 0.72916666666667, 0.3, 0.041666666666667
60512, 0.75, 0.3, 0.020833333333333
60513, 0.75, 0.325, 0.041666666666667
60514, 0.72916666666667, 0.35, 0.041666666666667
60515, 0.75, 0.35, 0.020833333333333
60516, 0.75, 0.375, 0.041666666666667
60517, 0.72916666666667, 0.4, 0.041666666666667
60518, 0.75, 0.4, 0.020833333333333
60519, 0.75, 0.425, 0.041666666666667
60520, 0.72916666666667, 0.45, 0.041666666666667
60521, 0.75, 0.45, 0.020833333333333
60522, 0.75, 0.475, 0.041666666666667
60523, 0.72916666666667, 0.5, 0.041666666666667
60524, 0.75, 0.5, 0.020833333333333
60525, 0.75, 0.525, 0.041666666666667
60526, 0.72916666666667, 0.55, 0.041666666666667
60527, 0.75, 0.55, 0.020833333333333
60528, 0.75, 0.575, 0.041666666666667
60529, 0.72916666666667, 0.6, 0.041666666666667
60530, 0.75, 0.6, 0.020833333333333
60531, 0.75, 0.625, 0.041666666666667
60532, 0.72916666666667, 0.65, 0.041666666666667
60533, 0.75, 0.65, 0.020833333333333
60534, 0.75, 0.675, 0.041666666666667
60535, 0.72916666666667, 0.7, 0.041666666666667
60536, 0.75, 0.7, 0.020833333333333
60537, 0.75, 0.725, 0.041666666666667
60538, 0.72916666666667, 0.75, 0.041666666666667
60539, 0.75, 0.75, 0.020833333333333
60540, 0.75, 0.775, 0.041666666666667
60541, 0.72916666666667, 0.8, 0.041666666666667
60542, 0.75, 0.8, 0.020833333333333
60543, 0.75, 0.825, 0.041666666666667
60544, 0.72916666666667, 0.85, 0.041666666666667
60545, 0.75, 0.85, 0.020833333333333
60546, 0.75, 0.875, 0.041666666666667
60547, 0.72916666666667, 0.9, 0.041666666666667
60548, 0.75, 0.9, 0.020833333333333
60549, 0.75, 0.925, 0.041666666666667
60550, 0.72916666666667, 0.95, 0.041666666666667
60551, 0.75, 0.95, 0.020833333333333
60552, 0.75, 0.975, 0.041666666666667
60553, 0.72916666666667, 1, 0.041666666666667
60554, 0.75, 1, 0.020833333333333
60555, 0.75, 1.025, 0.041666666666667
60556, 0.72916666666667, 1.05, 0.041666666666667
60557, 0.75, 1.05, 0.020833333333333
60558, 0.75, 1.075, 0.041666666666667
60559, 0.72916666666667, 1.1, 0.041666666666667
60560, 0.75, 1.1, 0.020833333333333
60561, 0.75, 1.125, 0.041666666666667
60562, 0.72916666666667, 1.15, 0.041666666666667
60563, 0.75, 1.15, 0.020833333333333
60564, 0.75, 1.175, 0.041666666666667
60565, 0.72916666666667, 1.2, 0.041666666666667
60566, 0.75, 1.2, 0.020833333333333
60567, 0.75, 1.225, 0.041666666666667
60568, 0.72916666666667, 1.25, 0.041666666666667
60569, 0.75, 1.25, 0.020833333333333
60570, 0.75, 1.275, 0.041666666666667
60571, 0.72916666666667, 1.3, 0.041666666666667
60572, 0.75, 1.3, 0.020833333333333
60573, 0.75, 1.325, 0.041666666666667
60574, 0.75, 0.175, 0.083333333333333
60575, 0.72916666666667, 0.2, 0.083333333333333
60576, 0.75, 0.2, 0.0625
60577, 0.75, 0.225, 0.083333333333333
60578, 0.72916666666667, 0.25, 0.083333333333333
60579, 0.75, 0.25, 0.0625
60580, 0.75, 0.275, 0.083333333333333
60581, 0.72916666666667, 0.3, 0.083333333333333
60582, 0.75, 0.3, 0.0625
60583, 0.75, 0.325, 0.083333333333333
60584, 0.72916666666667, 0.35, 0.083333333333333
60585, 0.75, 0.35, 0.0625
60586, 0.75, 0.375, 0.083333333333333
60587, 0.72916666666667, 0.4, 0.083333333333333
60588, 0.75, 0.4, 0.0625
60589, 0.75, 0.425, 0.083333333333333
60590, 0.72916666666667, 0.45, 0.083333333333333
60591, 0.75, 0.45, 0.0625
60592, 0.75, 0.475, 0.083333333333333
60593, 0.72916666666667, 0.5, 0.083333333333333
60594, 0.75, 0.5, 0.0625
60595, 0.75, 0.525, 0.083333333333333
60596, 0.72916666666667, 0.55, 0.083333333333333
60597, 0.75, 0.55, 0.0625
60598, 0.75, 0.575, 0.083333333333333
60599, 0.72916666666667, 0.6, 0.083333333333333
60600, 0.75, 0.6, 0.0625
60601, 0.75, 0.625, 0.083333333333333
60602, 0.72916666666667, 0.65, 0.083333333333333
60603, 0.75, 0.65, 0.0625
60604, 0.75, 0.675, 0.083333333333333
60605, 0.72916666666667, 0.7, 0.083333333333333
60606, 0.75, 0.7, 0.0625
60607, 0.75, 0.725, 0.083333333333333
60608, 0.72916666666667, 0.75, 0.083333333333333
60609, 0.75, 0.75, 0.0625
60610, 0.75, 0.775, 0.083333333333333
60611, 0.72916666666667, 0.8, 0.083333333333333
60612, 0.75, 0.8, 0.0625
60613, 0.75, 0.825, 0.083333333333333
60614, 0.72916666666667, 0.85, 0.083333333333333
60615, 0.75, 0.85, 0.0625
60616, 0.75, 0.875, 0.083333333333333
60617, 0.72916666666667, 0.9, 0.083333333333333
60618, 0.75, 0.9, 0.0625
60619, 0.75, 0.925, 0.083333333333333
60620, 0.72916666666667, 0.95, 0.083333333333333
60621, 0.75, 0.95, 0.0625
60622, 0.75, 0.975, 0.083333333333333
60623, 0.72916666666667, 1, 0.083333333333333
60624, 0.75, 1, 0.0625
60625, 0.75, 1.025, 0.083333333333333
60626, 0.72916666666667, 1.05, 0.083333333333333
60627, 0.75, 1.05, 0.0625
60628, 0.75, 1.075, 0.083333333333333
60629, 0.72916666666667, 1.1, 0.083333333333333
60630, 0.75, 1.1, 0.0625
60631, 0.75, 1.125, 0.083333333333333
60632, 0.72916666666667, 1.15, 0.083333333333333
60633, 0.75, 1.15, 0.0625
60634, 0.75, 1.175, 0.083333333333333
60635, 0.72916666666667, 1.2, 0.083333333333333
60636, 0.75, 1.2, 0.0625
60637, 0.75, 1.225, 0.083333333333333
60638, 0.72916666666667, 1.25, 0.083333333333333
60639, 0.75, 1.25, 0.0625
60640, 0.75, 1.275, 0.083333333333333
60641, 0.72916666666667, 1.3, 0.083333333333333
60642, 0.75, 1.3, 0.0625
60643, 0.75, 1.325, 0.083333333333333
60644, 0.75, 0.175, 0.125
60645, 0.72916666666667, 0.2, 0.125
60646, 0.75, 0.2, 0.10416666666667
60647, 0.75, 0.225, 0.125
60648, 0.72916666666667, 0.25, 0.125
60649, 0.75, 0.25, 0.10416666666667
60650, 0.75, 0.275, 0.125
60651, 0.72916666666667, 0.3, 0.125
60652, 0.75, 0.3, 0.10416666666667
60653, 0.75, 0.325, 0.125
60654, 0.72916666666667, 0.35, 0.125
60655, 0.75, 0.35, 0.10416666666667
60656, 0.75, 0.375, 0.125
60657, 0.72916666666667, 0.4, 0.125
60658, 0.75, 0.4, 0.10416666666667
60659, 0.75, 0.425, 0.125
60660, 0.72916666666667, 0.45, 0.125
60661, 0.75, 0.45, 0.10416666666667
60662, 0.75, 0.475, 0.125
60663, 0.72916666666667, 0.5, 0.125
60664, 0.75, 0.5, 0.10416666666667
60665, 0.75, 0.525, 0.125
60666, 0.72916666666667, 0.55, 0.125
60667, 0.75, 0.55, 0.10416666666667
60668, 0.75, 0.575, 0.125
60669, 0.72916666666667, 0.6, 0.125
60670, 0.75, 0.6, 0.10416666666667
60671, 0.75, 0.625, 0.125
60672, 0.72916666666667, 0.65, 0.125
60673, 0.75, 0.65, 0.10416666666667
60674, 0.75, 0.675, 0.125
60675, 0.72916666666667, 0.7, 0.125
60676, 0.75, 0.7, 0.10416666666667
60677, 0.75, 0.725, 0.125
60678, 0.72916666666667, 0.75, 0.125
60679, 0.75, 0.75, 0.10416666666667
60680, 0.75, 0.775, 0.125
60681, 0.72916666666667, 0.8, 0.125
60682, 0.75, 0.8, 0.10416666666667
60683, 0.75, 0.825, 0.125
60684, 0.72916666666667, 0.85, 0.125
60685, 0.75, 0.85, 0.10416666666667
60686, 0.75, 0.875, 0.125
60687, 0.72916666666667, 0.9, 0.125
60688, 0.75, 0.9, 0.10416666666667
60689, 0.75, 0.925, 0.125
60690, 0.72916666666667, 0.95, 0.125
60691, 0.75, 0.95, 0.10416666666667
60692, 0.75, 0.975, 0.125
60693, 0.72916666666667, 1, 0.125
60694, 0.75, 1, 0.10416666666667
60695, 0.75, 1.025, 0.125
60696, 0.72916666666667, 1.05, 0.125
60697, 0.75, 1.05, 0.10416666666667
60698, 0.75, 1.075, 0.125
60699, 0.72916666666667, 1.1, 0.125
60700, 0.75, 1.1, 0.10416666666667
60701, 0.75, 1.125, 0.125
60702, 0.72916666666667, 1.15, 0.125
60703, 0.75, 1.15, 0.10416666666667
60704, 0.75, 1.175, 0.125
60705, 0.72916666666667, 1.2, 0.125
60706, 0.75, 1.2, 0.10416666666667
60707, 0.75, 1.225, 0.125
60708, 0.72916666666667, 1.25, 0.125
60709, 0.75, 1.25, 0.10416666666667
60710, 0.75, 1.275, 0.125
60711, 0.72916666666667, 1.3, 0.125
60712, 0.75, 1.3, 0.10416666666667
60713, 0.75, 1.325, 0.125
60714, 0.75, 0.175, 0.16666666666667
60715, 0.72916666666667, 0.2, 0.16666666666667
60716, 0.75, 0.2, 0.14583333333333
60717, 0.75, 0.225, 0.16666666666667
60718, 0.72916666666667, 0.25, 0.16666666666667
60719, 0.75, 0.25, 0.14583333333333
60720, 0.75, 0.275, 0.16666666666667
60721, 0.72916666666667, 0.3, 0.16666666666667
60722, 0.75, 0.3, 0.14583333333333
60723, 0.75, 0.325, 0.16666666666667
60724, 0.72916666666667, 0.35, 0.16666666666667
60725, 0.75, 0.35, 0.14583333333333
60726, 0.75, 0.375, 0.16666666666667
60727, 0.72916666666667, 0.4, 0.16666666666667
60728, 0.75, 0.4, 0.14583333333333
60729, 0.75, 0.425, 0.16666666666667
60730, 0.72916666666667, 0.45, 0.16666666666667
60731, 0.75, 0.45, 0.14583333333333
60732, 0.75, 0.475, 0.16666666666667
60733, 0.72916666666667, 0.5, 0.16666666666667
60734, 0.75, 0.5, 0.14583333333333
60735, 0.75, 0.525, 0.16666666666667
60736, 0.72916666666667, 0.55, 0.16666666666667
60737, 0.75, 0.55, 0.14583333333333
60738, 0.75, 0.575, 0.16666666666667
60739, 0.72916666666667, 0.6, 0.16666666666667
60740, 0.75, 0.6, 0.14583333333333
60741, 0.75, 0.625, 0.16666666666667
60742, 0.72916666666667, 0.65, 0.16666666666667
60743, 0.75, 0.65, 0.14583333333333
60744, 0.75, 0.675, 0.16666666666667
60745, 0.72916666666667, 0.7, 0.16666666666667
60746, 0.75, 0.7, 0.14583333333333
60747, 0.75, 0.725, 0.16666666666667
60748, 0.72916666666667, 0.75, 0.16666666666667
60749, 0.75, 0.75, 0.14583333333333
60750, 0.75, 0.775, 0.16666666666667
60751, 0.72916666666667, 0.8, 0.16666666666667
60752, 0.75, 0.8, 0.14583333333333
60753, 0.75, 0.825, 0.16666666666667
60754, 0.72916666666667, 0.85, 0.16666666666667
60755, 0.75, 0.85, 0.14583333333333
60756, 0.75, 0.875, 0.16666666666667
60757, 0.72916666666667, 0.9, 0.16666666666667
60758, 0.75, 0.9, 0.14583333333333
60759, 0.75, 0.925, 0.16666666666667
60760, 0.72916666666667, 0.95, 0.16666666666667
60761, 0.75, 0.95, 0.14583333333333
60762, 0.75, 0.975, 0.16666666666667
60763, 0.72916666666667, 1, 0.16666666666667
60764, 0.75, 1, 0.14583333333333
60765, 0.75, 1.025, 0.16666666666667
60766, 0.72916666666667, 1.05, 0.16666666666667
60767, 0.75, 1.05, 0.14583333333333
60768, 0.75, 1.075, 0.16666666666667
60769, 0.72916666666667, 1.1, 0.16666666666667
60770, 0.75, 1.1, 0.14583333333333
60771, 0.75, 1.125, 0.16666666666667
60772, 0.72916666666667, 1.15, 0.16666666666667
60773, 0.75, 1.15, 0.14583333333333
60774, 0.75, 1.175, 0.16666666666667
60775, 0.72916666666667, 1.2, 0.16666666666667
60776, 0.75, 1.2, 0.14583333333333
60777, 0.75, 1.225, 0.16666666666667
60778, 0.72916666666667, 1.25, 0.16666666666667
60779, 0.75, 1.25, 0.14583333333333
60780, 0.75, 1.275, 0.16666666666667
60781, 0.72916666666667, 1.3, 0.16666666666667
60782, 0.75, 1.3, 0.14583333333333
60783, 0.75, 1.325, 0.16666666666667
60784, 0.75, 0.175, 0.20833333333333
60785, 0.72916666666667, 0.2, 0.20833333333333
60786, 0.75, 0.2, 0.1875
60787, 0.75, 0.225, 0.20833333333333
60788, 0.72916666666667, 0.25, 0.20833333333333
60789, 0.75, 0.25, 0.1875
60790, 0.75, 0.275, 0.20833333333333
60791, 0.72916666666667, 0.3, 0.20833333333333
60792, 0.75, 0.3, 0.1875
60793, 0.75, 0.325, 0.20833333333333
60794, 0.72916666666667, 0.35, 0.20833333333333
60795, 0.75, 0.35, 0.1875
60796, 0.75, 0.375, 0.20833333333333
60797, 0.72916666666667, 0.4, 0.20833333333333
60798, 0.75, 0.4, 0.1875
60799, 0.75, 0.425, 0.20833333333333
60800, 0.72916666666667, 0.45, 0.20833333333333
60801, 0.75, 0.45, 0.1875
60802, 0.75, 0.475, 0.20833333333333
60803, 0.72916666666667, 0.5, 0.20833333333333
60804, 0.75, 0.5, 0.1875
60805, 0.75, 0.525, 0.20833333333333
60806, 0.72916666666667, 0.55, 0.20833333333333
60807, 0.75, 0.55, 0.1875
60808, 0.75, 0.575, 0.20833333333333
60809, 0.72916666666667, 0.6, 0.20833333333333
60810, 0.75, 0.6, 0.1875
60811, 0.75, 0.625, 0.20833333333333
60812, 0.72916666666667, 0.65, 0.20833333333333
60813, 0.75, 0.65, 0.1875
60814, 0.75, 0.675, 0.20833333333333
60815, 0.72916666666667, 0.7, 0.20833333333333
60816, 0.75, 0.7, 0.1875
60817, 0.75, 0.725, 0.20833333333333
60818, 0.72916666666667, 0.75, 0.20833333333333
60819, 0.75, 0.75, 0.1875
60820, 0.75, 0.775, 0.20833333333333
60821, 0.72916666666667, 0.8, 0.20833333333333
60822, 0.75, 0.8, 0.1875
60823, 0.75, 0.825, 0.20833333333333
60824, 0.72916666666667, 0.85, 0.20833333333333
60825, 0.75, 0.85, 0.1875
60826, 0.75, 0.875, 0.20833333333333
60827, 0.72916666666667, 0.9, 0.20833333333333
60828, 0.75, 0.9, 0.1875
60829, 0.75, 0.925, 0.20833333333333
60830, 0.72916666666667, 0.95, 0.20833333333333
60831, 0.75, 0.95, 0.1875
60832, 0.75, 0.975, 0.20833333333333
60833, 0.72916666666667, 1, 0.20833333333333
60834, 0.75, 1, 0.1875
60835, 0.75, 1.025, 0.20833333333333
60836, 0.72916666666667, 1.05, 0.20833333333333
60837, 0.75, 1.05, 0.1875
60838, 0.75, 1.075, 0.20833333333333
60839, 0.72916666666667, 1.1, 0.20833333333333
60840, 0.75, 1.1, 0.1875
60841, 0.75, 1.125, 0.20833333333333
60842, 0.72916666666667, 1.15, 0.20833333333333
60843, 0.75, 1.15, 0.1875
60844, 0.75, 1.175, 0.20833333333333
60845, 0.72916666666667, 1.2, 0.20833333333333
60846, 0.75, 1.2, 0.1875
60847, 0.75, 1.225, 0.20833333333333
60848, 0.72916666666667, 1.25, 0.20833333333333
60849, 0.75, 1.25, 0.1875
60850, 0.75, 1.275, 0.20833333333333
60851, 0.72916666666667, 1.3, 0.20833333333333
60852, 0.75, 1.3, 0.1875
60853, 0.75, 1.325, 0.20833333333333
60854, 0.75, 0.175, 0.25
60855, 0.72916666666667, 0.2, 0.25
60856, 0.75, 0.2, 0.22916666666667
60857, 0.75, 0.225, 0.25
60858, 0.72916666666667, 0.25, 0.25
60859, 0.75, 0.25, 0.22916666666667
60860, 0.75, 0.275, 0.25
60861, 0.72916666666667, 0.3, 0.25
60862, 0.75, 0.3, 0.22916666666667
60863, 0.75, 0.325, 0.25
60864, 0.72916666666667, 0.35, 0.25
60865, 0.75, 0.35, 0.22916666666667
60866, 0.75, 0.375, 0.25
60867, 0.72916666666667, 0.4, 0.25
60868, 0.75, 0.4, 0.22916666666667
60869, 0.75, 0.425, 0.25
60870, 0.72916666666667, 0.45, 0.25
60871, 0.75, 0.45, 0.22916666666667
60872, 0.75, 0.475, 0.25
60873, 0.72916666666667, 0.5, 0.25
60874, 0.75, 0.5, 0.22916666666667
60875, 0.75, 0.525, 0.25
60876, 0.72916666666667, 0.55, 0.25
60877, 0.75, 0.55, 0.22916666666667
60878, 0.75, 0.575, 0.25
60879, 0.72916666666667, 0.6, 0.25
60880, 0.75, 0.6, 0.22916666666667
60881, 0.75, 0.625, 0.25
60882, 0.72916666666667, 0.65, 0.25
60883, 0.75, 0.65, 0.22916666666667
60884, 0.75, 0.675, 0.25
60885, 0.72916666666667, 0.7, 0.25
60886, 0.75, 0.7, 0.22916666666667
60887, 0.75, 0.725, 0.25
60888, 0.72916666666667, 0.75, 0.25
60889, 0.75, 0.75, 0.22916666666667
60890, 0.75, 0.775, 0.25
60891, 0.72916666666667, 0.8, 0.25
60892, 0.75, 0.8, 0.22916666666667
60893, 0.75, 0.825, 0.25
60894, 0.72916666666667, 0.85, 0.25
60895, 0.75, 0.85, 0.22916666666667
60896, 0.75, 0.875, 0.25
60897, 0.72916666666667, 0.9, 0.25
60898, 0.75, 0.9, 0.22916666666667
60899, 0.75, 0.925, 0.25
60900, 0.72916666666667, 0.95, 0.25
60901, 0.75, 0.95, 0.22916666666667
60902, 0.75, 0.975, 0.25
60903, 0.72916666666667, 1, 0.25
60904, 0.75, 1, 0.22916666666667
60905, 0.75, 1.025, 0.25
60906, 0.72916666666667, 1.05, 0.25
60907, 0.75, 1.05, 0.22916666666667
60908, 0.75, 1.075, 0.25
60909, 0.72916666666667, 1.1, 0.25
60910, 0.75, 1.1, 0.22916666666667
60911, 0.75, 1.125, 0.25
60912, 0.72916666666667, 1.15, 0.25
60913, 0.75, 1.15, 0.22916666666667
60914, 0.75, 1.175, 0.25
60915, 0.72916666666667, 1.2, 0.25
60916, 0.75, 1.2, 0.22916666666667
60917, 0.75, 1.225, 0.25
60918, 0.72916666666667, 1.25, 0.25
60919, 0.75, 1.25, 0.22916666666667
60920, 0.75, 1.275, 0.25
60921, 0.72916666666667, 1.3, 0.25
60922, 0.75, 1.3, 0.22916666666667
60923, 0.75, 1.325, 0.25
60924, 0.75, 0.175, 0.29166666666667
60925, 0.72916666666667, 0.2, 0.29166666666667
60926, 0.75, 0.2, 0.27083333333333
60927, 0.75, 0.225, 0.29166666666667
60928, 0.72916666666667, 0.25, 0.29166666666667
60929, 0.75, 0.25, 0.27083333333333
60930, 0.75, 0.275, 0.29166666666667
60931, 0.72916666666667, 0.3, 0.29166666666667
60932, 0.75, 0.3, 0.27083333333333
60933, 0.75, 0.325, 0.29166666666667
60934, 0.72916666666667, 0.35, 0.29166666666667
60935, 0.75, 0.35, 0.27083333333333
60936, 0.75, 0.375, 0.29166666666667
60937, 0.72916666666667, 0.4, 0.29166666666667
60938, 0.75, 0.4, 0.27083333333333
60939, 0.75, 0.425, 0.29166666666667
60940, 0.72916666666667, 0.45, 0.29166666666667
60941, 0.75, 0.45, 0.27083333333333
60942, 0.75, 0.475, 0.29166666666667
60943, 0.72916666666667, 0.5, 0.29166666666667
60944, 0.75, 0.5, 0.27083333333333
60945, 0.75, 0.525, 0.29166666666667
60946, 0.72916666666667, 0.55, 0.29166666666667
60947, 0.75, 0.55, 0.27083333333333
60948, 0.75, 0.575, 0.29166666666667
60949, 0.72916666666667, 0.6, 0.29166666666667
60950, 0.75, 0.6, 0.27083333333333
60951, 0.75, 0.625, 0.29166666666667
60952, 0.72916666666667, 0.65, 0.29166666666667
60953, 0.75, 0.65, 0.27083333333333
60954, 0.75, 0.675, 0.29166666666667
60955, 0.72916666666667, 0.7, 0.29166666666667
60956, 0.75, 0.7, 0.27083333333333
60957, 0.75, 0.725, 0.29166666666667
60958, 0.72916666666667, 0.75, 0.29166666666667
60959, 0.75, 0.75, 0.27083333333333
60960, 0.75, 0.775, 0.29166666666667
60961, 0.72916666666667, 0.8, 0.29166666666667
60962, 0.75, 0.8, 0.27083333333333
60963, 0.75, 0.825, 0.29166666666667
60964, 0.72916666666667, 0.85, 0.29166666666667
60965, 0.75, 0.85, 0.27083333333333
60966, 0.75, 0.875, 0.29166666666667
60967, 0.72916666666667, 0.9, 0.29166666666667
60968, 0.75, 0.9, 0.27083333333333
60969, 0.75, 0.925, 0.29166666666667
60970, 0.72916666666667, 0.95, 0.29166666666667
60971, 0.75, 0.95, 0.27083333333333
60972, 0.75, 0.975, 0.29166666666667
60973, 0.72916666666667, 1, 0.29166666666667
60974, 0.75, 1, 0.27083333333333
60975, 0.75, 1.025, 0.29166666666667
60976, 0.72916666666667, 1.05, 0.29166666666667
60977, 0.75, 1.05, 0.27083333333333
60978, 0.75, 1.075, 0.29166666666667
60979, 0.72916666666667, 1.1, 0.29166666666667
60980, 0.75, 1.1, 0.27083333333333
60981, 0.75, 1.125, 0.29166666666667
60982, 0.72916666666667, 1.15, 0.29166666666667
60983, 0.75, 1.15, 0.27083333333333
60984, 0.75, 1.175, 0.29166666666667
60985, 0.72916666666667, 1.2, 0.29166666666667
60986, 0.75, 1.2, 0.27083333333333
60987, 0.75, 1.225, 0.29166666666667
60988, 0.72916666666667, 1.25, 0.29166666666667
60989, 0.75, 1.25, 0.27083333333333
60990, 0.75, 1.275, 0.29166666666667
60991, 0.72916666666667, 1.3, 0.29166666666667
60992, 0.75, 1.3, 0.27083333333333
60993, 0.75, 1.325, 0.29166666666667
60994, 0.75, 0.175, 0.33333333333333
60995, 0.72916666666667, 0.2, 0.33333333333333
60996, 0.75, 0.2, 0.3125
60997, 0.75, 0.225, 0.33333333333333
60998, 0.72916666666667, 0.25, 0.33333333333333
60999, 0.75, 0.25, 0.3125
61000, 0.75, 0.275, 0.33333333333333
61001, 0.72916666666667, 0.3, 0.33333333333333
61002, 0.75, 0.3, 0.3125
61003, 0.75, 0.325, 0.33333333333333
61004, 0.72916666666667, 0.35, 0.33333333333333
61005, 0.75, 0.35, 0.3125
61006, 0.75, 0.375, 0.33333333333333
61007, 0.72916666666667, 0.4, 0.33333333333333
61008, 0.75, 0.4, 0.3125
61009, 0.75, 0.425, 0.33333333333333
61010, 0.72916666666667, 0.45, 0.33333333333333
61011, 0.75, 0.45, 0.3125
61012, 0.75, 0.475, 0.33333333333333
61013, 0.72916666666667, 0.5, 0.33333333333333
61014, 0.75, 0.5, 0.3125
61015, 0.75, 0.525, 0.33333333333333
61016, 0.72916666666667, 0.55, 0.33333333333333
61017, 0.75, 0.55, 0.3125
61018, 0.75, 0.575, 0.33333333333333
61019, 0.72916666666667, 0.6, 0.33333333333333
61020, 0.75, 0.6, 0.3125
61021, 0.75, 0.625, 0.33333333333333
61022, 0.72916666666667, 0.65, 0.33333333333333
61023, 0.75, 0.65, 0.3125
61024, 0.75, 0.675, 0.33333333333333
61025, 0.72916666666667, 0.7, 0.33333333333333
61026, 0.75, 0.7, 0.3125
61027, 0.75, 0.725, 0.33333333333333
61028, 0.72916666666667, 0.75, 0.33333333333333
61029, 0.75, 0.75, 0.3125
61030, 0.75, 0.775, 0.33333333333333
61031, 0.72916666666667, 0.8, 0.33333333333333
61032, 0.75, 0.8, 0.3125
61033, 0.75, 0.825, 0.33333333333333
61034, 0.72916666666667, 0.85, 0.33333333333333
61035, 0.75, 0.85, 0.3125
61036, 0.75, 0.875, 0.33333333333333
61037, 0.72916666666667, 0.9, 0.33333333333333
61038, 0.75, 0.9, 0.3125
61039, 0.75, 0.925, 0.33333333333333
61040, 0.72916666666667, 0.95, 0.33333333333333
61041, 0.75, 0.95, 0.3125
61042, 0.75, 0.975, 0.33333333333333
61043, 0.72916666666667, 1, 0.33333333333333
61044, 0.75, 1, 0.3125
61045, 0.75, 1.025, 0.33333333333333
61046, 0.72916666666667, 1.05, 0.33333333333333
61047, 0.75, 1.05, 0.3125
61048, 0.75, 1.075, 0.33333333333333
61049, 0.72916666666667, 1.1, 0.33333333333333
61050, 0.75, 1.1, 0.3125
61051, 0.75, 1.125, 0.33333333333333
61052, 0.72916666666667, 1.15, 0.33333333333333
61053, 0.75, 1.15, 0.3125
61054, 0.75, 1.175, 0.33333333333333
61055, 0.72916666666667, 1.2, 0.33333333333333
61056, 0.75, 1.2, 0.3125
61057, 0.75, 1.225, 0.33333333333333
61058, 0.72916666666667, 1.25, 0.33333333333333
61059, 0.75, 1.25, 0.3125
61060, 0.75, 1.275, 0.33333333333333
61061, 0.72916666666667, 1.3, 0.33333333333333
61062, 0.75, 1.3, 0.3125
61063, 0.75, 1.325, 0.33333333333333
61064, 0.75, 0.175, 0.375
61065, 0.72916666666667, 0.2, 0.375
61066, 0.75, 0.2, 0.35416666666667
61067, 0.75, 0.225, 0.375
61068, 0.72916666666667, 0.25, 0.375
61069, 0.75, 0.25, 0.35416666666667
61070, 0.75, 0.275, 0.375
61071, 0.72916666666667, 0.3, 0.375
61072, 0.75, 0.3, 0.35416666666667
61073, 0.75, 0.325, 0.375
61074, 0.72916666666667, 0.35, 0.375
61075, 0.75, 0.35, 0.35416666666667
61076, 0.75, 0.375, 0.375
61077, 0.72916666666667, 0.4, 0.375
61078, 0.75, 0.4, 0.35416666666667
61079, 0.75, 0.425, 0.375
61080, 0.72916666666667, 0.45, 0.375
61081, 0.75, 0.45, 0.35416666666667
61082, 0.75, 0.475, 0.375
61083, 0.72916666666667, 0.5, 0.375
61084, 0.75, 0.5, 0.35416666666667
61085, 0.75, 0.525, 0.375
61086, 0.72916666666667, 0.55, 0.375
61087, 0.75, 0.55, 0.35416666666667
61088, 0.75, 0.575, 0.375
61089, 0.72916666666667, 0.6, 0.375
61090, 0.75, 0.6, 0.35416666666667
61091, 0.75, 0.625, 0.375
61092, 0.72916666666667, 0.65, 0.375
61093, 0.75, 0.65, 0.35416666666667
61094, 0.75, 0.675, 0.375
61095, 0.72916666666667, 0.7, 0.375
61096, 0.75, 0.7, 0.35416666666667
61097, 0.75, 0.725, 0.375
61098, 0.72916666666667, 0.75, 0.375
61099, 0.75, 0.75, 0.35416666666667
61100, 0.75, 0.775, 0.375
61101, 0.72916666666667, 0.8, 0.375
61102, 0.75, 0.8, 0.35416666666667
61103, 0.75, 0.825, 0.375
61104, 0.72916666666667, 0.85, 0.375
61105, 0.75, 0.85, 0.35416666666667
61106, 0.75, 0.875, 0.375
61107, 0.72916666666667, 0.9, 0.375
61108, 0.75, 0.9, 0.35416666666667
61109, 0.75, 0.925, 0.375
61110, 0.72916666666667, 0.95, 0.375
61111, 0.75, 0.95, 0.35416666666667
61112, 0.75, 0.975, 0.375
61113, 0.72916666666667, 1, 0.375
61114, 0.75, 1, 0.35416666666667
61115, 0.75, 1.025, 0.375
61116, 0.72916666666667, 1.05, 0.375
61117, 0.75, 1.05, 0.35416666666667
61118, 0.75, 1.075, 0.375
61119, 0.72916666666667, 1.1, 0.375
61120, 0.75, 1.1, 0.35416666666667
61121, 0.75, 1.125, 0.375
61122, 0.72916666666667, 1.15, 0.375
61123, 0.75, 1.15, 0.35416666666667
61124, 0.75, 1.175, 0.375
61125, 0.72916666666667, 1.2, 0.375
61126, 0.75, 1.2, 0.35416666666667
61127, 0.75, 1.225, 0.375
61128, 0.72916666666667, 1.25, 0.375
61129, 0.75, 1.25, 0.35416666666667
61130, 0.75, 1.275, 0.375
61131, 0.72916666666667, 1.3, 0.375
61132, 0.75, 1.3, 0.35416666666667
61133, 0.75, 1.325, 0.375
61134, 0.75, 0.175, 0.41666666666667
61135, 0.72916666666667, 0.2, 0.41666666666667
61136, 0.75, 0.2, 0.39583333333333
61137, 0.75, 0.225, 0.41666666666667
61138, 0.72916666666667, 0.25, 0.41666666666667
61139, 0.75, 0.25, 0.39583333333333
61140, 0.75, 0.275, 0.41666666666667
61141, 0.72916666666667, 0.3, 0.41666666666667
61142, 0.75, 0.3, 0.39583333333333
61143, 0.75, 0.325, 0.41666666666667
61144, 0.72916666666667, 0.35, 0.41666666666667
61145, 0.75, 0.35, 0.39583333333333
61146, 0.75, 0.375, 0.41666666666667
61147, 0.72916666666667, 0.4, 0.41666666666667
61148, 0.75, 0.4, 0.39583333333333
61149, 0.75, 0.425, 0.41666666666667
61150, 0.72916666666667, 0.45, 0.41666666666667
61151, 0.75, 0.45, 0.39583333333333
61152, 0.75, 0.475, 0.41666666666667
61153, 0.72916666666667, 0.5, 0.41666666666667
61154, 0.75, 0.5, 0.39583333333333
61155, 0.75, 0.525, 0.41666666666667
61156, 0.72916666666667, 0.55, 0.41666666666667
61157, 0.75, 0.55, 0.39583333333333
61158, 0.75, 0.575, 0.41666666666667
61159, 0.72916666666667, 0.6, 0.41666666666667
61160, 0.75, 0.6, 0.39583333333333
61161, 0.75, 0.625, 0.41666666666667
61162, 0.72916666666667, 0.65, 0.41666666666667
61163, 0.75, 0.65, 0.39583333333333
61164, 0.75, 0.675, 0.41666666666667
61165, 0.72916666666667, 0.7, 0.41666666666667
61166, 0.75, 0.7, 0.39583333333333
61167, 0.75, 0.725, 0.41666666666667
61168, 0.72916666666667, 0.75, 0.41666666666667
61169, 0.75, 0.75, 0.39583333333333
61170, 0.75, 0.775, 0.41666666666667
61171, 0.72916666666667, 0.8, 0.41666666666667
61172, 0.75, 0.8, 0.39583333333333
61173, 0.75, 0.825, 0.41666666666667
61174, 0.72916666666667, 0.85, 0.41666666666667
61175, 0.75, 0.85, 0.39583333333333
61176, 0.75, 0.875, 0.41666666666667
61177, 0.72916666666667, 0.9, 0.41666666666667
61178, 0.75, 0.9, 0.39583333333333
61179, 0.75, 0.925, 0.41666666666667
61180, 0.72916666666667, 0.95, 0.41666666666667
61181, 0.75, 0.95, 0.39583333333333
61182, 0.75, 0.975, 0.41666666666667
61183, 0.72916666666667, 1, 0.41666666666667
61184, 0.75, 1, 0.39583333333333
61185, 0.75, 1.025, 0.41666666666667
61186, 0.72916666666667, 1.05, 0.41666666666667
61187, 0.75, 1.05, 0.39583333333333
61188, 0.75, 1.075, 0.41666666666667
61189, 0.72916666666667, 1.1, 0.41666666666667
61190, 0.75, 1.1, 0.39583333333333
61191, 0.75, 1.125, 0.41666666666667
61192, 0.72916666666667, 1.15, 0.41666666666667
61193, 0.75, 1.15, 0.39583333333333
61194, 0.75, 1.175, 0.41666666666667
61195, 0.72916666666667, 1.2, 0.41666666666667
61196, 0.75, 1.2, 0.39583333333333
61197, 0.75, 1.225, 0.41666666666667
61198, 0.72916666666667, 1.25, 0.41666666666667
61199, 0.75, 1.25, 0.39583333333333
61200, 0.75, 1.275, 0.41666666666667
61201, 0.72916666666667, 1.3, 0.41666666666667
61202, 0.75, 1.3, 0.39583333333333
61203, 0.75, 1.325, 0.41666666666667
61204, 0.75, 0.175, 0.45833333333333
61205, 0.72916666666667, 0.2, 0.45833333333333
61206, 0.75, 0.2, 0.4375
61207, 0.75, 0.225, 0.45833333333333
61208, 0.72916666666667, 0.25, 0.45833333333333
61209, 0.75, 0.25, 0.4375
61210, 0.75, 0.275, 0.45833333333333
61211, 0.72916666666667, 0.3, 0.45833333333333
61212, 0.75, 0.3, 0.4375
61213, 0.75, 0.325, 0.45833333333333
61214, 0.72916666666667, 0.35, 0.45833333333333
61215, 0.75, 0.35, 0.4375
61216, 0.75, 0.375, 0.45833333333333
61217, 0.72916666666667, 0.4, 0.45833333333333
61218, 0.75, 0.4, 0.4375
61219, 0.75, 0.425, 0.45833333333333
61220, 0.72916666666667, 0.45, 0.45833333333333
61221, 0.75, 0.45, 0.4375
61222, 0.75, 0.475, 0.45833333333333
61223, 0.72916666666667, 0.5, 0.45833333333333
61224, 0.75, 0.5, 0.4375
61225, 0.75, 0.525, 0.45833333333333
61226, 0.72916666666667, 0.55, 0.45833333333333
61227, 0.75, 0.55, 0.4375
61228, 0.75, 0.575, 0.45833333333333
61229, 0.72916666666667, 0.6, 0.45833333333333
61230, 0.75, 0.6, 0.4375
61231, 0.75, 0.625, 0.45833333333333
61232, 0.72916666666667, 0.65, 0.45833333333333
61233, 0.75, 0.65, 0.4375
61234, 0.75, 0.675, 0.45833333333333
61235, 0.72916666666667, 0.7, 0.45833333333333
61236, 0.75, 0.7, 0.4375
61237, 0.75, 0.725, 0.45833333333333
61238, 0.72916666666667, 0.75, 0.45833333333333
61239, 0.75, 0.75, 0.4375
61240, 0.75, 0.775, 0.45833333333333
61241, 0.72916666666667, 0.8, 0.45833333333333
61242, 0.75, 0.8, 0.4375
61243, 0.75, 0.825, 0.45833333333333
61244, 0.72916666666667, 0.85, 0.45833333333333
61245, 0.75, 0.85, 0.4375
61246, 0.75, 0.875, 0.45833333333333
61247, 0.72916666666667, 0.9, 0.45833333333333
61248, 0.75, 0.9, 0.4375
61249, 0.75, 0.925, 0.45833333333333
61250, 0.72916666666667, 0.95, 0.45833333333333
61251, 0.75, 0.95, 0.4375
61252, 0.75, 0.975, 0.45833333333333
61253, 0.72916666666667, 1, 0.45833333333333
61254, 0.75, 1, 0.4375
61255, 0.75, 1.025, 0.45833333333333
61256, 0.72916666666667, 1.05, 0.45833333333333
61257, 0.75, 1.05, 0.4375
61258, 0.75, 1.075, 0.45833333333333
61259, 0.72916666666667, 1.1, 0.45833333333333
61260, 0.75, 1.1, 0.4375
61261, 0.75, 1.125, 0.45833333333333
61262, 0.72916666666667, 1.15, 0.45833333333333
61263, 0.75, 1.15, 0.4375
61264, 0.75, 1.175, 0.45833333333333
61265, 0.72916666666667, 1.2, 0.45833333333333
61266, 0.75, 1.2, 0.4375
61267, 0.75, 1.225, 0.45833333333333
61268, 0.72916666666667, 1.25, 0.45833333333333
61269, 0.75, 1.25, 0.4375
61270, 0.75, 1.275, 0.45833333333333
61271, 0.72916666666667, 1.3, 0.45833333333333
61272, 0.75, 1.3, 0.4375
61273, 0.75, 1.325, 0.45833333333333
61274, 0.75, 0.2, 0.47916666666667
61275, 0.75, 0.25, 0.47916666666667
61276, 0.75, 0.3, 0.47916666666667
61277, 0.75, 0.35, 0.47916666666667
61278, 0.75, 0.4, 0.47916666666667
61279, 0.75, 0.45, 0.47916666666667
61280, 0.75, 0.5, 0.47916666666667
61281, 0.75, 0.55, 0.47916666666667
61282, 0.75, 0.6, 0.47916666666667
61283, 0.75, 0.65, 0.47916666666667
61284, 0.75, 0.7, 0.47916666666667
61285, 0.75, 0.75, 0.47916666666667
61286, 0.75, 0.8, 0.47916666666667
61287, 0.75, 0.85, 0.47916666666667
61288, 0.75, 0.9, 0.47916666666667
61289, 0.75, 0.95, 0.47916666666667
61290, 0.75, 1, 0.47916666666667
61291, 0.75, 1.05, 0.47916666666667
61292, 0.75, 1.1, 0.47916666666667
61293, 0.75, 1.15, 0.47916666666667
61294, 0.75, 1.2, 0.47916666666667
61295, 0.75, 1.25, 0.47916666666667
61296, 0.75, 1.3, 0.47916666666667
61297, 0.79166666666667, 0.175, 0.041666666666667
61298, 0.77083333333333, 0.2, 0.041666666666667
61299, 0.79166666666667, 0.2, 0.020833333333333
61300, 0.79166666666667, 0.225, 0.041666666666667
61301, 0.77083333333333, 0.25, 0.041666666666667
61302, 0.79166666666667, 0.25, 0.020833333333333
61303, 0.79166666666667, 0.275, 0.041666666666667
61304, 0.77083333333333, 0.3, 0.041666666666667
61305, 0.79166666666667, 0.3, 0.020833333333333
61306, 0.79166666666667, 0.325, 0.041666666666667
61307, 0.77083333333333, 0.35, 0.041666666666667
61308, 0.79166666666667, 0.35, 0.020833333333333
61309, 0.79166666666667, 0.375, 0.041666666666667
61310, 0.77083333333333, 0.4, 0.041666666666667
61311, 0.79166666666667, 0.4, 0.020833333333333
61312, 0.79166666666667, 0.425, 0.041666666666667
61313, 0.77083333333333, 0.45, 0.041666666666667
61314, 0.79166666666667, 0.45, 0.020833333333333
61315, 0.79166666666667, 0.475, 0.041666666666667
61316, 0.77083333333333, 0.5, 0.041666666666667
61317, 0.79166666666667, 0.5, 0.020833333333333
61318, 0.79166666666667, 0.525, 0.041666666666667
61319, 0.77083333333333, 0.55, 0.041666666666667
61320, 0.79166666666667, 0.55, 0.020833333333333
61321, 0.79166666666667, 0.575, 0.041666666666667
61322, 0.77083333333333, 0.6, 0.041666666666667
61323, 0.79166666666667, 0.6, 0.020833333333333
61324, 0.79166666666667, 0.625, 0.041666666666667
61325, 0.77083333333333, 0.65, 0.041666666666667
61326, 0.79166666666667, 0.65, 0.020833333333333
61327, 0.79166666666667, 0.675, 0.041666666666667
61328, 0.77083333333333, 0.7, 0.041666666666667
61329, 0.79166666666667, 0.7, 0.020833333333333
61330, 0.79166666666667, 0.725, 0.041666666666667
61331, 0.77083333333333, 0.75, 0.041666666666667
61332, 0.79166666666667, 0.75, 0.020833333333333
61333, 0.79166666666667, 0.775, 0.041666666666667
61334, 0.77083333333333, 0.8, 0.041666666666667
61335, 0.79166666666667, 0.8, 0.020833333333333
61336, 0.79166666666667, 0.825, 0.041666666666667
61337, 0.77083333333333, 0.85, 0.041666666666667
61338, 0.79166666666667, 0.85, 0.020833333333333
61339, 0.79166666666667, 0.875, 0.041666666666667
61340, 0.77083333333333, 0.9, 0.041666666666667
61341, 0.79166666666667, 0.9, 0.020833333333333
61342, 0.79166666666667, 0.925, 0.041666666666667
61343, 0.77083333333333, 0.95, 0.041666666666667
61344, 0.79166666666667, 0.95, 0.020833333333333
61345, 0.79166666666667, 0.975, 0.041666666666667
61346, 0.77083333333333, 1, 0.041666666666667
61347, 0.79166666666667, 1, 0.020833333333333
61348, 0.79166666666667, 1.025, 0.041666666666667
61349, 0.77083333333333, 1.05, 0.041666666666667
61350, 0.79166666666667, 1.05, 0.020833333333333
61351, 0.79166666666667, 1.075, 0.041666666666667
61352, 0.77083333333333, 1.1, 0.041666666666667
61353, 0.79166666666667, 1.1, 0.020833333333333
61354, 0.79166666666667, 1.125, 0.041666666666667
61355, 0.77083333333333, 1.15, 0.041666666666667
61356, 0.79166666666667, 1.15, 0.020833333333333
61357, 0.79166666666667, 1.175, 0.041666666666667
61358, 0.77083333333333, 1.2, 0.041666666666667
61359, 0.79166666666667, 1.2, 0.020833333333333
61360, 0.79166666666667, 1.225, 0.041666666666667
61361, 0.77083333333333, 1.25, 0.041666666666667
61362, 0.79166666666667, 1.25, 0.020833333333333
61363, 0.79166666666667, 1.275, 0.041666666666667
61364, 0.77083333333333, 1.3, 0.041666666666667
61365, 0.79166666666667, 1.3, 0.020833333333333
61366, 0.79166666666667, 1.325, 0.041666666666667
61367, 0.79166666666667, 0.175, 0.083333333333333
61368, 0.77083333333333, 0.2, 0.083333333333333
61369, 0.79166666666667, 0.2, 0.0625
61370, 0.79166666666667, 0.225, 0.083333333333333
61371, 0.77083333333333, 0.25, 0.083333333333333
61372, 0.79166666666667, 0.25, 0.0625
61373, 0.79166666666667, 0.275, 0.083333333333333
61374, 0.77083333333333, 0.3, 0.083333333333333
61375, 0.79166666666667, 0.3, 0.0625
61376, 0.79166666666667, 0.325, 0.083333333333333
61377, 0.77083333333333, 0.35, 0.083333333333333
61378, 0.79166666666667, 0.35, 0.0625
61379, 0.79166666666667, 0.375, 0.083333333333333
61380, 0.77083333333333, 0.4, 0.083333333333333
61381, 0.79166666666667, 0.4, 0.0625
61382, 0.79166666666667, 0.425, 0.083333333333333
61383, 0.77083333333333, 0.45, 0.083333333333333
61384, 0.79166666666667, 0.45, 0.0625
61385, 0.79166666666667, 0.475, 0.083333333333333
61386, 0.77083333333333, 0.5, 0.083333333333333
61387, 0.79166666666667, 0.5, 0.0625
61388, 0.79166666666667, 0.525, 0.083333333333333
61389, 0.77083333333333, 0.55, 0.083333333333333
61390, 0.79166666666667, 0.55, 0.0625
61391, 0.79166666666667, 0.575, 0.083333333333333
61392, 0.77083333333333, 0.6, 0.083333333333333
61393, 0.79166666666667, 0.6, 0.0625
61394, 0.79166666666667, 0.625, 0.083333333333333
61395, 0.77083333333333, 0.65, 0.083333333333333
61396, 0.79166666666667, 0.65, 0.0625
61397, 0.79166666666667, 0.675, 0.083333333333333
61398, 0.77083333333333, 0.7, 0.083333333333333
61399, 0.79166666666667, 0.7, 0.0625
61400, 0.79166666666667, 0.725, 0.083333333333333
61401, 0.77083333333333, 0.75, 0.083333333333333
61402, 0.79166666666667, 0.75, 0.0625
61403, 0.79166666666667, 0.775, 0.083333333333333
61404, 0.77083333333333, 0.8, 0.083333333333333
61405, 0.79166666666667, 0.8, 0.0625
61406, 0.79166666666667, 0.825, 0.083333333333333
61407, 0.77083333333333, 0.85, 0.083333333333333
61408, 0.79166666666667, 0.85, 0.0625
61409, 0.79166666666667, 0.875, 0.083333333333333
61410, 0.77083333333333, 0.9, 0.083333333333333
61411, 0.79166666666667, 0.9, 0.0625
61412, 0.79166666666667, 0.925, 0.083333333333333
61413, 0.77083333333333, 0.95, 0.083333333333333
61414, 0.79166666666667, 0.95, 0.0625
61415, 0.79166666666667, 0.975, 0.083333333333333
61416, 0.77083333333333, 1, 0.083333333333333
61417, 0.79166666666667, 1, 0.0625
61418, 0.79166666666667, 1.025, 0.083333333333333
61419, 0.77083333333333, 1.05, 0.083333333333333
61420, 0.79166666666667, 1.05, 0.0625
61421, 0.79166666666667, 1.075, 0.083333333333333
61422, 0.77083333333333, 1.1, 0.083333333333333
61423, 0.79166666666667, 1.1, 0.0625
61424, 0.79166666666667, 1.125, 0.083333333333333
61425, 0.77083333333333, 1.15, 0.083333333333333
61426, 0.79166666666667, 1.15, 0.0625
61427, 0.79166666666667, 1.175, 0.083333333333333
61428, 0.77083333333333, 1.2, 0.083333333333333
61429, 0.79166666666667, 1.2, 0.0625
61430, 0.79166666666667, 1.225, 0.083333333333333
61431, 0.77083333333333, 1.25, 0.083333333333333
61432, 0.79166666666667, 1.25, 0.0625
61433, 0.79166666666667, 1.275, 0.083333333333333
61434, 0.77083333333333, 1.3, 0.083333333333333
61435, 0.79166666666667, 1.3, 0.0625
61436, 0.79166666666667, 1.325, 0.083333333333333
61437, 0.79166666666667, 0.175, 0.125
61438, 0.77083333333333, 0.2, 0.125
61439, 0.79166666666667, 0.2, 0.10416666666667
61440, 0.79166666666667, 0.225, 0.125
61441, 0.77083333333333, 0.25, 0.125
61442, 0.79166666666667, 0.25, 0.10416666666667
61443, 0.79166666666667, 0.275, 0.125
61444, 0.77083333333333, 0.3, 0.125
61445, 0.79166666666667, 0.3, 0.10416666666667
61446, 0.79166666666667, 0.325, 0.125
61447, 0.77083333333333, 0.35, 0.125
61448, 0.79166666666667, 0.35, 0.10416666666667
61449, 0.79166666666667, 0.375, 0.125
61450, 0.77083333333333, 0.4, 0.125
61451, 0.79166666666667, 0.4, 0.10416666666667
61452, 0.79166666666667, 0.425, 0.125
61453, 0.77083333333333, 0.45, 0.125
61454, 0.79166666666667, 0.45, 0.10416666666667
61455, 0.79166666666667, 0.475, 0.125
61456, 0.77083333333333, 0.5, 0.125
61457, 0.79166666666667, 0.5, 0.10416666666667
61458, 0.79166666666667, 0.525, 0.125
61459, 0.77083333333333, 0.55, 0.125
61460, 0.79166666666667, 0.55, 0.10416666666667
61461, 0.79166666666667, 0.575, 0.125
61462, 0.77083333333333, 0.6, 0.125
61463, 0.79166666666667, 0.6, 0.10416666666667
61464, 0.79166666666667, 0.625, 0.125
61465, 0.77083333333333, 0.65, 0.125
61466, 0.79166666666667, 0.65, 0.10416666666667
61467, 0.79166666666667, 0.675, 0.125
61468, 0.77083333333333, 0.7, 0.125
61469, 0.79166666666667, 0.7, 0.10416666666667
61470, 0.79166666666667, 0.725, 0.125
61471, 0.77083333333333, 0.75, 0.125
61472, 0.79166666666667, 0.75, 0.10416666666667
61473, 0.79166666666667, 0.775, 0.125
61474, 0.77083333333333, 0.8, 0.125
61475, 0.79166666666667, 0.8, 0.10416666666667
61476, 0.79166666666667, 0.825, 0.125
61477, 0.77083333333333, 0.85, 0.125
61478, 0.79166666666667, 0.85, 0.10416666666667
61479, 0.79166666666667, 0.875, 0.125
61480, 0.77083333333333, 0.9, 0.125
61481, 0.79166666666667, 0.9, 0.10416666666667
61482, 0.79166666666667, 0.925, 0.125
61483, 0.77083333333333, 0.95, 0.125
61484, 0.79166666666667, 0.95, 0.10416666666667
61485, 0.79166666666667, 0.975, 0.125
61486, 0.77083333333333, 1, 0.125
61487, 0.79166666666667, 1, 0.10416666666667
61488, 0.79166666666667, 1.025, 0.125
61489, 0.77083333333333, 1.05, 0.125
61490, 0.79166666666667, 1.05, 0.10416666666667
61491, 0.79166666666667, 1.075, 0.125
61492, 0.77083333333333, 1.1, 0.125
61493, 0.79166666666667, 1.1, 0.10416666666667
61494, 0.79166666666667, 1.125, 0.125
61495, 0.77083333333333, 1.15, 0.125
61496, 0.79166666666667, 1.15, 0.10416666666667
61497, 0.79166666666667, 1.175, 0.125
61498, 0.77083333333333, 1.2, 0.125
61499, 0.79166666666667, 1.2, 0.10416666666667
61500, 0.79166666666667, 1.225, 0.125
61501, 0.77083333333333, 1.25, 0.125
61502, 0.79166666666667, 1.25, 0.10416666666667
61503, 0.79166666666667, 1.275, 0.125
61504, 0.77083333333333, 1.3, 0.125
61505, 0.79166666666667, 1.3, 0.10416666666667
61506, 0.79166666666667, 1.325, 0.125
61507, 0.79166666666667, 0.175, 0.16666666666667
61508, 0.77083333333333, 0.2, 0.16666666666667
61509, 0.79166666666667, 0.2, 0.14583333333333
61510, 0.79166666666667, 0.225, 0.16666666666667
61511, 0.77083333333333, 0.25, 0.16666666666667
61512, 0.79166666666667, 0.25, 0.14583333333333
61513, 0.79166666666667, 0.275, 0.16666666666667
61514, 0.77083333333333, 0.3, 0.16666666666667
61515, 0.79166666666667, 0.3, 0.14583333333333
61516, 0.79166666666667, 0.325, 0.16666666666667
61517, 0.77083333333333, 0.35, 0.16666666666667
61518, 0.79166666666667, 0.35, 0.14583333333333
61519, 0.79166666666667, 0.375, 0.16666666666667
61520, 0.77083333333333, 0.4, 0.16666666666667
61521, 0.79166666666667, 0.4, 0.14583333333333
61522, 0.79166666666667, 0.425, 0.16666666666667
61523, 0.77083333333333, 0.45, 0.16666666666667
61524, 0.79166666666667, 0.45, 0.14583333333333
61525, 0.79166666666667, 0.475, 0.16666666666667
61526, 0.77083333333333, 0.5, 0.16666666666667
61527, 0.79166666666667, 0.5, 0.14583333333333
61528, 0.79166666666667, 0.525, 0.16666666666667
61529, 0.77083333333333, 0.55, 0.16666666666667
61530, 0.79166666666667, 0.55, 0.14583333333333
61531, 0.79166666666667, 0.575, 0.16666666666667
61532, 0.77083333333333, 0.6, 0.16666666666667
61533, 0.79166666666667, 0.6, 0.14583333333333
61534, 0.79166666666667, 0.625, 0.16666666666667
61535, 0.77083333333333, 0.65, 0.16666666666667
61536, 0.79166666666667, 0.65, 0.14583333333333
61537, 0.79166666666667, 0.675, 0.16666666666667
61538, 0.77083333333333, 0.7, 0.16666666666667
61539, 0.79166666666667, 0.7, 0.14583333333333
61540, 0.79166666666667, 0.725, 0.16666666666667
61541, 0.77083333333333, 0.75, 0.16666666666667
61542, 0.79166666666667, 0.75, 0.14583333333333
61543, 0.79166666666667, 0.775, 0.16666666666667
61544, 0.77083333333333, 0.8, 0.16666666666667
61545, 0.79166666666667, 0.8, 0.14583333333333
61546, 0.79166666666667, 0.825, 0.16666666666667
61547, 0.77083333333333, 0.85, 0.16666666666667
61548, 0.79166666666667, 0.85, 0.14583333333333
61549, 0.79166666666667, 0.875, 0.16666666666667
61550, 0.77083333333333, 0.9, 0.16666666666667
61551, 0.79166666666667, 0.9, 0.14583333333333
61552, 0.79166666666667, 0.925, 0.16666666666667
61553, 0.77083333333333, 0.95, 0.16666666666667
61554, 0.79166666666667, 0.95, 0.14583333333333
61555, 0.79166666666667, 0.975, 0.16666666666667
61556, 0.77083333333333, 1, 0.16666666666667
61557, 0.79166666666667, 1, 0.14583333333333
61558, 0.79166666666667, 1.025, 0.16666666666667
61559, 0.77083333333333, 1.05, 0.16666666666667
61560, 0.79166666666667, 1.05, 0.14583333333333
61561, 0.79166666666667, 1.075, 0.16666666666667
61562, 0.77083333333333, 1.1, 0.16666666666667
61563, 0.79166666666667, 1.1, 0.14583333333333
61564, 0.79166666666667, 1.125, 0.16666666666667
61565, 0.77083333333333, 1.15, 0.16666666666667
61566, 0.79166666666667, 1.15, 0.14583333333333
61567, 0.79166666666667, 1.175, 0.16666666666667
61568, 0.77083333333333, 1.2, 0.16666666666667
61569, 0.79166666666667, 1.2, 0.14583333333333
61570, 0.79166666666667, 1.225, 0.16666666666667
61571, 0.77083333333333, 1.25, 0.16666666666667
61572, 0.79166666666667, 1.25, 0.14583333333333
61573, 0.79166666666667, 1.275, 0.16666666666667
61574, 0.77083333333333, 1.3, 0.16666666666667
61575, 0.79166666666667, 1.3, 0.14583333333333
61576, 0.79166666666667, 1.325, 0.16666666666667
61577, 0.79166666666667, 0.175, 0.20833333333333
61578, 0.77083333333333, 0.2, 0.20833333333333
61579, 0.79166666666667, 0.2, 0.1875
61580, 0.79166666666667, 0.225, 0.20833333333333
61581, 0.77083333333333, 0.25, 0.20833333333333
61582, 0.79166666666667, 0.25, 0.1875
61583, 0.79166666666667, 0.275, 0.20833333333333
61584, 0.77083333333333, 0.3, 0.20833333333333
61585, 0.79166666666667, 0.3, 0.1875
61586, 0.79166666666667, 0.325, 0.20833333333333
61587, 0.77083333333333, 0.35, 0.20833333333333
61588, 0.79166666666667, 0.35, 0.1875
61589, 0.79166666666667, 0.375, 0.20833333333333
61590, 0.77083333333333, 0.4, 0.20833333333333
61591, 0.79166666666667, 0.4, 0.1875
61592, 0.79166666666667, 0.425, 0.20833333333333
61593, 0.77083333333333, 0.45, 0.20833333333333
61594, 0.79166666666667, 0.45, 0.1875
61595, 0.79166666666667, 0.475, 0.20833333333333
61596, 0.77083333333333, 0.5, 0.20833333333333
61597, 0.79166666666667, 0.5, 0.1875
61598, 0.79166666666667, 0.525, 0.20833333333333
61599, 0.77083333333333, 0.55, 0.20833333333333
61600, 0.79166666666667, 0.55, 0.1875
61601, 0.79166666666667, 0.575, 0.20833333333333
61602, 0.77083333333333, 0.6, 0.20833333333333
61603, 0.79166666666667, 0.6, 0.1875
61604, 0.79166666666667, 0.625, 0.20833333333333
61605, 0.77083333333333, 0.65, 0.20833333333333
61606, 0.79166666666667, 0.65, 0.1875
61607, 0.79166666666667, 0.675, 0.20833333333333
61608, 0.77083333333333, 0.7, 0.20833333333333
61609, 0.79166666666667, 0.7, 0.1875
61610, 0.79166666666667, 0.725, 0.20833333333333
61611, 0.77083333333333, 0.75, 0.20833333333333
61612, 0.79166666666667, 0.75, 0.1875
61613, 0.79166666666667, 0.775, 0.20833333333333
61614, 0.77083333333333, 0.8, 0.20833333333333
61615, 0.79166666666667, 0.8, 0.1875
61616, 0.79166666666667, 0.825, 0.20833333333333
61617, 0.77083333333333, 0.85, 0.20833333333333
61618, 0.79166666666667, 0.85, 0.1875
61619, 0.79166666666667, 0.875, 0.20833333333333
61620, 0.77083333333333, 0.9, 0.20833333333333
61621, 0.79166666666667, 0.9, 0.1875
61622, 0.79166666666667, 0.925, 0.20833333333333
61623, 0.77083333333333, 0.95, 0.20833333333333
61624, 0.79166666666667, 0.95, 0.1875
61625, 0.79166666666667, 0.975, 0.20833333333333
61626, 0.77083333333333, 1, 0.20833333333333
61627, 0.79166666666667, 1, 0.1875
61628, 0.79166666666667, 1.025, 0.20833333333333
61629, 0.77083333333333, 1.05, 0.20833333333333
61630, 0.79166666666667, 1.05, 0.1875
61631, 0.79166666666667, 1.075, 0.20833333333333
61632, 0.77083333333333, 1.1, 0.20833333333333
61633, 0.79166666666667, 1.1, 0.1875
61634, 0.79166666666667, 1.125, 0.20833333333333
61635, 0.77083333333333, 1.15, 0.20833333333333
61636, 0.79166666666667, 1.15, 0.1875
61637, 0.79166666666667, 1.175, 0.20833333333333
61638, 0.77083333333333, 1.2, 0.20833333333333
61639, 0.79166666666667, 1.2, 0.1875
61640, 0.79166666666667, 1.225, 0.20833333333333
61641, 0.77083333333333, 1.25, 0.20833333333333
61642, 0.79166666666667, 1.25, 0.1875
61643, 0.79166666666667, 1.275, 0.20833333333333
61644, 0.77083333333333, 1.3, 0.20833333333333
61645, 0.79166666666667, 1.3, 0.1875
61646, 0.79166666666667, 1.325, 0.20833333333333
61647, 0.79166666666667, 0.175, 0.25
61648, 0.77083333333333, 0.2, 0.25
61649, 0.79166666666667, 0.2, 0.22916666666667
61650, 0.79166666666667, 0.225, 0.25
61651, 0.77083333333333, 0.25, 0.25
61652, 0.79166666666667, 0.25, 0.22916666666667
61653, 0.79166666666667, 0.275, 0.25
61654, 0.77083333333333, 0.3, 0.25
61655, 0.79166666666667, 0.3, 0.22916666666667
61656, 0.79166666666667, 0.325, 0.25
61657, 0.77083333333333, 0.35, 0.25
61658, 0.79166666666667, 0.35, 0.22916666666667
61659, 0.79166666666667, 0.375, 0.25
61660, 0.77083333333333, 0.4, 0.25
61661, 0.79166666666667, 0.4, 0.22916666666667
61662, 0.79166666666667, 0.425, 0.25
61663, 0.77083333333333, 0.45, 0.25
61664, 0.79166666666667, 0.45, 0.22916666666667
61665, 0.79166666666667, 0.475, 0.25
61666, 0.77083333333333, 0.5, 0.25
61667, 0.79166666666667, 0.5, 0.22916666666667
61668, 0.79166666666667, 0.525, 0.25
61669, 0.77083333333333, 0.55, 0.25
61670, 0.79166666666667, 0.55, 0.22916666666667
61671, 0.79166666666667, 0.575, 0.25
61672, 0.77083333333333, 0.6, 0.25
61673, 0.79166666666667, 0.6, 0.22916666666667
61674, 0.79166666666667, 0.625, 0.25
61675, 0.77083333333333, 0.65, 0.25
61676, 0.79166666666667, 0.65, 0.22916666666667
61677, 0.79166666666667, 0.675, 0.25
61678, 0.77083333333333, 0.7, 0.25
61679, 0.79166666666667, 0.7, 0.22916666666667
61680, 0.79166666666667, 0.725, 0.25
61681, 0.77083333333333, 0.75, 0.25
61682, 0.79166666666667, 0.75, 0.22916666666667
61683, 0.79166666666667, 0.775, 0.25
61684, 0.77083333333333, 0.8, 0.25
61685, 0.79166666666667, 0.8, 0.22916666666667
61686, 0.79166666666667, 0.825, 0.25
61687, 0.77083333333333, 0.85, 0.25
61688, 0.79166666666667, 0.85, 0.22916666666667
61689, 0.79166666666667, 0.875, 0.25
61690, 0.77083333333333, 0.9, 0.25
61691, 0.79166666666667, 0.9, 0.22916666666667
61692, 0.79166666666667, 0.925, 0.25
61693, 0.77083333333333, 0.95, 0.25
61694, 0.79166666666667, 0.95, 0.22916666666667
61695, 0.79166666666667, 0.975, 0.25
61696, 0.77083333333333, 1, 0.25
61697, 0.79166666666667, 1, 0.22916666666667
61698, 0.79166666666667, 1.025, 0.25
61699, 0.77083333333333, 1.05, 0.25
61700, 0.79166666666667, 1.05, 0.22916666666667
61701, 0.79166666666667, 1.075, 0.25
61702, 0.77083333333333, 1.1, 0.25
61703, 0.79166666666667, 1.1, 0.22916666666667
61704, 0.79166666666667, 1.125, 0.25
61705, 0.77083333333333, 1.15, 0.25
61706, 0.79166666666667, 1.15, 0.22916666666667
61707, 0.79166666666667, 1.175, 0.25
61708, 0.77083333333333, 1.2, 0.25
61709, 0.79166666666667, 1.2, 0.22916666666667
61710, 0.79166666666667, 1.225, 0.25
61711, 0.77083333333333, 1.25, 0.25
61712, 0.79166666666667, 1.25, 0.22916666666667
61713, 0.79166666666667, 1.275, 0.25
61714, 0.77083333333333, 1.3, 0.25
61715, 0.79166666666667, 1.3, 0.22916666666667
61716, 0.79166666666667, 1.325, 0.25
61717, 0.79166666666667, 0.175, 0.29166666666667
61718, 0.77083333333333, 0.2, 0.29166666666667
61719, 0.79166666666667, 0.2, 0.27083333333333
61720, 0.79166666666667, 0.225, 0.29166666666667
61721, 0.77083333333333, 0.25, 0.29166666666667
61722, 0.79166666666667, 0.25, 0.27083333333333
61723, 0.79166666666667, 0.275, 0.29166666666667
61724, 0.77083333333333, 0.3, 0.29166666666667
61725, 0.79166666666667, 0.3, 0.27083333333333
61726, 0.79166666666667, 0.325, 0.29166666666667
61727, 0.77083333333333, 0.35, 0.29166666666667
61728, 0.79166666666667, 0.35, 0.27083333333333
61729, 0.79166666666667, 0.375, 0.29166666666667
