35407, 0.75, -0.08, 0.5
35408, 0.75, -0.12, 0.5
35409, 0.75, -0.16, 0.5
35410, 0.79166666666667, -0.04, 0.5
35411, 0.79166666666667, -0.08, 0.5
35412, 0.79166666666667, -0.12, 0.5
35413, 0.79166666666667, -0.16, 0.5
35414, 0.83333333333333, -0.04, 0.5
35415, 0.83333333333333, -0.08, 0.5
35416, 0.83333333333333, -0.12, 0.5
35417, 0.83333333333333, -0.16, 0.5
35418, 0.875, -0.04, 0.5
35419, 0.875, -0.08, 0.5
35420, 0.875, -0.12, 0.5
35421, 0.875, -0.16, 0.5
35422, 0.91666666666667, -0.04, 0.5
35423, 0.91666666666667, -0.08, 0.5
35424, 0.91666666666667, -0.12, 0.5
35425, 0.91666666666667, -0.16, 0.5
35426, 0.95833333333333, -0.04, 0.5
35427, 0.95833333333333, -0.08, 0.5
35428, 0.95833333333333, -0.12, 0.5
35429, 0.95833333333333, -0.16, 0.5
35430, 0.020833333333333, -0.04, 0.5
35431, 0.041666666666667, -0.02, 0.5
35432, 0.020833333333333, -0.08, 0.5
35433, 0.041666666666667, -0.06, 0.5
35434, 0.020833333333333, -0.12, 0.5
35435, 0.041666666666667, -0.1, 0.5
35436, 0.020833333333333, -0.16, 0.5
35437, 0.041666666666667, -0.14, 0.5
35438, 0.041666666666667, -0.18, 0.5
35439, 0.0625, -0.04, 0.5
35440, 0.083333333333333, -0.02, 0.5
35441, 0.0625, -0.08, 0.5
35442, 0.083333333333333, -0.06, 0.5
35443, 0.0625, -0.12, 0.5
35444, 0.083333333333333, -0.1, 0.5
35445, 0.0625, -0.16, 0.5
35446, 0.083333333333333, -0.14, 0.5
35447, 0.083333333333333, -0.18, 0.5
35448, 0.10416666666667, -0.04, 0.5
35449, 0.125, -0.02, 0.5
35450, 0.10416666666667, -0.08, 0.5
35451, 0.125, -0.06, 0.5
35452, 0.10416666666667, -0.12, 0.5
35453, 0.125, -0.1, 0.5
35454, 0.10416666666667, -0.16, 0.5
35455, 0.125, -0.14, 0.5
35456, 0.125, -0.18, 0.5
35457, 0.14583333333333, -0.04, 0.5
35458, 0.16666666666667, -0.02, 0.5
35459, 0.14583333333333, -0.08, 0.5
35460, 0.16666666666667, -0.06, 0.5
35461, 0.14583333333333, -0.12, 0.5
35462, 0.16666666666667, -0.1, 0.5
35463, 0.14583333333333, -0.16, 0.5
35464, 0.16666666666667, -0.14, 0.5
35465, 0.16666666666667, -0.18, 0.5
35466, 0.1875, -0.04, 0.5
35467, 0.20833333333333, -0.02, 0.5
35468, 0.1875, -0.08, 0.5
35469, 0.20833333333333, -0.06, 0.5
35470, 0.1875, -0.12, 0.5
35471, 0.20833333333333, -0.1, 0.5
35472, 0.1875, -0.16, 0.5
35473, 0.20833333333333, -0.14, 0.5
35474, 0.20833333333333, -0.18, 0.5
35475, 0.22916666666667, -0.04, 0.5
35476, 0.25, -0.02, 0.5
35477, 0.22916666666667, -0.08, 0.5
35478, 0.25, -0.06, 0.5
35479, 0.22916666666667, -0.12, 0.5
35480, 0.25, -0.1, 0.5
35481, 0.22916666666667, -0.16, 0.5
35482, 0.25, -0.14, 0.5
35483, 0.25, -0.18, 0.5
35484, 0.27083333333333, -0.04, 0.5
35485, 0.29166666666667, -0.02, 0.5
35486, 0.27083333333333, -0.08, 0.5
35487, 0.29166666666667, -0.06, 0.5
35488, 0.27083333333333, -0.12, 0.5
35489, 0.29166666666667, -0.1, 0.5
35490, 0.27083333333333, -0.16, 0.5
35491, 0.29166666666667, -0.14, 0.5
35492, 0.29166666666667, -0.18, 0.5
35493, 0.3125, -0.04, 0.5
35494, 0.33333333333333, -0.02, 0.5
35495, 0.3125, -0.08, 0.5
35496, 0.33333333333333, -0.06, 0.5
35497, 0.3125, -0.12, 0.5
35498, 0.33333333333333, -0.1, 0.5
35499, 0.3125, -0.16, 0.5
35500, 0.33333333333333, -0.14, 0.5
35501, 0.33333333333333, -0.18, 0.5
35502, 0.35416666666667, -0.04, 0.5
35503, 0.375, -0.02, 0.5
35504, 0.35416666666667, -0.08, 0.5
35505, 0.375, -0.06, 0.5
35506, 0.35416666666667, -0.12, 0.5
35507, 0.375, -0.1, 0.5
35508, 0.35416666666667, -0.16, 0.5
35509, 0.375, -0.14, 0.5
35510, 0.375, -0.18, 0.5
35511, 0.39583333333333, -0.04, 0.5
35512, 0.41666666666667, -0.02, 0.5
35513, 0.39583333333333, -0.08, 0.5
35514, 0.41666666666667, -0.06, 0.5
35515, 0.39583333333333, -0.12, 0.5
35516, 0.41666666666667, -0.1, 0.5
35517, 0.39583333333333, -0.16, 0.5
35518, 0.41666666666667, -0.14, 0.5
35519, 0.41666666666667, -0.18, 0.5
35520, 0.4375, -0.04, 0.5
35521, 0.45833333333333, -0.02, 0.5
35522, 0.4375, -0.08, 0.5
35523, 0.45833333333333, -0.06, 0.5
35524, 0.4375, -0.12, 0.5
35525, 0.45833333333333, -0.1, 0.5
35526, 0.4375, -0.16, 0.5
35527, 0.45833333333333, -0.14, 0.5
35528, 0.45833333333333, -0.18, 0.5
35529, 0.47916666666667, -0.04, 0.5
35530, 0.5, -0.02, 0.5
35531, 0.47916666666667, -0.08, 0.5
35532, 0.5, -0.06, 0.5
35533, 0.47916666666667, -0.12, 0.5
35534, 0.5, -0.1, 0.5
35535, 0.47916666666667, -0.16, 0.5
35536, 0.5, -0.14, 0.5
35537, 0.5, -0.18, 0.5
35538, 0.52083333333333, -0.04, 0.5
35539, 0.54166666666667, -0.02, 0.5
35540, 0.52083333333333, -0.08, 0.5
35541, 0.54166666666667, -0.06, 0.5
35542, 0.52083333333333, -0.12, 0.5
35543, 0.54166666666667, -0.1, 0.5
35544, 0.52083333333333, -0.16, 0.5
35545, 0.54166666666667, -0.14, 0.5
35546, 0.54166666666667, -0.18, 0.5
35547, 0.5625, -0.04, 0.5
35548, 0.58333333333333, -0.02, 0.5
35549, 0.5625, -0.08, 0.5
35550, 0.58333333333333, -0.06, 0.5
35551, 0.5625, -0.12, 0.5
35552, 0.58333333333333, -0.1, 0.5
35553, 0.5625, -0.16, 0.5
35554, 0.58333333333333, -0.14, 0.5
35555, 0.58333333333333, -0.18, 0.5
35556, 0.60416666666667, -0.04, 0.5
35557, 0.625, -0.02, 0.5
35558, 0.60416666666667, -0.08, 0.5
35559, 0.625, -0.06, 0.5
35560, 0.60416666666667, -0.12, 0.5
35561, 0.625, -0.1, 0.5
35562, 0.60416666666667, -0.16, 0.5
35563, 0.625, -0.14, 0.5
35564, 0.625, -0.18, 0.5
35565, 0.64583333333333, -0.04, 0.5
35566, 0.66666666666667, -0.02, 0.5
35567, 0.64583333333333, -0.08, 0.5
35568, 0.66666666666667, -0.06, 0.5
35569, 0.64583333333333, -0.12, 0.5
35570, 0.66666666666667, -0.1, 0.5
35571, 0.64583333333333, -0.16, 0.5
35572, 0.66666666666667, -0.14, 0.5
35573, 0.66666666666667, -0.18, 0.5
35574, 0.6875, -0.04, 0.5
35575, 0.70833333333333, -0.02, 0.5
35576, 0.6875, -0.08, 0.5
35577, 0.70833333333333, -0.06, 0.5
35578, 0.6875, -0.12, 0.5
35579, 0.70833333333333, -0.1, 0.5
35580, 0.6875, -0.16, 0.5
35581, 0.70833333333333, -0.14, 0.5
35582, 0.70833333333333, -0.18, 0.5
35583, 0.72916666666667, -0.04, 0.5
35584, 0.75, -0.02, 0.5
35585, 0.72916666666667, -0.08, 0.5
35586, 0.75, -0.06, 0.5
35587, 0.72916666666667, -0.12, 0.5
35588, 0.75, -0.1, 0.5
35589, 0.72916666666667, -0.16, 0.5
35590, 0.75, -0.14, 0.5
35591, 0.75, -0.18, 0.5
35592, 0.77083333333333, -0.04, 0.5
35593, 0.79166666666667, -0.02, 0.5
35594, 0.77083333333333, -0.08, 0.5
35595, 0.79166666666667, -0.06, 0.5
35596, 0.77083333333333, -0.12, 0.5
35597, 0.79166666666667, -0.1, 0.5
35598, 0.77083333333333, -0.16, 0.5
35599, 0.79166666666667, -0.14, 0.5
35600, 0.79166666666667, -0.18, 0.5
35601, 0.8125, -0.04, 0.5
35602, 0.83333333333333, -0.02, 0.5
35603, 0.8125, -0.08, 0.5
35604, 0.83333333333333, -0.06, 0.5
35605, 0.8125, -0.12, 0.5
35606, 0.83333333333333, -0.1, 0.5
35607, 0.8125, -0.16, 0.5
35608, 0.83333333333333, -0.14, 0.5
35609, 0.83333333333333, -0.18, 0.5
35610, 0.85416666666667, -0.04, 0.5
35611, 0.875, -0.02, 0.5
35612, 0.85416666666667, -0.08, 0.5
35613, 0.875, -0.06, 0.5
35614, 0.85416666666667, -0.12, 0.5
35615, 0.875, -0.1, 0.5
35616, 0.85416666666667, -0.16, 0.5
35617, 0.875, -0.14, 0.5
35618, 0.875, -0.18, 0.5
35619, 0.89583333333333, -0.04, 0.5
35620, 0.91666666666667, -0.02, 0.5
35621, 0.89583333333333, -0.08, 0.5
35622, 0.91666666666667, -0.06, 0.5
35623, 0.89583333333333, -0.12, 0.5
35624, 0.91666666666667, -0.1, 0.5
35625, 0.89583333333333, -0.16, 0.5
35626, 0.91666666666667, -0.14, 0.5
35627, 0.91666666666667, -0.18, 0.5
35628, 0.9375, -0.04, 0.5
35629, 0.95833333333333, -0.02, 0.5
35630, 0.9375, -0.08, 0.5
35631, 0.95833333333333, -0.06, 0.5
35632, 0.9375, -0.12, 0.5
35633, 0.95833333333333, -0.1, 0.5
35634, 0.9375, -0.16, 0.5
35635, 0.95833333333333, -0.14, 0.5
35636, 0.95833333333333, -0.18, 0.5
35637, 0.97916666666667, -0.04, 0.5
35638, 0.97916666666667, -0.08, 0.5
35639, 0.97916666666667, -0.12, 0.5
35640, 0.97916666666667, -0.16, 0.5
35641, 0, -0.04, 0.041666666666667
35642, 0, -0.08, 0.041666666666667
35643, 0, -0.12, 0.041666666666667
35644, 0, -0.16, 0.041666666666667
35645, 0, -0.04, 0.083333333333333
35646, 0, -0.08, 0.083333333333333
35647, 0, -0.12, 0.083333333333333
35648, 0, -0.16, 0.083333333333333
35649, 0, -0.04, 0.125
35650, 0, -0.08, 0.125
35651, 0, -0.12, 0.125
35652, 0, -0.16, 0.125
35653, 0, -0.04, 0.16666666666667
35654, 0, -0.08, 0.16666666666667
35655, 0, -0.12, 0.16666666666667
35656, 0, -0.16, 0.16666666666667
35657, 0, -0.04, 0.20833333333333
35658, 0, -0.08, 0.20833333333333
35659, 0, -0.12, 0.20833333333333
35660, 0, -0.16, 0.20833333333333
35661, 0, -0.04, 0.25
35662, 0, -0.08, 0.25
35663, 0, -0.12, 0.25
35664, 0, -0.16, 0.25
35665, 0, -0.04, 0.29166666666667
35666, 0, -0.08, 0.29166666666667
35667, 0, -0.12, 0.29166666666667
35668, 0, -0.16, 0.29166666666667
35669, 0, -0.04, 0.33333333333333
35670, 0, -0.08, 0.33333333333333
35671, 0, -0.12, 0.33333333333333
35672, 0, -0.16, 0.33333333333333
35673, 0, -0.04, 0.375
35674, 0, -0.08, 0.375
35675, 0, -0.12, 0.375
35676, 0, -0.16, 0.375
35677, 0, -0.04, 0.41666666666667
35678, 0, -0.08, 0.41666666666667
35679, 0, -0.12, 0.41666666666667
35680, 0, -0.16, 0.41666666666667
35681, 0, -0.04, 0.45833333333333
35682, 0, -0.08, 0.45833333333333
35683, 0, -0.12, 0.45833333333333
35684, 0, -0.16, 0.45833333333333
35685, 0, -0.04, 0.020833333333333
35686, 0, -0.02, 0.041666666666667
35687, 0, -0.08, 0.020833333333333
35688, 0, -0.06, 0.041666666666667
35689, 0, -0.12, 0.020833333333333
35690, 0, -0.1, 0.041666666666667
35691, 0, -0.16, 0.020833333333333
35692, 0, -0.14, 0.041666666666667
35693, 0, -0.18, 0.041666666666667
35694, 0, -0.04, 0.0625
35695, 0, -0.02, 0.083333333333333
35696, 0, -0.08, 0.0625
35697, 0, -0.06, 0.083333333333333
35698, 0, -0.12, 0.0625
35699, 0, -0.1, 0.083333333333333
35700, 0, -0.16, 0.0625
35701, 0, -0.14, 0.083333333333333
35702, 0, -0.18, 0.083333333333333
35703, 0, -0.04, 0.10416666666667
35704, 0, -0.02, 0.125
35705, 0, -0.08, 0.10416666666667
35706, 0, -0.06, 0.125
35707, 0, -0.12, 0.10416666666667
35708, 0, -0.1, 0.125
35709, 0, -0.16, 0.10416666666667
35710, 0, -0.14, 0.125
35711, 0, -0.18, 0.125
35712, 0, -0.04, 0.14583333333333
35713, 0, -0.02, 0.16666666666667
35714, 0, -0.08, 0.14583333333333
35715, 0, -0.06, 0.16666666666667
35716, 0, -0.12, 0.14583333333333
35717, 0, -0.1, 0.16666666666667
35718, 0, -0.16, 0.14583333333333
35719, 0, -0.14, 0.16666666666667
35720, 0, -0.18, 0.16666666666667
35721, 0, -0.04, 0.1875
35722, 0, -0.02, 0.20833333333333
35723, 0, -0.08, 0.1875
35724, 0, -0.06, 0.20833333333333
35725, 0, -0.12, 0.1875
35726, 0, -0.1, 0.20833333333333
35727, 0, -0.16, 0.1875
35728, 0, -0.14, 0.20833333333333
35729, 0, -0.18, 0.20833333333333
35730, 0, -0.04, 0.22916666666667
35731, 0, -0.02, 0.25
35732, 0, -0.08, 0.22916666666667
35733, 0, -0.06, 0.25
35734, 0, -0.12, 0.22916666666667
35735, 0, -0.1, 0.25
35736, 0, -0.16, 0.22916666666667
35737, 0, -0.14, 0.25
35738, 0, -0.18, 0.25
35739, 0, -0.04, 0.27083333333333
35740, 0, -0.02, 0.29166666666667
35741, 0, -0.08, 0.27083333333333
35742, 0, -0.06, 0.29166666666667
35743, 0, -0.12, 0.27083333333333
35744, 0, -0.1, 0.29166666666667
35745, 0, -0.16, 0.27083333333333
35746, 0, -0.14, 0.29166666666667
35747, 0, -0.18, 0.29166666666667
35748, 0, -0.04, 0.3125
35749, 0, -0.02, 0.33333333333333
35750, 0, -0.08, 0.3125
35751, 0, -0.06, 0.33333333333333
35752, 0, -0.12, 0.3125
35753, 0, -0.1, 0.33333333333333
35754, 0, -0.16, 0.3125
35755, 0, -0.14, 0.33333333333333
35756, 0, -0.18, 0.33333333333333
35757, 0, -0.04, 0.35416666666667
35758, 0, -0.02, 0.375
35759, 0, -0.08, 0.35416666666667
35760, 0, -0.06, 0.375
35761, 0, -0.12, 0.35416666666667
35762, 0, -0.1, 0.375
35763, 0, -0.16, 0.35416666666667
35764, 0, -0.14, 0.375
35765, 0, -0.18, 0.375
35766, 0, -0.04, 0.39583333333333
35767, 0, -0.02, 0.41666666666667
35768, 0, -0.08, 0.39583333333333
35769, 0, -0.06, 0.41666666666667
35770, 0, -0.12, 0.39583333333333
35771, 0, -0.1, 0.41666666666667
35772, 0, -0.16, 0.39583333333333
35773, 0, -0.14, 0.41666666666667
35774, 0, -0.18, 0.41666666666667
35775, 0, -0.04, 0.4375
35776, 0, -0.02, 0.45833333333333
35777, 0, -0.08, 0.4375
35778, 0, -0.06, 0.45833333333333
35779, 0, -0.12, 0.4375
35780, 0, -0.1, 0.45833333333333
35781, 0, -0.16, 0.4375
35782, 0, -0.14, 0.45833333333333
35783, 0, -0.18, 0.45833333333333
35784, 0, -0.04, 0.47916666666667
35785, 0, -0.08, 0.47916666666667
35786, 0, -0.12, 0.47916666666667
35787, 0, -0.16, 0.47916666666667
35788, 0.041666666666667, -0.2, 0.041666666666667
35789, 0.041666666666667, -0.2, 0.083333333333333
35790, 0.041666666666667, -0.2, 0.125
35791, 0.041666666666667, -0.2, 0.16666666666667
35792, 0.041666666666667, -0.2, 0.20833333333333
35793, 0.041666666666667, -0.2, 0.25
35794, 0.041666666666667, -0.2, 0.29166666666667
35795, 0.041666666666667, -0.2, 0.33333333333333
35796, 0.041666666666667, -0.2, 0.375
35797, 0.041666666666667, -0.2, 0.41666666666667
35798, 0.041666666666667, -0.2, 0.45833333333333
35799, 0.083333333333333, -0.2, 0.041666666666667
35800, 0.083333333333333, -0.2, 0.083333333333333
35801, 0.083333333333333, -0.2, 0.125
35802, 0.083333333333333, -0.2, 0.16666666666667
35803, 0.083333333333333, -0.2, 0.20833333333333
35804, 0.083333333333333, -0.2, 0.25
35805, 0.083333333333333, -0.2, 0.29166666666667
35806, 0.083333333333333, -0.2, 0.33333333333333
35807, 0.083333333333333, -0.2, 0.375
35808, 0.083333333333333, -0.2, 0.41666666666667
35809, 0.083333333333333, -0.2, 0.45833333333333
35810, 0.125, -0.2, 0.041666666666667
35811, 0.125, -0.2, 0.083333333333333
35812, 0.125, -0.2, 0.125
35813, 0.125, -0.2, 0.16666666666667
35814, 0.125, -0.2, 0.20833333333333
35815, 0.125, -0.2, 0.25
35816, 0.125, -0.2, 0.29166666666667
35817, 0.125, -0.2, 0.33333333333333
35818, 0.125, -0.2, 0.375
35819, 0.125, -0.2, 0.41666666666667
35820, 0.125, -0.2, 0.45833333333333
35821, 0.16666666666667, -0.2, 0.041666666666667
35822, 0.16666666666667, -0.2, 0.083333333333333
35823, 0.16666666666667, -0.2, 0.125
35824, 0.16666666666667, -0.2, 0.16666666666667
35825, 0.16666666666667, -0.2, 0.20833333333333
35826, 0.16666666666667, -0.2, 0.25
35827, 0.16666666666667, -0.2, 0.29166666666667
35828, 0.16666666666667, -0.2, 0.33333333333333
35829, 0.16666666666667, -0.2, 0.375
35830, 0.16666666666667, -0.2, 0.41666666666667
35831, 0.16666666666667, -0.2, 0.45833333333333
35832, 0.20833333333333, -0.2, 0.041666666666667
35833, 0.20833333333333, -0.2, 0.083333333333333
35834, 0.20833333333333, -0.2, 0.125
35835, 0.20833333333333, -0.2, 0.16666666666667
35836, 0.20833333333333, -0.2, 0.20833333333333
35837, 0.20833333333333, -0.2, 0.25
35838, 0.20833333333333, -0.2, 0.29166666666667
35839, 0.20833333333333, -0.2, 0.33333333333333
35840, 0.20833333333333, -0.2, 0.375
35841, 0.20833333333333, -0.2, 0.41666666666667
35842, 0.20833333333333, -0.2, 0.45833333333333
35843, 0.25, -0.2, 0.041666666666667
35844, 0.25, -0.2, 0.083333333333333
35845, 0.25, -0.2, 0.125
35846, 0.25, -0.2, 0.16666666666667
35847, 0.25, -0.2, 0.20833333333333
35848, 0.25, -0.2, 0.25
35849, 0.25, -0.2, 0.29166666666667
35850, 0.25, -0.2, 0.33333333333333
35851, 0.25, -0.2, 0.375
35852, 0.25, -0.2, 0.41666666666667
35853, 0.25, -0.2, 0.45833333333333
35854, 0.29166666666667, -0.2, 0.041666666666667
35855, 0.29166666666667, -0.2, 0.083333333333333
35856, 0.29166666666667, -0.2, 0.125
35857, 0.29166666666667, -0.2, 0.16666666666667
35858, 0.29166666666667, -0.2, 0.20833333333333
35859, 0.29166666666667, -0.2, 0.25
35860, 0.29166666666667, -0.2, 0.29166666666667
35861, 0.29166666666667, -0.2, 0.33333333333333
35862, 0.29166666666667, -0.2, 0.375
35863, 0.29166666666667, -0.2, 0.41666666666667
35864, 0.29166666666667, -0.2, 0.45833333333333
35865, 0.33333333333333, -0.2, 0.041666666666667
35866, 0.33333333333333, -0.2, 0.083333333333333
35867, 0.33333333333333, -0.2, 0.125
35868, 0.33333333333333, -0.2, 0.16666666666667
35869, 0.33333333333333, -0.2, 0.20833333333333
35870, 0.33333333333333, -0.2, 0.25
35871, 0.33333333333333, -0.2, 0.29166666666667
35872, 0.33333333333333, -0.2, 0.33333333333333
35873, 0.33333333333333, -0.2, 0.375
35874, 0.33333333333333, -0.2, 0.41666666666667
35875, 0.33333333333333, -0.2, 0.45833333333333
35876, 0.375, -0.2, 0.041666666666667
35877, 0.375, -0.2, 0.083333333333333
35878, 0.375, -0.2, 0.125
35879, 0.375, -0.2, 0.16666666666667
35880, 0.375, -0.2, 0.20833333333333
35881, 0.375, -0.2, 0.25
35882, 0.375, -0.2, 0.29166666666667
35883, 0.375, -0.2, 0.33333333333333
35884, 0.375, -0.2, 0.375
35885, 0.375, -0.2, 0.41666666666667
35886, 0.375, -0.2, 0.45833333333333
35887, 0.41666666666667, -0.2, 0.041666666666667
35888, 0.41666666666667, -0.2, 0.083333333333333
35889, 0.41666666666667, -0.2, 0.125
35890, 0.41666666666667, -0.2, 0.16666666666667
35891, 0.41666666666667, -0.2, 0.20833333333333
35892, 0.41666666666667, -0.2, 0.25
35893, 0.41666666666667, -0.2, 0.29166666666667
35894, 0.41666666666667, -0.2, 0.33333333333333
35895, 0.41666666666667, -0.2, 0.375
35896, 0.41666666666667, -0.2, 0.41666666666667
35897, 0.41666666666667, -0.2, 0.45833333333333
35898, 0.45833333333333, -0.2, 0.041666666666667
35899, 0.45833333333333, -0.2, 0.083333333333333
35900, 0.45833333333333, -0.2, 0.125
35901, 0.45833333333333, -0.2, 0.16666666666667
35902, 0.45833333333333, -0.2, 0.20833333333333
35903, 0.45833333333333, -0.2, 0.25
35904, 0.45833333333333, -0.2, 0.29166666666667
35905, 0.45833333333333, -0.2, 0.33333333333333
35906, 0.45833333333333, -0.2, 0.375
35907, 0.45833333333333, -0.2, 0.41666666666667
35908, 0.45833333333333, -0.2, 0.45833333333333
35909, 0.5, -0.2, 0.041666666666667
35910, 0.5, -0.2, 0.083333333333333
35911, 0.5, -0.2, 0.125
35912, 0.5, -0.2, 0.16666666666667
35913, 0.5, -0.2, 0.20833333333333
35914, 0.5, -0.2, 0.25
35915, 0.5, -0.2, 0.29166666666667
35916, 0.5, -0.2, 0.33333333333333
35917, 0.5, -0.2, 0.375
35918, 0.5, -0.2, 0.41666666666667
35919, 0.5, -0.2, 0.45833333333333
35920, 0.54166666666667, -0.2, 0.041666666666667
35921, 0.54166666666667, -0.2, 0.083333333333333
35922, 0.54166666666667, -0.2, 0.125
35923, 0.54166666666667, -0.2, 0.16666666666667
35924, 0.54166666666667, -0.2, 0.20833333333333
35925, 0.54166666666667, -0.2, 0.25
35926, 0.54166666666667, -0.2, 0.29166666666667
35927, 0.54166666666667, -0.2, 0.33333333333333
35928, 0.54166666666667, -0.2, 0.375
35929, 0.54166666666667, -0.2, 0.41666666666667
35930, 0.54166666666667, -0.2, 0.45833333333333
35931, 0.58333333333333, -0.2, 0.041666666666667
35932, 0.58333333333333, -0.2, 0.083333333333333
35933, 0.58333333333333, -0.2, 0.125
35934, 0.58333333333333, -0.2, 0.16666666666667
35935, 0.58333333333333, -0.2, 0.20833333333333
35936, 0.58333333333333, -0.2, 0.25
35937, 0.58333333333333, -0.2, 0.29166666666667
35938, 0.58333333333333, -0.2, 0.33333333333333
35939, 0.58333333333333, -0.2, 0.375
35940, 0.58333333333333, -0.2, 0.41666666666667
35941, 0.58333333333333, -0.2, 0.45833333333333
35942, 0.625, -0.2, 0.041666666666667
35943, 0.625, -0.2, 0.083333333333333
35944, 0.625, -0.2, 0.125
35945, 0.625, -0.2, 0.16666666666667
35946, 0.625, -0.2, 0.20833333333333
35947, 0.625, -0.2, 0.25
35948, 0.625, -0.2, 0.29166666666667
35949, 0.625, -0.2, 0.33333333333333
35950, 0.625, -0.2, 0.375
35951, 0.625, -0.2, 0.41666666666667
35952, 0.625, -0.2, 0.45833333333333
35953, 0.66666666666667, -0.2, 0.041666666666667
35954, 0.66666666666667, -0.2, 0.083333333333333
35955, 0.66666666666667, -0.2, 0.125
35956, 0.66666666666667, -0.2, 0.16666666666667
35957, 0.66666666666667, -0.2, 0.20833333333333
35958, 0.66666666666667, -0.2, 0.25
35959, 0.66666666666667, -0.2, 0.29166666666667
35960, 0.66666666666667, -0.2, 0.33333333333333
35961, 0.66666666666667, -0.2, 0.375
35962, 0.66666666666667, -0.2, 0.41666666666667
35963, 0.66666666666667, -0.2, 0.45833333333333
35964, 0.70833333333333, -0.2, 0.041666666666667
35965, 0.70833333333333, -0.2, 0.083333333333333
35966, 0.70833333333333, -0.2, 0.125
35967, 0.70833333333333, -0.2, 0.16666666666667
35968, 0.70833333333333, -0.2, 0.20833333333333
35969, 0.70833333333333, -0.2, 0.25
35970, 0.70833333333333, -0.2, 0.29166666666667
35971, 0.70833333333333, -0.2, 0.33333333333333
35972, 0.70833333333333, -0.2, 0.375
35973, 0.70833333333333, -0.2, 0.41666666666667
35974, 0.70833333333333, -0.2, 0.45833333333333
35975, 0.75, -0.2, 0.041666666666667
35976, 0.75, -0.2, 0.083333333333333
35977, 0.75, -0.2, 0.125
35978, 0.75, -0.2, 0.16666666666667
35979, 0.75, -0.2, 0.20833333333333
35980, 0.75, -0.2, 0.25
35981, 0.75, -0.2, 0.29166666666667
35982, 0.75, -0.2, 0.33333333333333
35983, 0.75, -0.2, 0.375
35984, 0.75, -0.2, 0.41666666666667
35985, 0.75, -0.2, 0.45833333333333
35986, 0.79166666666667, -0.2, 0.041666666666667
35987, 0.79166666666667, -0.2, 0.083333333333333
35988, 0.79166666666667, -0.2, 0.125
35989, 0.79166666666667, -0.2, 0.16666666666667
35990, 0.79166666666667, -0.2, 0.20833333333333
35991, 0.79166666666667, -0.2, 0.25
35992, 0.79166666666667, -0.2, 0.29166666666667
35993, 0.79166666666667, -0.2, 0.33333333333333
35994, 0.79166666666667, -0.2, 0.375
35995, 0.79166666666667, -0.2, 0.41666666666667
35996, 0.79166666666667, -0.2, 0.45833333333333
35997, 0.83333333333333, -0.2, 0.041666666666667
35998, 0.83333333333333, -0.2, 0.083333333333333
35999, 0.83333333333333, -0.2, 0.125
36000, 0.83333333333333, -0.2, 0.16666666666667
36001, 0.83333333333333, -0.2, 0.20833333333333
36002, 0.83333333333333, -0.2, 0.25
36003, 0.83333333333333, -0.2, 0.29166666666667
36004, 0.83333333333333, -0.2, 0.33333333333333
36005, 0.83333333333333, -0.2, 0.375
36006, 0.83333333333333, -0.2, 0.41666666666667
36007, 0.83333333333333, -0.2, 0.45833333333333
36008, 0.875, -0.2, 0.041666666666667
36009, 0.875, -0.2, 0.083333333333333
36010, 0.875, -0.2, 0.125
36011, 0.875, -0.2, 0.16666666666667
36012, 0.875, -0.2, 0.20833333333333
36013, 0.875, -0.2, 0.25
36014, 0.875, -0.2, 0.29166666666667
36015, 0.875, -0.2, 0.33333333333333
36016, 0.875, -0.2, 0.375
36017, 0.875, -0.2, 0.41666666666667
36018, 0.875, -0.2, 0.45833333333333
36019, 0.91666666666667, -0.2, 0.041666666666667
36020, 0.91666666666667, -0.2, 0.083333333333333
36021, 0.91666666666667, -0.2, 0.125
36022, 0.91666666666667, -0.2, 0.16666666666667
36023, 0.91666666666667, -0.2, 0.20833333333333
36024, 0.91666666666667, -0.2, 0.25
36025, 0.91666666666667, -0.2, 0.29166666666667
36026, 0.91666666666667, -0.2, 0.33333333333333
36027, 0.91666666666667, -0.2, 0.375
36028, 0.91666666666667, -0.2, 0.41666666666667
36029, 0.91666666666667, -0.2, 0.45833333333333
36030, 0.95833333333333, -0.2, 0.041666666666667
36031, 0.95833333333333, -0.2, 0.083333333333333
36032, 0.95833333333333, -0.2, 0.125
36033, 0.95833333333333, -0.2, 0.16666666666667
36034, 0.95833333333333, -0.2, 0.20833333333333
36035, 0.95833333333333, -0.2, 0.25
36036, 0.95833333333333, -0.2, 0.29166666666667
36037, 0.95833333333333, -0.2, 0.33333333333333
36038, 0.95833333333333, -0.2, 0.375
36039, 0.95833333333333, -0.2, 0.41666666666667
36040, 0.95833333333333, -0.2, 0.45833333333333
36041, 0.041666666666667, -0.2, 0.020833333333333
36042, 0.020833333333333, -0.2, 0.041666666666667
36043, 0.041666666666667, -0.2, 0.0625
36044, 0.020833333333333, -0.2, 0.083333333333333
36045, 0.041666666666667, -0.2, 0.10416666666667
36046, 0.020833333333333, -0.2, 0.125
36047, 0.041666666666667, -0.2, 0.14583333333333
36048, 0.020833333333333, -0.2, 0.16666666666667
36049, 0.041666666666667, -0.2, 0.1875
36050, 0.020833333333333, -0.2, 0.20833333333333
36051, 0.041666666666667, -0.2, 0.22916666666667
36052, 0.020833333333333, -0.2, 0.25
36053, 0.041666666666667, -0.2, 0.27083333333333
36054, 0.020833333333333, -0.2, 0.29166666666667
36055, 0.041666666666667, -0.2, 0.3125
36056, 0.020833333333333, -0.2, 0.33333333333333
36057, 0.041666666666667, -0.2, 0.35416666666667
36058, 0.020833333333333, -0.2, 0.375
36059, 0.041666666666667, -0.2, 0.39583333333333
36060, 0.020833333333333, -0.2, 0.41666666666667
36061, 0.041666666666667, -0.2, 0.4375
36062, 0.020833333333333, -0.2, 0.45833333333333
36063, 0.041666666666667, -0.2, 0.47916666666667
36064, 0.083333333333333, -0.2, 0.020833333333333
36065, 0.0625, -0.2, 0.041666666666667
36066, 0.083333333333333, -0.2, 0.0625
36067, 0.0625, -0.2, 0.083333333333333
36068, 0.083333333333333, -0.2, 0.10416666666667
36069, 0.0625, -0.2, 0.125
36070, 0.083333333333333, -0.2, 0.14583333333333
36071, 0.0625, -0.2, 0.16666666666667
36072, 0.083333333333333, -0.2, 0.1875
36073, 0.0625, -0.2, 0.20833333333333
36074, 0.083333333333333, -0.2, 0.22916666666667
36075, 0.0625, -0.2, 0.25
36076, 0.083333333333333, -0.2, 0.27083333333333
36077, 0.0625, -0.2, 0.29166666666667
36078, 0.083333333333333, -0.2, 0.3125
36079, 0.0625, -0.2, 0.33333333333333
36080, 0.083333333333333, -0.2, 0.35416666666667
36081, 0.0625, -0.2, 0.375
36082, 0.083333333333333, -0.2, 0.39583333333333
36083, 0.0625, -0.2, 0.41666666666667
36084, 0.083333333333333, -0.2, 0.4375
36085, 0.0625, -0.2, 0.45833333333333
36086, 0.083333333333333, -0.2, 0.47916666666667
36087, 0.125, -0.2, 0.020833333333333
36088, 0.10416666666667, -0.2, 0.041666666666667
36089, 0.125, -0.2, 0.0625
36090, 0.10416666666667, -0.2, 0.083333333333333
36091, 0.125, -0.2, 0.10416666666667
36092, 0.10416666666667, -0.2, 0.125
36093, 0.125, -0.2, 0.14583333333333
36094, 0.10416666666667, -0.2, 0.16666666666667
36095, 0.125, -0.2, 0.1875
36096, 0.10416666666667, -0.2, 0.20833333333333
36097, 0.125, -0.2, 0.22916666666667
36098, 0.10416666666667, -0.2, 0.25
36099, 0.125, -0.2, 0.27083333333333
36100, 0.10416666666667, -0.2, 0.29166666666667
36101, 0.125, -0.2, 0.3125
36102, 0.10416666666667, -0.2, 0.33333333333333
36103, 0.125, -0.2, 0.35416666666667
36104, 0.10416666666667, -0.2, 0.375
36105, 0.125, -0.2, 0.39583333333333
36106, 0.10416666666667, -0.2, 0.41666666666667
36107, 0.125, -0.2, 0.4375
36108, 0.10416666666667, -0.2, 0.45833333333333
36109, 0.125, -0.2, 0.47916666666667
36110, 0.16666666666667, -0.2, 0.020833333333333
36111, 0.14583333333333, -0.2, 0.041666666666667
36112, 0.16666666666667, -0.2, 0.0625
36113, 0.14583333333333, -0.2, 0.083333333333333
36114, 0.16666666666667, -0.2, 0.10416666666667
36115, 0.14583333333333, -0.2, 0.125
36116, 0.16666666666667, -0.2, 0.14583333333333
36117, 0.14583333333333, -0.2, 0.16666666666667
36118, 0.16666666666667, -0.2, 0.1875
36119, 0.14583333333333, -0.2, 0.20833333333333
36120, 0.16666666666667, -0.2, 0.22916666666667
36121, 0.14583333333333, -0.2, 0.25
36122, 0.16666666666667, -0.2, 0.27083333333333
36123, 0.14583333333333, -0.2, 0.29166666666667
36124, 0.16666666666667, -0.2, 0.3125
36125, 0.14583333333333, -0.2, 0.33333333333333
36126, 0.16666666666667, -0.2, 0.35416666666667
36127, 0.14583333333333, -0.2, 0.375
36128, 0.16666666666667, -0.2, 0.39583333333333
36129, 0.14583333333333, -0.2, 0.41666666666667
36130, 0.16666666666667, -0.2, 0.4375
36131, 0.14583333333333, -0.2, 0.45833333333333
36132, 0.16666666666667, -0.2, 0.47916666666667
36133, 0.20833333333333, -0.2, 0.020833333333333
36134, 0.1875, -0.2, 0.041666666666667
36135, 0.20833333333333, -0.2, 0.0625
36136, 0.1875, -0.2, 0.083333333333333
36137, 0.20833333333333, -0.2, 0.10416666666667
36138, 0.1875, -0.2, 0.125
36139, 0.20833333333333, -0.2, 0.14583333333333
36140, 0.1875, -0.2, 0.16666666666667
36141, 0.20833333333333, -0.2, 0.1875
36142, 0.1875, -0.2, 0.20833333333333
36143, 0.20833333333333, -0.2, 0.22916666666667
36144, 0.1875, -0.2, 0.25
36145, 0.20833333333333, -0.2, 0.27083333333333
36146, 0.1875, -0.2, 0.29166666666667
36147, 0.20833333333333, -0.2, 0.3125
36148, 0.1875, -0.2, 0.33333333333333
36149, 0.20833333333333, -0.2, 0.35416666666667
36150, 0.1875, -0.2, 0.375
36151, 0.20833333333333, -0.2, 0.39583333333333
36152, 0.1875, -0.2, 0.41666666666667
36153, 0.20833333333333, -0.2, 0.4375
36154, 0.1875, -0.2, 0.45833333333333
36155, 0.20833333333333, -0.2, 0.47916666666667
36156, 0.25, -0.2, 0.020833333333333
36157, 0.22916666666667, -0.2, 0.041666666666667
36158, 0.25, -0.2, 0.0625
36159, 0.22916666666667, -0.2, 0.083333333333333
36160, 0.25, -0.2, 0.10416666666667
36161, 0.22916666666667, -0.2, 0.125
36162, 0.25, -0.2, 0.14583333333333
36163, 0.22916666666667, -0.2, 0.16666666666667
36164, 0.25, -0.2, 0.1875
36165, 0.22916666666667, -0.2, 0.20833333333333
36166, 0.25, -0.2, 0.22916666666667
36167, 0.22916666666667, -0.2, 0.25
36168, 0.25, -0.2, 0.27083333333333
36169, 0.22916666666667, -0.2, 0.29166666666667
36170, 0.25, -0.2, 0.3125
36171, 0.22916666666667, -0.2, 0.33333333333333
36172, 0.25, -0.2, 0.35416666666667
36173, 0.22916666666667, -0.2, 0.375
36174, 0.25, -0.2, 0.39583333333333
36175, 0.22916666666667, -0.2, 0.41666666666667
36176, 0.25, -0.2, 0.4375
36177, 0.22916666666667, -0.2, 0.45833333333333
36178, 0.25, -0.2, 0.47916666666667
36179, 0.29166666666667, -0.2, 0.020833333333333
36180, 0.27083333333333, -0.2, 0.041666666666667
36181, 0.29166666666667, -0.2, 0.0625
36182, 0.27083333333333, -0.2, 0.083333333333333
36183, 0.29166666666667, -0.2, 0.10416666666667
36184, 0.27083333333333, -0.2, 0.125
36185, 0.29166666666667, -0.2, 0.14583333333333
36186, 0.27083333333333, -0.2, 0.16666666666667
36187, 0.29166666666667, -0.2, 0.1875
36188, 0.27083333333333, -0.2, 0.20833333333333
36189, 0.29166666666667, -0.2, 0.22916666666667
36190, 0.27083333333333, -0.2, 0.25
36191, 0.29166666666667, -0.2, 0.27083333333333
36192, 0.27083333333333, -0.2, 0.29166666666667
36193, 0.29166666666667, -0.2, 0.3125
36194, 0.27083333333333, -0.2, 0.33333333333333
36195, 0.29166666666667, -0.2, 0.35416666666667
36196, 0.27083333333333, -0.2, 0.375
36197, 0.29166666666667, -0.2, 0.39583333333333
36198, 0.27083333333333, -0.2, 0.41666666666667
36199, 0.29166666666667, -0.2, 0.4375
36200, 0.27083333333333, -0.2, 0.45833333333333
36201, 0.29166666666667, -0.2, 0.47916666666667
36202, 0.33333333333333, -0.2, 0.020833333333333
36203, 0.3125, -0.2, 0.041666666666667
36204, 0.33333333333333, -0.2, 0.0625
36205, 0.3125, -0.2, 0.083333333333333
36206, 0.33333333333333, -0.2, 0.10416666666667
36207, 0.3125, -0.2, 0.125
36208, 0.33333333333333, -0.2, 0.14583333333333
36209, 0.3125, -0.2, 0.16666666666667
36210, 0.33333333333333, -0.2, 0.1875
36211, 0.3125, -0.2, 0.20833333333333
36212, 0.33333333333333, -0.2, 0.22916666666667
36213, 0.3125, -0.2, 0.25
36214, 0.33333333333333, -0.2, 0.27083333333333
36215, 0.3125, -0.2, 0.29166666666667
36216, 0.33333333333333, -0.2, 0.3125
36217, 0.3125, -0.2, 0.33333333333333
36218, 0.33333333333333, -0.2, 0.35416666666667
36219, 0.3125, -0.2, 0.375
36220, 0.33333333333333, -0.2, 0.39583333333333
36221, 0.3125, -0.2, 0.41666666666667
36222, 0.33333333333333, -0.2, 0.4375
36223, 0.3125, -0.2, 0.45833333333333
36224, 0.33333333333333, -0.2, 0.47916666666667
36225, 0.375, -0.2, 0.020833333333333
36226, 0.35416666666667, -0.2, 0.041666666666667
36227, 0.375, -0.2, 0.0625
36228, 0.35416666666667, -0.2, 0.083333333333333
36229, 0.375, -0.2, 0.10416666666667
36230, 0.35416666666667, -0.2, 0.125
36231, 0.375, -0.2, 0.14583333333333
36232, 0.35416666666667, -0.2, 0.16666666666667
36233, 0.375, -0.2, 0.1875
36234, 0.35416666666667, -0.2, 0.20833333333333
36235, 0.375, -0.2, 0.22916666666667
36236, 0.35416666666667, -0.2, 0.25
36237, 0.375, -0.2, 0.27083333333333
36238, 0.35416666666667, -0.2, 0.29166666666667
36239, 0.375, -0.2, 0.3125
36240, 0.35416666666667, -0.2, 0.33333333333333
36241, 0.375, -0.2, 0.35416666666667
36242, 0.35416666666667, -0.2, 0.375
36243, 0.375, -0.2, 0.39583333333333
36244, 0.35416666666667, -0.2, 0.41666666666667
36245, 0.375, -0.2, 0.4375
36246, 0.35416666666667, -0.2, 0.45833333333333
36247, 0.375, -0.2, 0.47916666666667
36248, 0.41666666666667, -0.2, 0.020833333333333
36249, 0.39583333333333, -0.2, 0.041666666666667
36250, 0.41666666666667, -0.2, 0.0625
36251, 0.39583333333333, -0.2, 0.083333333333333
36252, 0.41666666666667, -0.2, 0.10416666666667
36253, 0.39583333333333, -0.2, 0.125
36254, 0.41666666666667, -0.2, 0.14583333333333
36255, 0.39583333333333, -0.2, 0.16666666666667
36256, 0.41666666666667, -0.2, 0.1875
36257, 0.39583333333333, -0.2, 0.20833333333333
36258, 0.41666666666667, -0.2, 0.22916666666667
36259, 0.39583333333333, -0.2, 0.25
36260, 0.41666666666667, -0.2, 0.27083333333333
36261, 0.39583333333333, -0.2, 0.29166666666667
36262, 0.41666666666667, -0.2, 0.3125
36263, 0.39583333333333, -0.2, 0.33333333333333
36264, 0.41666666666667, -0.2, 0.35416666666667
36265, 0.39583333333333, -0.2, 0.375
36266, 0.41666666666667, -0.2, 0.39583333333333
36267, 0.39583333333333, -0.2, 0.41666666666667
36268, 0.41666666666667, -0.2, 0.4375
36269, 0.39583333333333, -0.2, 0.45833333333333
36270, 0.41666666666667, -0.2, 0.47916666666667
36271, 0.45833333333333, -0.2, 0.020833333333333
36272, 0.4375, -0.2, 0.041666666666667
36273, 0.45833333333333, -0.2, 0.0625
36274, 0.4375, -0.2, 0.083333333333333
36275, 0.45833333333333, -0.2, 0.10416666666667
36276, 0.4375, -0.2, 0.125
36277, 0.45833333333333, -0.2, 0.14583333333333
36278, 0.4375, -0.2, 0.16666666666667
36279, 0.45833333333333, -0.2, 0.1875
36280, 0.4375, -0.2, 0.20833333333333
36281, 0.45833333333333, -0.2, 0.22916666666667
36282, 0.4375, -0.2, 0.25
36283, 0.45833333333333, -0.2, 0.27083333333333
36284, 0.4375, -0.2, 0.29166666666667
36285, 0.45833333333333, -0.2, 0.3125
36286, 0.4375, -0.2, 0.33333333333333
36287, 0.45833333333333, -0.2, 0.35416666666667
36288, 0.4375, -0.2, 0.375
36289, 0.45833333333333, -0.2, 0.39583333333333
36290, 0.4375, -0.2, 0.41666666666667
36291, 0.45833333333333, -0.2, 0.4375
36292, 0.4375, -0.2, 0.45833333333333
36293, 0.45833333333333, -0.2, 0.47916666666667
36294, 0.5, -0.2, 0.020833333333333
36295, 0.47916666666667, -0.2, 0.041666666666667
36296, 0.5, -0.2, 0.0625
36297, 0.47916666666667, -0.2, 0.083333333333333
36298, 0.5, -0.2, 0.10416666666667
36299, 0.47916666666667, -0.2, 0.125
36300, 0.5, -0.2, 0.14583333333333
36301, 0.47916666666667, -0.2, 0.16666666666667
36302, 0.5, -0.2, 0.1875
36303, 0.47916666666667, -0.2, 0.20833333333333
36304, 0.5, -0.2, 0.22916666666667
36305, 0.47916666666667, -0.2, 0.25
36306, 0.5, -0.2, 0.27083333333333
36307, 0.47916666666667, -0.2, 0.29166666666667
36308, 0.5, -0.2, 0.3125
36309, 0.47916666666667, -0.2, 0.33333333333333
36310, 0.5, -0.2, 0.35416666666667
36311, 0.47916666666667, -0.2, 0.375
36312, 0.5, -0.2, 0.39583333333333
36313, 0.47916666666667, -0.2, 0.41666666666667
36314, 0.5, -0.2, 0.4375
36315, 0.47916666666667, -0.2, 0.45833333333333
36316, 0.5, -0.2, 0.47916666666667
36317, 0.54166666666667, -0.2, 0.020833333333333
36318, 0.52083333333333, -0.2, 0.041666666666667
36319, 0.54166666666667, -0.2, 0.0625
36320, 0.52083333333333, -0.2, 0.083333333333333
36321, 0.54166666666667, -0.2, 0.10416666666667
36322, 0.52083333333333, -0.2, 0.125
36323, 0.54166666666667, -0.2, 0.14583333333333
36324, 0.52083333333333, -0.2, 0.16666666666667
36325, 0.54166666666667, -0.2, 0.1875
36326, 0.52083333333333, -0.2, 0.20833333333333
36327, 0.54166666666667, -0.2, 0.22916666666667
36328, 0.52083333333333, -0.2, 0.25
36329, 0.54166666666667, -0.2, 0.27083333333333
36330, 0.52083333333333, -0.2, 0.29166666666667
36331, 0.54166666666667, -0.2, 0.3125
36332, 0.52083333333333, -0.2, 0.33333333333333
36333, 0.54166666666667, -0.2, 0.35416666666667
36334, 0.52083333333333, -0.2, 0.375
36335, 0.54166666666667, -0.2, 0.39583333333333
36336, 0.52083333333333, -0.2, 0.41666666666667
36337, 0.54166666666667, -0.2, 0.4375
36338, 0.52083333333333, -0.2, 0.45833333333333
36339, 0.54166666666667, -0.2, 0.47916666666667
36340, 0.58333333333333, -0.2, 0.020833333333333
36341, 0.5625, -0.2, 0.041666666666667
36342, 0.58333333333333, -0.2, 0.0625
36343, 0.5625, -0.2, 0.083333333333333
36344, 0.58333333333333, -0.2, 0.10416666666667
36345, 0.5625, -0.2, 0.125
36346, 0.58333333333333, -0.2, 0.14583333333333
36347, 0.5625, -0.2, 0.16666666666667
36348, 0.58333333333333, -0.2, 0.1875
36349, 0.5625, -0.2, 0.20833333333333
36350, 0.58333333333333, -0.2, 0.22916666666667
36351, 0.5625, -0.2, 0.25
36352, 0.58333333333333, -0.2, 0.27083333333333
36353, 0.5625, -0.2, 0.29166666666667
36354, 0.58333333333333, -0.2, 0.3125
36355, 0.5625, -0.2, 0.33333333333333
36356, 0.58333333333333, -0.2, 0.35416666666667
36357, 0.5625, -0.2, 0.375
36358, 0.58333333333333, -0.2, 0.39583333333333
36359, 0.5625, -0.2, 0.41666666666667
36360, 0.58333333333333, -0.2, 0.4375
36361, 0.5625, -0.2, 0.45833333333333
36362, 0.58333333333333, -0.2, 0.47916666666667
36363, 0.625, -0.2, 0.020833333333333
36364, 0.60416666666667, -0.2, 0.041666666666667
36365, 0.625, -0.2, 0.0625
36366, 0.60416666666667, -0.2, 0.083333333333333
36367, 0.625, -0.2, 0.10416666666667
36368, 0.60416666666667, -0.2, 0.125
36369, 0.625, -0.2, 0.14583333333333
36370, 0.60416666666667, -0.2, 0.16666666666667
36371, 0.625, -0.2, 0.1875
36372, 0.60416666666667, -0.2, 0.20833333333333
36373, 0.625, -0.2, 0.22916666666667
36374, 0.60416666666667, -0.2, 0.25
36375, 0.625, -0.2, 0.27083333333333
36376, 0.60416666666667, -0.2, 0.29166666666667
36377, 0.625, -0.2, 0.3125
36378, 0.60416666666667, -0.2, 0.33333333333333
36379, 0.625, -0.2, 0.35416666666667
36380, 0.60416666666667, -0.2, 0.375
36381, 0.625, -0.2, 0.39583333333333
36382, 0.60416666666667, -0.2, 0.41666666666667
36383, 0.625, -0.2, 0.4375
36384, 0.60416666666667, -0.2, 0.45833333333333
36385, 0.625, -0.2, 0.47916666666667
36386, 0.66666666666667, -0.2, 0.020833333333333
36387, 0.64583333333333, -0.2, 0.041666666666667
36388, 0.66666666666667, -0.2, 0.0625
36389, 0.64583333333333, -0.2, 0.083333333333333
36390, 0.66666666666667, -0.2, 0.10416666666667
36391, 0.64583333333333, -0.2, 0.125
36392, 0.66666666666667, -0.2, 0.14583333333333
36393, 0.64583333333333, -0.2, 0.16666666666667
36394, 0.66666666666667, -0.2, 0.1875
36395, 0.64583333333333, -0.2, 0.20833333333333
36396, 0.66666666666667, -0.2, 0.22916666666667
36397, 0.64583333333333, -0.2, 0.25
36398, 0.66666666666667, -0.2, 0.27083333333333
36399, 0.64583333333333, -0.2, 0.29166666666667
36400, 0.66666666666667, -0.2, 0.3125
36401, 0.64583333333333, -0.2, 0.33333333333333
36402, 0.66666666666667, -0.2, 0.35416666666667
36403, 0.64583333333333, -0.2, 0.375
36404, 0.66666666666667, -0.2, 0.39583333333333
36405, 0.64583333333333, -0.2, 0.41666666666667
36406, 0.66666666666667, -0.2, 0.4375
36407, 0.64583333333333, -0.2, 0.45833333333333
36408, 0.66666666666667, -0.2, 0.47916666666667
36409, 0.70833333333333, -0.2, 0.020833333333333
36410, 0.6875, -0.2, 0.041666666666667
36411, 0.70833333333333, -0.2, 0.0625
36412, 0.6875, -0.2, 0.083333333333333
36413, 0.70833333333333, -0.2, 0.10416666666667
36414, 0.6875, -0.2, 0.125
36415, 0.70833333333333, -0.2, 0.14583333333333
36416, 0.6875, -0.2, 0.16666666666667
36417, 0.70833333333333, -0.2, 0.1875
36418, 0.6875, -0.2, 0.20833333333333
36419, 0.70833333333333, -0.2, 0.22916666666667
36420, 0.6875, -0.2, 0.25
36421, 0.70833333333333, -0.2, 0.27083333333333
36422, 0.6875, -0.2, 0.29166666666667
36423, 0.70833333333333, -0.2, 0.3125
36424, 0.6875, -0.2, 0.33333333333333
36425, 0.70833333333333, -0.2, 0.35416666666667
36426, 0.6875, -0.2, 0.375
36427, 0.70833333333333, -0.2, 0.39583333333333
36428, 0.6875, -0.2, 0.41666666666667
36429, 0.70833333333333, -0.2, 0.4375
36430, 0.6875, -0.2, 0.45833333333333
36431, 0.70833333333333, -0.2, 0.47916666666667
36432, 0.75, -0.2, 0.020833333333333
36433, 0.72916666666667, -0.2, 0.041666666666667
36434, 0.75, -0.2, 0.0625
36435, 0.72916666666667, -0.2, 0.083333333333333
36436, 0.75, -0.2, 0.10416666666667
36437, 0.72916666666667, -0.2, 0.125
36438, 0.75, -0.2, 0.14583333333333
36439, 0.72916666666667, -0.2, 0.16666666666667
36440, 0.75, -0.2, 0.1875
36441, 0.72916666666667, -0.2, 0.20833333333333
36442, 0.75, -0.2, 0.22916666666667
36443, 0.72916666666667, -0.2, 0.25
36444, 0.75, -0.2, 0.27083333333333
36445, 0.72916666666667, -0.2, 0.29166666666667
36446, 0.75, -0.2, 0.3125
36447, 0.72916666666667, -0.2, 0.33333333333333
36448, 0.75, -0.2, 0.35416666666667
36449, 0.72916666666667, -0.2, 0.375
36450, 0.75, -0.2, 0.39583333333333
36451, 0.72916666666667, -0.2, 0.41666666666667
36452, 0.75, -0.2, 0.4375
36453, 0.72916666666667, -0.2, 0.45833333333333
36454, 0.75, -0.2, 0.47916666666667
36455, 0.79166666666667, -0.2, 0.020833333333333
36456, 0.77083333333333, -0.2, 0.041666666666667
36457, 0.79166666666667, -0.2, 0.0625
36458, 0.77083333333333, -0.2, 0.083333333333333
36459, 0.79166666666667, -0.2, 0.10416666666667
36460, 0.77083333333333, -0.2, 0.125
36461, 0.79166666666667, -0.2, 0.14583333333333
36462, 0.77083333333333, -0.2, 0.16666666666667
36463, 0.79166666666667, -0.2, 0.1875
36464, 0.77083333333333, -0.2, 0.20833333333333
36465, 0.79166666666667, -0.2, 0.22916666666667
36466, 0.77083333333333, -0.2, 0.25
36467, 0.79166666666667, -0.2, 0.27083333333333
36468, 0.77083333333333, -0.2, 0.29166666666667
36469, 0.79166666666667, -0.2, 0.3125
36470, 0.77083333333333, -0.2, 0.33333333333333
36471, 0.79166666666667, -0.2, 0.35416666666667
36472, 0.77083333333333, -0.2, 0.375
36473, 0.79166666666667, -0.2, 0.39583333333333
36474, 0.77083333333333, -0.2, 0.41666666666667
36475, 0.79166666666667, -0.2, 0.4375
36476, 0.77083333333333, -0.2, 0.45833333333333
36477, 0.79166666666667, -0.2, 0.47916666666667
36478, 0.83333333333333, -0.2, 0.020833333333333
36479, 0.8125, -0.2, 0.041666666666667
36480, 0.83333333333333, -0.2, 0.0625
36481, 0.8125, -0.2, 0.083333333333333
36482, 0.83333333333333, -0.2, 0.10416666666667
36483, 0.8125, -0.2, 0.125
36484, 0.83333333333333, -0.2, 0.14583333333333
36485, 0.8125, -0.2, 0.16666666666667
36486, 0.83333333333333, -0.2, 0.1875
36487, 0.8125, -0.2, 0.20833333333333
36488, 0.83333333333333, -0.2, 0.22916666666667
36489, 0.8125, -0.2, 0.25
36490, 0.83333333333333, -0.2, 0.27083333333333
36491, 0.8125, -0.2, 0.29166666666667
36492, 0.83333333333333, -0.2, 0.3125
36493, 0.8125, -0.2, 0.33333333333333
36494, 0.83333333333333, -0.2, 0.35416666666667
36495, 0.8125, -0.2, 0.375
36496, 0.83333333333333, -0.2, 0.39583333333333
36497, 0.8125, -0.2, 0.41666666666667
36498, 0.83333333333333, -0.2, 0.4375
36499, 0.8125, -0.2, 0.45833333333333
36500, 0.83333333333333, -0.2, 0.47916666666667
36501, 0.875, -0.2, 0.020833333333333
36502, 0.85416666666667, -0.2, 0.041666666666667
36503, 0.875, -0.2, 0.0625
36504, 0.85416666666667, -0.2, 0.083333333333333
36505, 0.875, -0.2, 0.10416666666667
36506, 0.85416666666667, -0.2, 0.125
36507, 0.875, -0.2, 0.14583333333333
36508, 0.85416666666667, -0.2, 0.16666666666667
36509, 0.875, -0.2, 0.1875
36510, 0.85416666666667, -0.2, 0.20833333333333
36511, 0.875, -0.2, 0.22916666666667
36512, 0.85416666666667, -0.2, 0.25
36513, 0.875, -0.2, 0.27083333333333
36514, 0.85416666666667, -0.2, 0.29166666666667
36515, 0.875, -0.2, 0.3125
36516, 0.85416666666667, -0.2, 0.33333333333333
36517, 0.875, -0.2, 0.35416666666667
36518, 0.85416666666667, -0.2, 0.375
36519, 0.875, -0.2, 0.39583333333333
36520, 0.85416666666667, -0.2, 0.41666666666667
36521, 0.875, -0.2, 0.4375
36522, 0.85416666666667, -0.2, 0.45833333333333
36523, 0.875, -0.2, 0.47916666666667
36524, 0.91666666666667, -0.2, 0.020833333333333
36525, 0.89583333333333, -0.2, 0.041666666666667
36526, 0.91666666666667, -0.2, 0.0625
36527, 0.89583333333333, -0.2, 0.083333333333333
36528, 0.91666666666667, -0.2, 0.10416666666667
36529, 0.89583333333333, -0.2, 0.125
36530, 0.91666666666667, -0.2, 0.14583333333333
36531, 0.89583333333333, -0.2, 0.16666666666667
36532, 0.91666666666667, -0.2, 0.1875
36533, 0.89583333333333, -0.2, 0.20833333333333
36534, 0.91666666666667, -0.2, 0.22916666666667
36535, 0.89583333333333, -0.2, 0.25
36536, 0.91666666666667, -0.2, 0.27083333333333
36537, 0.89583333333333, -0.2, 0.29166666666667
36538, 0.91666666666667, -0.2, 0.3125
36539, 0.89583333333333, -0.2, 0.33333333333333
36540, 0.91666666666667, -0.2, 0.35416666666667
36541, 0.89583333333333, -0.2, 0.375
36542, 0.91666666666667, -0.2, 0.39583333333333
36543, 0.89583333333333, -0.2, 0.41666666666667
36544, 0.91666666666667, -0.2, 0.4375
36545, 0.89583333333333, -0.2, 0.45833333333333
36546, 0.91666666666667, -0.2, 0.47916666666667
36547, 0.95833333333333, -0.2, 0.020833333333333
36548, 0.9375, -0.2, 0.041666666666667
36549, 0.95833333333333, -0.2, 0.0625
36550, 0.9375, -0.2, 0.083333333333333
36551, 0.95833333333333, -0.2, 0.10416666666667
36552, 0.9375, -0.2, 0.125
36553, 0.95833333333333, -0.2, 0.14583333333333
36554, 0.9375, -0.2, 0.16666666666667
36555, 0.95833333333333, -0.2, 0.1875
36556, 0.9375, -0.2, 0.20833333333333
36557, 0.95833333333333, -0.2, 0.22916666666667
36558, 0.9375, -0.2, 0.25
36559, 0.95833333333333, -0.2, 0.27083333333333
36560, 0.9375, -0.2, 0.29166666666667
36561, 0.95833333333333, -0.2, 0.3125
36562, 0.9375, -0.2, 0.33333333333333
36563, 0.95833333333333, -0.2, 0.35416666666667
36564, 0.9375, -0.2, 0.375
36565, 0.95833333333333, -0.2, 0.39583333333333
36566, 0.9375, -0.2, 0.41666666666667
36567, 0.95833333333333, -0.2, 0.4375
36568, 0.9375, -0.2, 0.45833333333333
36569, 0.95833333333333, -0.2, 0.47916666666667
36570, 0.97916666666667, -0.2, 0.041666666666667
36571, 0.97916666666667, -0.2, 0.083333333333333
36572, 0.97916666666667, -0.2, 0.125
36573, 0.97916666666667, -0.2, 0.16666666666667
36574, 0.97916666666667, -0.2, 0.20833333333333
36575, 0.97916666666667, -0.2, 0.25
36576, 0.97916666666667, -0.2, 0.29166666666667
36577, 0.97916666666667, -0.2, 0.33333333333333
36578, 0.97916666666667, -0.2, 0.375
36579, 0.97916666666667, -0.2, 0.41666666666667
36580, 0.97916666666667, -0.2, 0.45833333333333
36581, -0.05, -0.04, 0.5
36582, -0.05, -0.08, 0.5
36583, -0.05, -0.12, 0.5
36584, -0.05, -0.16, 0.5
36585, -0.05, -0.04, 0
36586, -0.05, -0.08, 0
36587, -0.05, -0.12, 0
36588, -0.05, -0.16, 0
36589, -0.1, -0.04, 0.041666666666667
36590, -0.1, -0.08, 0.041666666666667
36591, -0.1, -0.12, 0.041666666666667
36592, -0.1, -0.16, 0.041666666666667
36593, -0.1, -0.04, 0.083333333333333
36594, -0.1, -0.08, 0.083333333333333
36595, -0.1, -0.12, 0.083333333333333
36596, -0.1, -0.16, 0.083333333333333
36597, -0.1, -0.04, 0.125
36598, -0.1, -0.08, 0.125
36599, -0.1, -0.12, 0.125
36600, -0.1, -0.16, 0.125
36601, -0.1, -0.04, 0.16666666666667
36602, -0.1, -0.08, 0.16666666666667
36603, -0.1, -0.12, 0.16666666666667
36604, -0.1, -0.16, 0.16666666666667
36605, -0.1, -0.04, 0.20833333333333
36606, -0.1, -0.08, 0.20833333333333
36607, -0.1, -0.12, 0.20833333333333
36608, -0.1, -0.16, 0.20833333333333
36609, -0.1, -0.04, 0.25
36610, -0.1, -0.08, 0.25
36611, -0.1, -0.12, 0.25
36612, -0.1, -0.16, 0.25
36613, -0.1, -0.04, 0.29166666666667
36614, -0.1, -0.08, 0.29166666666667
36615, -0.1, -0.12, 0.29166666666667
36616, -0.1, -0.16, 0.29166666666667
36617, -0.1, -0.04, 0.33333333333333
36618, -0.1, -0.08, 0.33333333333333
36619, -0.1, -0.12, 0.33333333333333
36620, -0.1, -0.16, 0.33333333333333
36621, -0.1, -0.04, 0.375
36622, -0.1, -0.08, 0.375
36623, -0.1, -0.12, 0.375
36624, -0.1, -0.16, 0.375
36625, -0.1, -0.04, 0.41666666666667
36626, -0.1, -0.08, 0.41666666666667
36627, -0.1, -0.12, 0.41666666666667
36628, -0.1, -0.16, 0.41666666666667
36629, -0.1, -0.04, 0.45833333333333
36630, -0.1, -0.08, 0.45833333333333
36631, -0.1, -0.12, 0.45833333333333
36632, -0.1, -0.16, 0.45833333333333
36633, -0.1, -0.04, 0.020833333333333
36634, -0.1, -0.02, 0.041666666666667
36635, -0.1, -0.08, 0.020833333333333
36636, -0.1, -0.06, 0.041666666666667
36637, -0.1, -0.12, 0.020833333333333
36638, -0.1, -0.1, 0.041666666666667
36639, -0.1, -0.16, 0.020833333333333
36640, -0.1, -0.14, 0.041666666666667
36641, -0.1, -0.18, 0.041666666666667
36642, -0.1, -0.04, 0.0625
36643, -0.1, -0.02, 0.083333333333333
36644, -0.1, -0.08, 0.0625
36645, -0.1, -0.06, 0.083333333333333
36646, -0.1, -0.12, 0.0625
36647, -0.1, -0.1, 0.083333333333333
36648, -0.1, -0.16, 0.0625
36649, -0.1, -0.14, 0.083333333333333
36650, -0.1, -0.18, 0.083333333333333
36651, -0.1, -0.04, 0.10416666666667
36652, -0.1, -0.02, 0.125
36653, -0.1, -0.08, 0.10416666666667
36654, -0.1, -0.06, 0.125
36655, -0.1, -0.12, 0.10416666666667
36656, -0.1, -0.1, 0.125
36657, -0.1, -0.16, 0.10416666666667
36658, -0.1, -0.14, 0.125
36659, -0.1, -0.18, 0.125
36660, -0.1, -0.04, 0.14583333333333
36661, -0.1, -0.02, 0.16666666666667
36662, -0.1, -0.08, 0.14583333333333
36663, -0.1, -0.06, 0.16666666666667
36664, -0.1, -0.12, 0.14583333333333
36665, -0.1, -0.1, 0.16666666666667
36666, -0.1, -0.16, 0.14583333333333
36667, -0.1, -0.14, 0.16666666666667
36668, -0.1, -0.18, 0.16666666666667
36669, -0.1, -0.04, 0.1875
36670, -0.1, -0.02, 0.20833333333333
36671, -0.1, -0.08, 0.1875
36672, -0.1, -0.06, 0.20833333333333
36673, -0.1, -0.12, 0.1875
36674, -0.1, -0.1, 0.20833333333333
36675, -0.1, -0.16, 0.1875
36676, -0.1, -0.14, 0.20833333333333
36677, -0.1, -0.18, 0.20833333333333
36678, -0.1, -0.04, 0.22916666666667
36679, -0.1, -0.02, 0.25
36680, -0.1, -0.08, 0.22916666666667
36681, -0.1, -0.06, 0.25
36682, -0.1, -0.12, 0.22916666666667
36683, -0.1, -0.1, 0.25
36684, -0.1, -0.16, 0.22916666666667
36685, -0.1, -0.14, 0.25
36686, -0.1, -0.18, 0.25
36687, -0.1, -0.04, 0.27083333333333
36688, -0.1, -0.02, 0.29166666666667
36689, -0.1, -0.08, 0.27083333333333
36690, -0.1, -0.06, 0.29166666666667
36691, -0.1, -0.12, 0.27083333333333
36692, -0.1, -0.1, 0.29166666666667
36693, -0.1, -0.16, 0.27083333333333
36694, -0.1, -0.14, 0.29166666666667
36695, -0.1, -0.18, 0.29166666666667
36696, -0.1, -0.04, 0.3125
36697, -0.1, -0.02, 0.33333333333333
36698, -0.1, -0.08, 0.3125
36699, -0.1, -0.06, 0.33333333333333
36700, -0.1, -0.12, 0.3125
36701, -0.1, -0.1, 0.33333333333333
36702, -0.1, -0.16, 0.3125
36703, -0.1, -0.14, 0.33333333333333
36704, -0.1, -0.18, 0.33333333333333
36705, -0.1, -0.04, 0.35416666666667
36706, -0.1, -0.02, 0.375
36707, -0.1, -0.08, 0.35416666666667
36708, -0.1, -0.06, 0.375
36709, -0.1, -0.12, 0.35416666666667
36710, -0.1, -0.1, 0.375
36711, -0.1, -0.16, 0.35416666666667
36712, -0.1, -0.14, 0.375
36713, -0.1, -0.18, 0.375
36714, -0.1, -0.04, 0.39583333333333
36715, -0.1, -0.02, 0.41666666666667
36716, -0.1, -0.08, 0.39583333333333
36717, -0.1, -0.06, 0.41666666666667
36718, -0.1, -0.12, 0.39583333333333
36719, -0.1, -0.1, 0.41666666666667
36720, -0.1, -0.16, 0.39583333333333
36721, -0.1, -0.14, 0.41666666666667
36722, -0.1, -0.18, 0.41666666666667
36723, -0.1, -0.04, 0.4375
36724, -0.1, -0.02, 0.45833333333333
36725, -0.1, -0.08, 0.4375
36726, -0.1, -0.06, 0.45833333333333
36727, -0.1, -0.12, 0.4375
36728, -0.1, -0.1, 0.45833333333333
36729, -0.1, -0.16, 0.4375
36730, -0.1, -0.14, 0.45833333333333
36731, -0.1, -0.18, 0.45833333333333
36732, -0.1, -0.04, 0.47916666666667
36733, -0.1, -0.08, 0.47916666666667
36734, -0.1, -0.12, 0.47916666666667
36735, -0.1, -0.16, 0.47916666666667
36736, -0.05, -0.2, 0.041666666666667
36737, -0.05, -0.2, 0.083333333333333
36738, -0.05, -0.2, 0.125
36739, -0.05, -0.2, 0.16666666666667
36740, -0.05, -0.2, 0.20833333333333
36741, -0.05, -0.2, 0.25
36742, -0.05, -0.2, 0.29166666666667
36743, -0.05, -0.2, 0.33333333333333
36744, -0.05, -0.2, 0.375
36745, -0.05, -0.2, 0.41666666666667
36746, -0.05, -0.2, 0.45833333333333
36747, 1.2416666666667, -0.04, 0.5
36748, 1.2416666666667, -0.08, 0.5
36749, 1.2416666666667, -0.12, 0.5
36750, 1.2416666666667, -0.16, 0.5
36751, 1.2833333333333, -0.04, 0.5
36752, 1.2833333333333, -0.08, 0.5
36753, 1.2833333333333, -0.12, 0.5
36754, 1.2833333333333, -0.16, 0.5
36755, 1.325, -0.04, 0.5
36756, 1.325, -0.08, 0.5
36757, 1.325, -0.12, 0.5
36758, 1.325, -0.16, 0.5
36759, 1.3666666666667, -0.04, 0.5
36760, 1.3666666666667, -0.08, 0.5
36761, 1.3666666666667, -0.12, 0.5
36762, 1.3666666666667, -0.16, 0.5
36763, 1.4083333333333, -0.04, 0.5
36764, 1.4083333333333, -0.08, 0.5
36765, 1.4083333333333, -0.12, 0.5
36766, 1.4083333333333, -0.16, 0.5
36767, 1.45, -0.04, 0.5
36768, 1.45, -0.08, 0.5
36769, 1.45, -0.12, 0.5
36770, 1.45, -0.16, 0.5
36771, 1.4916666666667, -0.04, 0.5
36772, 1.4916666666667, -0.08, 0.5
36773, 1.4916666666667, -0.12, 0.5
36774, 1.4916666666667, -0.16, 0.5
36775, 1.5333333333333, -0.04, 0.5
36776, 1.5333333333333, -0.08, 0.5
36777, 1.5333333333333, -0.12, 0.5
36778, 1.5333333333333, -0.16, 0.5
36779, 1.575, -0.04, 0.5
36780, 1.575, -0.08, 0.5
36781, 1.575, -0.12, 0.5
36782, 1.575, -0.16, 0.5
36783, 1.6166666666667, -0.04, 0.5
36784, 1.6166666666667, -0.08, 0.5
36785, 1.6166666666667, -0.12, 0.5
36786, 1.6166666666667, -0.16, 0.5
36787, 1.6583333333333, -0.04, 0.5
36788, 1.6583333333333, -0.08, 0.5
36789, 1.6583333333333, -0.12, 0.5
36790, 1.6583333333333, -0.16, 0.5
36791, 1.7, -0.04, 0.5
36792, 1.7, -0.08, 0.5
36793, 1.7, -0.12, 0.5
36794, 1.7, -0.16, 0.5
36795, 1.7416666666667, -0.04, 0.5
36796, 1.7416666666667, -0.08, 0.5
36797, 1.7416666666667, -0.12, 0.5
36798, 1.7416666666667, -0.16, 0.5
36799, 1.7833333333333, -0.04, 0.5
36800, 1.7833333333333, -0.08, 0.5
36801, 1.7833333333333, -0.12, 0.5
36802, 1.7833333333333, -0.16, 0.5
36803, 1.825, -0.04, 0.5
36804, 1.825, -0.08, 0.5
36805, 1.825, -0.12, 0.5
36806, 1.825, -0.16, 0.5
36807, 1.8666666666667, -0.04, 0.5
36808, 1.8666666666667, -0.08, 0.5
36809, 1.8666666666667, -0.12, 0.5
36810, 1.8666666666667, -0.16, 0.5
36811, 1.9083333333333, -0.04, 0.5
36812, 1.9083333333333, -0.08, 0.5
36813, 1.9083333333333, -0.12, 0.5
36814, 1.9083333333333, -0.16, 0.5
36815, 1.95, -0.04, 0.5
36816, 1.95, -0.08, 0.5
36817, 1.95, -0.12, 0.5
36818, 1.95, -0.16, 0.5
36819, 1.9916666666667, -0.04, 0.5
36820, 1.9916666666667, -0.08, 0.5
36821, 1.9916666666667, -0.12, 0.5
36822, 1.9916666666667, -0.16, 0.5
36823, 2.0333333333333, -0.04, 0.5
36824, 2.0333333333333, -0.08, 0.5
36825, 2.0333333333333, -0.12, 0.5
36826, 2.0333333333333, -0.16, 0.5
36827, 2.075, -0.04, 0.5
36828, 2.075, -0.08, 0.5
36829, 2.075, -0.12, 0.5
36830, 2.075, -0.16, 0.5
36831, 2.1166666666667, -0.04, 0.5
36832, 2.1166666666667, -0.08, 0.5
36833, 2.1166666666667, -0.12, 0.5
36834, 2.1166666666667, -0.16, 0.5
36835, 2.1583333333333, -0.04, 0.5
36836, 2.1583333333333, -0.08, 0.5
36837, 2.1583333333333, -0.12, 0.5
36838, 2.1583333333333, -0.16, 0.5
36839, 1.2208333333333, -0.04, 0.5
36840, 1.2416666666667, -0.02, 0.5
36841, 1.2208333333333, -0.08, 0.5
36842, 1.2416666666667, -0.06, 0.5
36843, 1.2208333333333, -0.12, 0.5
36844, 1.2416666666667, -0.1, 0.5
36845, 1.2208333333333, -0.16, 0.5
36846, 1.2416666666667, -0.14, 0.5
36847, 1.2416666666667, -0.18, 0.5
36848, 1.2625, -0.04, 0.5
36849, 1.2833333333333, -0.02, 0.5
36850, 1.2625, -0.08, 0.5
36851, 1.2833333333333, -0.06, 0.5
36852, 1.2625, -0.12, 0.5
36853, 1.2833333333333, -0.1, 0.5
36854, 1.2625, -0.16, 0.5
36855, 1.2833333333333, -0.14, 0.5
36856, 1.2833333333333, -0.18, 0.5
36857, 1.3041666666667, -0.04, 0.5
36858, 1.325, -0.02, 0.5
36859, 1.3041666666667, -0.08, 0.5
36860, 1.325, -0.06, 0.5
36861, 1.3041666666667, -0.12, 0.5
36862, 1.325, -0.1, 0.5
36863, 1.3041666666667, -0.16, 0.5
36864, 1.325, -0.14, 0.5
36865, 1.325, -0.18, 0.5
36866, 1.3458333333333, -0.04, 0.5
36867, 1.3666666666667, -0.02, 0.5
36868, 1.3458333333333, -0.08, 0.5
36869, 1.3666666666667, -0.06, 0.5
36870, 1.3458333333333, -0.12, 0.5
36871, 1.3666666666667, -0.1, 0.5
36872, 1.3458333333333, -0.16, 0.5
36873, 1.3666666666667, -0.14, 0.5
36874, 1.3666666666667, -0.18, 0.5
36875, 1.3875, -0.04, 0.5
36876, 1.4083333333333, -0.02, 0.5
36877, 1.3875, -0.08, 0.5
36878, 1.4083333333333, -0.06, 0.5
36879, 1.3875, -0.12, 0.5
36880, 1.4083333333333, -0.1, 0.5
36881, 1.3875, -0.16, 0.5
36882, 1.4083333333333, -0.14, 0.5
36883, 1.4083333333333, -0.18, 0.5
36884, 1.4291666666667, -0.04, 0.5
36885, 1.45, -0.02, 0.5
36886, 1.4291666666667, -0.08, 0.5
36887, 1.45, -0.06, 0.5
36888, 1.4291666666667, -0.12, 0.5
36889, 1.45, -0.1, 0.5
36890, 1.4291666666667, -0.16, 0.5
36891, 1.45, -0.14, 0.5
36892, 1.45, -0.18, 0.5
36893, 1.4708333333333, -0.04, 0.5
36894, 1.4916666666667, -0.02, 0.5
36895, 1.4708333333333, -0.08, 0.5
36896, 1.4916666666667, -0.06, 0.5
36897, 1.4708333333333, -0.12, 0.5
36898, 1.4916666666667, -0.1, 0.5
36899, 1.4708333333333, -0.16, 0.5
36900, 1.4916666666667, -0.14, 0.5
36901, 1.4916666666667, -0.18, 0.5
36902, 1.5125, -0.04, 0.5
36903, 1.5333333333333, -0.02, 0.5
36904, 1.5125, -0.08, 0.5
36905, 1.5333333333333, -0.06, 0.5
36906, 1.5125, -0.12, 0.5
36907, 1.5333333333333, -0.1, 0.5
36908, 1.5125, -0.16, 0.5
36909, 1.5333333333333, -0.14, 0.5
36910, 1.5333333333333, -0.18, 0.5
36911, 1.5541666666667, -0.04, 0.5
36912, 1.575, -0.02, 0.5
36913, 1.5541666666667, -0.08, 0.5
36914, 1.575, -0.06, 0.5
36915, 1.5541666666667, -0.12, 0.5
36916, 1.575, -0.1, 0.5
36917, 1.5541666666667, -0.16, 0.5
36918, 1.575, -0.14, 0.5
36919, 1.575, -0.18, 0.5
36920, 1.5958333333333, -0.04, 0.5
36921, 1.6166666666667, -0.02, 0.5
36922, 1.5958333333333, -0.08, 0.5
36923, 1.6166666666667, -0.06, 0.5
36924, 1.5958333333333, -0.12, 0.5
36925, 1.6166666666667, -0.1, 0.5
36926, 1.5958333333333, -0.16, 0.5
36927, 1.6166666666667, -0.14, 0.5
36928, 1.6166666666667, -0.18, 0.5
36929, 1.6375, -0.04, 0.5
36930, 1.6583333333333, -0.02, 0.5
36931, 1.6375, -0.08, 0.5
36932, 1.6583333333333, -0.06, 0.5
36933, 1.6375, -0.12, 0.5
36934, 1.6583333333333, -0.1, 0.5
36935, 1.6375, -0.16, 0.5
36936, 1.6583333333333, -0.14, 0.5
36937, 1.6583333333333, -0.18, 0.5
36938, 1.6791666666667, -0.04, 0.5
36939, 1.7, -0.02, 0.5
36940, 1.6791666666667, -0.08, 0.5
36941, 1.7, -0.06, 0.5
36942, 1.6791666666667, -0.12, 0.5
36943, 1.7, -0.1, 0.5
36944, 1.6791666666667, -0.16, 0.5
36945, 1.7, -0.14, 0.5
36946, 1.7, -0.18, 0.5
36947, 1.7208333333333, -0.04, 0.5
36948, 1.7416666666667, -0.02, 0.5
36949, 1.7208333333333, -0.08, 0.5
36950, 1.7416666666667, -0.06, 0.5
36951, 1.7208333333333, -0.12, 0.5
36952, 1.7416666666667, -0.1, 0.5
36953, 1.7208333333333, -0.16, 0.5
36954, 1.7416666666667, -0.14, 0.5
36955, 1.7416666666667, -0.18, 0.5
36956, 1.7625, -0.04, 0.5
36957, 1.7833333333333, -0.02, 0.5
36958, 1.7625, -0.08, 0.5
36959, 1.7833333333333, -0.06, 0.5
36960, 1.7625, -0.12, 0.5
36961, 1.7833333333333, -0.1, 0.5
36962, 1.7625, -0.16, 0.5
36963, 1.7833333333333, -0.14, 0.5
36964, 1.7833333333333, -0.18, 0.5
36965, 1.8041666666667, -0.04, 0.5
36966, 1.825, -0.02, 0.5
36967, 1.8041666666667, -0.08, 0.5
36968, 1.825, -0.06, 0.5
36969, 1.8041666666667, -0.12, 0.5
36970, 1.825, -0.1, 0.5
36971, 1.8041666666667, -0.16, 0.5
36972, 1.825, -0.14, 0.5
36973, 1.825, -0.18, 0.5
36974, 1.8458333333333, -0.04, 0.5
36975, 1.8666666666667, -0.02, 0.5
36976, 1.8458333333333, -0.08, 0.5
36977, 1.8666666666667, -0.06, 0.5
36978, 1.8458333333333, -0.12, 0.5
36979, 1.8666666666667, -0.1, 0.5
36980, 1.8458333333333, -0.16, 0.5
36981, 1.8666666666667, -0.14, 0.5
36982, 1.8666666666667, -0.18, 0.5
36983, 1.8875, -0.04, 0.5
36984, 1.9083333333333, -0.02, 0.5
36985, 1.8875, -0.08, 0.5
36986, 1.9083333333333, -0.06, 0.5
36987, 1.8875, -0.12, 0.5
36988, 1.9083333333333, -0.1, 0.5
36989, 1.8875, -0.16, 0.5
36990, 1.9083333333333, -0.14, 0.5
36991, 1.9083333333333, -0.18, 0.5
36992, 1.9291666666667, -0.04, 0.5
36993, 1.95, -0.02, 0.5
36994, 1.9291666666667, -0.08, 0.5
36995, 1.95, -0.06, 0.5
36996, 1.9291666666667, -0.12, 0.5
36997, 1.95, -0.1, 0.5
36998, 1.9291666666667, -0.16, 0.5
36999, 1.95, -0.14, 0.5
37000, 1.95, -0.18, 0.5
37001, 1.9708333333333, -0.04, 0.5
37002, 1.9916666666667, -0.02, 0.5
37003, 1.9708333333333, -0.08, 0.5
37004, 1.9916666666667, -0.06, 0.5
37005, 1.9708333333333, -0.12, 0.5
37006, 1.9916666666667, -0.1, 0.5
37007, 1.9708333333333, -0.16, 0.5
37008, 1.9916666666667, -0.14, 0.5
37009, 1.9916666666667, -0.18, 0.5
37010, 2.0125, -0.04, 0.5
37011, 2.0333333333333, -0.02, 0.5
37012, 2.0125, -0.08, 0.5
37013, 2.0333333333333, -0.06, 0.5
37014, 2.0125, -0.12, 0.5
37015, 2.0333333333333, -0.1, 0.5
37016, 2.0125, -0.16, 0.5
37017, 2.0333333333333, -0.14, 0.5
37018, 2.0333333333333, -0.18, 0.5
37019, 2.0541666666667, -0.04, 0.5
37020, 2.075, -0.02, 0.5
37021, 2.0541666666667, -0.08, 0.5
37022, 2.075, -0.06, 0.5
37023, 2.0541666666667, -0.12, 0.5
37024, 2.075, -0.1, 0.5
37025, 2.0541666666667, -0.16, 0.5
37026, 2.075, -0.14, 0.5
37027, 2.075, -0.18, 0.5
37028, 2.0958333333333, -0.04, 0.5
37029, 2.1166666666667, -0.02, 0.5
37030, 2.0958333333333, -0.08, 0.5
37031, 2.1166666666667, -0.06, 0.5
37032, 2.0958333333333, -0.12, 0.5
37033, 2.1166666666667, -0.1, 0.5
37034, 2.0958333333333, -0.16, 0.5
37035, 2.1166666666667, -0.14, 0.5
37036, 2.1166666666667, -0.18, 0.5
37037, 2.1375, -0.04, 0.5
37038, 2.1583333333333, -0.02, 0.5
37039, 2.1375, -0.08, 0.5
37040, 2.1583333333333, -0.06, 0.5
37041, 2.1375, -0.12, 0.5
37042, 2.1583333333333, -0.1, 0.5
37043, 2.1375, -0.16, 0.5
37044, 2.1583333333333, -0.14, 0.5
37045, 2.1583333333333, -0.18, 0.5
37046, 2.1791666666667, -0.04, 0.5
37047, 2.1791666666667, -0.08, 0.5
37048, 2.1791666666667, -0.12, 0.5
37049, 2.1791666666667, -0.16, 0.5
37050, 1.2416666666667, -0.04, 0
37051, 1.2416666666667, -0.08, 0
37052, 1.2416666666667, -0.12, 0
37053, 1.2416666666667, -0.16, 0
37054, 1.2833333333333, -0.04, 0
37055, 1.2833333333333, -0.08, 0
37056, 1.2833333333333, -0.12, 0
37057, 1.2833333333333, -0.16, 0
37058, 1.325, -0.04, 0
37059, 1.325, -0.08, 0
37060, 1.325, -0.12, 0
37061, 1.325, -0.16, 0
37062, 1.3666666666667, -0.04, 0
37063, 1.3666666666667, -0.08, 0
37064, 1.3666666666667, -0.12, 0
37065, 1.3666666666667, -0.16, 0
37066, 1.4083333333333, -0.04, 0
37067, 1.4083333333333, -0.08, 0
37068, 1.4083333333333, -0.12, 0
37069, 1.4083333333333, -0.16, 0
37070, 1.45, -0.04, 0
37071, 1.45, -0.08, 0
37072, 1.45, -0.12, 0
37073, 1.45, -0.16, 0
37074, 1.4916666666667, -0.04, 0
37075, 1.4916666666667, -0.08, 0
37076, 1.4916666666667, -0.12, 0
37077, 1.4916666666667, -0.16, 0
37078, 1.5333333333333, -0.04, 0
37079, 1.5333333333333, -0.08, 0
37080, 1.5333333333333, -0.12, 0
37081, 1.5333333333333, -0.16, 0
37082, 1.575, -0.04, 0
37083, 1.575, -0.08, 0
37084, 1.575, -0.12, 0
37085, 1.575, -0.16, 0
37086, 1.6166666666667, -0.04, 0
37087, 1.6166666666667, -0.08, 0
37088, 1.6166666666667, -0.12, 0
37089, 1.6166666666667, -0.16, 0
37090, 1.6583333333333, -0.04, 0
37091, 1.6583333333333, -0.08, 0
37092, 1.6583333333333, -0.12, 0
37093, 1.6583333333333, -0.16, 0
37094, 1.7, -0.04, 0
37095, 1.7, -0.08, 0
37096, 1.7, -0.12, 0
37097, 1.7, -0.16, 0
37098, 1.7416666666667, -0.04, 0
37099, 1.7416666666667, -0.08, 0
37100, 1.7416666666667, -0.12, 0
37101, 1.7416666666667, -0.16, 0
37102, 1.7833333333333, -0.04, 0
37103, 1.7833333333333, -0.08, 0
37104, 1.7833333333333, -0.12, 0
37105, 1.7833333333333, -0.16, 0
37106, 1.825, -0.04, 0
37107, 1.825, -0.08, 0
37108, 1.825, -0.12, 0
37109, 1.825, -0.16, 0
37110, 1.8666666666667, -0.04, 0
37111, 1.8666666666667, -0.08, 0
37112, 1.8666666666667, -0.12, 0
37113, 1.8666666666667, -0.16, 0
37114, 1.9083333333333, -0.04, 0
37115, 1.9083333333333, -0.08, 0
37116, 1.9083333333333, -0.12, 0
37117, 1.9083333333333, -0.16, 0
37118, 1.95, -0.04, 0
37119, 1.95, -0.08, 0
37120, 1.95, -0.12, 0
37121, 1.95, -0.16, 0
37122, 1.9916666666667, -0.04, 0
37123, 1.9916666666667, -0.08, 0
37124, 1.9916666666667, -0.12, 0
37125, 1.9916666666667, -0.16, 0
37126, 2.0333333333333, -0.04, 0
37127, 2.0333333333333, -0.08, 0
37128, 2.0333333333333, -0.12, 0
37129, 2.0333333333333, -0.16, 0
37130, 2.075, -0.04, 0
37131, 2.075, -0.08, 0
37132, 2.075, -0.12, 0
37133, 2.075, -0.16, 0
37134, 2.1166666666667, -0.04, 0
37135, 2.1166666666667, -0.08, 0
37136, 2.1166666666667, -0.12, 0
37137, 2.1166666666667, -0.16, 0
37138, 2.1583333333333, -0.04, 0
37139, 2.1583333333333, -0.08, 0
37140, 2.1583333333333, -0.12, 0
37141, 2.1583333333333, -0.16, 0
37142, 1.2416666666667, -0.02, 0
37143, 1.2208333333333, -0.04, 0
37144, 1.2416666666667, -0.06, 0
37145, 1.2208333333333, -0.08, 0
37146, 1.2416666666667, -0.1, 0
37147, 1.2208333333333, -0.12, 0
37148, 1.2416666666667, -0.14, 0
37149, 1.2208333333333, -0.16, 0
37150, 1.2416666666667, -0.18, 0
37151, 1.2833333333333, -0.02, 0
37152, 1.2625, -0.04, 0
37153, 1.2833333333333, -0.06, 0
37154, 1.2625, -0.08, 0
37155, 1.2833333333333, -0.1, 0
37156, 1.2625, -0.12, 0
37157, 1.2833333333333, -0.14, 0
37158, 1.2625, -0.16, 0
37159, 1.2833333333333, -0.18, 0
37160, 1.325, -0.02, 0
37161, 1.3041666666667, -0.04, 0
37162, 1.325, -0.06, 0
37163, 1.3041666666667, -0.08, 0
37164, 1.325, -0.1, 0
37165, 1.3041666666667, -0.12, 0
37166, 1.325, -0.14, 0
37167, 1.3041666666667, -0.16, 0
37168, 1.325, -0.18, 0
37169, 1.3666666666667, -0.02, 0
37170, 1.3458333333333, -0.04, 0
37171, 1.3666666666667, -0.06, 0
37172, 1.3458333333333, -0.08, 0
37173, 1.3666666666667, -0.1, 0
37174, 1.3458333333333, -0.12, 0
37175, 1.3666666666667, -0.14, 0
37176, 1.3458333333333, -0.16, 0
37177, 1.3666666666667, -0.18, 0
37178, 1.4083333333333, -0.02, 0
37179, 1.3875, -0.04, 0
37180, 1.4083333333333, -0.06, 0
37181, 1.3875, -0.08, 0
37182, 1.4083333333333, -0.1, 0
37183, 1.3875, -0.12, 0
37184, 1.4083333333333, -0.14, 0
37185, 1.3875, -0.16, 0
37186, 1.4083333333333, -0.18, 0
37187, 1.45, -0.02, 0
37188, 1.4291666666667, -0.04, 0
37189, 1.45, -0.06, 0
37190, 1.4291666666667, -0.08, 0
37191, 1.45, -0.1, 0
37192, 1.4291666666667, -0.12, 0
37193, 1.45, -0.14, 0
37194, 1.4291666666667, -0.16, 0
37195, 1.45, -0.18, 0
37196, 1.4916666666667, -0.02, 0
37197, 1.4708333333333, -0.04, 0
37198, 1.4916666666667, -0.06, 0
37199, 1.4708333333333, -0.08, 0
37200, 1.4916666666667, -0.1, 0
37201, 1.4708333333333, -0.12, 0
37202, 1.4916666666667, -0.14, 0
37203, 1.4708333333333, -0.16, 0
37204, 1.4916666666667, -0.18, 0
37205, 1.5333333333333, -0.02, 0
37206, 1.5125, -0.04, 0
37207, 1.5333333333333, -0.06, 0
37208, 1.5125, -0.08, 0
37209, 1.5333333333333, -0.1, 0
37210, 1.5125, -0.12, 0
37211, 1.5333333333333, -0.14, 0
37212, 1.5125, -0.16, 0
37213, 1.5333333333333, -0.18, 0
37214, 1.575, -0.02, 0
37215, 1.5541666666667, -0.04, 0
37216, 1.575, -0.06, 0
37217, 1.5541666666667, -0.08, 0
37218, 1.575, -0.1, 0
37219, 1.5541666666667, -0.12, 0
37220, 1.575, -0.14, 0
37221, 1.5541666666667, -0.16, 0
37222, 1.575, -0.18, 0
37223, 1.6166666666667, -0.02, 0
37224, 1.5958333333333, -0.04, 0
37225, 1.6166666666667, -0.06, 0
37226, 1.5958333333333, -0.08, 0
37227, 1.6166666666667, -0.1, 0
37228, 1.5958333333333, -0.12, 0
37229, 1.6166666666667, -0.14, 0
37230, 1.5958333333333, -0.16, 0
37231, 1.6166666666667, -0.18, 0
37232, 1.6583333333333, -0.02, 0
37233, 1.6375, -0.04, 0
37234, 1.6583333333333, -0.06, 0
37235, 1.6375, -0.08, 0
37236, 1.6583333333333, -0.1, 0
37237, 1.6375, -0.12, 0
37238, 1.6583333333333, -0.14, 0
37239, 1.6375, -0.16, 0
37240, 1.6583333333333, -0.18, 0
37241, 1.7, -0.02, 0
37242, 1.6791666666667, -0.04, 0
37243, 1.7, -0.06, 0
37244, 1.6791666666667, -0.08, 0
37245, 1.7, -0.1, 0
37246, 1.6791666666667, -0.12, 0
37247, 1.7, -0.14, 0
37248, 1.6791666666667, -0.16, 0
37249, 1.7, -0.18, 0
37250, 1.7416666666667, -0.02, 0
37251, 1.7208333333333, -0.04, 0
37252, 1.7416666666667, -0.06, 0
37253, 1.7208333333333, -0.08, 0
37254, 1.7416666666667, -0.1, 0
37255, 1.7208333333333, -0.12, 0
37256, 1.7416666666667, -0.14, 0
37257, 1.7208333333333, -0.16, 0
37258, 1.7416666666667, -0.18, 0
37259, 1.7833333333333, -0.02, 0
37260, 1.7625, -0.04, 0
37261, 1.7833333333333, -0.06, 0
37262, 1.7625, -0.08, 0
37263, 1.7833333333333, -0.1, 0
37264, 1.7625, -0.12, 0
37265, 1.7833333333333, -0.14, 0
37266, 1.7625, -0.16, 0
37267, 1.7833333333333, -0.18, 0
37268, 1.825, -0.02, 0
37269, 1.8041666666667, -0.04, 0
37270, 1.825, -0.06, 0
37271, 1.8041666666667, -0.08, 0
37272, 1.825, -0.1, 0
37273, 1.8041666666667, -0.12, 0
37274, 1.825, -0.14, 0
37275, 1.8041666666667, -0.16, 0
37276, 1.825, -0.18, 0
37277, 1.8666666666667, -0.02, 0
37278, 1.8458333333333, -0.04, 0
37279, 1.8666666666667, -0.06, 0
37280, 1.8458333333333, -0.08, 0
37281, 1.8666666666667, -0.1, 0
37282, 1.8458333333333, -0.12, 0
37283, 1.8666666666667, -0.14, 0
37284, 1.8458333333333, -0.16, 0
37285, 1.8666666666667, -0.18, 0
37286, 1.9083333333333, -0.02, 0
37287, 1.8875, -0.04, 0
37288, 1.9083333333333, -0.06, 0
37289, 1.8875, -0.08, 0
37290, 1.9083333333333, -0.1, 0
37291, 1.8875, -0.12, 0
37292, 1.9083333333333, -0.14, 0
37293, 1.8875, -0.16, 0
37294, 1.9083333333333, -0.18, 0
37295, 1.95, -0.02, 0
37296, 1.9291666666667, -0.04, 0
37297, 1.95, -0.06, 0
37298, 1.9291666666667, -0.08, 0
37299, 1.95, -0.1, 0
37300, 1.9291666666667, -0.12, 0
37301, 1.95, -0.14, 0
37302, 1.9291666666667, -0.16, 0
37303, 1.95, -0.18, 0
37304, 1.9916666666667, -0.02, 0
37305, 1.9708333333333, -0.04, 0
37306, 1.9916666666667, -0.06, 0
37307, 1.9708333333333, -0.08, 0
37308, 1.9916666666667, -0.1, 0
37309, 1.9708333333333, -0.12, 0
37310, 1.9916666666667, -0.14, 0
37311, 1.9708333333333, -0.16, 0
37312, 1.9916666666667, -0.18, 0
37313, 2.0333333333333, -0.02, 0
37314, 2.0125, -0.04, 0
37315, 2.0333333333333, -0.06, 0
37316, 2.0125, -0.08, 0
37317, 2.0333333333333, -0.1, 0
37318, 2.0125, -0.12, 0
37319, 2.0333333333333, -0.14, 0
37320, 2.0125, -0.16, 0
37321, 2.0333333333333, -0.18, 0
37322, 2.075, -0.02, 0
37323, 2.0541666666667, -0.04, 0
37324, 2.075, -0.06, 0
37325, 2.0541666666667, -0.08, 0
37326, 2.075, -0.1, 0
37327, 2.0541666666667, -0.12, 0
37328, 2.075, -0.14, 0
37329, 2.0541666666667, -0.16, 0
37330, 2.075, -0.18, 0
37331, 2.1166666666667, -0.02, 0
37332, 2.0958333333333, -0.04, 0
37333, 2.1166666666667, -0.06, 0
37334, 2.0958333333333, -0.08, 0
37335, 2.1166666666667, -0.1, 0
37336, 2.0958333333333, -0.12, 0
37337, 2.1166666666667, -0.14, 0
37338, 2.0958333333333, -0.16, 0
37339, 2.1166666666667, -0.18, 0
37340, 2.1583333333333, -0.02, 0
37341, 2.1375, -0.04, 0
37342, 2.1583333333333, -0.06, 0
37343, 2.1375, -0.08, 0
37344, 2.1583333333333, -0.1, 0
37345, 2.1375, -0.12, 0
37346, 2.1583333333333, -0.14, 0
37347, 2.1375, -0.16, 0
37348, 2.1583333333333, -0.18, 0
37349, 2.1791666666667, -0.04, 0
37350, 2.1791666666667, -0.08, 0
37351, 2.1791666666667, -0.12, 0
37352, 2.1791666666667, -0.16, 0
37353, 1.2, -0.04, 0.041666666666667
37354, 1.2, -0.08, 0.041666666666667
37355, 1.2, -0.12, 0.041666666666667
37356, 1.2, -0.16, 0.041666666666667
37357, 1.2, -0.04, 0.083333333333333
37358, 1.2, -0.08, 0.083333333333333
37359, 1.2, -0.12, 0.083333333333333
37360, 1.2, -0.16, 0.083333333333333
37361, 1.2, -0.04, 0.125
37362, 1.2, -0.08, 0.125
37363, 1.2, -0.12, 0.125
37364, 1.2, -0.16, 0.125
37365, 1.2, -0.04, 0.16666666666667
37366, 1.2, -0.08, 0.16666666666667
37367, 1.2, -0.12, 0.16666666666667
37368, 1.2, -0.16, 0.16666666666667
37369, 1.2, -0.04, 0.20833333333333
37370, 1.2, -0.08, 0.20833333333333
37371, 1.2, -0.12, 0.20833333333333
37372, 1.2, -0.16, 0.20833333333333
37373, 1.2, -0.04, 0.25
37374, 1.2, -0.08, 0.25
37375, 1.2, -0.12, 0.25
37376, 1.2, -0.16, 0.25
37377, 1.2, -0.04, 0.29166666666667
37378, 1.2, -0.08, 0.29166666666667
37379, 1.2, -0.12, 0.29166666666667
37380, 1.2, -0.16, 0.29166666666667
37381, 1.2, -0.04, 0.33333333333333
37382, 1.2, -0.08, 0.33333333333333
37383, 1.2, -0.12, 0.33333333333333
37384, 1.2, -0.16, 0.33333333333333
37385, 1.2, -0.04, 0.375
37386, 1.2, -0.08, 0.375
37387, 1.2, -0.12, 0.375
37388, 1.2, -0.16, 0.375
37389, 1.2, -0.04, 0.41666666666667
37390, 1.2, -0.08, 0.41666666666667
37391, 1.2, -0.12, 0.41666666666667
37392, 1.2, -0.16, 0.41666666666667
37393, 1.2, -0.04, 0.45833333333333
37394, 1.2, -0.08, 0.45833333333333
37395, 1.2, -0.12, 0.45833333333333
37396, 1.2, -0.16, 0.45833333333333
37397, 1.2, -0.04, 0.020833333333333
37398, 1.2, -0.02, 0.041666666666667
37399, 1.2, -0.08, 0.020833333333333
37400, 1.2, -0.06, 0.041666666666667
37401, 1.2, -0.12, 0.020833333333333
37402, 1.2, -0.1, 0.041666666666667
37403, 1.2, -0.16, 0.020833333333333
37404, 1.2, -0.14, 0.041666666666667
37405, 1.2, -0.18, 0.041666666666667
37406, 1.2, -0.04, 0.0625
37407, 1.2, -0.02, 0.083333333333333
37408, 1.2, -0.08, 0.0625
37409, 1.2, -0.06, 0.083333333333333
37410, 1.2, -0.12, 0.0625
37411, 1.2, -0.1, 0.083333333333333
37412, 1.2, -0.16, 0.0625
37413, 1.2, -0.14, 0.083333333333333
37414, 1.2, -0.18, 0.083333333333333
37415, 1.2, -0.04, 0.10416666666667
37416, 1.2, -0.02, 0.125
37417, 1.2, -0.08, 0.10416666666667
37418, 1.2, -0.06, 0.125
37419, 1.2, -0.12, 0.10416666666667
37420, 1.2, -0.1, 0.125
37421, 1.2, -0.16, 0.10416666666667
37422, 1.2, -0.14, 0.125
37423, 1.2, -0.18, 0.125
37424, 1.2, -0.04, 0.14583333333333
37425, 1.2, -0.02, 0.16666666666667
37426, 1.2, -0.08, 0.14583333333333
37427, 1.2, -0.06, 0.16666666666667
37428, 1.2, -0.12, 0.14583333333333
37429, 1.2, -0.1, 0.16666666666667
37430, 1.2, -0.16, 0.14583333333333
37431, 1.2, -0.14, 0.16666666666667
37432, 1.2, -0.18, 0.16666666666667
37433, 1.2, -0.04, 0.1875
37434, 1.2, -0.02, 0.20833333333333
37435, 1.2, -0.08, 0.1875
37436, 1.2, -0.06, 0.20833333333333
37437, 1.2, -0.12, 0.1875
37438, 1.2, -0.1, 0.20833333333333
37439, 1.2, -0.16, 0.1875
37440, 1.2, -0.14, 0.20833333333333
37441, 1.2, -0.18, 0.20833333333333
37442, 1.2, -0.04, 0.22916666666667
37443, 1.2, -0.02, 0.25
37444, 1.2, -0.08, 0.22916666666667
37445, 1.2, -0.06, 0.25
37446, 1.2, -0.12, 0.22916666666667
37447, 1.2, -0.1, 0.25
37448, 1.2, -0.16, 0.22916666666667
37449, 1.2, -0.14, 0.25
37450, 1.2, -0.18, 0.25
37451, 1.2, -0.04, 0.27083333333333
37452, 1.2, -0.02, 0.29166666666667
37453, 1.2, -0.08, 0.27083333333333
37454, 1.2, -0.06, 0.29166666666667
37455, 1.2, -0.12, 0.27083333333333
37456, 1.2, -0.1, 0.29166666666667
37457, 1.2, -0.16, 0.27083333333333
37458, 1.2, -0.14, 0.29166666666667
37459, 1.2, -0.18, 0.29166666666667
37460, 1.2, -0.04, 0.3125
37461, 1.2, -0.02, 0.33333333333333
37462, 1.2, -0.08, 0.3125
37463, 1.2, -0.06, 0.33333333333333
37464, 1.2, -0.12, 0.3125
37465, 1.2, -0.1, 0.33333333333333
37466, 1.2, -0.16, 0.3125
37467, 1.2, -0.14, 0.33333333333333
37468, 1.2, -0.18, 0.33333333333333
37469, 1.2, -0.04, 0.35416666666667
37470, 1.2, -0.02, 0.375
37471, 1.2, -0.08, 0.35416666666667
37472, 1.2, -0.06, 0.375
37473, 1.2, -0.12, 0.35416666666667
37474, 1.2, -0.1, 0.375
37475, 1.2, -0.16, 0.35416666666667
37476, 1.2, -0.14, 0.375
37477, 1.2, -0.18, 0.375
37478, 1.2, -0.04, 0.39583333333333
37479, 1.2, -0.02, 0.41666666666667
37480, 1.2, -0.08, 0.39583333333333
37481, 1.2, -0.06, 0.41666666666667
37482, 1.2, -0.12, 0.39583333333333
37483, 1.2, -0.1, 0.41666666666667
37484, 1.2, -0.16, 0.39583333333333
37485, 1.2, -0.14, 0.41666666666667
37486, 1.2, -0.18, 0.41666666666667
37487, 1.2, -0.04, 0.4375
37488, 1.2, -0.02, 0.45833333333333
37489, 1.2, -0.08, 0.4375
37490, 1.2, -0.06, 0.45833333333333
37491, 1.2, -0.12, 0.4375
37492, 1.2, -0.1, 0.45833333333333
37493, 1.2, -0.16, 0.4375
37494, 1.2, -0.14, 0.45833333333333
37495, 1.2, -0.18, 0.45833333333333
37496, 1.2, -0.04, 0.47916666666667
37497, 1.2, -0.08, 0.47916666666667
37498, 1.2, -0.12, 0.47916666666667
37499, 1.2, -0.16, 0.47916666666667
37500, 2.2, -0.04, 0.041666666666667
37501, 2.2, -0.08, 0.041666666666667
37502, 2.2, -0.12, 0.041666666666667
37503, 2.2, -0.16, 0.041666666666667
37504, 2.2, -0.04, 0.083333333333333
37505, 2.2, -0.08, 0.083333333333333
37506, 2.2, -0.12, 0.083333333333333
37507, 2.2, -0.16, 0.083333333333333
37508, 2.2, -0.04, 0.125
37509, 2.2, -0.08, 0.125
37510, 2.2, -0.12, 0.125
37511, 2.2, -0.16, 0.125
37512, 2.2, -0.04, 0.16666666666667
37513, 2.2, -0.08, 0.16666666666667
37514, 2.2, -0.12, 0.16666666666667
37515, 2.2, -0.16, 0.16666666666667
37516, 2.2, -0.04, 0.20833333333333
37517, 2.2, -0.08, 0.20833333333333
37518, 2.2, -0.12, 0.20833333333333
37519, 2.2, -0.16, 0.20833333333333
37520, 2.2, -0.04, 0.25
37521, 2.2, -0.08, 0.25
37522, 2.2, -0.12, 0.25
37523, 2.2, -0.16, 0.25
37524, 2.2, -0.04, 0.29166666666667
37525, 2.2, -0.08, 0.29166666666667
37526, 2.2, -0.12, 0.29166666666667
37527, 2.2, -0.16, 0.29166666666667
37528, 2.2, -0.04, 0.33333333333333
37529, 2.2, -0.08, 0.33333333333333
37530, 2.2, -0.12, 0.33333333333333
37531, 2.2, -0.16, 0.33333333333333
37532, 2.2, -0.04, 0.375
37533, 2.2, -0.08, 0.375
37534, 2.2, -0.12, 0.375
37535, 2.2, -0.16, 0.375
37536, 2.2, -0.04, 0.41666666666667
37537, 2.2, -0.08, 0.41666666666667
37538, 2.2, -0.12, 0.41666666666667
37539, 2.2, -0.16, 0.41666666666667
37540, 2.2, -0.04, 0.45833333333333
37541, 2.2, -0.08, 0.45833333333333
37542, 2.2, -0.12, 0.45833333333333
37543, 2.2, -0.16, 0.45833333333333
37544, 2.2, -0.02, 0.041666666666667
37545, 2.2, -0.04, 0.020833333333333
37546, 2.2, -0.06, 0.041666666666667
37547, 2.2, -0.08, 0.020833333333333
37548, 2.2, -0.1, 0.041666666666667
37549, 2.2, -0.12, 0.020833333333333
37550, 2.2, -0.14, 0.041666666666667
37551, 2.2, -0.16, 0.020833333333333
37552, 2.2, -0.18, 0.041666666666667
37553, 2.2, -0.02, 0.083333333333333
37554, 2.2, -0.04, 0.0625
37555, 2.2, -0.06, 0.083333333333333
37556, 2.2, -0.08, 0.0625
37557, 2.2, -0.1, 0.083333333333333
37558, 2.2, -0.12, 0.0625
37559, 2.2, -0.14, 0.083333333333333
37560, 2.2, -0.16, 0.0625
37561, 2.2, -0.18, 0.083333333333333
37562, 2.2, -0.02, 0.125
37563, 2.2, -0.04, 0.10416666666667
37564, 2.2, -0.06, 0.125
37565, 2.2, -0.08, 0.10416666666667
37566, 2.2, -0.1, 0.125
37567, 2.2, -0.12, 0.10416666666667
37568, 2.2, -0.14, 0.125
37569, 2.2, -0.16, 0.10416666666667
37570, 2.2, -0.18, 0.125
37571, 2.2, -0.02, 0.16666666666667
37572, 2.2, -0.04, 0.14583333333333
37573, 2.2, -0.06, 0.16666666666667
37574, 2.2, -0.08, 0.14583333333333
37575, 2.2, -0.1, 0.16666666666667
37576, 2.2, -0.12, 0.14583333333333
37577, 2.2, -0.14, 0.16666666666667
37578, 2.2, -0.16, 0.14583333333333
37579, 2.2, -0.18, 0.16666666666667
37580, 2.2, -0.02, 0.20833333333333
37581, 2.2, -0.04, 0.1875
37582, 2.2, -0.06, 0.20833333333333
37583, 2.2, -0.08, 0.1875
37584, 2.2, -0.1, 0.20833333333333
37585, 2.2, -0.12, 0.1875
37586, 2.2, -0.14, 0.20833333333333
37587, 2.2, -0.16, 0.1875
37588, 2.2, -0.18, 0.20833333333333
37589, 2.2, -0.02, 0.25
37590, 2.2, -0.04, 0.22916666666667
37591, 2.2, -0.06, 0.25
37592, 2.2, -0.08, 0.22916666666667
37593, 2.2, -0.1, 0.25
37594, 2.2, -0.12, 0.22916666666667
37595, 2.2, -0.14, 0.25
37596, 2.2, -0.16, 0.22916666666667
37597, 2.2, -0.18, 0.25
37598, 2.2, -0.02, 0.29166666666667
37599, 2.2, -0.04, 0.27083333333333
37600, 2.2, -0.06, 0.29166666666667
37601, 2.2, -0.08, 0.27083333333333
37602, 2.2, -0.1, 0.29166666666667
37603, 2.2, -0.12, 0.27083333333333
37604, 2.2, -0.14, 0.29166666666667
37605, 2.2, -0.16, 0.27083333333333
37606, 2.2, -0.18, 0.29166666666667
37607, 2.2, -0.02, 0.33333333333333
37608, 2.2, -0.04, 0.3125
37609, 2.2, -0.06, 0.33333333333333
37610, 2.2, -0.08, 0.3125
37611, 2.2, -0.1, 0.33333333333333
37612, 2.2, -0.12, 0.3125
37613, 2.2, -0.14, 0.33333333333333
37614, 2.2, -0.16, 0.3125
37615, 2.2, -0.18, 0.33333333333333
37616, 2.2, -0.02, 0.375
37617, 2.2, -0.04, 0.35416666666667
37618, 2.2, -0.06, 0.375
37619, 2.2, -0.08, 0.35416666666667
37620, 2.2, -0.1, 0.375
37621, 2.2, -0.12, 0.35416666666667
37622, 2.2, -0.14, 0.375
37623, 2.2, -0.16, 0.35416666666667
37624, 2.2, -0.18, 0.375
37625, 2.2, -0.02, 0.41666666666667
37626, 2.2, -0.04, 0.39583333333333
37627, 2.2, -0.06, 0.41666666666667
37628, 2.2, -0.08, 0.39583333333333
37629, 2.2, -0.1, 0.41666666666667
37630, 2.2, -0.12, 0.39583333333333
37631, 2.2, -0.14, 0.41666666666667
37632, 2.2, -0.16, 0.39583333333333
37633, 2.2, -0.18, 0.41666666666667
37634, 2.2, -0.02, 0.45833333333333
37635, 2.2, -0.04, 0.4375
37636, 2.2, -0.06, 0.45833333333333
37637, 2.2, -0.08, 0.4375
37638, 2.2, -0.1, 0.45833333333333
37639, 2.2, -0.12, 0.4375
37640, 2.2, -0.14, 0.45833333333333
37641, 2.2, -0.16, 0.4375
37642, 2.2, -0.18, 0.45833333333333
37643, 2.2, -0.04, 0.47916666666667
37644, 2.2, -0.08, 0.47916666666667
37645, 2.2, -0.12, 0.47916666666667
37646, 2.2, -0.16, 0.47916666666667
37647, 1.2416666666667, -0.2, 0.041666666666667
37648, 1.2833333333333, -0.2, 0.041666666666667
37649, 1.325, -0.2, 0.041666666666667
37650, 1.3666666666667, -0.2, 0.041666666666667
37651, 1.4083333333333, -0.2, 0.041666666666667
37652, 1.45, -0.2, 0.041666666666667
37653, 1.4916666666667, -0.2, 0.041666666666667
37654, 1.5333333333333, -0.2, 0.041666666666667
37655, 1.575, -0.2, 0.041666666666667
37656, 1.6166666666667, -0.2, 0.041666666666667
37657, 1.6583333333333, -0.2, 0.041666666666667
37658, 1.7, -0.2, 0.041666666666667
37659, 1.7416666666667, -0.2, 0.041666666666667
37660, 1.7833333333333, -0.2, 0.041666666666667
37661, 1.825, -0.2, 0.041666666666667
37662, 1.8666666666667, -0.2, 0.041666666666667
37663, 1.9083333333333, -0.2, 0.041666666666667
37664, 1.95, -0.2, 0.041666666666667
37665, 1.9916666666667, -0.2, 0.041666666666667
37666, 2.0333333333333, -0.2, 0.041666666666667
37667, 2.075, -0.2, 0.041666666666667
37668, 2.1166666666667, -0.2, 0.041666666666667
37669, 2.1583333333333, -0.2, 0.041666666666667
37670, 1.2416666666667, -0.2, 0.083333333333333
37671, 1.2833333333333, -0.2, 0.083333333333333
37672, 1.325, -0.2, 0.083333333333333
37673, 1.3666666666667, -0.2, 0.083333333333333
37674, 1.4083333333333, -0.2, 0.083333333333333
37675, 1.45, -0.2, 0.083333333333333
37676, 1.4916666666667, -0.2, 0.083333333333333
37677, 1.5333333333333, -0.2, 0.083333333333333
37678, 1.575, -0.2, 0.083333333333333
37679, 1.6166666666667, -0.2, 0.083333333333333
37680, 1.6583333333333, -0.2, 0.083333333333333
37681, 1.7, -0.2, 0.083333333333333
37682, 1.7416666666667, -0.2, 0.083333333333333
37683, 1.7833333333333, -0.2, 0.083333333333333
37684, 1.825, -0.2, 0.083333333333333
37685, 1.8666666666667, -0.2, 0.083333333333333
37686, 1.9083333333333, -0.2, 0.083333333333333
37687, 1.95, -0.2, 0.083333333333333
37688, 1.9916666666667, -0.2, 0.083333333333333
37689, 2.0333333333333, -0.2, 0.083333333333333
37690, 2.075, -0.2, 0.083333333333333
37691, 2.1166666666667, -0.2, 0.083333333333333
37692, 2.1583333333333, -0.2, 0.083333333333333
37693, 1.2416666666667, -0.2, 0.125
37694, 1.2833333333333, -0.2, 0.125
37695, 1.325, -0.2, 0.125
37696, 1.3666666666667, -0.2, 0.125
37697, 1.4083333333333, -0.2, 0.125
37698, 1.45, -0.2, 0.125
37699, 1.4916666666667, -0.2, 0.125
37700, 1.5333333333333, -0.2, 0.125
37701, 1.575, -0.2, 0.125
37702, 1.6166666666667, -0.2, 0.125
37703, 1.6583333333333, -0.2, 0.125
37704, 1.7, -0.2, 0.125
37705, 1.7416666666667, -0.2, 0.125
37706, 1.7833333333333, -0.2, 0.125
37707, 1.825, -0.2, 0.125
37708, 1.8666666666667, -0.2, 0.125
37709, 1.9083333333333, -0.2, 0.125
37710, 1.95, -0.2, 0.125
37711, 1.9916666666667, -0.2, 0.125
37712, 2.0333333333333, -0.2, 0.125
37713, 2.075, -0.2, 0.125
37714, 2.1166666666667, -0.2, 0.125
37715, 2.1583333333333, -0.2, 0.125
37716, 1.2416666666667, -0.2, 0.16666666666667
37717, 1.2833333333333, -0.2, 0.16666666666667
37718, 1.325, -0.2, 0.16666666666667
37719, 1.3666666666667, -0.2, 0.16666666666667
37720, 1.4083333333333, -0.2, 0.16666666666667
37721, 1.45, -0.2, 0.16666666666667
37722, 1.4916666666667, -0.2, 0.16666666666667
37723, 1.5333333333333, -0.2, 0.16666666666667
37724, 1.575, -0.2, 0.16666666666667
37725, 1.6166666666667, -0.2, 0.16666666666667
37726, 1.6583333333333, -0.2, 0.16666666666667
37727, 1.7, -0.2, 0.16666666666667
37728, 1.7416666666667, -0.2, 0.16666666666667
37729, 1.7833333333333, -0.2, 0.16666666666667
37730, 1.825, -0.2, 0.16666666666667
37731, 1.8666666666667, -0.2, 0.16666666666667
37732, 1.9083333333333, -0.2, 0.16666666666667
37733, 1.95, -0.2, 0.16666666666667
37734, 1.9916666666667, -0.2, 0.16666666666667
37735, 2.0333333333333, -0.2, 0.16666666666667
37736, 2.075, -0.2, 0.16666666666667
37737, 2.1166666666667, -0.2, 0.16666666666667
37738, 2.1583333333333, -0.2, 0.16666666666667
37739, 1.2416666666667, -0.2, 0.20833333333333
37740, 1.2833333333333, -0.2, 0.20833333333333
37741, 1.325, -0.2, 0.20833333333333
37742, 1.3666666666667, -0.2, 0.20833333333333
37743, 1.4083333333333, -0.2, 0.20833333333333
37744, 1.45, -0.2, 0.20833333333333
37745, 1.4916666666667, -0.2, 0.20833333333333
37746, 1.5333333333333, -0.2, 0.20833333333333
37747, 1.575, -0.2, 0.20833333333333
37748, 1.6166666666667, -0.2, 0.20833333333333
37749, 1.6583333333333, -0.2, 0.20833333333333
37750, 1.7, -0.2, 0.20833333333333
37751, 1.7416666666667, -0.2, 0.20833333333333
37752, 1.7833333333333, -0.2, 0.20833333333333
37753, 1.825, -0.2, 0.20833333333333
37754, 1.8666666666667, -0.2, 0.20833333333333
37755, 1.9083333333333, -0.2, 0.20833333333333
37756, 1.95, -0.2, 0.20833333333333
37757, 1.9916666666667, -0.2, 0.20833333333333
37758, 2.0333333333333, -0.2, 0.20833333333333
37759, 2.075, -0.2, 0.20833333333333
37760, 2.1166666666667, -0.2, 0.20833333333333
37761, 2.1583333333333, -0.2, 0.20833333333333
37762, 1.2416666666667, -0.2, 0.25
37763, 1.2833333333333, -0.2, 0.25
37764, 1.325, -0.2, 0.25
37765, 1.3666666666667, -0.2, 0.25
37766, 1.4083333333333, -0.2, 0.25
37767, 1.45, -0.2, 0.25
37768, 1.4916666666667, -0.2, 0.25
37769, 1.5333333333333, -0.2, 0.25
37770, 1.575, -0.2, 0.25
37771, 1.6166666666667, -0.2, 0.25
37772, 1.6583333333333, -0.2, 0.25
37773, 1.7, -0.2, 0.25
37774, 1.7416666666667, -0.2, 0.25
37775, 1.7833333333333, -0.2, 0.25
37776, 1.825, -0.2, 0.25
37777, 1.8666666666667, -0.2, 0.25
37778, 1.9083333333333, -0.2, 0.25
37779, 1.95, -0.2, 0.25
37780, 1.9916666666667, -0.2, 0.25
37781, 2.0333333333333, -0.2, 0.25
37782, 2.075, -0.2, 0.25
37783, 2.1166666666667, -0.2, 0.25
37784, 2.1583333333333, -0.2, 0.25
37785, 1.2416666666667, -0.2, 0.29166666666667
37786, 1.2833333333333, -0.2, 0.29166666666667
37787, 1.325, -0.2, 0.29166666666667
37788, 1.3666666666667, -0.2, 0.29166666666667
37789, 1.4083333333333, -0.2, 0.29166666666667
37790, 1.45, -0.2, 0.29166666666667
37791, 1.4916666666667, -0.2, 0.29166666666667
37792, 1.5333333333333, -0.2, 0.29166666666667
37793, 1.575, -0.2, 0.29166666666667
37794, 1.6166666666667, -0.2, 0.29166666666667
37795, 1.6583333333333, -0.2, 0.29166666666667
37796, 1.7, -0.2, 0.29166666666667
37797, 1.7416666666667, -0.2, 0.29166666666667
37798, 1.7833333333333, -0.2, 0.29166666666667
37799, 1.825, -0.2, 0.29166666666667
37800, 1.8666666666667, -0.2, 0.29166666666667
37801, 1.9083333333333, -0.2, 0.29166666666667
37802, 1.95, -0.2, 0.29166666666667
37803, 1.9916666666667, -0.2, 0.29166666666667
37804, 2.0333333333333, -0.2, 0.29166666666667
37805, 2.075, -0.2, 0.29166666666667
37806, 2.1166666666667, -0.2, 0.29166666666667
37807, 2.1583333333333, -0.2, 0.29166666666667
37808, 1.2416666666667, -0.2, 0.33333333333333
37809, 1.2833333333333, -0.2, 0.33333333333333
37810, 1.325, -0.2, 0.33333333333333
37811, 1.3666666666667, -0.2, 0.33333333333333
37812, 1.4083333333333, -0.2, 0.33333333333333
37813, 1.45, -0.2, 0.33333333333333
37814, 1.4916666666667, -0.2, 0.33333333333333
37815, 1.5333333333333, -0.2, 0.33333333333333
37816, 1.575, -0.2, 0.33333333333333
37817, 1.6166666666667, -0.2, 0.33333333333333
37818, 1.6583333333333, -0.2, 0.33333333333333
37819, 1.7, -0.2, 0.33333333333333
37820, 1.7416666666667, -0.2, 0.33333333333333
37821, 1.7833333333333, -0.2, 0.33333333333333
37822, 1.825, -0.2, 0.33333333333333
37823, 1.8666666666667, -0.2, 0.33333333333333
37824, 1.9083333333333, -0.2, 0.33333333333333
37825, 1.95, -0.2, 0.33333333333333
37826, 1.9916666666667, -0.2, 0.33333333333333
37827, 2.0333333333333, -0.2, 0.33333333333333
37828, 2.075, -0.2, 0.33333333333333
37829, 2.1166666666667, -0.2, 0.33333333333333
37830, 2.1583333333333, -0.2, 0.33333333333333
37831, 1.2416666666667, -0.2, 0.375
37832, 1.2833333333333, -0.2, 0.375
37833, 1.325, -0.2, 0.375
37834, 1.3666666666667, -0.2, 0.375
37835, 1.4083333333333, -0.2, 0.375
37836, 1.45, -0.2, 0.375
37837, 1.4916666666667, -0.2, 0.375
37838, 1.5333333333333, -0.2, 0.375
37839, 1.575, -0.2, 0.375
37840, 1.6166666666667, -0.2, 0.375
37841, 1.6583333333333, -0.2, 0.375
37842, 1.7, -0.2, 0.375
37843, 1.7416666666667, -0.2, 0.375
37844, 1.7833333333333, -0.2, 0.375
37845, 1.825, -0.2, 0.375
37846, 1.8666666666667, -0.2, 0.375
37847, 1.9083333333333, -0.2, 0.375
37848, 1.95, -0.2, 0.375
37849, 1.9916666666667, -0.2, 0.375
37850, 2.0333333333333, -0.2, 0.375
37851, 2.075, -0.2, 0.375
37852, 2.1166666666667, -0.2, 0.375
37853, 2.1583333333333, -0.2, 0.375
37854, 1.2416666666667, -0.2, 0.41666666666667
37855, 1.2833333333333, -0.2, 0.41666666666667
37856, 1.325, -0.2, 0.41666666666667
37857, 1.3666666666667, -0.2, 0.41666666666667
37858, 1.4083333333333, -0.2, 0.41666666666667
37859, 1.45, -0.2, 0.41666666666667
37860, 1.4916666666667, -0.2, 0.41666666666667
37861, 1.5333333333333, -0.2, 0.41666666666667
37862, 1.575, -0.2, 0.41666666666667
37863, 1.6166666666667, -0.2, 0.41666666666667
37864, 1.6583333333333, -0.2, 0.41666666666667
37865, 1.7, -0.2, 0.41666666666667
37866, 1.7416666666667, -0.2, 0.41666666666667
37867, 1.7833333333333, -0.2, 0.41666666666667
37868, 1.825, -0.2, 0.41666666666667
37869, 1.8666666666667, -0.2, 0.41666666666667
37870, 1.9083333333333, -0.2, 0.41666666666667
37871, 1.95, -0.2, 0.41666666666667
37872, 1.9916666666667, -0.2, 0.41666666666667
37873, 2.0333333333333, -0.2, 0.41666666666667
37874, 2.075, -0.2, 0.41666666666667
37875, 2.1166666666667, -0.2, 0.41666666666667
37876, 2.1583333333333, -0.2, 0.41666666666667
37877, 1.2416666666667, -0.2, 0.45833333333333
37878, 1.2833333333333, -0.2, 0.45833333333333
37879, 1.325, -0.2, 0.45833333333333
37880, 1.3666666666667, -0.2, 0.45833333333333
37881, 1.4083333333333, -0.2, 0.45833333333333
37882, 1.45, -0.2, 0.45833333333333
37883, 1.4916666666667, -0.2, 0.45833333333333
37884, 1.5333333333333, -0.2, 0.45833333333333
37885, 1.575, -0.2, 0.45833333333333
37886, 1.6166666666667, -0.2, 0.45833333333333
37887, 1.6583333333333, -0.2, 0.45833333333333
37888, 1.7, -0.2, 0.45833333333333
37889, 1.7416666666667, -0.2, 0.45833333333333
37890, 1.7833333333333, -0.2, 0.45833333333333
37891, 1.825, -0.2, 0.45833333333333
37892, 1.8666666666667, -0.2, 0.45833333333333
37893, 1.9083333333333, -0.2, 0.45833333333333
37894, 1.95, -0.2, 0.45833333333333
37895, 1.9916666666667, -0.2, 0.45833333333333
37896, 2.0333333333333, -0.2, 0.45833333333333
37897, 2.075, -0.2, 0.45833333333333
37898, 2.1166666666667, -0.2, 0.45833333333333
37899, 2.1583333333333, -0.2, 0.45833333333333
37900, 1.2416666666667, -0.2, 0.020833333333333
37901, 1.2208333333333, -0.2, 0.041666666666667
37902, 1.2833333333333, -0.2, 0.020833333333333
37903, 1.2625, -0.2, 0.041666666666667
37904, 1.325, -0.2, 0.020833333333333
37905, 1.3041666666667, -0.2, 0.041666666666667
37906, 1.3666666666667, -0.2, 0.020833333333333
37907, 1.3458333333333, -0.2, 0.041666666666667
37908, 1.4083333333333, -0.2, 0.020833333333333
37909, 1.3875, -0.2, 0.041666666666667
37910, 1.45, -0.2, 0.020833333333333
37911, 1.4291666666667, -0.2, 0.041666666666667
37912, 1.4916666666667, -0.2, 0.020833333333333
37913, 1.4708333333333, -0.2, 0.041666666666667
37914, 1.5333333333333, -0.2, 0.020833333333333
37915, 1.5125, -0.2, 0.041666666666667
37916, 1.575, -0.2, 0.020833333333333
37917, 1.5541666666667, -0.2, 0.041666666666667
37918, 1.6166666666667, -0.2, 0.020833333333333
37919, 1.5958333333333, -0.2, 0.041666666666667
37920, 1.6583333333333, -0.2, 0.020833333333333
37921, 1.6375, -0.2, 0.041666666666667
37922, 1.7, -0.2, 0.020833333333333
37923, 1.6791666666667, -0.2, 0.041666666666667
37924, 1.7416666666667, -0.2, 0.020833333333333
37925, 1.7208333333333, -0.2, 0.041666666666667
37926, 1.7833333333333, -0.2, 0.020833333333333
37927, 1.7625, -0.2, 0.041666666666667
37928, 1.825, -0.2, 0.020833333333333
37929, 1.8041666666667, -0.2, 0.041666666666667
37930, 1.8666666666667, -0.2, 0.020833333333333
37931, 1.8458333333333, -0.2, 0.041666666666667
37932, 1.9083333333333, -0.2, 0.020833333333333
37933, 1.8875, -0.2, 0.041666666666667
37934, 1.95, -0.2, 0.020833333333333
37935, 1.9291666666667, -0.2, 0.041666666666667
37936, 1.9916666666667, -0.2, 0.020833333333333
37937, 1.9708333333333, -0.2, 0.041666666666667
37938, 2.0333333333333, -0.2, 0.020833333333333
37939, 2.0125, -0.2, 0.041666666666667
37940, 2.075, -0.2, 0.020833333333333
37941, 2.0541666666667, -0.2, 0.041666666666667
37942, 2.1166666666667, -0.2, 0.020833333333333
37943, 2.0958333333333, -0.2, 0.041666666666667
37944, 2.1583333333333, -0.2, 0.020833333333333
37945, 2.1375, -0.2, 0.041666666666667
37946, 2.1791666666667, -0.2, 0.041666666666667
37947, 1.2416666666667, -0.2, 0.0625
37948, 1.2208333333333, -0.2, 0.083333333333333
37949, 1.2833333333333, -0.2, 0.0625
37950, 1.2625, -0.2, 0.083333333333333
37951, 1.325, -0.2, 0.0625
37952, 1.3041666666667, -0.2, 0.083333333333333
37953, 1.3666666666667, -0.2, 0.0625
37954, 1.3458333333333, -0.2, 0.083333333333333
37955, 1.4083333333333, -0.2, 0.0625
37956, 1.3875, -0.2, 0.083333333333333
37957, 1.45, -0.2, 0.0625
37958, 1.4291666666667, -0.2, 0.083333333333333
37959, 1.4916666666667, -0.2, 0.0625
37960, 1.4708333333333, -0.2, 0.083333333333333
37961, 1.5333333333333, -0.2, 0.0625
37962, 1.5125, -0.2, 0.083333333333333
37963, 1.575, -0.2, 0.0625
37964, 1.5541666666667, -0.2, 0.083333333333333
37965, 1.6166666666667, -0.2, 0.0625
37966, 1.5958333333333, -0.2, 0.083333333333333
37967, 1.6583333333333, -0.2, 0.0625
37968, 1.6375, -0.2, 0.083333333333333
37969, 1.7, -0.2, 0.0625
37970, 1.6791666666667, -0.2, 0.083333333333333
37971, 1.7416666666667, -0.2, 0.0625
37972, 1.7208333333333, -0.2, 0.083333333333333
37973, 1.7833333333333, -0.2, 0.0625
37974, 1.7625, -0.2, 0.083333333333333
37975, 1.825, -0.2, 0.0625
37976, 1.8041666666667, -0.2, 0.083333333333333
37977, 1.8666666666667, -0.2, 0.0625
37978, 1.8458333333333, -0.2, 0.083333333333333
37979, 1.9083333333333, -0.2, 0.0625
37980, 1.8875, -0.2, 0.083333333333333
37981, 1.95, -0.2, 0.0625
37982, 1.9291666666667, -0.2, 0.083333333333333
37983, 1.9916666666667, -0.2, 0.0625
37984, 1.9708333333333, -0.2, 0.083333333333333
37985, 2.0333333333333, -0.2, 0.0625
37986, 2.0125, -0.2, 0.083333333333333
37987, 2.075, -0.2, 0.0625
37988, 2.0541666666667, -0.2, 0.083333333333333
37989, 2.1166666666667, -0.2, 0.0625
37990, 2.0958333333333, -0.2, 0.083333333333333
37991, 2.1583333333333, -0.2, 0.0625
37992, 2.1375, -0.2, 0.083333333333333
37993, 2.1791666666667, -0.2, 0.083333333333333
37994, 1.2416666666667, -0.2, 0.10416666666667
37995, 1.2208333333333, -0.2, 0.125
37996, 1.2833333333333, -0.2, 0.10416666666667
37997, 1.2625, -0.2, 0.125
37998, 1.325, -0.2, 0.10416666666667
37999, 1.3041666666667, -0.2, 0.125
38000, 1.3666666666667, -0.2, 0.10416666666667
38001, 1.3458333333333, -0.2, 0.125
38002, 1.4083333333333, -0.2, 0.10416666666667
38003, 1.3875, -0.2, 0.125
38004, 1.45, -0.2, 0.10416666666667
38005, 1.4291666666667, -0.2, 0.125
38006, 1.4916666666667, -0.2, 0.10416666666667
38007, 1.4708333333333, -0.2, 0.125
38008, 1.5333333333333, -0.2, 0.10416666666667
38009, 1.5125, -0.2, 0.125
38010, 1.575, -0.2, 0.10416666666667
38011, 1.5541666666667, -0.2, 0.125
38012, 1.6166666666667, -0.2, 0.10416666666667
38013, 1.5958333333333, -0.2, 0.125
38014, 1.6583333333333, -0.2, 0.10416666666667
38015, 1.6375, -0.2, 0.125
38016, 1.7, -0.2, 0.10416666666667
38017, 1.6791666666667, -0.2, 0.125
38018, 1.7416666666667, -0.2, 0.10416666666667
38019, 1.7208333333333, -0.2, 0.125
38020, 1.7833333333333, -0.2, 0.10416666666667
38021, 1.7625, -0.2, 0.125
38022, 1.825, -0.2, 0.10416666666667
38023, 1.8041666666667, -0.2, 0.125
38024, 1.8666666666667, -0.2, 0.10416666666667
38025, 1.8458333333333, -0.2, 0.125
38026, 1.9083333333333, -0.2, 0.10416666666667
38027, 1.8875, -0.2, 0.125
38028, 1.95, -0.2, 0.10416666666667
38029, 1.9291666666667, -0.2, 0.125
38030, 1.9916666666667, -0.2, 0.10416666666667
38031, 1.9708333333333, -0.2, 0.125
38032, 2.0333333333333, -0.2, 0.10416666666667
38033, 2.0125, -0.2, 0.125
38034, 2.075, -0.2, 0.10416666666667
38035, 2.0541666666667, -0.2, 0.125
38036, 2.1166666666667, -0.2, 0.10416666666667
38037, 2.0958333333333, -0.2, 0.125
38038, 2.1583333333333, -0.2, 0.10416666666667
38039, 2.1375, -0.2, 0.125
38040, 2.1791666666667, -0.2, 0.125
38041, 1.2416666666667, -0.2, 0.14583333333333
38042, 1.2208333333333, -0.2, 0.16666666666667
38043, 1.2833333333333, -0.2, 0.14583333333333
38044, 1.2625, -0.2, 0.16666666666667
38045, 1.325, -0.2, 0.14583333333333
38046, 1.3041666666667, -0.2, 0.16666666666667
38047, 1.3666666666667, -0.2, 0.14583333333333
38048, 1.3458333333333, -0.2, 0.16666666666667
38049, 1.4083333333333, -0.2, 0.14583333333333
38050, 1.3875, -0.2, 0.16666666666667
38051, 1.45, -0.2, 0.14583333333333
38052, 1.4291666666667, -0.2, 0.16666666666667
38053, 1.4916666666667, -0.2, 0.14583333333333
38054, 1.4708333333333, -0.2, 0.16666666666667
38055, 1.5333333333333, -0.2, 0.14583333333333
38056, 1.5125, -0.2, 0.16666666666667
38057, 1.575, -0.2, 0.14583333333333
38058, 1.5541666666667, -0.2, 0.16666666666667
38059, 1.6166666666667, -0.2, 0.14583333333333
38060, 1.5958333333333, -0.2, 0.16666666666667
38061, 1.6583333333333, -0.2, 0.14583333333333
38062, 1.6375, -0.2, 0.16666666666667
38063, 1.7, -0.2, 0.14583333333333
38064, 1.6791666666667, -0.2, 0.16666666666667
38065, 1.7416666666667, -0.2, 0.14583333333333
38066, 1.7208333333333, -0.2, 0.16666666666667
38067, 1.7833333333333, -0.2, 0.14583333333333
38068, 1.7625, -0.2, 0.16666666666667
38069, 1.825, -0.2, 0.14583333333333
38070, 1.8041666666667, -0.2, 0.16666666666667
38071, 1.8666666666667, -0.2, 0.14583333333333
38072, 1.8458333333333, -0.2, 0.16666666666667
38073, 1.9083333333333, -0.2, 0.14583333333333
38074, 1.8875, -0.2, 0.16666666666667
38075, 1.95, -0.2, 0.14583333333333
38076, 1.9291666666667, -0.2, 0.16666666666667
38077, 1.9916666666667, -0.2, 0.14583333333333
38078, 1.9708333333333, -0.2, 0.16666666666667
38079, 2.0333333333333, -0.2, 0.14583333333333
38080, 2.0125, -0.2, 0.16666666666667
38081, 2.075, -0.2, 0.14583333333333
38082, 2.0541666666667, -0.2, 0.16666666666667
38083, 2.1166666666667, -0.2, 0.14583333333333
38084, 2.0958333333333, -0.2, 0.16666666666667
38085, 2.1583333333333, -0.2, 0.14583333333333
38086, 2.1375, -0.2, 0.16666666666667
38087, 2.1791666666667, -0.2, 0.16666666666667
38088, 1.2416666666667, -0.2, 0.1875
38089, 1.2208333333333, -0.2, 0.20833333333333
38090, 1.2833333333333, -0.2, 0.1875
38091, 1.2625, -0.2, 0.20833333333333
38092, 1.325, -0.2, 0.1875
38093, 1.3041666666667, -0.2, 0.20833333333333
38094, 1.3666666666667, -0.2, 0.1875
38095, 1.3458333333333, -0.2, 0.20833333333333
38096, 1.4083333333333, -0.2, 0.1875
38097, 1.3875, -0.2, 0.20833333333333
38098, 1.45, -0.2, 0.1875
38099, 1.4291666666667, -0.2, 0.20833333333333
38100, 1.4916666666667, -0.2, 0.1875
38101, 1.4708333333333, -0.2, 0.20833333333333
38102, 1.5333333333333, -0.2, 0.1875
38103, 1.5125, -0.2, 0.20833333333333
38104, 1.575, -0.2, 0.1875
38105, 1.5541666666667, -0.2, 0.20833333333333
38106, 1.6166666666667, -0.2, 0.1875
38107, 1.5958333333333, -0.2, 0.20833333333333
38108, 1.6583333333333, -0.2, 0.1875
38109, 1.6375, -0.2, 0.20833333333333
38110, 1.7, -0.2, 0.1875
38111, 1.6791666666667, -0.2, 0.20833333333333
38112, 1.7416666666667, -0.2, 0.1875
38113, 1.7208333333333, -0.2, 0.20833333333333
38114, 1.7833333333333, -0.2, 0.1875
38115, 1.7625, -0.2, 0.20833333333333
38116, 1.825, -0.2, 0.1875
38117, 1.8041666666667, -0.2, 0.20833333333333
38118, 1.8666666666667, -0.2, 0.1875
38119, 1.8458333333333, -0.2, 0.20833333333333
38120, 1.9083333333333, -0.2, 0.1875
38121, 1.8875, -0.2, 0.20833333333333
38122, 1.95, -0.2, 0.1875
38123, 1.9291666666667, -0.2, 0.20833333333333
38124, 1.9916666666667, -0.2, 0.1875
38125, 1.9708333333333, -0.2, 0.20833333333333
38126, 2.0333333333333, -0.2, 0.1875
38127, 2.0125, -0.2, 0.20833333333333
38128, 2.075, -0.2, 0.1875
38129, 2.0541666666667, -0.2, 0.20833333333333
38130, 2.1166666666667, -0.2, 0.1875
38131, 2.0958333333333, -0.2, 0.20833333333333
38132, 2.1583333333333, -0.2, 0.1875
38133, 2.1375, -0.2, 0.20833333333333
38134, 2.1791666666667, -0.2, 0.20833333333333
38135, 1.2416666666667, -0.2, 0.22916666666667
38136, 1.2208333333333, -0.2, 0.25
38137, 1.2833333333333, -0.2, 0.22916666666667
38138, 1.2625, -0.2, 0.25
38139, 1.325, -0.2, 0.22916666666667
38140, 1.3041666666667, -0.2, 0.25
38141, 1.3666666666667, -0.2, 0.22916666666667
38142, 1.3458333333333, -0.2, 0.25
38143, 1.4083333333333, -0.2, 0.22916666666667
38144, 1.3875, -0.2, 0.25
38145, 1.45, -0.2, 0.22916666666667
38146, 1.4291666666667, -0.2, 0.25
38147, 1.4916666666667, -0.2, 0.22916666666667
38148, 1.4708333333333, -0.2, 0.25
38149, 1.5333333333333, -0.2, 0.22916666666667
38150, 1.5125, -0.2, 0.25
38151, 1.575, -0.2, 0.22916666666667
38152, 1.5541666666667, -0.2, 0.25
38153, 1.6166666666667, -0.2, 0.22916666666667
38154, 1.5958333333333, -0.2, 0.25
38155, 1.6583333333333, -0.2, 0.22916666666667
38156, 1.6375, -0.2, 0.25
38157, 1.7, -0.2, 0.22916666666667
38158, 1.6791666666667, -0.2, 0.25
38159, 1.7416666666667, -0.2, 0.22916666666667
38160, 1.7208333333333, -0.2, 0.25
