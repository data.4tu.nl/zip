49601, 0.16666666666667, 1.15, 0.10416666666667
49602, 0.16666666666667, 1.175, 0.125
49603, 0.14583333333333, 1.2, 0.125
49604, 0.16666666666667, 1.2, 0.10416666666667
49605, 0.16666666666667, 1.225, 0.125
49606, 0.14583333333333, 1.25, 0.125
49607, 0.16666666666667, 1.25, 0.10416666666667
49608, 0.16666666666667, 1.275, 0.125
49609, 0.14583333333333, 1.3, 0.125
49610, 0.16666666666667, 1.3, 0.10416666666667
49611, 0.16666666666667, 1.325, 0.125
49612, 0.16666666666667, 0.175, 0.16666666666667
49613, 0.14583333333333, 0.2, 0.16666666666667
49614, 0.16666666666667, 0.2, 0.14583333333333
49615, 0.16666666666667, 0.225, 0.16666666666667
49616, 0.14583333333333, 0.25, 0.16666666666667
49617, 0.16666666666667, 0.25, 0.14583333333333
49618, 0.16666666666667, 0.275, 0.16666666666667
49619, 0.14583333333333, 0.3, 0.16666666666667
49620, 0.16666666666667, 0.3, 0.14583333333333
49621, 0.16666666666667, 0.325, 0.16666666666667
49622, 0.14583333333333, 0.35, 0.16666666666667
49623, 0.16666666666667, 0.35, 0.14583333333333
49624, 0.16666666666667, 0.375, 0.16666666666667
49625, 0.14583333333333, 0.4, 0.16666666666667
49626, 0.16666666666667, 0.4, 0.14583333333333
49627, 0.16666666666667, 0.425, 0.16666666666667
49628, 0.14583333333333, 0.45, 0.16666666666667
49629, 0.16666666666667, 0.45, 0.14583333333333
49630, 0.16666666666667, 0.475, 0.16666666666667
49631, 0.14583333333333, 0.5, 0.16666666666667
49632, 0.16666666666667, 0.5, 0.14583333333333
49633, 0.16666666666667, 0.525, 0.16666666666667
49634, 0.14583333333333, 0.55, 0.16666666666667
49635, 0.16666666666667, 0.55, 0.14583333333333
49636, 0.16666666666667, 0.575, 0.16666666666667
49637, 0.14583333333333, 0.6, 0.16666666666667
49638, 0.16666666666667, 0.6, 0.14583333333333
49639, 0.16666666666667, 0.625, 0.16666666666667
49640, 0.14583333333333, 0.65, 0.16666666666667
49641, 0.16666666666667, 0.65, 0.14583333333333
49642, 0.16666666666667, 0.675, 0.16666666666667
49643, 0.14583333333333, 0.7, 0.16666666666667
49644, 0.16666666666667, 0.7, 0.14583333333333
49645, 0.16666666666667, 0.725, 0.16666666666667
49646, 0.14583333333333, 0.75, 0.16666666666667
49647, 0.16666666666667, 0.75, 0.14583333333333
49648, 0.16666666666667, 0.775, 0.16666666666667
49649, 0.14583333333333, 0.8, 0.16666666666667
49650, 0.16666666666667, 0.8, 0.14583333333333
49651, 0.16666666666667, 0.825, 0.16666666666667
49652, 0.14583333333333, 0.85, 0.16666666666667
49653, 0.16666666666667, 0.85, 0.14583333333333
49654, 0.16666666666667, 0.875, 0.16666666666667
49655, 0.14583333333333, 0.9, 0.16666666666667
49656, 0.16666666666667, 0.9, 0.14583333333333
49657, 0.16666666666667, 0.925, 0.16666666666667
49658, 0.14583333333333, 0.95, 0.16666666666667
49659, 0.16666666666667, 0.95, 0.14583333333333
49660, 0.16666666666667, 0.975, 0.16666666666667
49661, 0.14583333333333, 1, 0.16666666666667
49662, 0.16666666666667, 1, 0.14583333333333
49663, 0.16666666666667, 1.025, 0.16666666666667
49664, 0.14583333333333, 1.05, 0.16666666666667
49665, 0.16666666666667, 1.05, 0.14583333333333
49666, 0.16666666666667, 1.075, 0.16666666666667
49667, 0.14583333333333, 1.1, 0.16666666666667
49668, 0.16666666666667, 1.1, 0.14583333333333
49669, 0.16666666666667, 1.125, 0.16666666666667
49670, 0.14583333333333, 1.15, 0.16666666666667
49671, 0.16666666666667, 1.15, 0.14583333333333
49672, 0.16666666666667, 1.175, 0.16666666666667
49673, 0.14583333333333, 1.2, 0.16666666666667
49674, 0.16666666666667, 1.2, 0.14583333333333
49675, 0.16666666666667, 1.225, 0.16666666666667
49676, 0.14583333333333, 1.25, 0.16666666666667
49677, 0.16666666666667, 1.25, 0.14583333333333
49678, 0.16666666666667, 1.275, 0.16666666666667
49679, 0.14583333333333, 1.3, 0.16666666666667
49680, 0.16666666666667, 1.3, 0.14583333333333
49681, 0.16666666666667, 1.325, 0.16666666666667
49682, 0.16666666666667, 0.175, 0.20833333333333
49683, 0.14583333333333, 0.2, 0.20833333333333
49684, 0.16666666666667, 0.2, 0.1875
49685, 0.16666666666667, 0.225, 0.20833333333333
49686, 0.14583333333333, 0.25, 0.20833333333333
49687, 0.16666666666667, 0.25, 0.1875
49688, 0.16666666666667, 0.275, 0.20833333333333
49689, 0.14583333333333, 0.3, 0.20833333333333
49690, 0.16666666666667, 0.3, 0.1875
49691, 0.16666666666667, 0.325, 0.20833333333333
49692, 0.14583333333333, 0.35, 0.20833333333333
49693, 0.16666666666667, 0.35, 0.1875
49694, 0.16666666666667, 0.375, 0.20833333333333
49695, 0.14583333333333, 0.4, 0.20833333333333
49696, 0.16666666666667, 0.4, 0.1875
49697, 0.16666666666667, 0.425, 0.20833333333333
49698, 0.14583333333333, 0.45, 0.20833333333333
49699, 0.16666666666667, 0.45, 0.1875
49700, 0.16666666666667, 0.475, 0.20833333333333
49701, 0.14583333333333, 0.5, 0.20833333333333
49702, 0.16666666666667, 0.5, 0.1875
49703, 0.16666666666667, 0.525, 0.20833333333333
49704, 0.14583333333333, 0.55, 0.20833333333333
49705, 0.16666666666667, 0.55, 0.1875
49706, 0.16666666666667, 0.575, 0.20833333333333
49707, 0.14583333333333, 0.6, 0.20833333333333
49708, 0.16666666666667, 0.6, 0.1875
49709, 0.16666666666667, 0.625, 0.20833333333333
49710, 0.14583333333333, 0.65, 0.20833333333333
49711, 0.16666666666667, 0.65, 0.1875
49712, 0.16666666666667, 0.675, 0.20833333333333
49713, 0.14583333333333, 0.7, 0.20833333333333
49714, 0.16666666666667, 0.7, 0.1875
49715, 0.16666666666667, 0.725, 0.20833333333333
49716, 0.14583333333333, 0.75, 0.20833333333333
49717, 0.16666666666667, 0.75, 0.1875
49718, 0.16666666666667, 0.775, 0.20833333333333
49719, 0.14583333333333, 0.8, 0.20833333333333
49720, 0.16666666666667, 0.8, 0.1875
49721, 0.16666666666667, 0.825, 0.20833333333333
49722, 0.14583333333333, 0.85, 0.20833333333333
49723, 0.16666666666667, 0.85, 0.1875
49724, 0.16666666666667, 0.875, 0.20833333333333
49725, 0.14583333333333, 0.9, 0.20833333333333
49726, 0.16666666666667, 0.9, 0.1875
49727, 0.16666666666667, 0.925, 0.20833333333333
49728, 0.14583333333333, 0.95, 0.20833333333333
49729, 0.16666666666667, 0.95, 0.1875
49730, 0.16666666666667, 0.975, 0.20833333333333
49731, 0.14583333333333, 1, 0.20833333333333
49732, 0.16666666666667, 1, 0.1875
49733, 0.16666666666667, 1.025, 0.20833333333333
49734, 0.14583333333333, 1.05, 0.20833333333333
49735, 0.16666666666667, 1.05, 0.1875
49736, 0.16666666666667, 1.075, 0.20833333333333
49737, 0.14583333333333, 1.1, 0.20833333333333
49738, 0.16666666666667, 1.1, 0.1875
49739, 0.16666666666667, 1.125, 0.20833333333333
49740, 0.14583333333333, 1.15, 0.20833333333333
49741, 0.16666666666667, 1.15, 0.1875
49742, 0.16666666666667, 1.175, 0.20833333333333
49743, 0.14583333333333, 1.2, 0.20833333333333
49744, 0.16666666666667, 1.2, 0.1875
49745, 0.16666666666667, 1.225, 0.20833333333333
49746, 0.14583333333333, 1.25, 0.20833333333333
49747, 0.16666666666667, 1.25, 0.1875
49748, 0.16666666666667, 1.275, 0.20833333333333
49749, 0.14583333333333, 1.3, 0.20833333333333
49750, 0.16666666666667, 1.3, 0.1875
49751, 0.16666666666667, 1.325, 0.20833333333333
49752, 0.16666666666667, 0.175, 0.25
49753, 0.14583333333333, 0.2, 0.25
49754, 0.16666666666667, 0.2, 0.22916666666667
49755, 0.16666666666667, 0.225, 0.25
49756, 0.14583333333333, 0.25, 0.25
49757, 0.16666666666667, 0.25, 0.22916666666667
49758, 0.16666666666667, 0.275, 0.25
49759, 0.14583333333333, 0.3, 0.25
49760, 0.16666666666667, 0.3, 0.22916666666667
49761, 0.16666666666667, 0.325, 0.25
49762, 0.14583333333333, 0.35, 0.25
49763, 0.16666666666667, 0.35, 0.22916666666667
49764, 0.16666666666667, 0.375, 0.25
49765, 0.14583333333333, 0.4, 0.25
49766, 0.16666666666667, 0.4, 0.22916666666667
49767, 0.16666666666667, 0.425, 0.25
49768, 0.14583333333333, 0.45, 0.25
49769, 0.16666666666667, 0.45, 0.22916666666667
49770, 0.16666666666667, 0.475, 0.25
49771, 0.14583333333333, 0.5, 0.25
49772, 0.16666666666667, 0.5, 0.22916666666667
49773, 0.16666666666667, 0.525, 0.25
49774, 0.14583333333333, 0.55, 0.25
49775, 0.16666666666667, 0.55, 0.22916666666667
49776, 0.16666666666667, 0.575, 0.25
49777, 0.14583333333333, 0.6, 0.25
49778, 0.16666666666667, 0.6, 0.22916666666667
49779, 0.16666666666667, 0.625, 0.25
49780, 0.14583333333333, 0.65, 0.25
49781, 0.16666666666667, 0.65, 0.22916666666667
49782, 0.16666666666667, 0.675, 0.25
49783, 0.14583333333333, 0.7, 0.25
49784, 0.16666666666667, 0.7, 0.22916666666667
49785, 0.16666666666667, 0.725, 0.25
49786, 0.14583333333333, 0.75, 0.25
49787, 0.16666666666667, 0.75, 0.22916666666667
49788, 0.16666666666667, 0.775, 0.25
49789, 0.14583333333333, 0.8, 0.25
49790, 0.16666666666667, 0.8, 0.22916666666667
49791, 0.16666666666667, 0.825, 0.25
49792, 0.14583333333333, 0.85, 0.25
49793, 0.16666666666667, 0.85, 0.22916666666667
49794, 0.16666666666667, 0.875, 0.25
49795, 0.14583333333333, 0.9, 0.25
49796, 0.16666666666667, 0.9, 0.22916666666667
49797, 0.16666666666667, 0.925, 0.25
49798, 0.14583333333333, 0.95, 0.25
49799, 0.16666666666667, 0.95, 0.22916666666667
49800, 0.16666666666667, 0.975, 0.25
49801, 0.14583333333333, 1, 0.25
49802, 0.16666666666667, 1, 0.22916666666667
49803, 0.16666666666667, 1.025, 0.25
49804, 0.14583333333333, 1.05, 0.25
49805, 0.16666666666667, 1.05, 0.22916666666667
49806, 0.16666666666667, 1.075, 0.25
49807, 0.14583333333333, 1.1, 0.25
49808, 0.16666666666667, 1.1, 0.22916666666667
49809, 0.16666666666667, 1.125, 0.25
49810, 0.14583333333333, 1.15, 0.25
49811, 0.16666666666667, 1.15, 0.22916666666667
49812, 0.16666666666667, 1.175, 0.25
49813, 0.14583333333333, 1.2, 0.25
49814, 0.16666666666667, 1.2, 0.22916666666667
49815, 0.16666666666667, 1.225, 0.25
49816, 0.14583333333333, 1.25, 0.25
49817, 0.16666666666667, 1.25, 0.22916666666667
49818, 0.16666666666667, 1.275, 0.25
49819, 0.14583333333333, 1.3, 0.25
49820, 0.16666666666667, 1.3, 0.22916666666667
49821, 0.16666666666667, 1.325, 0.25
49822, 0.16666666666667, 0.175, 0.29166666666667
49823, 0.14583333333333, 0.2, 0.29166666666667
49824, 0.16666666666667, 0.2, 0.27083333333333
49825, 0.16666666666667, 0.225, 0.29166666666667
49826, 0.14583333333333, 0.25, 0.29166666666667
49827, 0.16666666666667, 0.25, 0.27083333333333
49828, 0.16666666666667, 0.275, 0.29166666666667
49829, 0.14583333333333, 0.3, 0.29166666666667
49830, 0.16666666666667, 0.3, 0.27083333333333
49831, 0.16666666666667, 0.325, 0.29166666666667
49832, 0.14583333333333, 0.35, 0.29166666666667
49833, 0.16666666666667, 0.35, 0.27083333333333
49834, 0.16666666666667, 0.375, 0.29166666666667
49835, 0.14583333333333, 0.4, 0.29166666666667
49836, 0.16666666666667, 0.4, 0.27083333333333
49837, 0.16666666666667, 0.425, 0.29166666666667
49838, 0.14583333333333, 0.45, 0.29166666666667
49839, 0.16666666666667, 0.45, 0.27083333333333
49840, 0.16666666666667, 0.475, 0.29166666666667
49841, 0.14583333333333, 0.5, 0.29166666666667
49842, 0.16666666666667, 0.5, 0.27083333333333
49843, 0.16666666666667, 0.525, 0.29166666666667
49844, 0.14583333333333, 0.55, 0.29166666666667
49845, 0.16666666666667, 0.55, 0.27083333333333
49846, 0.16666666666667, 0.575, 0.29166666666667
49847, 0.14583333333333, 0.6, 0.29166666666667
49848, 0.16666666666667, 0.6, 0.27083333333333
49849, 0.16666666666667, 0.625, 0.29166666666667
49850, 0.14583333333333, 0.65, 0.29166666666667
49851, 0.16666666666667, 0.65, 0.27083333333333
49852, 0.16666666666667, 0.675, 0.29166666666667
49853, 0.14583333333333, 0.7, 0.29166666666667
49854, 0.16666666666667, 0.7, 0.27083333333333
49855, 0.16666666666667, 0.725, 0.29166666666667
49856, 0.14583333333333, 0.75, 0.29166666666667
49857, 0.16666666666667, 0.75, 0.27083333333333
49858, 0.16666666666667, 0.775, 0.29166666666667
49859, 0.14583333333333, 0.8, 0.29166666666667
49860, 0.16666666666667, 0.8, 0.27083333333333
49861, 0.16666666666667, 0.825, 0.29166666666667
49862, 0.14583333333333, 0.85, 0.29166666666667
49863, 0.16666666666667, 0.85, 0.27083333333333
49864, 0.16666666666667, 0.875, 0.29166666666667
49865, 0.14583333333333, 0.9, 0.29166666666667
49866, 0.16666666666667, 0.9, 0.27083333333333
49867, 0.16666666666667, 0.925, 0.29166666666667
49868, 0.14583333333333, 0.95, 0.29166666666667
49869, 0.16666666666667, 0.95, 0.27083333333333
49870, 0.16666666666667, 0.975, 0.29166666666667
49871, 0.14583333333333, 1, 0.29166666666667
49872, 0.16666666666667, 1, 0.27083333333333
49873, 0.16666666666667, 1.025, 0.29166666666667
49874, 0.14583333333333, 1.05, 0.29166666666667
49875, 0.16666666666667, 1.05, 0.27083333333333
49876, 0.16666666666667, 1.075, 0.29166666666667
49877, 0.14583333333333, 1.1, 0.29166666666667
49878, 0.16666666666667, 1.1, 0.27083333333333
49879, 0.16666666666667, 1.125, 0.29166666666667
49880, 0.14583333333333, 1.15, 0.29166666666667
49881, 0.16666666666667, 1.15, 0.27083333333333
49882, 0.16666666666667, 1.175, 0.29166666666667
49883, 0.14583333333333, 1.2, 0.29166666666667
49884, 0.16666666666667, 1.2, 0.27083333333333
49885, 0.16666666666667, 1.225, 0.29166666666667
49886, 0.14583333333333, 1.25, 0.29166666666667
49887, 0.16666666666667, 1.25, 0.27083333333333
49888, 0.16666666666667, 1.275, 0.29166666666667
49889, 0.14583333333333, 1.3, 0.29166666666667
49890, 0.16666666666667, 1.3, 0.27083333333333
49891, 0.16666666666667, 1.325, 0.29166666666667
49892, 0.16666666666667, 0.175, 0.33333333333333
49893, 0.14583333333333, 0.2, 0.33333333333333
49894, 0.16666666666667, 0.2, 0.3125
49895, 0.16666666666667, 0.225, 0.33333333333333
49896, 0.14583333333333, 0.25, 0.33333333333333
49897, 0.16666666666667, 0.25, 0.3125
49898, 0.16666666666667, 0.275, 0.33333333333333
49899, 0.14583333333333, 0.3, 0.33333333333333
49900, 0.16666666666667, 0.3, 0.3125
49901, 0.16666666666667, 0.325, 0.33333333333333
49902, 0.14583333333333, 0.35, 0.33333333333333
49903, 0.16666666666667, 0.35, 0.3125
49904, 0.16666666666667, 0.375, 0.33333333333333
49905, 0.14583333333333, 0.4, 0.33333333333333
49906, 0.16666666666667, 0.4, 0.3125
49907, 0.16666666666667, 0.425, 0.33333333333333
49908, 0.14583333333333, 0.45, 0.33333333333333
49909, 0.16666666666667, 0.45, 0.3125
49910, 0.16666666666667, 0.475, 0.33333333333333
49911, 0.14583333333333, 0.5, 0.33333333333333
49912, 0.16666666666667, 0.5, 0.3125
49913, 0.16666666666667, 0.525, 0.33333333333333
49914, 0.14583333333333, 0.55, 0.33333333333333
49915, 0.16666666666667, 0.55, 0.3125
49916, 0.16666666666667, 0.575, 0.33333333333333
49917, 0.14583333333333, 0.6, 0.33333333333333
49918, 0.16666666666667, 0.6, 0.3125
49919, 0.16666666666667, 0.625, 0.33333333333333
49920, 0.14583333333333, 0.65, 0.33333333333333
49921, 0.16666666666667, 0.65, 0.3125
49922, 0.16666666666667, 0.675, 0.33333333333333
49923, 0.14583333333333, 0.7, 0.33333333333333
49924, 0.16666666666667, 0.7, 0.3125
49925, 0.16666666666667, 0.725, 0.33333333333333
49926, 0.14583333333333, 0.75, 0.33333333333333
49927, 0.16666666666667, 0.75, 0.3125
49928, 0.16666666666667, 0.775, 0.33333333333333
49929, 0.14583333333333, 0.8, 0.33333333333333
49930, 0.16666666666667, 0.8, 0.3125
49931, 0.16666666666667, 0.825, 0.33333333333333
49932, 0.14583333333333, 0.85, 0.33333333333333
49933, 0.16666666666667, 0.85, 0.3125
49934, 0.16666666666667, 0.875, 0.33333333333333
49935, 0.14583333333333, 0.9, 0.33333333333333
49936, 0.16666666666667, 0.9, 0.3125
49937, 0.16666666666667, 0.925, 0.33333333333333
49938, 0.14583333333333, 0.95, 0.33333333333333
49939, 0.16666666666667, 0.95, 0.3125
49940, 0.16666666666667, 0.975, 0.33333333333333
49941, 0.14583333333333, 1, 0.33333333333333
49942, 0.16666666666667, 1, 0.3125
49943, 0.16666666666667, 1.025, 0.33333333333333
49944, 0.14583333333333, 1.05, 0.33333333333333
49945, 0.16666666666667, 1.05, 0.3125
49946, 0.16666666666667, 1.075, 0.33333333333333
49947, 0.14583333333333, 1.1, 0.33333333333333
49948, 0.16666666666667, 1.1, 0.3125
49949, 0.16666666666667, 1.125, 0.33333333333333
49950, 0.14583333333333, 1.15, 0.33333333333333
49951, 0.16666666666667, 1.15, 0.3125
49952, 0.16666666666667, 1.175, 0.33333333333333
49953, 0.14583333333333, 1.2, 0.33333333333333
49954, 0.16666666666667, 1.2, 0.3125
49955, 0.16666666666667, 1.225, 0.33333333333333
49956, 0.14583333333333, 1.25, 0.33333333333333
49957, 0.16666666666667, 1.25, 0.3125
49958, 0.16666666666667, 1.275, 0.33333333333333
49959, 0.14583333333333, 1.3, 0.33333333333333
49960, 0.16666666666667, 1.3, 0.3125
49961, 0.16666666666667, 1.325, 0.33333333333333
49962, 0.16666666666667, 0.175, 0.375
49963, 0.14583333333333, 0.2, 0.375
49964, 0.16666666666667, 0.2, 0.35416666666667
49965, 0.16666666666667, 0.225, 0.375
49966, 0.14583333333333, 0.25, 0.375
49967, 0.16666666666667, 0.25, 0.35416666666667
49968, 0.16666666666667, 0.275, 0.375
49969, 0.14583333333333, 0.3, 0.375
49970, 0.16666666666667, 0.3, 0.35416666666667
49971, 0.16666666666667, 0.325, 0.375
49972, 0.14583333333333, 0.35, 0.375
49973, 0.16666666666667, 0.35, 0.35416666666667
49974, 0.16666666666667, 0.375, 0.375
49975, 0.14583333333333, 0.4, 0.375
49976, 0.16666666666667, 0.4, 0.35416666666667
49977, 0.16666666666667, 0.425, 0.375
49978, 0.14583333333333, 0.45, 0.375
49979, 0.16666666666667, 0.45, 0.35416666666667
49980, 0.16666666666667, 0.475, 0.375
49981, 0.14583333333333, 0.5, 0.375
49982, 0.16666666666667, 0.5, 0.35416666666667
49983, 0.16666666666667, 0.525, 0.375
49984, 0.14583333333333, 0.55, 0.375
49985, 0.16666666666667, 0.55, 0.35416666666667
49986, 0.16666666666667, 0.575, 0.375
49987, 0.14583333333333, 0.6, 0.375
49988, 0.16666666666667, 0.6, 0.35416666666667
49989, 0.16666666666667, 0.625, 0.375
49990, 0.14583333333333, 0.65, 0.375
49991, 0.16666666666667, 0.65, 0.35416666666667
49992, 0.16666666666667, 0.675, 0.375
49993, 0.14583333333333, 0.7, 0.375
49994, 0.16666666666667, 0.7, 0.35416666666667
49995, 0.16666666666667, 0.725, 0.375
49996, 0.14583333333333, 0.75, 0.375
49997, 0.16666666666667, 0.75, 0.35416666666667
49998, 0.16666666666667, 0.775, 0.375
49999, 0.14583333333333, 0.8, 0.375
50000, 0.16666666666667, 0.8, 0.35416666666667
50001, 0.16666666666667, 0.825, 0.375
50002, 0.14583333333333, 0.85, 0.375
50003, 0.16666666666667, 0.85, 0.35416666666667
50004, 0.16666666666667, 0.875, 0.375
50005, 0.14583333333333, 0.9, 0.375
50006, 0.16666666666667, 0.9, 0.35416666666667
50007, 0.16666666666667, 0.925, 0.375
50008, 0.14583333333333, 0.95, 0.375
50009, 0.16666666666667, 0.95, 0.35416666666667
50010, 0.16666666666667, 0.975, 0.375
50011, 0.14583333333333, 1, 0.375
50012, 0.16666666666667, 1, 0.35416666666667
50013, 0.16666666666667, 1.025, 0.375
50014, 0.14583333333333, 1.05, 0.375
50015, 0.16666666666667, 1.05, 0.35416666666667
50016, 0.16666666666667, 1.075, 0.375
50017, 0.14583333333333, 1.1, 0.375
50018, 0.16666666666667, 1.1, 0.35416666666667
50019, 0.16666666666667, 1.125, 0.375
50020, 0.14583333333333, 1.15, 0.375
50021, 0.16666666666667, 1.15, 0.35416666666667
50022, 0.16666666666667, 1.175, 0.375
50023, 0.14583333333333, 1.2, 0.375
50024, 0.16666666666667, 1.2, 0.35416666666667
50025, 0.16666666666667, 1.225, 0.375
50026, 0.14583333333333, 1.25, 0.375
50027, 0.16666666666667, 1.25, 0.35416666666667
50028, 0.16666666666667, 1.275, 0.375
50029, 0.14583333333333, 1.3, 0.375
50030, 0.16666666666667, 1.3, 0.35416666666667
50031, 0.16666666666667, 1.325, 0.375
50032, 0.16666666666667, 0.175, 0.41666666666667
50033, 0.14583333333333, 0.2, 0.41666666666667
50034, 0.16666666666667, 0.2, 0.39583333333333
50035, 0.16666666666667, 0.225, 0.41666666666667
50036, 0.14583333333333, 0.25, 0.41666666666667
50037, 0.16666666666667, 0.25, 0.39583333333333
50038, 0.16666666666667, 0.275, 0.41666666666667
50039, 0.14583333333333, 0.3, 0.41666666666667
50040, 0.16666666666667, 0.3, 0.39583333333333
50041, 0.16666666666667, 0.325, 0.41666666666667
50042, 0.14583333333333, 0.35, 0.41666666666667
50043, 0.16666666666667, 0.35, 0.39583333333333
50044, 0.16666666666667, 0.375, 0.41666666666667
50045, 0.14583333333333, 0.4, 0.41666666666667
50046, 0.16666666666667, 0.4, 0.39583333333333
50047, 0.16666666666667, 0.425, 0.41666666666667
50048, 0.14583333333333, 0.45, 0.41666666666667
50049, 0.16666666666667, 0.45, 0.39583333333333
50050, 0.16666666666667, 0.475, 0.41666666666667
50051, 0.14583333333333, 0.5, 0.41666666666667
50052, 0.16666666666667, 0.5, 0.39583333333333
50053, 0.16666666666667, 0.525, 0.41666666666667
50054, 0.14583333333333, 0.55, 0.41666666666667
50055, 0.16666666666667, 0.55, 0.39583333333333
50056, 0.16666666666667, 0.575, 0.41666666666667
50057, 0.14583333333333, 0.6, 0.41666666666667
50058, 0.16666666666667, 0.6, 0.39583333333333
50059, 0.16666666666667, 0.625, 0.41666666666667
50060, 0.14583333333333, 0.65, 0.41666666666667
50061, 0.16666666666667, 0.65, 0.39583333333333
50062, 0.16666666666667, 0.675, 0.41666666666667
50063, 0.14583333333333, 0.7, 0.41666666666667
50064, 0.16666666666667, 0.7, 0.39583333333333
50065, 0.16666666666667, 0.725, 0.41666666666667
50066, 0.14583333333333, 0.75, 0.41666666666667
50067, 0.16666666666667, 0.75, 0.39583333333333
50068, 0.16666666666667, 0.775, 0.41666666666667
50069, 0.14583333333333, 0.8, 0.41666666666667
50070, 0.16666666666667, 0.8, 0.39583333333333
50071, 0.16666666666667, 0.825, 0.41666666666667
50072, 0.14583333333333, 0.85, 0.41666666666667
50073, 0.16666666666667, 0.85, 0.39583333333333
50074, 0.16666666666667, 0.875, 0.41666666666667
50075, 0.14583333333333, 0.9, 0.41666666666667
50076, 0.16666666666667, 0.9, 0.39583333333333
50077, 0.16666666666667, 0.925, 0.41666666666667
50078, 0.14583333333333, 0.95, 0.41666666666667
50079, 0.16666666666667, 0.95, 0.39583333333333
50080, 0.16666666666667, 0.975, 0.41666666666667
50081, 0.14583333333333, 1, 0.41666666666667
50082, 0.16666666666667, 1, 0.39583333333333
50083, 0.16666666666667, 1.025, 0.41666666666667
50084, 0.14583333333333, 1.05, 0.41666666666667
50085, 0.16666666666667, 1.05, 0.39583333333333
50086, 0.16666666666667, 1.075, 0.41666666666667
50087, 0.14583333333333, 1.1, 0.41666666666667
50088, 0.16666666666667, 1.1, 0.39583333333333
50089, 0.16666666666667, 1.125, 0.41666666666667
50090, 0.14583333333333, 1.15, 0.41666666666667
50091, 0.16666666666667, 1.15, 0.39583333333333
50092, 0.16666666666667, 1.175, 0.41666666666667
50093, 0.14583333333333, 1.2, 0.41666666666667
50094, 0.16666666666667, 1.2, 0.39583333333333
50095, 0.16666666666667, 1.225, 0.41666666666667
50096, 0.14583333333333, 1.25, 0.41666666666667
50097, 0.16666666666667, 1.25, 0.39583333333333
50098, 0.16666666666667, 1.275, 0.41666666666667
50099, 0.14583333333333, 1.3, 0.41666666666667
50100, 0.16666666666667, 1.3, 0.39583333333333
50101, 0.16666666666667, 1.325, 0.41666666666667
50102, 0.16666666666667, 0.175, 0.45833333333333
50103, 0.14583333333333, 0.2, 0.45833333333333
50104, 0.16666666666667, 0.2, 0.4375
50105, 0.16666666666667, 0.225, 0.45833333333333
50106, 0.14583333333333, 0.25, 0.45833333333333
50107, 0.16666666666667, 0.25, 0.4375
50108, 0.16666666666667, 0.275, 0.45833333333333
50109, 0.14583333333333, 0.3, 0.45833333333333
50110, 0.16666666666667, 0.3, 0.4375
50111, 0.16666666666667, 0.325, 0.45833333333333
50112, 0.14583333333333, 0.35, 0.45833333333333
50113, 0.16666666666667, 0.35, 0.4375
50114, 0.16666666666667, 0.375, 0.45833333333333
50115, 0.14583333333333, 0.4, 0.45833333333333
50116, 0.16666666666667, 0.4, 0.4375
50117, 0.16666666666667, 0.425, 0.45833333333333
50118, 0.14583333333333, 0.45, 0.45833333333333
50119, 0.16666666666667, 0.45, 0.4375
50120, 0.16666666666667, 0.475, 0.45833333333333
50121, 0.14583333333333, 0.5, 0.45833333333333
50122, 0.16666666666667, 0.5, 0.4375
50123, 0.16666666666667, 0.525, 0.45833333333333
50124, 0.14583333333333, 0.55, 0.45833333333333
50125, 0.16666666666667, 0.55, 0.4375
50126, 0.16666666666667, 0.575, 0.45833333333333
50127, 0.14583333333333, 0.6, 0.45833333333333
50128, 0.16666666666667, 0.6, 0.4375
50129, 0.16666666666667, 0.625, 0.45833333333333
50130, 0.14583333333333, 0.65, 0.45833333333333
50131, 0.16666666666667, 0.65, 0.4375
50132, 0.16666666666667, 0.675, 0.45833333333333
50133, 0.14583333333333, 0.7, 0.45833333333333
50134, 0.16666666666667, 0.7, 0.4375
50135, 0.16666666666667, 0.725, 0.45833333333333
50136, 0.14583333333333, 0.75, 0.45833333333333
50137, 0.16666666666667, 0.75, 0.4375
50138, 0.16666666666667, 0.775, 0.45833333333333
50139, 0.14583333333333, 0.8, 0.45833333333333
50140, 0.16666666666667, 0.8, 0.4375
50141, 0.16666666666667, 0.825, 0.45833333333333
50142, 0.14583333333333, 0.85, 0.45833333333333
50143, 0.16666666666667, 0.85, 0.4375
50144, 0.16666666666667, 0.875, 0.45833333333333
50145, 0.14583333333333, 0.9, 0.45833333333333
50146, 0.16666666666667, 0.9, 0.4375
50147, 0.16666666666667, 0.925, 0.45833333333333
50148, 0.14583333333333, 0.95, 0.45833333333333
50149, 0.16666666666667, 0.95, 0.4375
50150, 0.16666666666667, 0.975, 0.45833333333333
50151, 0.14583333333333, 1, 0.45833333333333
50152, 0.16666666666667, 1, 0.4375
50153, 0.16666666666667, 1.025, 0.45833333333333
50154, 0.14583333333333, 1.05, 0.45833333333333
50155, 0.16666666666667, 1.05, 0.4375
50156, 0.16666666666667, 1.075, 0.45833333333333
50157, 0.14583333333333, 1.1, 0.45833333333333
50158, 0.16666666666667, 1.1, 0.4375
50159, 0.16666666666667, 1.125, 0.45833333333333
50160, 0.14583333333333, 1.15, 0.45833333333333
50161, 0.16666666666667, 1.15, 0.4375
50162, 0.16666666666667, 1.175, 0.45833333333333
50163, 0.14583333333333, 1.2, 0.45833333333333
50164, 0.16666666666667, 1.2, 0.4375
50165, 0.16666666666667, 1.225, 0.45833333333333
50166, 0.14583333333333, 1.25, 0.45833333333333
50167, 0.16666666666667, 1.25, 0.4375
50168, 0.16666666666667, 1.275, 0.45833333333333
50169, 0.14583333333333, 1.3, 0.45833333333333
50170, 0.16666666666667, 1.3, 0.4375
50171, 0.16666666666667, 1.325, 0.45833333333333
50172, 0.16666666666667, 0.2, 0.47916666666667
50173, 0.16666666666667, 0.25, 0.47916666666667
50174, 0.16666666666667, 0.3, 0.47916666666667
50175, 0.16666666666667, 0.35, 0.47916666666667
50176, 0.16666666666667, 0.4, 0.47916666666667
50177, 0.16666666666667, 0.45, 0.47916666666667
50178, 0.16666666666667, 0.5, 0.47916666666667
50179, 0.16666666666667, 0.55, 0.47916666666667
50180, 0.16666666666667, 0.6, 0.47916666666667
50181, 0.16666666666667, 0.65, 0.47916666666667
50182, 0.16666666666667, 0.7, 0.47916666666667
50183, 0.16666666666667, 0.75, 0.47916666666667
50184, 0.16666666666667, 0.8, 0.47916666666667
50185, 0.16666666666667, 0.85, 0.47916666666667
50186, 0.16666666666667, 0.9, 0.47916666666667
50187, 0.16666666666667, 0.95, 0.47916666666667
50188, 0.16666666666667, 1, 0.47916666666667
50189, 0.16666666666667, 1.05, 0.47916666666667
50190, 0.16666666666667, 1.1, 0.47916666666667
50191, 0.16666666666667, 1.15, 0.47916666666667
50192, 0.16666666666667, 1.2, 0.47916666666667
50193, 0.16666666666667, 1.25, 0.47916666666667
50194, 0.16666666666667, 1.3, 0.47916666666667
50195, 0.20833333333333, 0.175, 0.041666666666667
50196, 0.1875, 0.2, 0.041666666666667
50197, 0.20833333333333, 0.2, 0.020833333333333
50198, 0.20833333333333, 0.225, 0.041666666666667
50199, 0.1875, 0.25, 0.041666666666667
50200, 0.20833333333333, 0.25, 0.020833333333333
50201, 0.20833333333333, 0.275, 0.041666666666667
50202, 0.1875, 0.3, 0.041666666666667
50203, 0.20833333333333, 0.3, 0.020833333333333
50204, 0.20833333333333, 0.325, 0.041666666666667
50205, 0.1875, 0.35, 0.041666666666667
50206, 0.20833333333333, 0.35, 0.020833333333333
50207, 0.20833333333333, 0.375, 0.041666666666667
50208, 0.1875, 0.4, 0.041666666666667
50209, 0.20833333333333, 0.4, 0.020833333333333
50210, 0.20833333333333, 0.425, 0.041666666666667
50211, 0.1875, 0.45, 0.041666666666667
50212, 0.20833333333333, 0.45, 0.020833333333333
50213, 0.20833333333333, 0.475, 0.041666666666667
50214, 0.1875, 0.5, 0.041666666666667
50215, 0.20833333333333, 0.5, 0.020833333333333
50216, 0.20833333333333, 0.525, 0.041666666666667
50217, 0.1875, 0.55, 0.041666666666667
50218, 0.20833333333333, 0.55, 0.020833333333333
50219, 0.20833333333333, 0.575, 0.041666666666667
50220, 0.1875, 0.6, 0.041666666666667
50221, 0.20833333333333, 0.6, 0.020833333333333
50222, 0.20833333333333, 0.625, 0.041666666666667
50223, 0.1875, 0.65, 0.041666666666667
50224, 0.20833333333333, 0.65, 0.020833333333333
50225, 0.20833333333333, 0.675, 0.041666666666667
50226, 0.1875, 0.7, 0.041666666666667
50227, 0.20833333333333, 0.7, 0.020833333333333
50228, 0.20833333333333, 0.725, 0.041666666666667
50229, 0.1875, 0.75, 0.041666666666667
50230, 0.20833333333333, 0.75, 0.020833333333333
50231, 0.20833333333333, 0.775, 0.041666666666667
50232, 0.1875, 0.8, 0.041666666666667
50233, 0.20833333333333, 0.8, 0.020833333333333
50234, 0.20833333333333, 0.825, 0.041666666666667
50235, 0.1875, 0.85, 0.041666666666667
50236, 0.20833333333333, 0.85, 0.020833333333333
50237, 0.20833333333333, 0.875, 0.041666666666667
50238, 0.1875, 0.9, 0.041666666666667
50239, 0.20833333333333, 0.9, 0.020833333333333
50240, 0.20833333333333, 0.925, 0.041666666666667
50241, 0.1875, 0.95, 0.041666666666667
50242, 0.20833333333333, 0.95, 0.020833333333333
50243, 0.20833333333333, 0.975, 0.041666666666667
50244, 0.1875, 1, 0.041666666666667
50245, 0.20833333333333, 1, 0.020833333333333
50246, 0.20833333333333, 1.025, 0.041666666666667
50247, 0.1875, 1.05, 0.041666666666667
50248, 0.20833333333333, 1.05, 0.020833333333333
50249, 0.20833333333333, 1.075, 0.041666666666667
50250, 0.1875, 1.1, 0.041666666666667
50251, 0.20833333333333, 1.1, 0.020833333333333
50252, 0.20833333333333, 1.125, 0.041666666666667
50253, 0.1875, 1.15, 0.041666666666667
50254, 0.20833333333333, 1.15, 0.020833333333333
50255, 0.20833333333333, 1.175, 0.041666666666667
50256, 0.1875, 1.2, 0.041666666666667
50257, 0.20833333333333, 1.2, 0.020833333333333
50258, 0.20833333333333, 1.225, 0.041666666666667
50259, 0.1875, 1.25, 0.041666666666667
50260, 0.20833333333333, 1.25, 0.020833333333333
50261, 0.20833333333333, 1.275, 0.041666666666667
50262, 0.1875, 1.3, 0.041666666666667
50263, 0.20833333333333, 1.3, 0.020833333333333
50264, 0.20833333333333, 1.325, 0.041666666666667
50265, 0.20833333333333, 0.175, 0.083333333333333
50266, 0.1875, 0.2, 0.083333333333333
50267, 0.20833333333333, 0.2, 0.0625
50268, 0.20833333333333, 0.225, 0.083333333333333
50269, 0.1875, 0.25, 0.083333333333333
50270, 0.20833333333333, 0.25, 0.0625
50271, 0.20833333333333, 0.275, 0.083333333333333
50272, 0.1875, 0.3, 0.083333333333333
50273, 0.20833333333333, 0.3, 0.0625
50274, 0.20833333333333, 0.325, 0.083333333333333
50275, 0.1875, 0.35, 0.083333333333333
50276, 0.20833333333333, 0.35, 0.0625
50277, 0.20833333333333, 0.375, 0.083333333333333
50278, 0.1875, 0.4, 0.083333333333333
50279, 0.20833333333333, 0.4, 0.0625
50280, 0.20833333333333, 0.425, 0.083333333333333
50281, 0.1875, 0.45, 0.083333333333333
50282, 0.20833333333333, 0.45, 0.0625
50283, 0.20833333333333, 0.475, 0.083333333333333
50284, 0.1875, 0.5, 0.083333333333333
50285, 0.20833333333333, 0.5, 0.0625
50286, 0.20833333333333, 0.525, 0.083333333333333
50287, 0.1875, 0.55, 0.083333333333333
50288, 0.20833333333333, 0.55, 0.0625
50289, 0.20833333333333, 0.575, 0.083333333333333
50290, 0.1875, 0.6, 0.083333333333333
50291, 0.20833333333333, 0.6, 0.0625
50292, 0.20833333333333, 0.625, 0.083333333333333
50293, 0.1875, 0.65, 0.083333333333333
50294, 0.20833333333333, 0.65, 0.0625
50295, 0.20833333333333, 0.675, 0.083333333333333
50296, 0.1875, 0.7, 0.083333333333333
50297, 0.20833333333333, 0.7, 0.0625
50298, 0.20833333333333, 0.725, 0.083333333333333
50299, 0.1875, 0.75, 0.083333333333333
50300, 0.20833333333333, 0.75, 0.0625
50301, 0.20833333333333, 0.775, 0.083333333333333
50302, 0.1875, 0.8, 0.083333333333333
50303, 0.20833333333333, 0.8, 0.0625
50304, 0.20833333333333, 0.825, 0.083333333333333
50305, 0.1875, 0.85, 0.083333333333333
50306, 0.20833333333333, 0.85, 0.0625
50307, 0.20833333333333, 0.875, 0.083333333333333
50308, 0.1875, 0.9, 0.083333333333333
50309, 0.20833333333333, 0.9, 0.0625
50310, 0.20833333333333, 0.925, 0.083333333333333
50311, 0.1875, 0.95, 0.083333333333333
50312, 0.20833333333333, 0.95, 0.0625
50313, 0.20833333333333, 0.975, 0.083333333333333
50314, 0.1875, 1, 0.083333333333333
50315, 0.20833333333333, 1, 0.0625
50316, 0.20833333333333, 1.025, 0.083333333333333
50317, 0.1875, 1.05, 0.083333333333333
50318, 0.20833333333333, 1.05, 0.0625
50319, 0.20833333333333, 1.075, 0.083333333333333
50320, 0.1875, 1.1, 0.083333333333333
50321, 0.20833333333333, 1.1, 0.0625
50322, 0.20833333333333, 1.125, 0.083333333333333
50323, 0.1875, 1.15, 0.083333333333333
50324, 0.20833333333333, 1.15, 0.0625
50325, 0.20833333333333, 1.175, 0.083333333333333
50326, 0.1875, 1.2, 0.083333333333333
50327, 0.20833333333333, 1.2, 0.0625
50328, 0.20833333333333, 1.225, 0.083333333333333
50329, 0.1875, 1.25, 0.083333333333333
50330, 0.20833333333333, 1.25, 0.0625
50331, 0.20833333333333, 1.275, 0.083333333333333
50332, 0.1875, 1.3, 0.083333333333333
50333, 0.20833333333333, 1.3, 0.0625
50334, 0.20833333333333, 1.325, 0.083333333333333
50335, 0.20833333333333, 0.175, 0.125
50336, 0.1875, 0.2, 0.125
50337, 0.20833333333333, 0.2, 0.10416666666667
50338, 0.20833333333333, 0.225, 0.125
50339, 0.1875, 0.25, 0.125
50340, 0.20833333333333, 0.25, 0.10416666666667
50341, 0.20833333333333, 0.275, 0.125
50342, 0.1875, 0.3, 0.125
50343, 0.20833333333333, 0.3, 0.10416666666667
50344, 0.20833333333333, 0.325, 0.125
50345, 0.1875, 0.35, 0.125
50346, 0.20833333333333, 0.35, 0.10416666666667
50347, 0.20833333333333, 0.375, 0.125
50348, 0.1875, 0.4, 0.125
50349, 0.20833333333333, 0.4, 0.10416666666667
50350, 0.20833333333333, 0.425, 0.125
50351, 0.1875, 0.45, 0.125
50352, 0.20833333333333, 0.45, 0.10416666666667
50353, 0.20833333333333, 0.475, 0.125
50354, 0.1875, 0.5, 0.125
50355, 0.20833333333333, 0.5, 0.10416666666667
50356, 0.20833333333333, 0.525, 0.125
50357, 0.1875, 0.55, 0.125
50358, 0.20833333333333, 0.55, 0.10416666666667
50359, 0.20833333333333, 0.575, 0.125
50360, 0.1875, 0.6, 0.125
50361, 0.20833333333333, 0.6, 0.10416666666667
50362, 0.20833333333333, 0.625, 0.125
50363, 0.1875, 0.65, 0.125
50364, 0.20833333333333, 0.65, 0.10416666666667
50365, 0.20833333333333, 0.675, 0.125
50366, 0.1875, 0.7, 0.125
50367, 0.20833333333333, 0.7, 0.10416666666667
50368, 0.20833333333333, 0.725, 0.125
50369, 0.1875, 0.75, 0.125
50370, 0.20833333333333, 0.75, 0.10416666666667
50371, 0.20833333333333, 0.775, 0.125
50372, 0.1875, 0.8, 0.125
50373, 0.20833333333333, 0.8, 0.10416666666667
50374, 0.20833333333333, 0.825, 0.125
50375, 0.1875, 0.85, 0.125
50376, 0.20833333333333, 0.85, 0.10416666666667
50377, 0.20833333333333, 0.875, 0.125
50378, 0.1875, 0.9, 0.125
50379, 0.20833333333333, 0.9, 0.10416666666667
50380, 0.20833333333333, 0.925, 0.125
50381, 0.1875, 0.95, 0.125
50382, 0.20833333333333, 0.95, 0.10416666666667
50383, 0.20833333333333, 0.975, 0.125
50384, 0.1875, 1, 0.125
50385, 0.20833333333333, 1, 0.10416666666667
50386, 0.20833333333333, 1.025, 0.125
50387, 0.1875, 1.05, 0.125
50388, 0.20833333333333, 1.05, 0.10416666666667
50389, 0.20833333333333, 1.075, 0.125
50390, 0.1875, 1.1, 0.125
50391, 0.20833333333333, 1.1, 0.10416666666667
50392, 0.20833333333333, 1.125, 0.125
50393, 0.1875, 1.15, 0.125
50394, 0.20833333333333, 1.15, 0.10416666666667
50395, 0.20833333333333, 1.175, 0.125
50396, 0.1875, 1.2, 0.125
50397, 0.20833333333333, 1.2, 0.10416666666667
50398, 0.20833333333333, 1.225, 0.125
50399, 0.1875, 1.25, 0.125
50400, 0.20833333333333, 1.25, 0.10416666666667
50401, 0.20833333333333, 1.275, 0.125
50402, 0.1875, 1.3, 0.125
50403, 0.20833333333333, 1.3, 0.10416666666667
50404, 0.20833333333333, 1.325, 0.125
50405, 0.20833333333333, 0.175, 0.16666666666667
50406, 0.1875, 0.2, 0.16666666666667
50407, 0.20833333333333, 0.2, 0.14583333333333
50408, 0.20833333333333, 0.225, 0.16666666666667
50409, 0.1875, 0.25, 0.16666666666667
50410, 0.20833333333333, 0.25, 0.14583333333333
50411, 0.20833333333333, 0.275, 0.16666666666667
50412, 0.1875, 0.3, 0.16666666666667
50413, 0.20833333333333, 0.3, 0.14583333333333
50414, 0.20833333333333, 0.325, 0.16666666666667
50415, 0.1875, 0.35, 0.16666666666667
50416, 0.20833333333333, 0.35, 0.14583333333333
50417, 0.20833333333333, 0.375, 0.16666666666667
50418, 0.1875, 0.4, 0.16666666666667
50419, 0.20833333333333, 0.4, 0.14583333333333
50420, 0.20833333333333, 0.425, 0.16666666666667
50421, 0.1875, 0.45, 0.16666666666667
50422, 0.20833333333333, 0.45, 0.14583333333333
50423, 0.20833333333333, 0.475, 0.16666666666667
50424, 0.1875, 0.5, 0.16666666666667
50425, 0.20833333333333, 0.5, 0.14583333333333
50426, 0.20833333333333, 0.525, 0.16666666666667
50427, 0.1875, 0.55, 0.16666666666667
50428, 0.20833333333333, 0.55, 0.14583333333333
50429, 0.20833333333333, 0.575, 0.16666666666667
50430, 0.1875, 0.6, 0.16666666666667
50431, 0.20833333333333, 0.6, 0.14583333333333
50432, 0.20833333333333, 0.625, 0.16666666666667
50433, 0.1875, 0.65, 0.16666666666667
50434, 0.20833333333333, 0.65, 0.14583333333333
50435, 0.20833333333333, 0.675, 0.16666666666667
50436, 0.1875, 0.7, 0.16666666666667
50437, 0.20833333333333, 0.7, 0.14583333333333
50438, 0.20833333333333, 0.725, 0.16666666666667
50439, 0.1875, 0.75, 0.16666666666667
50440, 0.20833333333333, 0.75, 0.14583333333333
50441, 0.20833333333333, 0.775, 0.16666666666667
50442, 0.1875, 0.8, 0.16666666666667
50443, 0.20833333333333, 0.8, 0.14583333333333
50444, 0.20833333333333, 0.825, 0.16666666666667
50445, 0.1875, 0.85, 0.16666666666667
50446, 0.20833333333333, 0.85, 0.14583333333333
50447, 0.20833333333333, 0.875, 0.16666666666667
50448, 0.1875, 0.9, 0.16666666666667
50449, 0.20833333333333, 0.9, 0.14583333333333
50450, 0.20833333333333, 0.925, 0.16666666666667
50451, 0.1875, 0.95, 0.16666666666667
50452, 0.20833333333333, 0.95, 0.14583333333333
50453, 0.20833333333333, 0.975, 0.16666666666667
50454, 0.1875, 1, 0.16666666666667
50455, 0.20833333333333, 1, 0.14583333333333
50456, 0.20833333333333, 1.025, 0.16666666666667
50457, 0.1875, 1.05, 0.16666666666667
50458, 0.20833333333333, 1.05, 0.14583333333333
50459, 0.20833333333333, 1.075, 0.16666666666667
50460, 0.1875, 1.1, 0.16666666666667
50461, 0.20833333333333, 1.1, 0.14583333333333
50462, 0.20833333333333, 1.125, 0.16666666666667
50463, 0.1875, 1.15, 0.16666666666667
50464, 0.20833333333333, 1.15, 0.14583333333333
50465, 0.20833333333333, 1.175, 0.16666666666667
50466, 0.1875, 1.2, 0.16666666666667
50467, 0.20833333333333, 1.2, 0.14583333333333
50468, 0.20833333333333, 1.225, 0.16666666666667
50469, 0.1875, 1.25, 0.16666666666667
50470, 0.20833333333333, 1.25, 0.14583333333333
50471, 0.20833333333333, 1.275, 0.16666666666667
50472, 0.1875, 1.3, 0.16666666666667
50473, 0.20833333333333, 1.3, 0.14583333333333
50474, 0.20833333333333, 1.325, 0.16666666666667
50475, 0.20833333333333, 0.175, 0.20833333333333
50476, 0.1875, 0.2, 0.20833333333333
50477, 0.20833333333333, 0.2, 0.1875
50478, 0.20833333333333, 0.225, 0.20833333333333
50479, 0.1875, 0.25, 0.20833333333333
50480, 0.20833333333333, 0.25, 0.1875
50481, 0.20833333333333, 0.275, 0.20833333333333
50482, 0.1875, 0.3, 0.20833333333333
50483, 0.20833333333333, 0.3, 0.1875
50484, 0.20833333333333, 0.325, 0.20833333333333
50485, 0.1875, 0.35, 0.20833333333333
50486, 0.20833333333333, 0.35, 0.1875
50487, 0.20833333333333, 0.375, 0.20833333333333
50488, 0.1875, 0.4, 0.20833333333333
50489, 0.20833333333333, 0.4, 0.1875
50490, 0.20833333333333, 0.425, 0.20833333333333
50491, 0.1875, 0.45, 0.20833333333333
50492, 0.20833333333333, 0.45, 0.1875
50493, 0.20833333333333, 0.475, 0.20833333333333
50494, 0.1875, 0.5, 0.20833333333333
50495, 0.20833333333333, 0.5, 0.1875
50496, 0.20833333333333, 0.525, 0.20833333333333
50497, 0.1875, 0.55, 0.20833333333333
50498, 0.20833333333333, 0.55, 0.1875
50499, 0.20833333333333, 0.575, 0.20833333333333
50500, 0.1875, 0.6, 0.20833333333333
50501, 0.20833333333333, 0.6, 0.1875
50502, 0.20833333333333, 0.625, 0.20833333333333
50503, 0.1875, 0.65, 0.20833333333333
50504, 0.20833333333333, 0.65, 0.1875
50505, 0.20833333333333, 0.675, 0.20833333333333
50506, 0.1875, 0.7, 0.20833333333333
50507, 0.20833333333333, 0.7, 0.1875
50508, 0.20833333333333, 0.725, 0.20833333333333
50509, 0.1875, 0.75, 0.20833333333333
50510, 0.20833333333333, 0.75, 0.1875
50511, 0.20833333333333, 0.775, 0.20833333333333
50512, 0.1875, 0.8, 0.20833333333333
50513, 0.20833333333333, 0.8, 0.1875
50514, 0.20833333333333, 0.825, 0.20833333333333
50515, 0.1875, 0.85, 0.20833333333333
50516, 0.20833333333333, 0.85, 0.1875
50517, 0.20833333333333, 0.875, 0.20833333333333
50518, 0.1875, 0.9, 0.20833333333333
50519, 0.20833333333333, 0.9, 0.1875
50520, 0.20833333333333, 0.925, 0.20833333333333
50521, 0.1875, 0.95, 0.20833333333333
50522, 0.20833333333333, 0.95, 0.1875
50523, 0.20833333333333, 0.975, 0.20833333333333
50524, 0.1875, 1, 0.20833333333333
50525, 0.20833333333333, 1, 0.1875
50526, 0.20833333333333, 1.025, 0.20833333333333
50527, 0.1875, 1.05, 0.20833333333333
50528, 0.20833333333333, 1.05, 0.1875
50529, 0.20833333333333, 1.075, 0.20833333333333
50530, 0.1875, 1.1, 0.20833333333333
50531, 0.20833333333333, 1.1, 0.1875
50532, 0.20833333333333, 1.125, 0.20833333333333
50533, 0.1875, 1.15, 0.20833333333333
50534, 0.20833333333333, 1.15, 0.1875
50535, 0.20833333333333, 1.175, 0.20833333333333
50536, 0.1875, 1.2, 0.20833333333333
50537, 0.20833333333333, 1.2, 0.1875
50538, 0.20833333333333, 1.225, 0.20833333333333
50539, 0.1875, 1.25, 0.20833333333333
50540, 0.20833333333333, 1.25, 0.1875
50541, 0.20833333333333, 1.275, 0.20833333333333
50542, 0.1875, 1.3, 0.20833333333333
50543, 0.20833333333333, 1.3, 0.1875
50544, 0.20833333333333, 1.325, 0.20833333333333
50545, 0.20833333333333, 0.175, 0.25
50546, 0.1875, 0.2, 0.25
50547, 0.20833333333333, 0.2, 0.22916666666667
50548, 0.20833333333333, 0.225, 0.25
50549, 0.1875, 0.25, 0.25
50550, 0.20833333333333, 0.25, 0.22916666666667
50551, 0.20833333333333, 0.275, 0.25
50552, 0.1875, 0.3, 0.25
50553, 0.20833333333333, 0.3, 0.22916666666667
50554, 0.20833333333333, 0.325, 0.25
50555, 0.1875, 0.35, 0.25
50556, 0.20833333333333, 0.35, 0.22916666666667
50557, 0.20833333333333, 0.375, 0.25
50558, 0.1875, 0.4, 0.25
50559, 0.20833333333333, 0.4, 0.22916666666667
50560, 0.20833333333333, 0.425, 0.25
50561, 0.1875, 0.45, 0.25
50562, 0.20833333333333, 0.45, 0.22916666666667
50563, 0.20833333333333, 0.475, 0.25
50564, 0.1875, 0.5, 0.25
50565, 0.20833333333333, 0.5, 0.22916666666667
50566, 0.20833333333333, 0.525, 0.25
50567, 0.1875, 0.55, 0.25
50568, 0.20833333333333, 0.55, 0.22916666666667
50569, 0.20833333333333, 0.575, 0.25
50570, 0.1875, 0.6, 0.25
50571, 0.20833333333333, 0.6, 0.22916666666667
50572, 0.20833333333333, 0.625, 0.25
50573, 0.1875, 0.65, 0.25
50574, 0.20833333333333, 0.65, 0.22916666666667
50575, 0.20833333333333, 0.675, 0.25
50576, 0.1875, 0.7, 0.25
50577, 0.20833333333333, 0.7, 0.22916666666667
50578, 0.20833333333333, 0.725, 0.25
50579, 0.1875, 0.75, 0.25
50580, 0.20833333333333, 0.75, 0.22916666666667
50581, 0.20833333333333, 0.775, 0.25
50582, 0.1875, 0.8, 0.25
50583, 0.20833333333333, 0.8, 0.22916666666667
50584, 0.20833333333333, 0.825, 0.25
50585, 0.1875, 0.85, 0.25
50586, 0.20833333333333, 0.85, 0.22916666666667
50587, 0.20833333333333, 0.875, 0.25
50588, 0.1875, 0.9, 0.25
50589, 0.20833333333333, 0.9, 0.22916666666667
50590, 0.20833333333333, 0.925, 0.25
50591, 0.1875, 0.95, 0.25
50592, 0.20833333333333, 0.95, 0.22916666666667
50593, 0.20833333333333, 0.975, 0.25
50594, 0.1875, 1, 0.25
50595, 0.20833333333333, 1, 0.22916666666667
50596, 0.20833333333333, 1.025, 0.25
50597, 0.1875, 1.05, 0.25
50598, 0.20833333333333, 1.05, 0.22916666666667
50599, 0.20833333333333, 1.075, 0.25
50600, 0.1875, 1.1, 0.25
50601, 0.20833333333333, 1.1, 0.22916666666667
50602, 0.20833333333333, 1.125, 0.25
50603, 0.1875, 1.15, 0.25
50604, 0.20833333333333, 1.15, 0.22916666666667
50605, 0.20833333333333, 1.175, 0.25
50606, 0.1875, 1.2, 0.25
50607, 0.20833333333333, 1.2, 0.22916666666667
50608, 0.20833333333333, 1.225, 0.25
50609, 0.1875, 1.25, 0.25
50610, 0.20833333333333, 1.25, 0.22916666666667
50611, 0.20833333333333, 1.275, 0.25
50612, 0.1875, 1.3, 0.25
50613, 0.20833333333333, 1.3, 0.22916666666667
50614, 0.20833333333333, 1.325, 0.25
50615, 0.20833333333333, 0.175, 0.29166666666667
50616, 0.1875, 0.2, 0.29166666666667
50617, 0.20833333333333, 0.2, 0.27083333333333
50618, 0.20833333333333, 0.225, 0.29166666666667
50619, 0.1875, 0.25, 0.29166666666667
50620, 0.20833333333333, 0.25, 0.27083333333333
50621, 0.20833333333333, 0.275, 0.29166666666667
50622, 0.1875, 0.3, 0.29166666666667
50623, 0.20833333333333, 0.3, 0.27083333333333
50624, 0.20833333333333, 0.325, 0.29166666666667
50625, 0.1875, 0.35, 0.29166666666667
50626, 0.20833333333333, 0.35, 0.27083333333333
50627, 0.20833333333333, 0.375, 0.29166666666667
50628, 0.1875, 0.4, 0.29166666666667
50629, 0.20833333333333, 0.4, 0.27083333333333
50630, 0.20833333333333, 0.425, 0.29166666666667
50631, 0.1875, 0.45, 0.29166666666667
50632, 0.20833333333333, 0.45, 0.27083333333333
50633, 0.20833333333333, 0.475, 0.29166666666667
50634, 0.1875, 0.5, 0.29166666666667
50635, 0.20833333333333, 0.5, 0.27083333333333
50636, 0.20833333333333, 0.525, 0.29166666666667
50637, 0.1875, 0.55, 0.29166666666667
50638, 0.20833333333333, 0.55, 0.27083333333333
50639, 0.20833333333333, 0.575, 0.29166666666667
50640, 0.1875, 0.6, 0.29166666666667
50641, 0.20833333333333, 0.6, 0.27083333333333
50642, 0.20833333333333, 0.625, 0.29166666666667
50643, 0.1875, 0.65, 0.29166666666667
50644, 0.20833333333333, 0.65, 0.27083333333333
50645, 0.20833333333333, 0.675, 0.29166666666667
50646, 0.1875, 0.7, 0.29166666666667
50647, 0.20833333333333, 0.7, 0.27083333333333
50648, 0.20833333333333, 0.725, 0.29166666666667
50649, 0.1875, 0.75, 0.29166666666667
50650, 0.20833333333333, 0.75, 0.27083333333333
50651, 0.20833333333333, 0.775, 0.29166666666667
50652, 0.1875, 0.8, 0.29166666666667
50653, 0.20833333333333, 0.8, 0.27083333333333
50654, 0.20833333333333, 0.825, 0.29166666666667
50655, 0.1875, 0.85, 0.29166666666667
50656, 0.20833333333333, 0.85, 0.27083333333333
50657, 0.20833333333333, 0.875, 0.29166666666667
50658, 0.1875, 0.9, 0.29166666666667
50659, 0.20833333333333, 0.9, 0.27083333333333
50660, 0.20833333333333, 0.925, 0.29166666666667
50661, 0.1875, 0.95, 0.29166666666667
50662, 0.20833333333333, 0.95, 0.27083333333333
50663, 0.20833333333333, 0.975, 0.29166666666667
50664, 0.1875, 1, 0.29166666666667
50665, 0.20833333333333, 1, 0.27083333333333
50666, 0.20833333333333, 1.025, 0.29166666666667
50667, 0.1875, 1.05, 0.29166666666667
50668, 0.20833333333333, 1.05, 0.27083333333333
50669, 0.20833333333333, 1.075, 0.29166666666667
50670, 0.1875, 1.1, 0.29166666666667
50671, 0.20833333333333, 1.1, 0.27083333333333
50672, 0.20833333333333, 1.125, 0.29166666666667
50673, 0.1875, 1.15, 0.29166666666667
50674, 0.20833333333333, 1.15, 0.27083333333333
50675, 0.20833333333333, 1.175, 0.29166666666667
50676, 0.1875, 1.2, 0.29166666666667
50677, 0.20833333333333, 1.2, 0.27083333333333
50678, 0.20833333333333, 1.225, 0.29166666666667
50679, 0.1875, 1.25, 0.29166666666667
50680, 0.20833333333333, 1.25, 0.27083333333333
50681, 0.20833333333333, 1.275, 0.29166666666667
50682, 0.1875, 1.3, 0.29166666666667
50683, 0.20833333333333, 1.3, 0.27083333333333
50684, 0.20833333333333, 1.325, 0.29166666666667
50685, 0.20833333333333, 0.175, 0.33333333333333
50686, 0.1875, 0.2, 0.33333333333333
50687, 0.20833333333333, 0.2, 0.3125
50688, 0.20833333333333, 0.225, 0.33333333333333
50689, 0.1875, 0.25, 0.33333333333333
50690, 0.20833333333333, 0.25, 0.3125
50691, 0.20833333333333, 0.275, 0.33333333333333
50692, 0.1875, 0.3, 0.33333333333333
50693, 0.20833333333333, 0.3, 0.3125
50694, 0.20833333333333, 0.325, 0.33333333333333
50695, 0.1875, 0.35, 0.33333333333333
50696, 0.20833333333333, 0.35, 0.3125
50697, 0.20833333333333, 0.375, 0.33333333333333
50698, 0.1875, 0.4, 0.33333333333333
50699, 0.20833333333333, 0.4, 0.3125
50700, 0.20833333333333, 0.425, 0.33333333333333
50701, 0.1875, 0.45, 0.33333333333333
50702, 0.20833333333333, 0.45, 0.3125
50703, 0.20833333333333, 0.475, 0.33333333333333
50704, 0.1875, 0.5, 0.33333333333333
50705, 0.20833333333333, 0.5, 0.3125
50706, 0.20833333333333, 0.525, 0.33333333333333
50707, 0.1875, 0.55, 0.33333333333333
50708, 0.20833333333333, 0.55, 0.3125
50709, 0.20833333333333, 0.575, 0.33333333333333
50710, 0.1875, 0.6, 0.33333333333333
50711, 0.20833333333333, 0.6, 0.3125
50712, 0.20833333333333, 0.625, 0.33333333333333
50713, 0.1875, 0.65, 0.33333333333333
50714, 0.20833333333333, 0.65, 0.3125
50715, 0.20833333333333, 0.675, 0.33333333333333
50716, 0.1875, 0.7, 0.33333333333333
50717, 0.20833333333333, 0.7, 0.3125
50718, 0.20833333333333, 0.725, 0.33333333333333
50719, 0.1875, 0.75, 0.33333333333333
50720, 0.20833333333333, 0.75, 0.3125
50721, 0.20833333333333, 0.775, 0.33333333333333
50722, 0.1875, 0.8, 0.33333333333333
50723, 0.20833333333333, 0.8, 0.3125
50724, 0.20833333333333, 0.825, 0.33333333333333
50725, 0.1875, 0.85, 0.33333333333333
50726, 0.20833333333333, 0.85, 0.3125
50727, 0.20833333333333, 0.875, 0.33333333333333
50728, 0.1875, 0.9, 0.33333333333333
50729, 0.20833333333333, 0.9, 0.3125
50730, 0.20833333333333, 0.925, 0.33333333333333
50731, 0.1875, 0.95, 0.33333333333333
50732, 0.20833333333333, 0.95, 0.3125
50733, 0.20833333333333, 0.975, 0.33333333333333
50734, 0.1875, 1, 0.33333333333333
50735, 0.20833333333333, 1, 0.3125
50736, 0.20833333333333, 1.025, 0.33333333333333
50737, 0.1875, 1.05, 0.33333333333333
50738, 0.20833333333333, 1.05, 0.3125
50739, 0.20833333333333, 1.075, 0.33333333333333
50740, 0.1875, 1.1, 0.33333333333333
50741, 0.20833333333333, 1.1, 0.3125
50742, 0.20833333333333, 1.125, 0.33333333333333
50743, 0.1875, 1.15, 0.33333333333333
50744, 0.20833333333333, 1.15, 0.3125
50745, 0.20833333333333, 1.175, 0.33333333333333
50746, 0.1875, 1.2, 0.33333333333333
50747, 0.20833333333333, 1.2, 0.3125
50748, 0.20833333333333, 1.225, 0.33333333333333
50749, 0.1875, 1.25, 0.33333333333333
50750, 0.20833333333333, 1.25, 0.3125
50751, 0.20833333333333, 1.275, 0.33333333333333
50752, 0.1875, 1.3, 0.33333333333333
50753, 0.20833333333333, 1.3, 0.3125
50754, 0.20833333333333, 1.325, 0.33333333333333
50755, 0.20833333333333, 0.175, 0.375
50756, 0.1875, 0.2, 0.375
50757, 0.20833333333333, 0.2, 0.35416666666667
50758, 0.20833333333333, 0.225, 0.375
50759, 0.1875, 0.25, 0.375
50760, 0.20833333333333, 0.25, 0.35416666666667
50761, 0.20833333333333, 0.275, 0.375
50762, 0.1875, 0.3, 0.375
50763, 0.20833333333333, 0.3, 0.35416666666667
50764, 0.20833333333333, 0.325, 0.375
50765, 0.1875, 0.35, 0.375
50766, 0.20833333333333, 0.35, 0.35416666666667
50767, 0.20833333333333, 0.375, 0.375
50768, 0.1875, 0.4, 0.375
50769, 0.20833333333333, 0.4, 0.35416666666667
50770, 0.20833333333333, 0.425, 0.375
50771, 0.1875, 0.45, 0.375
50772, 0.20833333333333, 0.45, 0.35416666666667
50773, 0.20833333333333, 0.475, 0.375
50774, 0.1875, 0.5, 0.375
50775, 0.20833333333333, 0.5, 0.35416666666667
50776, 0.20833333333333, 0.525, 0.375
50777, 0.1875, 0.55, 0.375
50778, 0.20833333333333, 0.55, 0.35416666666667
50779, 0.20833333333333, 0.575, 0.375
50780, 0.1875, 0.6, 0.375
50781, 0.20833333333333, 0.6, 0.35416666666667
50782, 0.20833333333333, 0.625, 0.375
50783, 0.1875, 0.65, 0.375
50784, 0.20833333333333, 0.65, 0.35416666666667
50785, 0.20833333333333, 0.675, 0.375
50786, 0.1875, 0.7, 0.375
50787, 0.20833333333333, 0.7, 0.35416666666667
50788, 0.20833333333333, 0.725, 0.375
50789, 0.1875, 0.75, 0.375
50790, 0.20833333333333, 0.75, 0.35416666666667
50791, 0.20833333333333, 0.775, 0.375
50792, 0.1875, 0.8, 0.375
50793, 0.20833333333333, 0.8, 0.35416666666667
50794, 0.20833333333333, 0.825, 0.375
50795, 0.1875, 0.85, 0.375
50796, 0.20833333333333, 0.85, 0.35416666666667
50797, 0.20833333333333, 0.875, 0.375
50798, 0.1875, 0.9, 0.375
50799, 0.20833333333333, 0.9, 0.35416666666667
50800, 0.20833333333333, 0.925, 0.375
50801, 0.1875, 0.95, 0.375
50802, 0.20833333333333, 0.95, 0.35416666666667
50803, 0.20833333333333, 0.975, 0.375
50804, 0.1875, 1, 0.375
50805, 0.20833333333333, 1, 0.35416666666667
50806, 0.20833333333333, 1.025, 0.375
50807, 0.1875, 1.05, 0.375
50808, 0.20833333333333, 1.05, 0.35416666666667
50809, 0.20833333333333, 1.075, 0.375
50810, 0.1875, 1.1, 0.375
50811, 0.20833333333333, 1.1, 0.35416666666667
50812, 0.20833333333333, 1.125, 0.375
50813, 0.1875, 1.15, 0.375
50814, 0.20833333333333, 1.15, 0.35416666666667
50815, 0.20833333333333, 1.175, 0.375
50816, 0.1875, 1.2, 0.375
50817, 0.20833333333333, 1.2, 0.35416666666667
50818, 0.20833333333333, 1.225, 0.375
50819, 0.1875, 1.25, 0.375
50820, 0.20833333333333, 1.25, 0.35416666666667
50821, 0.20833333333333, 1.275, 0.375
50822, 0.1875, 1.3, 0.375
50823, 0.20833333333333, 1.3, 0.35416666666667
50824, 0.20833333333333, 1.325, 0.375
50825, 0.20833333333333, 0.175, 0.41666666666667
50826, 0.1875, 0.2, 0.41666666666667
50827, 0.20833333333333, 0.2, 0.39583333333333
50828, 0.20833333333333, 0.225, 0.41666666666667
50829, 0.1875, 0.25, 0.41666666666667
50830, 0.20833333333333, 0.25, 0.39583333333333
50831, 0.20833333333333, 0.275, 0.41666666666667
50832, 0.1875, 0.3, 0.41666666666667
50833, 0.20833333333333, 0.3, 0.39583333333333
50834, 0.20833333333333, 0.325, 0.41666666666667
50835, 0.1875, 0.35, 0.41666666666667
50836, 0.20833333333333, 0.35, 0.39583333333333
50837, 0.20833333333333, 0.375, 0.41666666666667
50838, 0.1875, 0.4, 0.41666666666667
50839, 0.20833333333333, 0.4, 0.39583333333333
50840, 0.20833333333333, 0.425, 0.41666666666667
50841, 0.1875, 0.45, 0.41666666666667
50842, 0.20833333333333, 0.45, 0.39583333333333
50843, 0.20833333333333, 0.475, 0.41666666666667
50844, 0.1875, 0.5, 0.41666666666667
50845, 0.20833333333333, 0.5, 0.39583333333333
50846, 0.20833333333333, 0.525, 0.41666666666667
50847, 0.1875, 0.55, 0.41666666666667
50848, 0.20833333333333, 0.55, 0.39583333333333
50849, 0.20833333333333, 0.575, 0.41666666666667
50850, 0.1875, 0.6, 0.41666666666667
50851, 0.20833333333333, 0.6, 0.39583333333333
50852, 0.20833333333333, 0.625, 0.41666666666667
50853, 0.1875, 0.65, 0.41666666666667
50854, 0.20833333333333, 0.65, 0.39583333333333
50855, 0.20833333333333, 0.675, 0.41666666666667
50856, 0.1875, 0.7, 0.41666666666667
50857, 0.20833333333333, 0.7, 0.39583333333333
50858, 0.20833333333333, 0.725, 0.41666666666667
50859, 0.1875, 0.75, 0.41666666666667
50860, 0.20833333333333, 0.75, 0.39583333333333
50861, 0.20833333333333, 0.775, 0.41666666666667
50862, 0.1875, 0.8, 0.41666666666667
50863, 0.20833333333333, 0.8, 0.39583333333333
50864, 0.20833333333333, 0.825, 0.41666666666667
50865, 0.1875, 0.85, 0.41666666666667
50866, 0.20833333333333, 0.85, 0.39583333333333
50867, 0.20833333333333, 0.875, 0.41666666666667
50868, 0.1875, 0.9, 0.41666666666667
50869, 0.20833333333333, 0.9, 0.39583333333333
50870, 0.20833333333333, 0.925, 0.41666666666667
50871, 0.1875, 0.95, 0.41666666666667
50872, 0.20833333333333, 0.95, 0.39583333333333
50873, 0.20833333333333, 0.975, 0.41666666666667
50874, 0.1875, 1, 0.41666666666667
50875, 0.20833333333333, 1, 0.39583333333333
50876, 0.20833333333333, 1.025, 0.41666666666667
50877, 0.1875, 1.05, 0.41666666666667
50878, 0.20833333333333, 1.05, 0.39583333333333
50879, 0.20833333333333, 1.075, 0.41666666666667
50880, 0.1875, 1.1, 0.41666666666667
50881, 0.20833333333333, 1.1, 0.39583333333333
50882, 0.20833333333333, 1.125, 0.41666666666667
50883, 0.1875, 1.15, 0.41666666666667
50884, 0.20833333333333, 1.15, 0.39583333333333
50885, 0.20833333333333, 1.175, 0.41666666666667
50886, 0.1875, 1.2, 0.41666666666667
50887, 0.20833333333333, 1.2, 0.39583333333333
50888, 0.20833333333333, 1.225, 0.41666666666667
50889, 0.1875, 1.25, 0.41666666666667
50890, 0.20833333333333, 1.25, 0.39583333333333
50891, 0.20833333333333, 1.275, 0.41666666666667
50892, 0.1875, 1.3, 0.41666666666667
50893, 0.20833333333333, 1.3, 0.39583333333333
50894, 0.20833333333333, 1.325, 0.41666666666667
50895, 0.20833333333333, 0.175, 0.45833333333333
50896, 0.1875, 0.2, 0.45833333333333
50897, 0.20833333333333, 0.2, 0.4375
50898, 0.20833333333333, 0.225, 0.45833333333333
50899, 0.1875, 0.25, 0.45833333333333
50900, 0.20833333333333, 0.25, 0.4375
50901, 0.20833333333333, 0.275, 0.45833333333333
50902, 0.1875, 0.3, 0.45833333333333
50903, 0.20833333333333, 0.3, 0.4375
50904, 0.20833333333333, 0.325, 0.45833333333333
50905, 0.1875, 0.35, 0.45833333333333
50906, 0.20833333333333, 0.35, 0.4375
50907, 0.20833333333333, 0.375, 0.45833333333333
50908, 0.1875, 0.4, 0.45833333333333
50909, 0.20833333333333, 0.4, 0.4375
50910, 0.20833333333333, 0.425, 0.45833333333333
50911, 0.1875, 0.45, 0.45833333333333
50912, 0.20833333333333, 0.45, 0.4375
50913, 0.20833333333333, 0.475, 0.45833333333333
50914, 0.1875, 0.5, 0.45833333333333
50915, 0.20833333333333, 0.5, 0.4375
50916, 0.20833333333333, 0.525, 0.45833333333333
50917, 0.1875, 0.55, 0.45833333333333
50918, 0.20833333333333, 0.55, 0.4375
50919, 0.20833333333333, 0.575, 0.45833333333333
50920, 0.1875, 0.6, 0.45833333333333
50921, 0.20833333333333, 0.6, 0.4375
50922, 0.20833333333333, 0.625, 0.45833333333333
50923, 0.1875, 0.65, 0.45833333333333
50924, 0.20833333333333, 0.65, 0.4375
50925, 0.20833333333333, 0.675, 0.45833333333333
50926, 0.1875, 0.7, 0.45833333333333
50927, 0.20833333333333, 0.7, 0.4375
50928, 0.20833333333333, 0.725, 0.45833333333333
50929, 0.1875, 0.75, 0.45833333333333
50930, 0.20833333333333, 0.75, 0.4375
50931, 0.20833333333333, 0.775, 0.45833333333333
50932, 0.1875, 0.8, 0.45833333333333
50933, 0.20833333333333, 0.8, 0.4375
50934, 0.20833333333333, 0.825, 0.45833333333333
50935, 0.1875, 0.85, 0.45833333333333
50936, 0.20833333333333, 0.85, 0.4375
50937, 0.20833333333333, 0.875, 0.45833333333333
50938, 0.1875, 0.9, 0.45833333333333
50939, 0.20833333333333, 0.9, 0.4375
50940, 0.20833333333333, 0.925, 0.45833333333333
50941, 0.1875, 0.95, 0.45833333333333
50942, 0.20833333333333, 0.95, 0.4375
50943, 0.20833333333333, 0.975, 0.45833333333333
50944, 0.1875, 1, 0.45833333333333
50945, 0.20833333333333, 1, 0.4375
50946, 0.20833333333333, 1.025, 0.45833333333333
50947, 0.1875, 1.05, 0.45833333333333
50948, 0.20833333333333, 1.05, 0.4375
50949, 0.20833333333333, 1.075, 0.45833333333333
50950, 0.1875, 1.1, 0.45833333333333
50951, 0.20833333333333, 1.1, 0.4375
50952, 0.20833333333333, 1.125, 0.45833333333333
50953, 0.1875, 1.15, 0.45833333333333
50954, 0.20833333333333, 1.15, 0.4375
50955, 0.20833333333333, 1.175, 0.45833333333333
50956, 0.1875, 1.2, 0.45833333333333
50957, 0.20833333333333, 1.2, 0.4375
50958, 0.20833333333333, 1.225, 0.45833333333333
50959, 0.1875, 1.25, 0.45833333333333
50960, 0.20833333333333, 1.25, 0.4375
50961, 0.20833333333333, 1.275, 0.45833333333333
50962, 0.1875, 1.3, 0.45833333333333
50963, 0.20833333333333, 1.3, 0.4375
50964, 0.20833333333333, 1.325, 0.45833333333333
50965, 0.20833333333333, 0.2, 0.47916666666667
50966, 0.20833333333333, 0.25, 0.47916666666667
50967, 0.20833333333333, 0.3, 0.47916666666667
50968, 0.20833333333333, 0.35, 0.47916666666667
50969, 0.20833333333333, 0.4, 0.47916666666667
50970, 0.20833333333333, 0.45, 0.47916666666667
50971, 0.20833333333333, 0.5, 0.47916666666667
50972, 0.20833333333333, 0.55, 0.47916666666667
50973, 0.20833333333333, 0.6, 0.47916666666667
50974, 0.20833333333333, 0.65, 0.47916666666667
50975, 0.20833333333333, 0.7, 0.47916666666667
50976, 0.20833333333333, 0.75, 0.47916666666667
50977, 0.20833333333333, 0.8, 0.47916666666667
50978, 0.20833333333333, 0.85, 0.47916666666667
50979, 0.20833333333333, 0.9, 0.47916666666667
50980, 0.20833333333333, 0.95, 0.47916666666667
50981, 0.20833333333333, 1, 0.47916666666667
50982, 0.20833333333333, 1.05, 0.47916666666667
50983, 0.20833333333333, 1.1, 0.47916666666667
50984, 0.20833333333333, 1.15, 0.47916666666667
50985, 0.20833333333333, 1.2, 0.47916666666667
50986, 0.20833333333333, 1.25, 0.47916666666667
50987, 0.20833333333333, 1.3, 0.47916666666667
50988, 0.25, 0.175, 0.041666666666667
50989, 0.22916666666667, 0.2, 0.041666666666667
50990, 0.25, 0.2, 0.020833333333333
50991, 0.25, 0.225, 0.041666666666667
50992, 0.22916666666667, 0.25, 0.041666666666667
50993, 0.25, 0.25, 0.020833333333333
50994, 0.25, 0.275, 0.041666666666667
50995, 0.22916666666667, 0.3, 0.041666666666667
50996, 0.25, 0.3, 0.020833333333333
50997, 0.25, 0.325, 0.041666666666667
50998, 0.22916666666667, 0.35, 0.041666666666667
50999, 0.25, 0.35, 0.020833333333333
51000, 0.25, 0.375, 0.041666666666667
51001, 0.22916666666667, 0.4, 0.041666666666667
51002, 0.25, 0.4, 0.020833333333333
51003, 0.25, 0.425, 0.041666666666667
51004, 0.22916666666667, 0.45, 0.041666666666667
51005, 0.25, 0.45, 0.020833333333333
51006, 0.25, 0.475, 0.041666666666667
51007, 0.22916666666667, 0.5, 0.041666666666667
51008, 0.25, 0.5, 0.020833333333333
51009, 0.25, 0.525, 0.041666666666667
51010, 0.22916666666667, 0.55, 0.041666666666667
51011, 0.25, 0.55, 0.020833333333333
51012, 0.25, 0.575, 0.041666666666667
51013, 0.22916666666667, 0.6, 0.041666666666667
51014, 0.25, 0.6, 0.020833333333333
51015, 0.25, 0.625, 0.041666666666667
51016, 0.22916666666667, 0.65, 0.041666666666667
51017, 0.25, 0.65, 0.020833333333333
51018, 0.25, 0.675, 0.041666666666667
51019, 0.22916666666667, 0.7, 0.041666666666667
51020, 0.25, 0.7, 0.020833333333333
51021, 0.25, 0.725, 0.041666666666667
51022, 0.22916666666667, 0.75, 0.041666666666667
51023, 0.25, 0.75, 0.020833333333333
51024, 0.25, 0.775, 0.041666666666667
51025, 0.22916666666667, 0.8, 0.041666666666667
51026, 0.25, 0.8, 0.020833333333333
51027, 0.25, 0.825, 0.041666666666667
51028, 0.22916666666667, 0.85, 0.041666666666667
51029, 0.25, 0.85, 0.020833333333333
51030, 0.25, 0.875, 0.041666666666667
51031, 0.22916666666667, 0.9, 0.041666666666667
51032, 0.25, 0.9, 0.020833333333333
51033, 0.25, 0.925, 0.041666666666667
51034, 0.22916666666667, 0.95, 0.041666666666667
51035, 0.25, 0.95, 0.020833333333333
51036, 0.25, 0.975, 0.041666666666667
51037, 0.22916666666667, 1, 0.041666666666667
51038, 0.25, 1, 0.020833333333333
51039, 0.25, 1.025, 0.041666666666667
51040, 0.22916666666667, 1.05, 0.041666666666667
51041, 0.25, 1.05, 0.020833333333333
51042, 0.25, 1.075, 0.041666666666667
51043, 0.22916666666667, 1.1, 0.041666666666667
51044, 0.25, 1.1, 0.020833333333333
51045, 0.25, 1.125, 0.041666666666667
51046, 0.22916666666667, 1.15, 0.041666666666667
51047, 0.25, 1.15, 0.020833333333333
51048, 0.25, 1.175, 0.041666666666667
51049, 0.22916666666667, 1.2, 0.041666666666667
51050, 0.25, 1.2, 0.020833333333333
51051, 0.25, 1.225, 0.041666666666667
51052, 0.22916666666667, 1.25, 0.041666666666667
51053, 0.25, 1.25, 0.020833333333333
51054, 0.25, 1.275, 0.041666666666667
51055, 0.22916666666667, 1.3, 0.041666666666667
51056, 0.25, 1.3, 0.020833333333333
51057, 0.25, 1.325, 0.041666666666667
51058, 0.25, 0.175, 0.083333333333333
51059, 0.22916666666667, 0.2, 0.083333333333333
51060, 0.25, 0.2, 0.0625
51061, 0.25, 0.225, 0.083333333333333
51062, 0.22916666666667, 0.25, 0.083333333333333
51063, 0.25, 0.25, 0.0625
51064, 0.25, 0.275, 0.083333333333333
51065, 0.22916666666667, 0.3, 0.083333333333333
51066, 0.25, 0.3, 0.0625
51067, 0.25, 0.325, 0.083333333333333
51068, 0.22916666666667, 0.35, 0.083333333333333
51069, 0.25, 0.35, 0.0625
51070, 0.25, 0.375, 0.083333333333333
51071, 0.22916666666667, 0.4, 0.083333333333333
51072, 0.25, 0.4, 0.0625
51073, 0.25, 0.425, 0.083333333333333
51074, 0.22916666666667, 0.45, 0.083333333333333
51075, 0.25, 0.45, 0.0625
51076, 0.25, 0.475, 0.083333333333333
51077, 0.22916666666667, 0.5, 0.083333333333333
51078, 0.25, 0.5, 0.0625
51079, 0.25, 0.525, 0.083333333333333
51080, 0.22916666666667, 0.55, 0.083333333333333
51081, 0.25, 0.55, 0.0625
51082, 0.25, 0.575, 0.083333333333333
51083, 0.22916666666667, 0.6, 0.083333333333333
51084, 0.25, 0.6, 0.0625
51085, 0.25, 0.625, 0.083333333333333
51086, 0.22916666666667, 0.65, 0.083333333333333
51087, 0.25, 0.65, 0.0625
51088, 0.25, 0.675, 0.083333333333333
51089, 0.22916666666667, 0.7, 0.083333333333333
51090, 0.25, 0.7, 0.0625
51091, 0.25, 0.725, 0.083333333333333
51092, 0.22916666666667, 0.75, 0.083333333333333
51093, 0.25, 0.75, 0.0625
51094, 0.25, 0.775, 0.083333333333333
51095, 0.22916666666667, 0.8, 0.083333333333333
51096, 0.25, 0.8, 0.0625
51097, 0.25, 0.825, 0.083333333333333
51098, 0.22916666666667, 0.85, 0.083333333333333
51099, 0.25, 0.85, 0.0625
51100, 0.25, 0.875, 0.083333333333333
51101, 0.22916666666667, 0.9, 0.083333333333333
51102, 0.25, 0.9, 0.0625
51103, 0.25, 0.925, 0.083333333333333
51104, 0.22916666666667, 0.95, 0.083333333333333
51105, 0.25, 0.95, 0.0625
51106, 0.25, 0.975, 0.083333333333333
51107, 0.22916666666667, 1, 0.083333333333333
51108, 0.25, 1, 0.0625
51109, 0.25, 1.025, 0.083333333333333
51110, 0.22916666666667, 1.05, 0.083333333333333
51111, 0.25, 1.05, 0.0625
51112, 0.25, 1.075, 0.083333333333333
51113, 0.22916666666667, 1.1, 0.083333333333333
51114, 0.25, 1.1, 0.0625
51115, 0.25, 1.125, 0.083333333333333
51116, 0.22916666666667, 1.15, 0.083333333333333
51117, 0.25, 1.15, 0.0625
51118, 0.25, 1.175, 0.083333333333333
51119, 0.22916666666667, 1.2, 0.083333333333333
51120, 0.25, 1.2, 0.0625
51121, 0.25, 1.225, 0.083333333333333
51122, 0.22916666666667, 1.25, 0.083333333333333
51123, 0.25, 1.25, 0.0625
51124, 0.25, 1.275, 0.083333333333333
51125, 0.22916666666667, 1.3, 0.083333333333333
51126, 0.25, 1.3, 0.0625
51127, 0.25, 1.325, 0.083333333333333
51128, 0.25, 0.175, 0.125
51129, 0.22916666666667, 0.2, 0.125
51130, 0.25, 0.2, 0.10416666666667
51131, 0.25, 0.225, 0.125
51132, 0.22916666666667, 0.25, 0.125
51133, 0.25, 0.25, 0.10416666666667
51134, 0.25, 0.275, 0.125
51135, 0.22916666666667, 0.3, 0.125
51136, 0.25, 0.3, 0.10416666666667
51137, 0.25, 0.325, 0.125
51138, 0.22916666666667, 0.35, 0.125
51139, 0.25, 0.35, 0.10416666666667
51140, 0.25, 0.375, 0.125
51141, 0.22916666666667, 0.4, 0.125
51142, 0.25, 0.4, 0.10416666666667
51143, 0.25, 0.425, 0.125
51144, 0.22916666666667, 0.45, 0.125
51145, 0.25, 0.45, 0.10416666666667
51146, 0.25, 0.475, 0.125
51147, 0.22916666666667, 0.5, 0.125
51148, 0.25, 0.5, 0.10416666666667
51149, 0.25, 0.525, 0.125
51150, 0.22916666666667, 0.55, 0.125
51151, 0.25, 0.55, 0.10416666666667
51152, 0.25, 0.575, 0.125
51153, 0.22916666666667, 0.6, 0.125
51154, 0.25, 0.6, 0.10416666666667
51155, 0.25, 0.625, 0.125
51156, 0.22916666666667, 0.65, 0.125
51157, 0.25, 0.65, 0.10416666666667
51158, 0.25, 0.675, 0.125
51159, 0.22916666666667, 0.7, 0.125
51160, 0.25, 0.7, 0.10416666666667
51161, 0.25, 0.725, 0.125
51162, 0.22916666666667, 0.75, 0.125
51163, 0.25, 0.75, 0.10416666666667
51164, 0.25, 0.775, 0.125
51165, 0.22916666666667, 0.8, 0.125
51166, 0.25, 0.8, 0.10416666666667
51167, 0.25, 0.825, 0.125
51168, 0.22916666666667, 0.85, 0.125
51169, 0.25, 0.85, 0.10416666666667
51170, 0.25, 0.875, 0.125
51171, 0.22916666666667, 0.9, 0.125
51172, 0.25, 0.9, 0.10416666666667
51173, 0.25, 0.925, 0.125
51174, 0.22916666666667, 0.95, 0.125
51175, 0.25, 0.95, 0.10416666666667
51176, 0.25, 0.975, 0.125
51177, 0.22916666666667, 1, 0.125
51178, 0.25, 1, 0.10416666666667
51179, 0.25, 1.025, 0.125
51180, 0.22916666666667, 1.05, 0.125
51181, 0.25, 1.05, 0.10416666666667
51182, 0.25, 1.075, 0.125
51183, 0.22916666666667, 1.1, 0.125
51184, 0.25, 1.1, 0.10416666666667
51185, 0.25, 1.125, 0.125
51186, 0.22916666666667, 1.15, 0.125
51187, 0.25, 1.15, 0.10416666666667
51188, 0.25, 1.175, 0.125
51189, 0.22916666666667, 1.2, 0.125
51190, 0.25, 1.2, 0.10416666666667
51191, 0.25, 1.225, 0.125
51192, 0.22916666666667, 1.25, 0.125
51193, 0.25, 1.25, 0.10416666666667
51194, 0.25, 1.275, 0.125
51195, 0.22916666666667, 1.3, 0.125
51196, 0.25, 1.3, 0.10416666666667
51197, 0.25, 1.325, 0.125
51198, 0.25, 0.175, 0.16666666666667
51199, 0.22916666666667, 0.2, 0.16666666666667
51200, 0.25, 0.2, 0.14583333333333
51201, 0.25, 0.225, 0.16666666666667
51202, 0.22916666666667, 0.25, 0.16666666666667
51203, 0.25, 0.25, 0.14583333333333
51204, 0.25, 0.275, 0.16666666666667
51205, 0.22916666666667, 0.3, 0.16666666666667
51206, 0.25, 0.3, 0.14583333333333
51207, 0.25, 0.325, 0.16666666666667
51208, 0.22916666666667, 0.35, 0.16666666666667
51209, 0.25, 0.35, 0.14583333333333
51210, 0.25, 0.375, 0.16666666666667
51211, 0.22916666666667, 0.4, 0.16666666666667
51212, 0.25, 0.4, 0.14583333333333
51213, 0.25, 0.425, 0.16666666666667
51214, 0.22916666666667, 0.45, 0.16666666666667
51215, 0.25, 0.45, 0.14583333333333
51216, 0.25, 0.475, 0.16666666666667
51217, 0.22916666666667, 0.5, 0.16666666666667
51218, 0.25, 0.5, 0.14583333333333
51219, 0.25, 0.525, 0.16666666666667
51220, 0.22916666666667, 0.55, 0.16666666666667
51221, 0.25, 0.55, 0.14583333333333
51222, 0.25, 0.575, 0.16666666666667
51223, 0.22916666666667, 0.6, 0.16666666666667
51224, 0.25, 0.6, 0.14583333333333
51225, 0.25, 0.625, 0.16666666666667
51226, 0.22916666666667, 0.65, 0.16666666666667
51227, 0.25, 0.65, 0.14583333333333
51228, 0.25, 0.675, 0.16666666666667
51229, 0.22916666666667, 0.7, 0.16666666666667
51230, 0.25, 0.7, 0.14583333333333
51231, 0.25, 0.725, 0.16666666666667
51232, 0.22916666666667, 0.75, 0.16666666666667
51233, 0.25, 0.75, 0.14583333333333
51234, 0.25, 0.775, 0.16666666666667
51235, 0.22916666666667, 0.8, 0.16666666666667
51236, 0.25, 0.8, 0.14583333333333
51237, 0.25, 0.825, 0.16666666666667
51238, 0.22916666666667, 0.85, 0.16666666666667
51239, 0.25, 0.85, 0.14583333333333
51240, 0.25, 0.875, 0.16666666666667
51241, 0.22916666666667, 0.9, 0.16666666666667
51242, 0.25, 0.9, 0.14583333333333
51243, 0.25, 0.925, 0.16666666666667
51244, 0.22916666666667, 0.95, 0.16666666666667
51245, 0.25, 0.95, 0.14583333333333
51246, 0.25, 0.975, 0.16666666666667
51247, 0.22916666666667, 1, 0.16666666666667
51248, 0.25, 1, 0.14583333333333
51249, 0.25, 1.025, 0.16666666666667
51250, 0.22916666666667, 1.05, 0.16666666666667
51251, 0.25, 1.05, 0.14583333333333
51252, 0.25, 1.075, 0.16666666666667
51253, 0.22916666666667, 1.1, 0.16666666666667
51254, 0.25, 1.1, 0.14583333333333
51255, 0.25, 1.125, 0.16666666666667
51256, 0.22916666666667, 1.15, 0.16666666666667
51257, 0.25, 1.15, 0.14583333333333
51258, 0.25, 1.175, 0.16666666666667
51259, 0.22916666666667, 1.2, 0.16666666666667
51260, 0.25, 1.2, 0.14583333333333
51261, 0.25, 1.225, 0.16666666666667
51262, 0.22916666666667, 1.25, 0.16666666666667
51263, 0.25, 1.25, 0.14583333333333
51264, 0.25, 1.275, 0.16666666666667
51265, 0.22916666666667, 1.3, 0.16666666666667
51266, 0.25, 1.3, 0.14583333333333
51267, 0.25, 1.325, 0.16666666666667
51268, 0.25, 0.175, 0.20833333333333
51269, 0.22916666666667, 0.2, 0.20833333333333
51270, 0.25, 0.2, 0.1875
51271, 0.25, 0.225, 0.20833333333333
51272, 0.22916666666667, 0.25, 0.20833333333333
51273, 0.25, 0.25, 0.1875
51274, 0.25, 0.275, 0.20833333333333
51275, 0.22916666666667, 0.3, 0.20833333333333
51276, 0.25, 0.3, 0.1875
51277, 0.25, 0.325, 0.20833333333333
51278, 0.22916666666667, 0.35, 0.20833333333333
51279, 0.25, 0.35, 0.1875
51280, 0.25, 0.375, 0.20833333333333
51281, 0.22916666666667, 0.4, 0.20833333333333
51282, 0.25, 0.4, 0.1875
51283, 0.25, 0.425, 0.20833333333333
51284, 0.22916666666667, 0.45, 0.20833333333333
51285, 0.25, 0.45, 0.1875
51286, 0.25, 0.475, 0.20833333333333
51287, 0.22916666666667, 0.5, 0.20833333333333
51288, 0.25, 0.5, 0.1875
51289, 0.25, 0.525, 0.20833333333333
51290, 0.22916666666667, 0.55, 0.20833333333333
51291, 0.25, 0.55, 0.1875
51292, 0.25, 0.575, 0.20833333333333
51293, 0.22916666666667, 0.6, 0.20833333333333
51294, 0.25, 0.6, 0.1875
51295, 0.25, 0.625, 0.20833333333333
51296, 0.22916666666667, 0.65, 0.20833333333333
51297, 0.25, 0.65, 0.1875
51298, 0.25, 0.675, 0.20833333333333
51299, 0.22916666666667, 0.7, 0.20833333333333
51300, 0.25, 0.7, 0.1875
51301, 0.25, 0.725, 0.20833333333333
51302, 0.22916666666667, 0.75, 0.20833333333333
51303, 0.25, 0.75, 0.1875
51304, 0.25, 0.775, 0.20833333333333
51305, 0.22916666666667, 0.8, 0.20833333333333
51306, 0.25, 0.8, 0.1875
51307, 0.25, 0.825, 0.20833333333333
51308, 0.22916666666667, 0.85, 0.20833333333333
51309, 0.25, 0.85, 0.1875
51310, 0.25, 0.875, 0.20833333333333
51311, 0.22916666666667, 0.9, 0.20833333333333
51312, 0.25, 0.9, 0.1875
51313, 0.25, 0.925, 0.20833333333333
51314, 0.22916666666667, 0.95, 0.20833333333333
51315, 0.25, 0.95, 0.1875
51316, 0.25, 0.975, 0.20833333333333
51317, 0.22916666666667, 1, 0.20833333333333
51318, 0.25, 1, 0.1875
51319, 0.25, 1.025, 0.20833333333333
51320, 0.22916666666667, 1.05, 0.20833333333333
51321, 0.25, 1.05, 0.1875
51322, 0.25, 1.075, 0.20833333333333
51323, 0.22916666666667, 1.1, 0.20833333333333
51324, 0.25, 1.1, 0.1875
51325, 0.25, 1.125, 0.20833333333333
51326, 0.22916666666667, 1.15, 0.20833333333333
51327, 0.25, 1.15, 0.1875
51328, 0.25, 1.175, 0.20833333333333
51329, 0.22916666666667, 1.2, 0.20833333333333
51330, 0.25, 1.2, 0.1875
51331, 0.25, 1.225, 0.20833333333333
51332, 0.22916666666667, 1.25, 0.20833333333333
51333, 0.25, 1.25, 0.1875
51334, 0.25, 1.275, 0.20833333333333
51335, 0.22916666666667, 1.3, 0.20833333333333
51336, 0.25, 1.3, 0.1875
51337, 0.25, 1.325, 0.20833333333333
51338, 0.25, 0.175, 0.25
51339, 0.22916666666667, 0.2, 0.25
51340, 0.25, 0.2, 0.22916666666667
51341, 0.25, 0.225, 0.25
51342, 0.22916666666667, 0.25, 0.25
51343, 0.25, 0.25, 0.22916666666667
51344, 0.25, 0.275, 0.25
51345, 0.22916666666667, 0.3, 0.25
51346, 0.25, 0.3, 0.22916666666667
51347, 0.25, 0.325, 0.25
51348, 0.22916666666667, 0.35, 0.25
51349, 0.25, 0.35, 0.22916666666667
51350, 0.25, 0.375, 0.25
51351, 0.22916666666667, 0.4, 0.25
51352, 0.25, 0.4, 0.22916666666667
51353, 0.25, 0.425, 0.25
51354, 0.22916666666667, 0.45, 0.25
51355, 0.25, 0.45, 0.22916666666667
51356, 0.25, 0.475, 0.25
51357, 0.22916666666667, 0.5, 0.25
51358, 0.25, 0.5, 0.22916666666667
51359, 0.25, 0.525, 0.25
51360, 0.22916666666667, 0.55, 0.25
51361, 0.25, 0.55, 0.22916666666667
51362, 0.25, 0.575, 0.25
51363, 0.22916666666667, 0.6, 0.25
51364, 0.25, 0.6, 0.22916666666667
51365, 0.25, 0.625, 0.25
51366, 0.22916666666667, 0.65, 0.25
51367, 0.25, 0.65, 0.22916666666667
51368, 0.25, 0.675, 0.25
51369, 0.22916666666667, 0.7, 0.25
51370, 0.25, 0.7, 0.22916666666667
51371, 0.25, 0.725, 0.25
51372, 0.22916666666667, 0.75, 0.25
51373, 0.25, 0.75, 0.22916666666667
51374, 0.25, 0.775, 0.25
51375, 0.22916666666667, 0.8, 0.25
51376, 0.25, 0.8, 0.22916666666667
51377, 0.25, 0.825, 0.25
51378, 0.22916666666667, 0.85, 0.25
51379, 0.25, 0.85, 0.22916666666667
51380, 0.25, 0.875, 0.25
51381, 0.22916666666667, 0.9, 0.25
51382, 0.25, 0.9, 0.22916666666667
51383, 0.25, 0.925, 0.25
51384, 0.22916666666667, 0.95, 0.25
51385, 0.25, 0.95, 0.22916666666667
51386, 0.25, 0.975, 0.25
51387, 0.22916666666667, 1, 0.25
51388, 0.25, 1, 0.22916666666667
51389, 0.25, 1.025, 0.25
51390, 0.22916666666667, 1.05, 0.25
51391, 0.25, 1.05, 0.22916666666667
51392, 0.25, 1.075, 0.25
51393, 0.22916666666667, 1.1, 0.25
51394, 0.25, 1.1, 0.22916666666667
51395, 0.25, 1.125, 0.25
51396, 0.22916666666667, 1.15, 0.25
51397, 0.25, 1.15, 0.22916666666667
51398, 0.25, 1.175, 0.25
51399, 0.22916666666667, 1.2, 0.25
51400, 0.25, 1.2, 0.22916666666667
51401, 0.25, 1.225, 0.25
51402, 0.22916666666667, 1.25, 0.25
51403, 0.25, 1.25, 0.22916666666667
51404, 0.25, 1.275, 0.25
51405, 0.22916666666667, 1.3, 0.25
51406, 0.25, 1.3, 0.22916666666667
51407, 0.25, 1.325, 0.25
51408, 0.25, 0.175, 0.29166666666667
51409, 0.22916666666667, 0.2, 0.29166666666667
51410, 0.25, 0.2, 0.27083333333333
51411, 0.25, 0.225, 0.29166666666667
51412, 0.22916666666667, 0.25, 0.29166666666667
51413, 0.25, 0.25, 0.27083333333333
51414, 0.25, 0.275, 0.29166666666667
51415, 0.22916666666667, 0.3, 0.29166666666667
51416, 0.25, 0.3, 0.27083333333333
51417, 0.25, 0.325, 0.29166666666667
51418, 0.22916666666667, 0.35, 0.29166666666667
51419, 0.25, 0.35, 0.27083333333333
51420, 0.25, 0.375, 0.29166666666667
51421, 0.22916666666667, 0.4, 0.29166666666667
51422, 0.25, 0.4, 0.27083333333333
51423, 0.25, 0.425, 0.29166666666667
51424, 0.22916666666667, 0.45, 0.29166666666667
51425, 0.25, 0.45, 0.27083333333333
51426, 0.25, 0.475, 0.29166666666667
51427, 0.22916666666667, 0.5, 0.29166666666667
51428, 0.25, 0.5, 0.27083333333333
51429, 0.25, 0.525, 0.29166666666667
51430, 0.22916666666667, 0.55, 0.29166666666667
51431, 0.25, 0.55, 0.27083333333333
51432, 0.25, 0.575, 0.29166666666667
51433, 0.22916666666667, 0.6, 0.29166666666667
51434, 0.25, 0.6, 0.27083333333333
51435, 0.25, 0.625, 0.29166666666667
51436, 0.22916666666667, 0.65, 0.29166666666667
51437, 0.25, 0.65, 0.27083333333333
51438, 0.25, 0.675, 0.29166666666667
51439, 0.22916666666667, 0.7, 0.29166666666667
51440, 0.25, 0.7, 0.27083333333333
51441, 0.25, 0.725, 0.29166666666667
51442, 0.22916666666667, 0.75, 0.29166666666667
51443, 0.25, 0.75, 0.27083333333333
51444, 0.25, 0.775, 0.29166666666667
51445, 0.22916666666667, 0.8, 0.29166666666667
51446, 0.25, 0.8, 0.27083333333333
51447, 0.25, 0.825, 0.29166666666667
51448, 0.22916666666667, 0.85, 0.29166666666667
51449, 0.25, 0.85, 0.27083333333333
51450, 0.25, 0.875, 0.29166666666667
51451, 0.22916666666667, 0.9, 0.29166666666667
51452, 0.25, 0.9, 0.27083333333333
51453, 0.25, 0.925, 0.29166666666667
51454, 0.22916666666667, 0.95, 0.29166666666667
51455, 0.25, 0.95, 0.27083333333333
51456, 0.25, 0.975, 0.29166666666667
51457, 0.22916666666667, 1, 0.29166666666667
51458, 0.25, 1, 0.27083333333333
51459, 0.25, 1.025, 0.29166666666667
51460, 0.22916666666667, 1.05, 0.29166666666667
51461, 0.25, 1.05, 0.27083333333333
51462, 0.25, 1.075, 0.29166666666667
51463, 0.22916666666667, 1.1, 0.29166666666667
51464, 0.25, 1.1, 0.27083333333333
51465, 0.25, 1.125, 0.29166666666667
51466, 0.22916666666667, 1.15, 0.29166666666667
51467, 0.25, 1.15, 0.27083333333333
51468, 0.25, 1.175, 0.29166666666667
51469, 0.22916666666667, 1.2, 0.29166666666667
51470, 0.25, 1.2, 0.27083333333333
51471, 0.25, 1.225, 0.29166666666667
51472, 0.22916666666667, 1.25, 0.29166666666667
51473, 0.25, 1.25, 0.27083333333333
51474, 0.25, 1.275, 0.29166666666667
51475, 0.22916666666667, 1.3, 0.29166666666667
51476, 0.25, 1.3, 0.27083333333333
51477, 0.25, 1.325, 0.29166666666667
51478, 0.25, 0.175, 0.33333333333333
51479, 0.22916666666667, 0.2, 0.33333333333333
51480, 0.25, 0.2, 0.3125
51481, 0.25, 0.225, 0.33333333333333
51482, 0.22916666666667, 0.25, 0.33333333333333
51483, 0.25, 0.25, 0.3125
51484, 0.25, 0.275, 0.33333333333333
51485, 0.22916666666667, 0.3, 0.33333333333333
51486, 0.25, 0.3, 0.3125
51487, 0.25, 0.325, 0.33333333333333
51488, 0.22916666666667, 0.35, 0.33333333333333
51489, 0.25, 0.35, 0.3125
51490, 0.25, 0.375, 0.33333333333333
51491, 0.22916666666667, 0.4, 0.33333333333333
51492, 0.25, 0.4, 0.3125
51493, 0.25, 0.425, 0.33333333333333
51494, 0.22916666666667, 0.45, 0.33333333333333
51495, 0.25, 0.45, 0.3125
51496, 0.25, 0.475, 0.33333333333333
51497, 0.22916666666667, 0.5, 0.33333333333333
51498, 0.25, 0.5, 0.3125
51499, 0.25, 0.525, 0.33333333333333
51500, 0.22916666666667, 0.55, 0.33333333333333
51501, 0.25, 0.55, 0.3125
51502, 0.25, 0.575, 0.33333333333333
51503, 0.22916666666667, 0.6, 0.33333333333333
51504, 0.25, 0.6, 0.3125
51505, 0.25, 0.625, 0.33333333333333
51506, 0.22916666666667, 0.65, 0.33333333333333
51507, 0.25, 0.65, 0.3125
51508, 0.25, 0.675, 0.33333333333333
51509, 0.22916666666667, 0.7, 0.33333333333333
51510, 0.25, 0.7, 0.3125
51511, 0.25, 0.725, 0.33333333333333
51512, 0.22916666666667, 0.75, 0.33333333333333
51513, 0.25, 0.75, 0.3125
51514, 0.25, 0.775, 0.33333333333333
51515, 0.22916666666667, 0.8, 0.33333333333333
51516, 0.25, 0.8, 0.3125
51517, 0.25, 0.825, 0.33333333333333
51518, 0.22916666666667, 0.85, 0.33333333333333
51519, 0.25, 0.85, 0.3125
51520, 0.25, 0.875, 0.33333333333333
51521, 0.22916666666667, 0.9, 0.33333333333333
51522, 0.25, 0.9, 0.3125
51523, 0.25, 0.925, 0.33333333333333
51524, 0.22916666666667, 0.95, 0.33333333333333
51525, 0.25, 0.95, 0.3125
51526, 0.25, 0.975, 0.33333333333333
51527, 0.22916666666667, 1, 0.33333333333333
51528, 0.25, 1, 0.3125
51529, 0.25, 1.025, 0.33333333333333
51530, 0.22916666666667, 1.05, 0.33333333333333
51531, 0.25, 1.05, 0.3125
51532, 0.25, 1.075, 0.33333333333333
51533, 0.22916666666667, 1.1, 0.33333333333333
51534, 0.25, 1.1, 0.3125
51535, 0.25, 1.125, 0.33333333333333
51536, 0.22916666666667, 1.15, 0.33333333333333
51537, 0.25, 1.15, 0.3125
51538, 0.25, 1.175, 0.33333333333333
51539, 0.22916666666667, 1.2, 0.33333333333333
51540, 0.25, 1.2, 0.3125
51541, 0.25, 1.225, 0.33333333333333
51542, 0.22916666666667, 1.25, 0.33333333333333
51543, 0.25, 1.25, 0.3125
51544, 0.25, 1.275, 0.33333333333333
51545, 0.22916666666667, 1.3, 0.33333333333333
51546, 0.25, 1.3, 0.3125
51547, 0.25, 1.325, 0.33333333333333
51548, 0.25, 0.175, 0.375
51549, 0.22916666666667, 0.2, 0.375
51550, 0.25, 0.2, 0.35416666666667
51551, 0.25, 0.225, 0.375
51552, 0.22916666666667, 0.25, 0.375
51553, 0.25, 0.25, 0.35416666666667
51554, 0.25, 0.275, 0.375
51555, 0.22916666666667, 0.3, 0.375
51556, 0.25, 0.3, 0.35416666666667
51557, 0.25, 0.325, 0.375
51558, 0.22916666666667, 0.35, 0.375
51559, 0.25, 0.35, 0.35416666666667
51560, 0.25, 0.375, 0.375
51561, 0.22916666666667, 0.4, 0.375
51562, 0.25, 0.4, 0.35416666666667
51563, 0.25, 0.425, 0.375
51564, 0.22916666666667, 0.45, 0.375
51565, 0.25, 0.45, 0.35416666666667
51566, 0.25, 0.475, 0.375
51567, 0.22916666666667, 0.5, 0.375
51568, 0.25, 0.5, 0.35416666666667
51569, 0.25, 0.525, 0.375
51570, 0.22916666666667, 0.55, 0.375
51571, 0.25, 0.55, 0.35416666666667
51572, 0.25, 0.575, 0.375
51573, 0.22916666666667, 0.6, 0.375
51574, 0.25, 0.6, 0.35416666666667
51575, 0.25, 0.625, 0.375
51576, 0.22916666666667, 0.65, 0.375
51577, 0.25, 0.65, 0.35416666666667
51578, 0.25, 0.675, 0.375
51579, 0.22916666666667, 0.7, 0.375
51580, 0.25, 0.7, 0.35416666666667
51581, 0.25, 0.725, 0.375
51582, 0.22916666666667, 0.75, 0.375
51583, 0.25, 0.75, 0.35416666666667
51584, 0.25, 0.775, 0.375
51585, 0.22916666666667, 0.8, 0.375
51586, 0.25, 0.8, 0.35416666666667
51587, 0.25, 0.825, 0.375
51588, 0.22916666666667, 0.85, 0.375
51589, 0.25, 0.85, 0.35416666666667
51590, 0.25, 0.875, 0.375
51591, 0.22916666666667, 0.9, 0.375
51592, 0.25, 0.9, 0.35416666666667
51593, 0.25, 0.925, 0.375
51594, 0.22916666666667, 0.95, 0.375
51595, 0.25, 0.95, 0.35416666666667
51596, 0.25, 0.975, 0.375
51597, 0.22916666666667, 1, 0.375
51598, 0.25, 1, 0.35416666666667
51599, 0.25, 1.025, 0.375
51600, 0.22916666666667, 1.05, 0.375
51601, 0.25, 1.05, 0.35416666666667
51602, 0.25, 1.075, 0.375
51603, 0.22916666666667, 1.1, 0.375
51604, 0.25, 1.1, 0.35416666666667
51605, 0.25, 1.125, 0.375
51606, 0.22916666666667, 1.15, 0.375
51607, 0.25, 1.15, 0.35416666666667
51608, 0.25, 1.175, 0.375
51609, 0.22916666666667, 1.2, 0.375
51610, 0.25, 1.2, 0.35416666666667
51611, 0.25, 1.225, 0.375
51612, 0.22916666666667, 1.25, 0.375
51613, 0.25, 1.25, 0.35416666666667
51614, 0.25, 1.275, 0.375
51615, 0.22916666666667, 1.3, 0.375
51616, 0.25, 1.3, 0.35416666666667
51617, 0.25, 1.325, 0.375
51618, 0.25, 0.175, 0.41666666666667
51619, 0.22916666666667, 0.2, 0.41666666666667
51620, 0.25, 0.2, 0.39583333333333
51621, 0.25, 0.225, 0.41666666666667
51622, 0.22916666666667, 0.25, 0.41666666666667
51623, 0.25, 0.25, 0.39583333333333
51624, 0.25, 0.275, 0.41666666666667
51625, 0.22916666666667, 0.3, 0.41666666666667
51626, 0.25, 0.3, 0.39583333333333
51627, 0.25, 0.325, 0.41666666666667
51628, 0.22916666666667, 0.35, 0.41666666666667
51629, 0.25, 0.35, 0.39583333333333
51630, 0.25, 0.375, 0.41666666666667
51631, 0.22916666666667, 0.4, 0.41666666666667
51632, 0.25, 0.4, 0.39583333333333
51633, 0.25, 0.425, 0.41666666666667
51634, 0.22916666666667, 0.45, 0.41666666666667
51635, 0.25, 0.45, 0.39583333333333
51636, 0.25, 0.475, 0.41666666666667
51637, 0.22916666666667, 0.5, 0.41666666666667
51638, 0.25, 0.5, 0.39583333333333
51639, 0.25, 0.525, 0.41666666666667
51640, 0.22916666666667, 0.55, 0.41666666666667
51641, 0.25, 0.55, 0.39583333333333
51642, 0.25, 0.575, 0.41666666666667
51643, 0.22916666666667, 0.6, 0.41666666666667
51644, 0.25, 0.6, 0.39583333333333
51645, 0.25, 0.625, 0.41666666666667
51646, 0.22916666666667, 0.65, 0.41666666666667
51647, 0.25, 0.65, 0.39583333333333
51648, 0.25, 0.675, 0.41666666666667
51649, 0.22916666666667, 0.7, 0.41666666666667
51650, 0.25, 0.7, 0.39583333333333
51651, 0.25, 0.725, 0.41666666666667
51652, 0.22916666666667, 0.75, 0.41666666666667
51653, 0.25, 0.75, 0.39583333333333
51654, 0.25, 0.775, 0.41666666666667
51655, 0.22916666666667, 0.8, 0.41666666666667
51656, 0.25, 0.8, 0.39583333333333
51657, 0.25, 0.825, 0.41666666666667
51658, 0.22916666666667, 0.85, 0.41666666666667
51659, 0.25, 0.85, 0.39583333333333
51660, 0.25, 0.875, 0.41666666666667
51661, 0.22916666666667, 0.9, 0.41666666666667
51662, 0.25, 0.9, 0.39583333333333
51663, 0.25, 0.925, 0.41666666666667
51664, 0.22916666666667, 0.95, 0.41666666666667
51665, 0.25, 0.95, 0.39583333333333
51666, 0.25, 0.975, 0.41666666666667
51667, 0.22916666666667, 1, 0.41666666666667
51668, 0.25, 1, 0.39583333333333
51669, 0.25, 1.025, 0.41666666666667
51670, 0.22916666666667, 1.05, 0.41666666666667
51671, 0.25, 1.05, 0.39583333333333
51672, 0.25, 1.075, 0.41666666666667
51673, 0.22916666666667, 1.1, 0.41666666666667
51674, 0.25, 1.1, 0.39583333333333
51675, 0.25, 1.125, 0.41666666666667
51676, 0.22916666666667, 1.15, 0.41666666666667
51677, 0.25, 1.15, 0.39583333333333
51678, 0.25, 1.175, 0.41666666666667
51679, 0.22916666666667, 1.2, 0.41666666666667
51680, 0.25, 1.2, 0.39583333333333
51681, 0.25, 1.225, 0.41666666666667
51682, 0.22916666666667, 1.25, 0.41666666666667
51683, 0.25, 1.25, 0.39583333333333
51684, 0.25, 1.275, 0.41666666666667
51685, 0.22916666666667, 1.3, 0.41666666666667
51686, 0.25, 1.3, 0.39583333333333
51687, 0.25, 1.325, 0.41666666666667
51688, 0.25, 0.175, 0.45833333333333
51689, 0.22916666666667, 0.2, 0.45833333333333
51690, 0.25, 0.2, 0.4375
51691, 0.25, 0.225, 0.45833333333333
51692, 0.22916666666667, 0.25, 0.45833333333333
51693, 0.25, 0.25, 0.4375
51694, 0.25, 0.275, 0.45833333333333
51695, 0.22916666666667, 0.3, 0.45833333333333
51696, 0.25, 0.3, 0.4375
51697, 0.25, 0.325, 0.45833333333333
51698, 0.22916666666667, 0.35, 0.45833333333333
51699, 0.25, 0.35, 0.4375
51700, 0.25, 0.375, 0.45833333333333
51701, 0.22916666666667, 0.4, 0.45833333333333
51702, 0.25, 0.4, 0.4375
51703, 0.25, 0.425, 0.45833333333333
51704, 0.22916666666667, 0.45, 0.45833333333333
51705, 0.25, 0.45, 0.4375
51706, 0.25, 0.475, 0.45833333333333
51707, 0.22916666666667, 0.5, 0.45833333333333
51708, 0.25, 0.5, 0.4375
51709, 0.25, 0.525, 0.45833333333333
51710, 0.22916666666667, 0.55, 0.45833333333333
51711, 0.25, 0.55, 0.4375
51712, 0.25, 0.575, 0.45833333333333
51713, 0.22916666666667, 0.6, 0.45833333333333
51714, 0.25, 0.6, 0.4375
51715, 0.25, 0.625, 0.45833333333333
51716, 0.22916666666667, 0.65, 0.45833333333333
51717, 0.25, 0.65, 0.4375
51718, 0.25, 0.675, 0.45833333333333
51719, 0.22916666666667, 0.7, 0.45833333333333
51720, 0.25, 0.7, 0.4375
51721, 0.25, 0.725, 0.45833333333333
51722, 0.22916666666667, 0.75, 0.45833333333333
51723, 0.25, 0.75, 0.4375
51724, 0.25, 0.775, 0.45833333333333
51725, 0.22916666666667, 0.8, 0.45833333333333
51726, 0.25, 0.8, 0.4375
51727, 0.25, 0.825, 0.45833333333333
51728, 0.22916666666667, 0.85, 0.45833333333333
51729, 0.25, 0.85, 0.4375
51730, 0.25, 0.875, 0.45833333333333
51731, 0.22916666666667, 0.9, 0.45833333333333
51732, 0.25, 0.9, 0.4375
51733, 0.25, 0.925, 0.45833333333333
51734, 0.22916666666667, 0.95, 0.45833333333333
51735, 0.25, 0.95, 0.4375
51736, 0.25, 0.975, 0.45833333333333
51737, 0.22916666666667, 1, 0.45833333333333
51738, 0.25, 1, 0.4375
51739, 0.25, 1.025, 0.45833333333333
51740, 0.22916666666667, 1.05, 0.45833333333333
51741, 0.25, 1.05, 0.4375
51742, 0.25, 1.075, 0.45833333333333
51743, 0.22916666666667, 1.1, 0.45833333333333
51744, 0.25, 1.1, 0.4375
51745, 0.25, 1.125, 0.45833333333333
51746, 0.22916666666667, 1.15, 0.45833333333333
51747, 0.25, 1.15, 0.4375
51748, 0.25, 1.175, 0.45833333333333
51749, 0.22916666666667, 1.2, 0.45833333333333
51750, 0.25, 1.2, 0.4375
51751, 0.25, 1.225, 0.45833333333333
51752, 0.22916666666667, 1.25, 0.45833333333333
51753, 0.25, 1.25, 0.4375
51754, 0.25, 1.275, 0.45833333333333
51755, 0.22916666666667, 1.3, 0.45833333333333
51756, 0.25, 1.3, 0.4375
51757, 0.25, 1.325, 0.45833333333333
51758, 0.25, 0.2, 0.47916666666667
51759, 0.25, 0.25, 0.47916666666667
51760, 0.25, 0.3, 0.47916666666667
51761, 0.25, 0.35, 0.47916666666667
51762, 0.25, 0.4, 0.47916666666667
51763, 0.25, 0.45, 0.47916666666667
51764, 0.25, 0.5, 0.47916666666667
51765, 0.25, 0.55, 0.47916666666667
51766, 0.25, 0.6, 0.47916666666667
51767, 0.25, 0.65, 0.47916666666667
51768, 0.25, 0.7, 0.47916666666667
51769, 0.25, 0.75, 0.47916666666667
51770, 0.25, 0.8, 0.47916666666667
51771, 0.25, 0.85, 0.47916666666667
51772, 0.25, 0.9, 0.47916666666667
51773, 0.25, 0.95, 0.47916666666667
51774, 0.25, 1, 0.47916666666667
51775, 0.25, 1.05, 0.47916666666667
51776, 0.25, 1.1, 0.47916666666667
51777, 0.25, 1.15, 0.47916666666667
51778, 0.25, 1.2, 0.47916666666667
51779, 0.25, 1.25, 0.47916666666667
51780, 0.25, 1.3, 0.47916666666667
51781, 0.29166666666667, 0.175, 0.041666666666667
51782, 0.27083333333333, 0.2, 0.041666666666667
51783, 0.29166666666667, 0.2, 0.020833333333333
51784, 0.29166666666667, 0.225, 0.041666666666667
51785, 0.27083333333333, 0.25, 0.041666666666667
51786, 0.29166666666667, 0.25, 0.020833333333333
51787, 0.29166666666667, 0.275, 0.041666666666667
51788, 0.27083333333333, 0.3, 0.041666666666667
51789, 0.29166666666667, 0.3, 0.020833333333333
51790, 0.29166666666667, 0.325, 0.041666666666667
51791, 0.27083333333333, 0.35, 0.041666666666667
51792, 0.29166666666667, 0.35, 0.020833333333333
51793, 0.29166666666667, 0.375, 0.041666666666667
51794, 0.27083333333333, 0.4, 0.041666666666667
51795, 0.29166666666667, 0.4, 0.020833333333333
51796, 0.29166666666667, 0.425, 0.041666666666667
51797, 0.27083333333333, 0.45, 0.041666666666667
51798, 0.29166666666667, 0.45, 0.020833333333333
51799, 0.29166666666667, 0.475, 0.041666666666667
51800, 0.27083333333333, 0.5, 0.041666666666667
51801, 0.29166666666667, 0.5, 0.020833333333333
51802, 0.29166666666667, 0.525, 0.041666666666667
51803, 0.27083333333333, 0.55, 0.041666666666667
51804, 0.29166666666667, 0.55, 0.020833333333333
51805, 0.29166666666667, 0.575, 0.041666666666667
51806, 0.27083333333333, 0.6, 0.041666666666667
51807, 0.29166666666667, 0.6, 0.020833333333333
51808, 0.29166666666667, 0.625, 0.041666666666667
51809, 0.27083333333333, 0.65, 0.041666666666667
51810, 0.29166666666667, 0.65, 0.020833333333333
51811, 0.29166666666667, 0.675, 0.041666666666667
51812, 0.27083333333333, 0.7, 0.041666666666667
51813, 0.29166666666667, 0.7, 0.020833333333333
51814, 0.29166666666667, 0.725, 0.041666666666667
51815, 0.27083333333333, 0.75, 0.041666666666667
51816, 0.29166666666667, 0.75, 0.020833333333333
51817, 0.29166666666667, 0.775, 0.041666666666667
51818, 0.27083333333333, 0.8, 0.041666666666667
51819, 0.29166666666667, 0.8, 0.020833333333333
51820, 0.29166666666667, 0.825, 0.041666666666667
51821, 0.27083333333333, 0.85, 0.041666666666667
51822, 0.29166666666667, 0.85, 0.020833333333333
51823, 0.29166666666667, 0.875, 0.041666666666667
51824, 0.27083333333333, 0.9, 0.041666666666667
51825, 0.29166666666667, 0.9, 0.020833333333333
51826, 0.29166666666667, 0.925, 0.041666666666667
51827, 0.27083333333333, 0.95, 0.041666666666667
51828, 0.29166666666667, 0.95, 0.020833333333333
51829, 0.29166666666667, 0.975, 0.041666666666667
51830, 0.27083333333333, 1, 0.041666666666667
51831, 0.29166666666667, 1, 0.020833333333333
51832, 0.29166666666667, 1.025, 0.041666666666667
51833, 0.27083333333333, 1.05, 0.041666666666667
51834, 0.29166666666667, 1.05, 0.020833333333333
51835, 0.29166666666667, 1.075, 0.041666666666667
51836, 0.27083333333333, 1.1, 0.041666666666667
51837, 0.29166666666667, 1.1, 0.020833333333333
51838, 0.29166666666667, 1.125, 0.041666666666667
51839, 0.27083333333333, 1.15, 0.041666666666667
51840, 0.29166666666667, 1.15, 0.020833333333333
51841, 0.29166666666667, 1.175, 0.041666666666667
51842, 0.27083333333333, 1.2, 0.041666666666667
51843, 0.29166666666667, 1.2, 0.020833333333333
51844, 0.29166666666667, 1.225, 0.041666666666667
51845, 0.27083333333333, 1.25, 0.041666666666667
51846, 0.29166666666667, 1.25, 0.020833333333333
51847, 0.29166666666667, 1.275, 0.041666666666667
51848, 0.27083333333333, 1.3, 0.041666666666667
51849, 0.29166666666667, 1.3, 0.020833333333333
51850, 0.29166666666667, 1.325, 0.041666666666667
51851, 0.29166666666667, 0.175, 0.083333333333333
51852, 0.27083333333333, 0.2, 0.083333333333333
51853, 0.29166666666667, 0.2, 0.0625
51854, 0.29166666666667, 0.225, 0.083333333333333
51855, 0.27083333333333, 0.25, 0.083333333333333
51856, 0.29166666666667, 0.25, 0.0625
51857, 0.29166666666667, 0.275, 0.083333333333333
51858, 0.27083333333333, 0.3, 0.083333333333333
51859, 0.29166666666667, 0.3, 0.0625
51860, 0.29166666666667, 0.325, 0.083333333333333
51861, 0.27083333333333, 0.35, 0.083333333333333
51862, 0.29166666666667, 0.35, 0.0625
51863, 0.29166666666667, 0.375, 0.083333333333333
51864, 0.27083333333333, 0.4, 0.083333333333333
51865, 0.29166666666667, 0.4, 0.0625
51866, 0.29166666666667, 0.425, 0.083333333333333
51867, 0.27083333333333, 0.45, 0.083333333333333
51868, 0.29166666666667, 0.45, 0.0625
51869, 0.29166666666667, 0.475, 0.083333333333333
51870, 0.27083333333333, 0.5, 0.083333333333333
51871, 0.29166666666667, 0.5, 0.0625
51872, 0.29166666666667, 0.525, 0.083333333333333
51873, 0.27083333333333, 0.55, 0.083333333333333
51874, 0.29166666666667, 0.55, 0.0625
51875, 0.29166666666667, 0.575, 0.083333333333333
51876, 0.27083333333333, 0.6, 0.083333333333333
51877, 0.29166666666667, 0.6, 0.0625
51878, 0.29166666666667, 0.625, 0.083333333333333
51879, 0.27083333333333, 0.65, 0.083333333333333
51880, 0.29166666666667, 0.65, 0.0625
51881, 0.29166666666667, 0.675, 0.083333333333333
51882, 0.27083333333333, 0.7, 0.083333333333333
51883, 0.29166666666667, 0.7, 0.0625
51884, 0.29166666666667, 0.725, 0.083333333333333
51885, 0.27083333333333, 0.75, 0.083333333333333
51886, 0.29166666666667, 0.75, 0.0625
51887, 0.29166666666667, 0.775, 0.083333333333333
51888, 0.27083333333333, 0.8, 0.083333333333333
51889, 0.29166666666667, 0.8, 0.0625
51890, 0.29166666666667, 0.825, 0.083333333333333
51891, 0.27083333333333, 0.85, 0.083333333333333
51892, 0.29166666666667, 0.85, 0.0625
51893, 0.29166666666667, 0.875, 0.083333333333333
51894, 0.27083333333333, 0.9, 0.083333333333333
51895, 0.29166666666667, 0.9, 0.0625
51896, 0.29166666666667, 0.925, 0.083333333333333
51897, 0.27083333333333, 0.95, 0.083333333333333
51898, 0.29166666666667, 0.95, 0.0625
51899, 0.29166666666667, 0.975, 0.083333333333333
51900, 0.27083333333333, 1, 0.083333333333333
51901, 0.29166666666667, 1, 0.0625
51902, 0.29166666666667, 1.025, 0.083333333333333
51903, 0.27083333333333, 1.05, 0.083333333333333
51904, 0.29166666666667, 1.05, 0.0625
51905, 0.29166666666667, 1.075, 0.083333333333333
51906, 0.27083333333333, 1.1, 0.083333333333333
51907, 0.29166666666667, 1.1, 0.0625
51908, 0.29166666666667, 1.125, 0.083333333333333
51909, 0.27083333333333, 1.15, 0.083333333333333
51910, 0.29166666666667, 1.15, 0.0625
51911, 0.29166666666667, 1.175, 0.083333333333333
51912, 0.27083333333333, 1.2, 0.083333333333333
51913, 0.29166666666667, 1.2, 0.0625
51914, 0.29166666666667, 1.225, 0.083333333333333
51915, 0.27083333333333, 1.25, 0.083333333333333
51916, 0.29166666666667, 1.25, 0.0625
51917, 0.29166666666667, 1.275, 0.083333333333333
51918, 0.27083333333333, 1.3, 0.083333333333333
51919, 0.29166666666667, 1.3, 0.0625
51920, 0.29166666666667, 1.325, 0.083333333333333
51921, 0.29166666666667, 0.175, 0.125
51922, 0.27083333333333, 0.2, 0.125
51923, 0.29166666666667, 0.2, 0.10416666666667
51924, 0.29166666666667, 0.225, 0.125
51925, 0.27083333333333, 0.25, 0.125
51926, 0.29166666666667, 0.25, 0.10416666666667
51927, 0.29166666666667, 0.275, 0.125
51928, 0.27083333333333, 0.3, 0.125
51929, 0.29166666666667, 0.3, 0.10416666666667
51930, 0.29166666666667, 0.325, 0.125
51931, 0.27083333333333, 0.35, 0.125
51932, 0.29166666666667, 0.35, 0.10416666666667
51933, 0.29166666666667, 0.375, 0.125
51934, 0.27083333333333, 0.4, 0.125
51935, 0.29166666666667, 0.4, 0.10416666666667
51936, 0.29166666666667, 0.425, 0.125
51937, 0.27083333333333, 0.45, 0.125
51938, 0.29166666666667, 0.45, 0.10416666666667
51939, 0.29166666666667, 0.475, 0.125
51940, 0.27083333333333, 0.5, 0.125
51941, 0.29166666666667, 0.5, 0.10416666666667
51942, 0.29166666666667, 0.525, 0.125
51943, 0.27083333333333, 0.55, 0.125
51944, 0.29166666666667, 0.55, 0.10416666666667
51945, 0.29166666666667, 0.575, 0.125
51946, 0.27083333333333, 0.6, 0.125
51947, 0.29166666666667, 0.6, 0.10416666666667
51948, 0.29166666666667, 0.625, 0.125
51949, 0.27083333333333, 0.65, 0.125
51950, 0.29166666666667, 0.65, 0.10416666666667
51951, 0.29166666666667, 0.675, 0.125
51952, 0.27083333333333, 0.7, 0.125
51953, 0.29166666666667, 0.7, 0.10416666666667
51954, 0.29166666666667, 0.725, 0.125
51955, 0.27083333333333, 0.75, 0.125
51956, 0.29166666666667, 0.75, 0.10416666666667
51957, 0.29166666666667, 0.775, 0.125
51958, 0.27083333333333, 0.8, 0.125
51959, 0.29166666666667, 0.8, 0.10416666666667
51960, 0.29166666666667, 0.825, 0.125
51961, 0.27083333333333, 0.85, 0.125
51962, 0.29166666666667, 0.85, 0.10416666666667
51963, 0.29166666666667, 0.875, 0.125
51964, 0.27083333333333, 0.9, 0.125
51965, 0.29166666666667, 0.9, 0.10416666666667
51966, 0.29166666666667, 0.925, 0.125
51967, 0.27083333333333, 0.95, 0.125
51968, 0.29166666666667, 0.95, 0.10416666666667
51969, 0.29166666666667, 0.975, 0.125
51970, 0.27083333333333, 1, 0.125
51971, 0.29166666666667, 1, 0.10416666666667
51972, 0.29166666666667, 1.025, 0.125
51973, 0.27083333333333, 1.05, 0.125
51974, 0.29166666666667, 1.05, 0.10416666666667
51975, 0.29166666666667, 1.075, 0.125
51976, 0.27083333333333, 1.1, 0.125
51977, 0.29166666666667, 1.1, 0.10416666666667
51978, 0.29166666666667, 1.125, 0.125
51979, 0.27083333333333, 1.15, 0.125
51980, 0.29166666666667, 1.15, 0.10416666666667
51981, 0.29166666666667, 1.175, 0.125
51982, 0.27083333333333, 1.2, 0.125
51983, 0.29166666666667, 1.2, 0.10416666666667
51984, 0.29166666666667, 1.225, 0.125
51985, 0.27083333333333, 1.25, 0.125
51986, 0.29166666666667, 1.25, 0.10416666666667
51987, 0.29166666666667, 1.275, 0.125
51988, 0.27083333333333, 1.3, 0.125
51989, 0.29166666666667, 1.3, 0.10416666666667
51990, 0.29166666666667, 1.325, 0.125
51991, 0.29166666666667, 0.175, 0.16666666666667
51992, 0.27083333333333, 0.2, 0.16666666666667
51993, 0.29166666666667, 0.2, 0.14583333333333
51994, 0.29166666666667, 0.225, 0.16666666666667
51995, 0.27083333333333, 0.25, 0.16666666666667
51996, 0.29166666666667, 0.25, 0.14583333333333
51997, 0.29166666666667, 0.275, 0.16666666666667
51998, 0.27083333333333, 0.3, 0.16666666666667
51999, 0.29166666666667, 0.3, 0.14583333333333
52000, 0.29166666666667, 0.325, 0.16666666666667
52001, 0.27083333333333, 0.35, 0.16666666666667
52002, 0.29166666666667, 0.35, 0.14583333333333
52003, 0.29166666666667, 0.375, 0.16666666666667
52004, 0.27083333333333, 0.4, 0.16666666666667
52005, 0.29166666666667, 0.4, 0.14583333333333
52006, 0.29166666666667, 0.425, 0.16666666666667
52007, 0.27083333333333, 0.45, 0.16666666666667
52008, 0.29166666666667, 0.45, 0.14583333333333
52009, 0.29166666666667, 0.475, 0.16666666666667
52010, 0.27083333333333, 0.5, 0.16666666666667
52011, 0.29166666666667, 0.5, 0.14583333333333
52012, 0.29166666666667, 0.525, 0.16666666666667
52013, 0.27083333333333, 0.55, 0.16666666666667
52014, 0.29166666666667, 0.55, 0.14583333333333
52015, 0.29166666666667, 0.575, 0.16666666666667
52016, 0.27083333333333, 0.6, 0.16666666666667
52017, 0.29166666666667, 0.6, 0.14583333333333
52018, 0.29166666666667, 0.625, 0.16666666666667
52019, 0.27083333333333, 0.65, 0.16666666666667
52020, 0.29166666666667, 0.65, 0.14583333333333
52021, 0.29166666666667, 0.675, 0.16666666666667
52022, 0.27083333333333, 0.7, 0.16666666666667
52023, 0.29166666666667, 0.7, 0.14583333333333
52024, 0.29166666666667, 0.725, 0.16666666666667
52025, 0.27083333333333, 0.75, 0.16666666666667
52026, 0.29166666666667, 0.75, 0.14583333333333
