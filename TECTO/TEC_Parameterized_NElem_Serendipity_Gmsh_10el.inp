11587, 28044, 28045, 28068, 28067, 28837, 28883, 28884, 28881
11588, 28045, 2848, 2849, 28068, 28838, 2872, 28885, 28883
11589, 2802, 28046, 28069, 2803, 28840, 28886, 28887, 2826
11590, 28046, 28047, 28070, 28069, 28842, 28888, 28889, 28886
11591, 28047, 28048, 28071, 28070, 28844, 28890, 28891, 28888
11592, 28048, 28049, 28072, 28071, 28846, 28892, 28893, 28890
11593, 28049, 28050, 28073, 28072, 28848, 28894, 28895, 28892
11594, 28050, 28051, 28074, 28073, 28850, 28896, 28897, 28894
11595, 28051, 28052, 28075, 28074, 28852, 28898, 28899, 28896
11596, 28052, 28053, 28076, 28075, 28854, 28900, 28901, 28898
11597, 28053, 28054, 28077, 28076, 28856, 28902, 28903, 28900
11598, 28054, 28055, 28078, 28077, 28858, 28904, 28905, 28902
11599, 28055, 28056, 28079, 28078, 28860, 28906, 28907, 28904
11600, 28056, 28057, 28080, 28079, 28862, 28908, 28909, 28906
11601, 28057, 28058, 28081, 28080, 28864, 28910, 28911, 28908
11602, 28058, 28059, 28082, 28081, 28866, 28912, 28913, 28910
11603, 28059, 28060, 28083, 28082, 28868, 28914, 28915, 28912
11604, 28060, 28061, 28084, 28083, 28870, 28916, 28917, 28914
11605, 28061, 28062, 28085, 28084, 28872, 28918, 28919, 28916
11606, 28062, 28063, 28086, 28085, 28874, 28920, 28921, 28918
11607, 28063, 28064, 28087, 28086, 28876, 28922, 28923, 28920
11608, 28064, 28065, 28088, 28087, 28878, 28924, 28925, 28922
11609, 28065, 28066, 28089, 28088, 28880, 28926, 28927, 28924
11610, 28066, 28067, 28090, 28089, 28882, 28928, 28929, 28926
11611, 28067, 28068, 28091, 28090, 28884, 28930, 28931, 28928
11612, 28068, 2849, 2850, 28091, 28885, 2873, 28932, 28930
11613, 2803, 28069, 28092, 2804, 28887, 28933, 28934, 2827
11614, 28069, 28070, 28093, 28092, 28889, 28935, 28936, 28933
11615, 28070, 28071, 28094, 28093, 28891, 28937, 28938, 28935
11616, 28071, 28072, 28095, 28094, 28893, 28939, 28940, 28937
11617, 28072, 28073, 28096, 28095, 28895, 28941, 28942, 28939
11618, 28073, 28074, 28097, 28096, 28897, 28943, 28944, 28941
11619, 28074, 28075, 28098, 28097, 28899, 28945, 28946, 28943
11620, 28075, 28076, 28099, 28098, 28901, 28947, 28948, 28945
11621, 28076, 28077, 28100, 28099, 28903, 28949, 28950, 28947
11622, 28077, 28078, 28101, 28100, 28905, 28951, 28952, 28949
11623, 28078, 28079, 28102, 28101, 28907, 28953, 28954, 28951
11624, 28079, 28080, 28103, 28102, 28909, 28955, 28956, 28953
11625, 28080, 28081, 28104, 28103, 28911, 28957, 28958, 28955
11626, 28081, 28082, 28105, 28104, 28913, 28959, 28960, 28957
11627, 28082, 28083, 28106, 28105, 28915, 28961, 28962, 28959
11628, 28083, 28084, 28107, 28106, 28917, 28963, 28964, 28961
11629, 28084, 28085, 28108, 28107, 28919, 28965, 28966, 28963
11630, 28085, 28086, 28109, 28108, 28921, 28967, 28968, 28965
11631, 28086, 28087, 28110, 28109, 28923, 28969, 28970, 28967
11632, 28087, 28088, 28111, 28110, 28925, 28971, 28972, 28969
11633, 28088, 28089, 28112, 28111, 28927, 28973, 28974, 28971
11634, 28089, 28090, 28113, 28112, 28929, 28975, 28976, 28973
11635, 28090, 28091, 28114, 28113, 28931, 28977, 28978, 28975
11636, 28091, 2850, 2851, 28114, 28932, 2874, 28979, 28977
11637, 2804, 28092, 28115, 2805, 28934, 28980, 28981, 2828
11638, 28092, 28093, 28116, 28115, 28936, 28982, 28983, 28980
11639, 28093, 28094, 28117, 28116, 28938, 28984, 28985, 28982
11640, 28094, 28095, 28118, 28117, 28940, 28986, 28987, 28984
11641, 28095, 28096, 28119, 28118, 28942, 28988, 28989, 28986
11642, 28096, 28097, 28120, 28119, 28944, 28990, 28991, 28988
11643, 28097, 28098, 28121, 28120, 28946, 28992, 28993, 28990
11644, 28098, 28099, 28122, 28121, 28948, 28994, 28995, 28992
11645, 28099, 28100, 28123, 28122, 28950, 28996, 28997, 28994
11646, 28100, 28101, 28124, 28123, 28952, 28998, 28999, 28996
11647, 28101, 28102, 28125, 28124, 28954, 29000, 29001, 28998
11648, 28102, 28103, 28126, 28125, 28956, 29002, 29003, 29000
11649, 28103, 28104, 28127, 28126, 28958, 29004, 29005, 29002
11650, 28104, 28105, 28128, 28127, 28960, 29006, 29007, 29004
11651, 28105, 28106, 28129, 28128, 28962, 29008, 29009, 29006
11652, 28106, 28107, 28130, 28129, 28964, 29010, 29011, 29008
11653, 28107, 28108, 28131, 28130, 28966, 29012, 29013, 29010
11654, 28108, 28109, 28132, 28131, 28968, 29014, 29015, 29012
11655, 28109, 28110, 28133, 28132, 28970, 29016, 29017, 29014
11656, 28110, 28111, 28134, 28133, 28972, 29018, 29019, 29016
11657, 28111, 28112, 28135, 28134, 28974, 29020, 29021, 29018
11658, 28112, 28113, 28136, 28135, 28976, 29022, 29023, 29020
11659, 28113, 28114, 28137, 28136, 28978, 29024, 29025, 29022
11660, 28114, 2851, 2852, 28137, 28979, 2875, 29026, 29024
11661, 2805, 28115, 28138, 2806, 28981, 29027, 29028, 2829
11662, 28115, 28116, 28139, 28138, 28983, 29029, 29030, 29027
11663, 28116, 28117, 28140, 28139, 28985, 29031, 29032, 29029
11664, 28117, 28118, 28141, 28140, 28987, 29033, 29034, 29031
11665, 28118, 28119, 28142, 28141, 28989, 29035, 29036, 29033
11666, 28119, 28120, 28143, 28142, 28991, 29037, 29038, 29035
11667, 28120, 28121, 28144, 28143, 28993, 29039, 29040, 29037
11668, 28121, 28122, 28145, 28144, 28995, 29041, 29042, 29039
11669, 28122, 28123, 28146, 28145, 28997, 29043, 29044, 29041
11670, 28123, 28124, 28147, 28146, 28999, 29045, 29046, 29043
11671, 28124, 28125, 28148, 28147, 29001, 29047, 29048, 29045
11672, 28125, 28126, 28149, 28148, 29003, 29049, 29050, 29047
11673, 28126, 28127, 28150, 28149, 29005, 29051, 29052, 29049
11674, 28127, 28128, 28151, 28150, 29007, 29053, 29054, 29051
11675, 28128, 28129, 28152, 28151, 29009, 29055, 29056, 29053
11676, 28129, 28130, 28153, 28152, 29011, 29057, 29058, 29055
11677, 28130, 28131, 28154, 28153, 29013, 29059, 29060, 29057
11678, 28131, 28132, 28155, 28154, 29015, 29061, 29062, 29059
11679, 28132, 28133, 28156, 28155, 29017, 29063, 29064, 29061
11680, 28133, 28134, 28157, 28156, 29019, 29065, 29066, 29063
11681, 28134, 28135, 28158, 28157, 29021, 29067, 29068, 29065
11682, 28135, 28136, 28159, 28158, 29023, 29069, 29070, 29067
11683, 28136, 28137, 28160, 28159, 29025, 29071, 29072, 29069
11684, 28137, 2852, 2853, 28160, 29026, 2876, 29073, 29071
11685, 2806, 28138, 28161, 2807, 29028, 29074, 29075, 2830
11686, 28138, 28139, 28162, 28161, 29030, 29076, 29077, 29074
11687, 28139, 28140, 28163, 28162, 29032, 29078, 29079, 29076
11688, 28140, 28141, 28164, 28163, 29034, 29080, 29081, 29078
11689, 28141, 28142, 28165, 28164, 29036, 29082, 29083, 29080
11690, 28142, 28143, 28166, 28165, 29038, 29084, 29085, 29082
11691, 28143, 28144, 28167, 28166, 29040, 29086, 29087, 29084
11692, 28144, 28145, 28168, 28167, 29042, 29088, 29089, 29086
11693, 28145, 28146, 28169, 28168, 29044, 29090, 29091, 29088
11694, 28146, 28147, 28170, 28169, 29046, 29092, 29093, 29090
11695, 28147, 28148, 28171, 28170, 29048, 29094, 29095, 29092
11696, 28148, 28149, 28172, 28171, 29050, 29096, 29097, 29094
11697, 28149, 28150, 28173, 28172, 29052, 29098, 29099, 29096
11698, 28150, 28151, 28174, 28173, 29054, 29100, 29101, 29098
11699, 28151, 28152, 28175, 28174, 29056, 29102, 29103, 29100
11700, 28152, 28153, 28176, 28175, 29058, 29104, 29105, 29102
11701, 28153, 28154, 28177, 28176, 29060, 29106, 29107, 29104
11702, 28154, 28155, 28178, 28177, 29062, 29108, 29109, 29106
11703, 28155, 28156, 28179, 28178, 29064, 29110, 29111, 29108
11704, 28156, 28157, 28180, 28179, 29066, 29112, 29113, 29110
11705, 28157, 28158, 28181, 28180, 29068, 29114, 29115, 29112
11706, 28158, 28159, 28182, 28181, 29070, 29116, 29117, 29114
11707, 28159, 28160, 28183, 28182, 29072, 29118, 29119, 29116
11708, 28160, 2853, 2854, 28183, 29073, 2877, 29120, 29118
11709, 2807, 28161, 28184, 2808, 29075, 29121, 29122, 2831
11710, 28161, 28162, 28185, 28184, 29077, 29123, 29124, 29121
11711, 28162, 28163, 28186, 28185, 29079, 29125, 29126, 29123
11712, 28163, 28164, 28187, 28186, 29081, 29127, 29128, 29125
11713, 28164, 28165, 28188, 28187, 29083, 29129, 29130, 29127
11714, 28165, 28166, 28189, 28188, 29085, 29131, 29132, 29129
11715, 28166, 28167, 28190, 28189, 29087, 29133, 29134, 29131
11716, 28167, 28168, 28191, 28190, 29089, 29135, 29136, 29133
11717, 28168, 28169, 28192, 28191, 29091, 29137, 29138, 29135
11718, 28169, 28170, 28193, 28192, 29093, 29139, 29140, 29137
11719, 28170, 28171, 28194, 28193, 29095, 29141, 29142, 29139
11720, 28171, 28172, 28195, 28194, 29097, 29143, 29144, 29141
11721, 28172, 28173, 28196, 28195, 29099, 29145, 29146, 29143
11722, 28173, 28174, 28197, 28196, 29101, 29147, 29148, 29145
11723, 28174, 28175, 28198, 28197, 29103, 29149, 29150, 29147
11724, 28175, 28176, 28199, 28198, 29105, 29151, 29152, 29149
11725, 28176, 28177, 28200, 28199, 29107, 29153, 29154, 29151
11726, 28177, 28178, 28201, 28200, 29109, 29155, 29156, 29153
11727, 28178, 28179, 28202, 28201, 29111, 29157, 29158, 29155
11728, 28179, 28180, 28203, 28202, 29113, 29159, 29160, 29157
11729, 28180, 28181, 28204, 28203, 29115, 29161, 29162, 29159
11730, 28181, 28182, 28205, 28204, 29117, 29163, 29164, 29161
11731, 28182, 28183, 28206, 28205, 29119, 29165, 29166, 29163
11732, 28183, 2854, 2855, 28206, 29120, 2878, 29167, 29165
11733, 2808, 28184, 28207, 2809, 29122, 29168, 29169, 2832
11734, 28184, 28185, 28208, 28207, 29124, 29170, 29171, 29168
11735, 28185, 28186, 28209, 28208, 29126, 29172, 29173, 29170
11736, 28186, 28187, 28210, 28209, 29128, 29174, 29175, 29172
11737, 28187, 28188, 28211, 28210, 29130, 29176, 29177, 29174
11738, 28188, 28189, 28212, 28211, 29132, 29178, 29179, 29176
11739, 28189, 28190, 28213, 28212, 29134, 29180, 29181, 29178
11740, 28190, 28191, 28214, 28213, 29136, 29182, 29183, 29180
11741, 28191, 28192, 28215, 28214, 29138, 29184, 29185, 29182
11742, 28192, 28193, 28216, 28215, 29140, 29186, 29187, 29184
11743, 28193, 28194, 28217, 28216, 29142, 29188, 29189, 29186
11744, 28194, 28195, 28218, 28217, 29144, 29190, 29191, 29188
11745, 28195, 28196, 28219, 28218, 29146, 29192, 29193, 29190
11746, 28196, 28197, 28220, 28219, 29148, 29194, 29195, 29192
11747, 28197, 28198, 28221, 28220, 29150, 29196, 29197, 29194
11748, 28198, 28199, 28222, 28221, 29152, 29198, 29199, 29196
11749, 28199, 28200, 28223, 28222, 29154, 29200, 29201, 29198
11750, 28200, 28201, 28224, 28223, 29156, 29202, 29203, 29200
11751, 28201, 28202, 28225, 28224, 29158, 29204, 29205, 29202
11752, 28202, 28203, 28226, 28225, 29160, 29206, 29207, 29204
11753, 28203, 28204, 28227, 28226, 29162, 29208, 29209, 29206
11754, 28204, 28205, 28228, 28227, 29164, 29210, 29211, 29208
11755, 28205, 28206, 28229, 28228, 29166, 29212, 29213, 29210
11756, 28206, 2855, 2856, 28229, 29167, 2879, 29214, 29212
11757, 2809, 28207, 28230, 2810, 29169, 29215, 29216, 2833
11758, 28207, 28208, 28231, 28230, 29171, 29217, 29218, 29215
11759, 28208, 28209, 28232, 28231, 29173, 29219, 29220, 29217
11760, 28209, 28210, 28233, 28232, 29175, 29221, 29222, 29219
11761, 28210, 28211, 28234, 28233, 29177, 29223, 29224, 29221
11762, 28211, 28212, 28235, 28234, 29179, 29225, 29226, 29223
11763, 28212, 28213, 28236, 28235, 29181, 29227, 29228, 29225
11764, 28213, 28214, 28237, 28236, 29183, 29229, 29230, 29227
11765, 28214, 28215, 28238, 28237, 29185, 29231, 29232, 29229
11766, 28215, 28216, 28239, 28238, 29187, 29233, 29234, 29231
11767, 28216, 28217, 28240, 28239, 29189, 29235, 29236, 29233
11768, 28217, 28218, 28241, 28240, 29191, 29237, 29238, 29235
11769, 28218, 28219, 28242, 28241, 29193, 29239, 29240, 29237
11770, 28219, 28220, 28243, 28242, 29195, 29241, 29242, 29239
11771, 28220, 28221, 28244, 28243, 29197, 29243, 29244, 29241
11772, 28221, 28222, 28245, 28244, 29199, 29245, 29246, 29243
11773, 28222, 28223, 28246, 28245, 29201, 29247, 29248, 29245
11774, 28223, 28224, 28247, 28246, 29203, 29249, 29250, 29247
11775, 28224, 28225, 28248, 28247, 29205, 29251, 29252, 29249
11776, 28225, 28226, 28249, 28248, 29207, 29253, 29254, 29251
11777, 28226, 28227, 28250, 28249, 29209, 29255, 29256, 29253
11778, 28227, 28228, 28251, 28250, 29211, 29257, 29258, 29255
11779, 28228, 28229, 28252, 28251, 29213, 29259, 29260, 29257
11780, 28229, 2856, 2857, 28252, 29214, 2880, 29261, 29259
11781, 2810, 28230, 28253, 2811, 29216, 29262, 29263, 2834
11782, 28230, 28231, 28254, 28253, 29218, 29264, 29265, 29262
11783, 28231, 28232, 28255, 28254, 29220, 29266, 29267, 29264
11784, 28232, 28233, 28256, 28255, 29222, 29268, 29269, 29266
11785, 28233, 28234, 28257, 28256, 29224, 29270, 29271, 29268
11786, 28234, 28235, 28258, 28257, 29226, 29272, 29273, 29270
11787, 28235, 28236, 28259, 28258, 29228, 29274, 29275, 29272
11788, 28236, 28237, 28260, 28259, 29230, 29276, 29277, 29274
11789, 28237, 28238, 28261, 28260, 29232, 29278, 29279, 29276
11790, 28238, 28239, 28262, 28261, 29234, 29280, 29281, 29278
11791, 28239, 28240, 28263, 28262, 29236, 29282, 29283, 29280
11792, 28240, 28241, 28264, 28263, 29238, 29284, 29285, 29282
11793, 28241, 28242, 28265, 28264, 29240, 29286, 29287, 29284
11794, 28242, 28243, 28266, 28265, 29242, 29288, 29289, 29286
11795, 28243, 28244, 28267, 28266, 29244, 29290, 29291, 29288
11796, 28244, 28245, 28268, 28267, 29246, 29292, 29293, 29290
11797, 28245, 28246, 28269, 28268, 29248, 29294, 29295, 29292
11798, 28246, 28247, 28270, 28269, 29250, 29296, 29297, 29294
11799, 28247, 28248, 28271, 28270, 29252, 29298, 29299, 29296
11800, 28248, 28249, 28272, 28271, 29254, 29300, 29301, 29298
11801, 28249, 28250, 28273, 28272, 29256, 29302, 29303, 29300
11802, 28250, 28251, 28274, 28273, 29258, 29304, 29305, 29302
11803, 28251, 28252, 28275, 28274, 29260, 29306, 29307, 29304
11804, 28252, 2857, 2858, 28275, 29261, 2881, 29308, 29306
11805, 2811, 28253, 28276, 2812, 29263, 29309, 29310, 2835
11806, 28253, 28254, 28277, 28276, 29265, 29311, 29312, 29309
11807, 28254, 28255, 28278, 28277, 29267, 29313, 29314, 29311
11808, 28255, 28256, 28279, 28278, 29269, 29315, 29316, 29313
11809, 28256, 28257, 28280, 28279, 29271, 29317, 29318, 29315
11810, 28257, 28258, 28281, 28280, 29273, 29319, 29320, 29317
11811, 28258, 28259, 28282, 28281, 29275, 29321, 29322, 29319
11812, 28259, 28260, 28283, 28282, 29277, 29323, 29324, 29321
11813, 28260, 28261, 28284, 28283, 29279, 29325, 29326, 29323
11814, 28261, 28262, 28285, 28284, 29281, 29327, 29328, 29325
11815, 28262, 28263, 28286, 28285, 29283, 29329, 29330, 29327
11816, 28263, 28264, 28287, 28286, 29285, 29331, 29332, 29329
11817, 28264, 28265, 28288, 28287, 29287, 29333, 29334, 29331
11818, 28265, 28266, 28289, 28288, 29289, 29335, 29336, 29333
11819, 28266, 28267, 28290, 28289, 29291, 29337, 29338, 29335
11820, 28267, 28268, 28291, 28290, 29293, 29339, 29340, 29337
11821, 28268, 28269, 28292, 28291, 29295, 29341, 29342, 29339
11822, 28269, 28270, 28293, 28292, 29297, 29343, 29344, 29341
11823, 28270, 28271, 28294, 28293, 29299, 29345, 29346, 29343
11824, 28271, 28272, 28295, 28294, 29301, 29347, 29348, 29345
11825, 28272, 28273, 28296, 28295, 29303, 29349, 29350, 29347
11826, 28273, 28274, 28297, 28296, 29305, 29351, 29352, 29349
11827, 28274, 28275, 28298, 28297, 29307, 29353, 29354, 29351
11828, 28275, 2858, 2859, 28298, 29308, 2882, 29355, 29353
11829, 2812, 28276, 28299, 2813, 29310, 29356, 29357, 2836
11830, 28276, 28277, 28300, 28299, 29312, 29358, 29359, 29356
11831, 28277, 28278, 28301, 28300, 29314, 29360, 29361, 29358
11832, 28278, 28279, 28302, 28301, 29316, 29362, 29363, 29360
11833, 28279, 28280, 28303, 28302, 29318, 29364, 29365, 29362
11834, 28280, 28281, 28304, 28303, 29320, 29366, 29367, 29364
11835, 28281, 28282, 28305, 28304, 29322, 29368, 29369, 29366
11836, 28282, 28283, 28306, 28305, 29324, 29370, 29371, 29368
11837, 28283, 28284, 28307, 28306, 29326, 29372, 29373, 29370
11838, 28284, 28285, 28308, 28307, 29328, 29374, 29375, 29372
11839, 28285, 28286, 28309, 28308, 29330, 29376, 29377, 29374
11840, 28286, 28287, 28310, 28309, 29332, 29378, 29379, 29376
11841, 28287, 28288, 28311, 28310, 29334, 29380, 29381, 29378
11842, 28288, 28289, 28312, 28311, 29336, 29382, 29383, 29380
11843, 28289, 28290, 28313, 28312, 29338, 29384, 29385, 29382
11844, 28290, 28291, 28314, 28313, 29340, 29386, 29387, 29384
11845, 28291, 28292, 28315, 28314, 29342, 29388, 29389, 29386
11846, 28292, 28293, 28316, 28315, 29344, 29390, 29391, 29388
11847, 28293, 28294, 28317, 28316, 29346, 29392, 29393, 29390
11848, 28294, 28295, 28318, 28317, 29348, 29394, 29395, 29392
11849, 28295, 28296, 28319, 28318, 29350, 29396, 29397, 29394
11850, 28296, 28297, 28320, 28319, 29352, 29398, 29399, 29396
11851, 28297, 28298, 28321, 28320, 29354, 29400, 29401, 29398
11852, 28298, 2859, 2860, 28321, 29355, 2883, 29402, 29400
11853, 2813, 28299, 2695, 65, 29357, 29403, 2718, 2837
11854, 28299, 28300, 2696, 2695, 29359, 29404, 2719, 29403
11855, 28300, 28301, 2697, 2696, 29361, 29405, 2720, 29404
11856, 28301, 28302, 2698, 2697, 29363, 29406, 2721, 29405
11857, 28302, 28303, 2699, 2698, 29365, 29407, 2722, 29406
11858, 28303, 28304, 2700, 2699, 29367, 29408, 2723, 29407
11859, 28304, 28305, 2701, 2700, 29369, 29409, 2724, 29408
11860, 28305, 28306, 2702, 2701, 29371, 29410, 2725, 29409
11861, 28306, 28307, 2703, 2702, 29373, 29411, 2726, 29410
11862, 28307, 28308, 2704, 2703, 29375, 29412, 2727, 29411
11863, 28308, 28309, 2705, 2704, 29377, 29413, 2728, 29412
11864, 28309, 28310, 2706, 2705, 29379, 29414, 2729, 29413
11865, 28310, 28311, 2707, 2706, 29381, 29415, 2730, 29414
11866, 28311, 28312, 2708, 2707, 29383, 29416, 2731, 29415
11867, 28312, 28313, 2709, 2708, 29385, 29417, 2732, 29416
11868, 28313, 28314, 2710, 2709, 29387, 29418, 2733, 29417
11869, 28314, 28315, 2711, 2710, 29389, 29419, 2734, 29418
11870, 28315, 28316, 2712, 2711, 29391, 29420, 2735, 29419
11871, 28316, 28317, 2713, 2712, 29393, 29421, 2736, 29420
11872, 28317, 28318, 2714, 2713, 29395, 29422, 2737, 29421
11873, 28318, 28319, 2715, 2714, 29397, 29423, 2738, 29422
11874, 28319, 28320, 2716, 2715, 29399, 29424, 2739, 29423
11875, 28320, 28321, 2717, 2716, 29401, 29425, 2740, 29424
11876, 28321, 2860, 66, 2717, 29402, 2884, 2741, 29425
*ELEMENT, type=CPS8, ELSET=Surface92
11877, 35, 69, 2887, 1794, 2885, 2910, 29426, 1817
11878, 1794, 2887, 2888, 1795, 29426, 2911, 29427, 1818
11879, 1795, 2888, 2889, 1796, 29427, 2912, 29428, 1819
11880, 1796, 2889, 2890, 1797, 29428, 2913, 29429, 1820
11881, 1797, 2890, 2891, 1798, 29429, 2914, 29430, 1821
11882, 1798, 2891, 2892, 1799, 29430, 2915, 29431, 1822
11883, 1799, 2892, 2893, 1800, 29431, 2916, 29432, 1823
11884, 1800, 2893, 2894, 1801, 29432, 2917, 29433, 1824
11885, 1801, 2894, 2895, 1802, 29433, 2918, 29434, 1825
11886, 1802, 2895, 2896, 1803, 29434, 2919, 29435, 1826
11887, 1803, 2896, 2897, 1804, 29435, 2920, 29436, 1827
11888, 1804, 2897, 2898, 1805, 29436, 2921, 29437, 1828
11889, 1805, 2898, 2899, 1806, 29437, 2922, 29438, 1829
11890, 1806, 2899, 2900, 1807, 29438, 2923, 29439, 1830
11891, 1807, 2900, 2901, 1808, 29439, 2924, 29440, 1831
11892, 1808, 2901, 2902, 1809, 29440, 2925, 29441, 1832
11893, 1809, 2902, 2903, 1810, 29441, 2926, 29442, 1833
11894, 1810, 2903, 2904, 1811, 29442, 2927, 29443, 1834
11895, 1811, 2904, 2905, 1812, 29443, 2928, 29444, 1835
11896, 1812, 2905, 2906, 1813, 29444, 2929, 29445, 1836
11897, 1813, 2906, 2907, 1814, 29445, 2930, 29446, 1837
11898, 1814, 2907, 2908, 1815, 29446, 2931, 29447, 1838
11899, 1815, 2908, 2909, 1816, 29447, 2932, 29448, 1839
11900, 1816, 2909, 70, 39, 29448, 2933, 2886, 1840
*ELEMENT, type=CPS8, ELSET=Surface93
11901, 36, 1841, 2936, 71, 1864, 29449, 2959, 2934
11902, 1841, 1842, 2937, 2936, 1865, 29450, 2960, 29449
11903, 1842, 1843, 2938, 2937, 1866, 29451, 2961, 29450
11904, 1843, 1844, 2939, 2938, 1867, 29452, 2962, 29451
11905, 1844, 1845, 2940, 2939, 1868, 29453, 2963, 29452
11906, 1845, 1846, 2941, 2940, 1869, 29454, 2964, 29453
11907, 1846, 1847, 2942, 2941, 1870, 29455, 2965, 29454
11908, 1847, 1848, 2943, 2942, 1871, 29456, 2966, 29455
11909, 1848, 1849, 2944, 2943, 1872, 29457, 2967, 29456
11910, 1849, 1850, 2945, 2944, 1873, 29458, 2968, 29457
11911, 1850, 1851, 2946, 2945, 1874, 29459, 2969, 29458
11912, 1851, 1852, 2947, 2946, 1875, 29460, 2970, 29459
11913, 1852, 1853, 2948, 2947, 1876, 29461, 2971, 29460
11914, 1853, 1854, 2949, 2948, 1877, 29462, 2972, 29461
11915, 1854, 1855, 2950, 2949, 1878, 29463, 2973, 29462
11916, 1855, 1856, 2951, 2950, 1879, 29464, 2974, 29463
11917, 1856, 1857, 2952, 2951, 1880, 29465, 2975, 29464
11918, 1857, 1858, 2953, 2952, 1881, 29466, 2976, 29465
11919, 1858, 1859, 2954, 2953, 1882, 29467, 2977, 29466
11920, 1859, 1860, 2955, 2954, 1883, 29468, 2978, 29467
11921, 1860, 1861, 2956, 2955, 1884, 29469, 2979, 29468
11922, 1861, 1862, 2957, 2956, 1885, 29470, 2980, 29469
11923, 1862, 1863, 2958, 2957, 1886, 29471, 2981, 29470
11924, 1863, 40, 72, 2958, 1887, 2935, 2982, 29471
*ELEMENT, type=CPS8, ELSET=Surface94
11925, 35, 1560, 2983, 69, 1583, 29472, 3006, 2885
11926, 1560, 1561, 2984, 2983, 1584, 29473, 3007, 29472
11927, 1561, 1562, 2985, 2984, 1585, 29474, 3008, 29473
11928, 1562, 1563, 2986, 2985, 1586, 29475, 3009, 29474
11929, 1563, 1564, 2987, 2986, 1587, 29476, 3010, 29475
11930, 1564, 1565, 2988, 2987, 1588, 29477, 3011, 29476
11931, 1565, 1566, 2989, 2988, 1589, 29478, 3012, 29477
11932, 1566, 1567, 2990, 2989, 1590, 29479, 3013, 29478
11933, 1567, 1568, 2991, 2990, 1591, 29480, 3014, 29479
11934, 1568, 1569, 2992, 2991, 1592, 29481, 3015, 29480
11935, 1569, 1570, 2993, 2992, 1593, 29482, 3016, 29481
11936, 1570, 1571, 2994, 2993, 1594, 29483, 3017, 29482
11937, 1571, 1572, 2995, 2994, 1595, 29484, 3018, 29483
11938, 1572, 1573, 2996, 2995, 1596, 29485, 3019, 29484
11939, 1573, 1574, 2997, 2996, 1597, 29486, 3020, 29485
11940, 1574, 1575, 2998, 2997, 1598, 29487, 3021, 29486
11941, 1575, 1576, 2999, 2998, 1599, 29488, 3022, 29487
11942, 1576, 1577, 3000, 2999, 1600, 29489, 3023, 29488
11943, 1577, 1578, 3001, 3000, 1601, 29490, 3024, 29489
11944, 1578, 1579, 3002, 3001, 1602, 29491, 3025, 29490
11945, 1579, 1580, 3003, 3002, 1603, 29492, 3026, 29491
11946, 1580, 1581, 3004, 3003, 1604, 29493, 3027, 29492
11947, 1581, 1582, 3005, 3004, 1605, 29494, 3028, 29493
11948, 1582, 36, 71, 3005, 1606, 2934, 3029, 29494
*ELEMENT, type=CPS8, ELSET=Surface95
11949, 39, 70, 3030, 1888, 2886, 3053, 29495, 1911
11950, 1888, 3030, 3031, 1889, 29495, 3054, 29496, 1912
11951, 1889, 3031, 3032, 1890, 29496, 3055, 29497, 1913
11952, 1890, 3032, 3033, 1891, 29497, 3056, 29498, 1914
11953, 1891, 3033, 3034, 1892, 29498, 3057, 29499, 1915
11954, 1892, 3034, 3035, 1893, 29499, 3058, 29500, 1916
11955, 1893, 3035, 3036, 1894, 29500, 3059, 29501, 1917
11956, 1894, 3036, 3037, 1895, 29501, 3060, 29502, 1918
11957, 1895, 3037, 3038, 1896, 29502, 3061, 29503, 1919
11958, 1896, 3038, 3039, 1897, 29503, 3062, 29504, 1920
11959, 1897, 3039, 3040, 1898, 29504, 3063, 29505, 1921
11960, 1898, 3040, 3041, 1899, 29505, 3064, 29506, 1922
11961, 1899, 3041, 3042, 1900, 29506, 3065, 29507, 1923
11962, 1900, 3042, 3043, 1901, 29507, 3066, 29508, 1924
11963, 1901, 3043, 3044, 1902, 29508, 3067, 29509, 1925
11964, 1902, 3044, 3045, 1903, 29509, 3068, 29510, 1926
11965, 1903, 3045, 3046, 1904, 29510, 3069, 29511, 1927
11966, 1904, 3046, 3047, 1905, 29511, 3070, 29512, 1928
11967, 1905, 3047, 3048, 1906, 29512, 3071, 29513, 1929
11968, 1906, 3048, 3049, 1907, 29513, 3072, 29514, 1930
11969, 1907, 3049, 3050, 1908, 29514, 3073, 29515, 1931
11970, 1908, 3050, 3051, 1909, 29515, 3074, 29516, 1932
11971, 1909, 3051, 3052, 1910, 29516, 3075, 29517, 1933
11972, 1910, 3052, 72, 40, 29517, 3076, 2935, 1934
*ELEMENT, type=CPS8, ELSET=Surface96
11973, 69, 2983, 29518, 2887, 3006, 30047, 30048, 2910
11974, 2887, 29518, 29519, 2888, 30048, 30049, 30050, 2911
11975, 2888, 29519, 29520, 2889, 30050, 30051, 30052, 2912
11976, 2889, 29520, 29521, 2890, 30052, 30053, 30054, 2913
11977, 2890, 29521, 29522, 2891, 30054, 30055, 30056, 2914
11978, 2891, 29522, 29523, 2892, 30056, 30057, 30058, 2915
11979, 2892, 29523, 29524, 2893, 30058, 30059, 30060, 2916
11980, 2893, 29524, 29525, 2894, 30060, 30061, 30062, 2917
11981, 2894, 29525, 29526, 2895, 30062, 30063, 30064, 2918
11982, 2895, 29526, 29527, 2896, 30064, 30065, 30066, 2919
11983, 2896, 29527, 29528, 2897, 30066, 30067, 30068, 2920
11984, 2897, 29528, 29529, 2898, 30068, 30069, 30070, 2921
11985, 2898, 29529, 29530, 2899, 30070, 30071, 30072, 2922
11986, 2899, 29530, 29531, 2900, 30072, 30073, 30074, 2923
11987, 2900, 29531, 29532, 2901, 30074, 30075, 30076, 2924
11988, 2901, 29532, 29533, 2902, 30076, 30077, 30078, 2925
11989, 2902, 29533, 29534, 2903, 30078, 30079, 30080, 2926
11990, 2903, 29534, 29535, 2904, 30080, 30081, 30082, 2927
11991, 2904, 29535, 29536, 2905, 30082, 30083, 30084, 2928
11992, 2905, 29536, 29537, 2906, 30084, 30085, 30086, 2929
11993, 2906, 29537, 29538, 2907, 30086, 30087, 30088, 2930
11994, 2907, 29538, 29539, 2908, 30088, 30089, 30090, 2931
11995, 2908, 29539, 29540, 2909, 30090, 30091, 30092, 2932
11996, 2909, 29540, 3030, 70, 30092, 30093, 3053, 2933
11997, 2983, 2984, 29541, 29518, 3007, 30094, 30095, 30047
11998, 29518, 29541, 29542, 29519, 30095, 30096, 30097, 30049
11999, 29519, 29542, 29543, 29520, 30097, 30098, 30099, 30051
12000, 29520, 29543, 29544, 29521, 30099, 30100, 30101, 30053
12001, 29521, 29544, 29545, 29522, 30101, 30102, 30103, 30055
12002, 29522, 29545, 29546, 29523, 30103, 30104, 30105, 30057
12003, 29523, 29546, 29547, 29524, 30105, 30106, 30107, 30059
12004, 29524, 29547, 29548, 29525, 30107, 30108, 30109, 30061
12005, 29525, 29548, 29549, 29526, 30109, 30110, 30111, 30063
12006, 29526, 29549, 29550, 29527, 30111, 30112, 30113, 30065
12007, 29527, 29550, 29551, 29528, 30113, 30114, 30115, 30067
12008, 29528, 29551, 29552, 29529, 30115, 30116, 30117, 30069
12009, 29529, 29552, 29553, 29530, 30117, 30118, 30119, 30071
12010, 29530, 29553, 29554, 29531, 30119, 30120, 30121, 30073
12011, 29531, 29554, 29555, 29532, 30121, 30122, 30123, 30075
12012, 29532, 29555, 29556, 29533, 30123, 30124, 30125, 30077
12013, 29533, 29556, 29557, 29534, 30125, 30126, 30127, 30079
12014, 29534, 29557, 29558, 29535, 30127, 30128, 30129, 30081
12015, 29535, 29558, 29559, 29536, 30129, 30130, 30131, 30083
12016, 29536, 29559, 29560, 29537, 30131, 30132, 30133, 30085
12017, 29537, 29560, 29561, 29538, 30133, 30134, 30135, 30087
12018, 29538, 29561, 29562, 29539, 30135, 30136, 30137, 30089
12019, 29539, 29562, 29563, 29540, 30137, 30138, 30139, 30091
12020, 29540, 29563, 3031, 3030, 30139, 30140, 3054, 30093
12021, 2984, 2985, 29564, 29541, 3008, 30141, 30142, 30094
12022, 29541, 29564, 29565, 29542, 30142, 30143, 30144, 30096
12023, 29542, 29565, 29566, 29543, 30144, 30145, 30146, 30098
12024, 29543, 29566, 29567, 29544, 30146, 30147, 30148, 30100
12025, 29544, 29567, 29568, 29545, 30148, 30149, 30150, 30102
12026, 29545, 29568, 29569, 29546, 30150, 30151, 30152, 30104
12027, 29546, 29569, 29570, 29547, 30152, 30153, 30154, 30106
12028, 29547, 29570, 29571, 29548, 30154, 30155, 30156, 30108
12029, 29548, 29571, 29572, 29549, 30156, 30157, 30158, 30110
12030, 29549, 29572, 29573, 29550, 30158, 30159, 30160, 30112
12031, 29550, 29573, 29574, 29551, 30160, 30161, 30162, 30114
12032, 29551, 29574, 29575, 29552, 30162, 30163, 30164, 30116
12033, 29552, 29575, 29576, 29553, 30164, 30165, 30166, 30118
12034, 29553, 29576, 29577, 29554, 30166, 30167, 30168, 30120
12035, 29554, 29577, 29578, 29555, 30168, 30169, 30170, 30122
12036, 29555, 29578, 29579, 29556, 30170, 30171, 30172, 30124
12037, 29556, 29579, 29580, 29557, 30172, 30173, 30174, 30126
12038, 29557, 29580, 29581, 29558, 30174, 30175, 30176, 30128
12039, 29558, 29581, 29582, 29559, 30176, 30177, 30178, 30130
12040, 29559, 29582, 29583, 29560, 30178, 30179, 30180, 30132
12041, 29560, 29583, 29584, 29561, 30180, 30181, 30182, 30134
12042, 29561, 29584, 29585, 29562, 30182, 30183, 30184, 30136
12043, 29562, 29585, 29586, 29563, 30184, 30185, 30186, 30138
12044, 29563, 29586, 3032, 3031, 30186, 30187, 3055, 30140
12045, 2985, 2986, 29587, 29564, 3009, 30188, 30189, 30141
12046, 29564, 29587, 29588, 29565, 30189, 30190, 30191, 30143
12047, 29565, 29588, 29589, 29566, 30191, 30192, 30193, 30145
12048, 29566, 29589, 29590, 29567, 30193, 30194, 30195, 30147
12049, 29567, 29590, 29591, 29568, 30195, 30196, 30197, 30149
12050, 29568, 29591, 29592, 29569, 30197, 30198, 30199, 30151
12051, 29569, 29592, 29593, 29570, 30199, 30200, 30201, 30153
12052, 29570, 29593, 29594, 29571, 30201, 30202, 30203, 30155
12053, 29571, 29594, 29595, 29572, 30203, 30204, 30205, 30157
12054, 29572, 29595, 29596, 29573, 30205, 30206, 30207, 30159
12055, 29573, 29596, 29597, 29574, 30207, 30208, 30209, 30161
12056, 29574, 29597, 29598, 29575, 30209, 30210, 30211, 30163
12057, 29575, 29598, 29599, 29576, 30211, 30212, 30213, 30165
12058, 29576, 29599, 29600, 29577, 30213, 30214, 30215, 30167
12059, 29577, 29600, 29601, 29578, 30215, 30216, 30217, 30169
12060, 29578, 29601, 29602, 29579, 30217, 30218, 30219, 30171
12061, 29579, 29602, 29603, 29580, 30219, 30220, 30221, 30173
12062, 29580, 29603, 29604, 29581, 30221, 30222, 30223, 30175
12063, 29581, 29604, 29605, 29582, 30223, 30224, 30225, 30177
12064, 29582, 29605, 29606, 29583, 30225, 30226, 30227, 30179
12065, 29583, 29606, 29607, 29584, 30227, 30228, 30229, 30181
12066, 29584, 29607, 29608, 29585, 30229, 30230, 30231, 30183
12067, 29585, 29608, 29609, 29586, 30231, 30232, 30233, 30185
12068, 29586, 29609, 3033, 3032, 30233, 30234, 3056, 30187
12069, 2986, 2987, 29610, 29587, 3010, 30235, 30236, 30188
12070, 29587, 29610, 29611, 29588, 30236, 30237, 30238, 30190
12071, 29588, 29611, 29612, 29589, 30238, 30239, 30240, 30192
12072, 29589, 29612, 29613, 29590, 30240, 30241, 30242, 30194
12073, 29590, 29613, 29614, 29591, 30242, 30243, 30244, 30196
12074, 29591, 29614, 29615, 29592, 30244, 30245, 30246, 30198
12075, 29592, 29615, 29616, 29593, 30246, 30247, 30248, 30200
12076, 29593, 29616, 29617, 29594, 30248, 30249, 30250, 30202
12077, 29594, 29617, 29618, 29595, 30250, 30251, 30252, 30204
12078, 29595, 29618, 29619, 29596, 30252, 30253, 30254, 30206
12079, 29596, 29619, 29620, 29597, 30254, 30255, 30256, 30208
12080, 29597, 29620, 29621, 29598, 30256, 30257, 30258, 30210
12081, 29598, 29621, 29622, 29599, 30258, 30259, 30260, 30212
12082, 29599, 29622, 29623, 29600, 30260, 30261, 30262, 30214
12083, 29600, 29623, 29624, 29601, 30262, 30263, 30264, 30216
12084, 29601, 29624, 29625, 29602, 30264, 30265, 30266, 30218
12085, 29602, 29625, 29626, 29603, 30266, 30267, 30268, 30220
12086, 29603, 29626, 29627, 29604, 30268, 30269, 30270, 30222
12087, 29604, 29627, 29628, 29605, 30270, 30271, 30272, 30224
12088, 29605, 29628, 29629, 29606, 30272, 30273, 30274, 30226
12089, 29606, 29629, 29630, 29607, 30274, 30275, 30276, 30228
12090, 29607, 29630, 29631, 29608, 30276, 30277, 30278, 30230
12091, 29608, 29631, 29632, 29609, 30278, 30279, 30280, 30232
12092, 29609, 29632, 3034, 3033, 30280, 30281, 3057, 30234
12093, 2987, 2988, 29633, 29610, 3011, 30282, 30283, 30235
12094, 29610, 29633, 29634, 29611, 30283, 30284, 30285, 30237
12095, 29611, 29634, 29635, 29612, 30285, 30286, 30287, 30239
12096, 29612, 29635, 29636, 29613, 30287, 30288, 30289, 30241
12097, 29613, 29636, 29637, 29614, 30289, 30290, 30291, 30243
12098, 29614, 29637, 29638, 29615, 30291, 30292, 30293, 30245
12099, 29615, 29638, 29639, 29616, 30293, 30294, 30295, 30247
12100, 29616, 29639, 29640, 29617, 30295, 30296, 30297, 30249
12101, 29617, 29640, 29641, 29618, 30297, 30298, 30299, 30251
12102, 29618, 29641, 29642, 29619, 30299, 30300, 30301, 30253
12103, 29619, 29642, 29643, 29620, 30301, 30302, 30303, 30255
12104, 29620, 29643, 29644, 29621, 30303, 30304, 30305, 30257
12105, 29621, 29644, 29645, 29622, 30305, 30306, 30307, 30259
12106, 29622, 29645, 29646, 29623, 30307, 30308, 30309, 30261
12107, 29623, 29646, 29647, 29624, 30309, 30310, 30311, 30263
12108, 29624, 29647, 29648, 29625, 30311, 30312, 30313, 30265
12109, 29625, 29648, 29649, 29626, 30313, 30314, 30315, 30267
12110, 29626, 29649, 29650, 29627, 30315, 30316, 30317, 30269
12111, 29627, 29650, 29651, 29628, 30317, 30318, 30319, 30271
12112, 29628, 29651, 29652, 29629, 30319, 30320, 30321, 30273
12113, 29629, 29652, 29653, 29630, 30321, 30322, 30323, 30275
12114, 29630, 29653, 29654, 29631, 30323, 30324, 30325, 30277
12115, 29631, 29654, 29655, 29632, 30325, 30326, 30327, 30279
12116, 29632, 29655, 3035, 3034, 30327, 30328, 3058, 30281
12117, 2988, 2989, 29656, 29633, 3012, 30329, 30330, 30282
12118, 29633, 29656, 29657, 29634, 30330, 30331, 30332, 30284
12119, 29634, 29657, 29658, 29635, 30332, 30333, 30334, 30286
12120, 29635, 29658, 29659, 29636, 30334, 30335, 30336, 30288
12121, 29636, 29659, 29660, 29637, 30336, 30337, 30338, 30290
12122, 29637, 29660, 29661, 29638, 30338, 30339, 30340, 30292
12123, 29638, 29661, 29662, 29639, 30340, 30341, 30342, 30294
12124, 29639, 29662, 29663, 29640, 30342, 30343, 30344, 30296
12125, 29640, 29663, 29664, 29641, 30344, 30345, 30346, 30298
12126, 29641, 29664, 29665, 29642, 30346, 30347, 30348, 30300
12127, 29642, 29665, 29666, 29643, 30348, 30349, 30350, 30302
12128, 29643, 29666, 29667, 29644, 30350, 30351, 30352, 30304
12129, 29644, 29667, 29668, 29645, 30352, 30353, 30354, 30306
12130, 29645, 29668, 29669, 29646, 30354, 30355, 30356, 30308
12131, 29646, 29669, 29670, 29647, 30356, 30357, 30358, 30310
12132, 29647, 29670, 29671, 29648, 30358, 30359, 30360, 30312
12133, 29648, 29671, 29672, 29649, 30360, 30361, 30362, 30314
12134, 29649, 29672, 29673, 29650, 30362, 30363, 30364, 30316
12135, 29650, 29673, 29674, 29651, 30364, 30365, 30366, 30318
12136, 29651, 29674, 29675, 29652, 30366, 30367, 30368, 30320
12137, 29652, 29675, 29676, 29653, 30368, 30369, 30370, 30322
12138, 29653, 29676, 29677, 29654, 30370, 30371, 30372, 30324
12139, 29654, 29677, 29678, 29655, 30372, 30373, 30374, 30326
12140, 29655, 29678, 3036, 3035, 30374, 30375, 3059, 30328
12141, 2989, 2990, 29679, 29656, 3013, 30376, 30377, 30329
12142, 29656, 29679, 29680, 29657, 30377, 30378, 30379, 30331
12143, 29657, 29680, 29681, 29658, 30379, 30380, 30381, 30333
12144, 29658, 29681, 29682, 29659, 30381, 30382, 30383, 30335
12145, 29659, 29682, 29683, 29660, 30383, 30384, 30385, 30337
12146, 29660, 29683, 29684, 29661, 30385, 30386, 30387, 30339
12147, 29661, 29684, 29685, 29662, 30387, 30388, 30389, 30341
12148, 29662, 29685, 29686, 29663, 30389, 30390, 30391, 30343
12149, 29663, 29686, 29687, 29664, 30391, 30392, 30393, 30345
12150, 29664, 29687, 29688, 29665, 30393, 30394, 30395, 30347
12151, 29665, 29688, 29689, 29666, 30395, 30396, 30397, 30349
12152, 29666, 29689, 29690, 29667, 30397, 30398, 30399, 30351
12153, 29667, 29690, 29691, 29668, 30399, 30400, 30401, 30353
12154, 29668, 29691, 29692, 29669, 30401, 30402, 30403, 30355
12155, 29669, 29692, 29693, 29670, 30403, 30404, 30405, 30357
12156, 29670, 29693, 29694, 29671, 30405, 30406, 30407, 30359
12157, 29671, 29694, 29695, 29672, 30407, 30408, 30409, 30361
12158, 29672, 29695, 29696, 29673, 30409, 30410, 30411, 30363
12159, 29673, 29696, 29697, 29674, 30411, 30412, 30413, 30365
12160, 29674, 29697, 29698, 29675, 30413, 30414, 30415, 30367
12161, 29675, 29698, 29699, 29676, 30415, 30416, 30417, 30369
12162, 29676, 29699, 29700, 29677, 30417, 30418, 30419, 30371
12163, 29677, 29700, 29701, 29678, 30419, 30420, 30421, 30373
12164, 29678, 29701, 3037, 3036, 30421, 30422, 3060, 30375
12165, 2990, 2991, 29702, 29679, 3014, 30423, 30424, 30376
12166, 29679, 29702, 29703, 29680, 30424, 30425, 30426, 30378
12167, 29680, 29703, 29704, 29681, 30426, 30427, 30428, 30380
12168, 29681, 29704, 29705, 29682, 30428, 30429, 30430, 30382
12169, 29682, 29705, 29706, 29683, 30430, 30431, 30432, 30384
12170, 29683, 29706, 29707, 29684, 30432, 30433, 30434, 30386
12171, 29684, 29707, 29708, 29685, 30434, 30435, 30436, 30388
12172, 29685, 29708, 29709, 29686, 30436, 30437, 30438, 30390
12173, 29686, 29709, 29710, 29687, 30438, 30439, 30440, 30392
12174, 29687, 29710, 29711, 29688, 30440, 30441, 30442, 30394
12175, 29688, 29711, 29712, 29689, 30442, 30443, 30444, 30396
12176, 29689, 29712, 29713, 29690, 30444, 30445, 30446, 30398
12177, 29690, 29713, 29714, 29691, 30446, 30447, 30448, 30400
12178, 29691, 29714, 29715, 29692, 30448, 30449, 30450, 30402
12179, 29692, 29715, 29716, 29693, 30450, 30451, 30452, 30404
12180, 29693, 29716, 29717, 29694, 30452, 30453, 30454, 30406
12181, 29694, 29717, 29718, 29695, 30454, 30455, 30456, 30408
12182, 29695, 29718, 29719, 29696, 30456, 30457, 30458, 30410
12183, 29696, 29719, 29720, 29697, 30458, 30459, 30460, 30412
12184, 29697, 29720, 29721, 29698, 30460, 30461, 30462, 30414
12185, 29698, 29721, 29722, 29699, 30462, 30463, 30464, 30416
12186, 29699, 29722, 29723, 29700, 30464, 30465, 30466, 30418
12187, 29700, 29723, 29724, 29701, 30466, 30467, 30468, 30420
12188, 29701, 29724, 3038, 3037, 30468, 30469, 3061, 30422
12189, 2991, 2992, 29725, 29702, 3015, 30470, 30471, 30423
12190, 29702, 29725, 29726, 29703, 30471, 30472, 30473, 30425
12191, 29703, 29726, 29727, 29704, 30473, 30474, 30475, 30427
12192, 29704, 29727, 29728, 29705, 30475, 30476, 30477, 30429
12193, 29705, 29728, 29729, 29706, 30477, 30478, 30479, 30431
12194, 29706, 29729, 29730, 29707, 30479, 30480, 30481, 30433
12195, 29707, 29730, 29731, 29708, 30481, 30482, 30483, 30435
12196, 29708, 29731, 29732, 29709, 30483, 30484, 30485, 30437
12197, 29709, 29732, 29733, 29710, 30485, 30486, 30487, 30439
12198, 29710, 29733, 29734, 29711, 30487, 30488, 30489, 30441
12199, 29711, 29734, 29735, 29712, 30489, 30490, 30491, 30443
12200, 29712, 29735, 29736, 29713, 30491, 30492, 30493, 30445
12201, 29713, 29736, 29737, 29714, 30493, 30494, 30495, 30447
12202, 29714, 29737, 29738, 29715, 30495, 30496, 30497, 30449
12203, 29715, 29738, 29739, 29716, 30497, 30498, 30499, 30451
12204, 29716, 29739, 29740, 29717, 30499, 30500, 30501, 30453
12205, 29717, 29740, 29741, 29718, 30501, 30502, 30503, 30455
12206, 29718, 29741, 29742, 29719, 30503, 30504, 30505, 30457
12207, 29719, 29742, 29743, 29720, 30505, 30506, 30507, 30459
12208, 29720, 29743, 29744, 29721, 30507, 30508, 30509, 30461
12209, 29721, 29744, 29745, 29722, 30509, 30510, 30511, 30463
12210, 29722, 29745, 29746, 29723, 30511, 30512, 30513, 30465
12211, 29723, 29746, 29747, 29724, 30513, 30514, 30515, 30467
12212, 29724, 29747, 3039, 3038, 30515, 30516, 3062, 30469
12213, 2992, 2993, 29748, 29725, 3016, 30517, 30518, 30470
12214, 29725, 29748, 29749, 29726, 30518, 30519, 30520, 30472
12215, 29726, 29749, 29750, 29727, 30520, 30521, 30522, 30474
12216, 29727, 29750, 29751, 29728, 30522, 30523, 30524, 30476
12217, 29728, 29751, 29752, 29729, 30524, 30525, 30526, 30478
12218, 29729, 29752, 29753, 29730, 30526, 30527, 30528, 30480
12219, 29730, 29753, 29754, 29731, 30528, 30529, 30530, 30482
12220, 29731, 29754, 29755, 29732, 30530, 30531, 30532, 30484
12221, 29732, 29755, 29756, 29733, 30532, 30533, 30534, 30486
12222, 29733, 29756, 29757, 29734, 30534, 30535, 30536, 30488
12223, 29734, 29757, 29758, 29735, 30536, 30537, 30538, 30490
12224, 29735, 29758, 29759, 29736, 30538, 30539, 30540, 30492
12225, 29736, 29759, 29760, 29737, 30540, 30541, 30542, 30494
12226, 29737, 29760, 29761, 29738, 30542, 30543, 30544, 30496
12227, 29738, 29761, 29762, 29739, 30544, 30545, 30546, 30498
12228, 29739, 29762, 29763, 29740, 30546, 30547, 30548, 30500
12229, 29740, 29763, 29764, 29741, 30548, 30549, 30550, 30502
12230, 29741, 29764, 29765, 29742, 30550, 30551, 30552, 30504
12231, 29742, 29765, 29766, 29743, 30552, 30553, 30554, 30506
12232, 29743, 29766, 29767, 29744, 30554, 30555, 30556, 30508
12233, 29744, 29767, 29768, 29745, 30556, 30557, 30558, 30510
12234, 29745, 29768, 29769, 29746, 30558, 30559, 30560, 30512
12235, 29746, 29769, 29770, 29747, 30560, 30561, 30562, 30514
12236, 29747, 29770, 3040, 3039, 30562, 30563, 3063, 30516
12237, 2993, 2994, 29771, 29748, 3017, 30564, 30565, 30517
12238, 29748, 29771, 29772, 29749, 30565, 30566, 30567, 30519
12239, 29749, 29772, 29773, 29750, 30567, 30568, 30569, 30521
12240, 29750, 29773, 29774, 29751, 30569, 30570, 30571, 30523
12241, 29751, 29774, 29775, 29752, 30571, 30572, 30573, 30525
12242, 29752, 29775, 29776, 29753, 30573, 30574, 30575, 30527
12243, 29753, 29776, 29777, 29754, 30575, 30576, 30577, 30529
12244, 29754, 29777, 29778, 29755, 30577, 30578, 30579, 30531
12245, 29755, 29778, 29779, 29756, 30579, 30580, 30581, 30533
12246, 29756, 29779, 29780, 29757, 30581, 30582, 30583, 30535
12247, 29757, 29780, 29781, 29758, 30583, 30584, 30585, 30537
12248, 29758, 29781, 29782, 29759, 30585, 30586, 30587, 30539
12249, 29759, 29782, 29783, 29760, 30587, 30588, 30589, 30541
12250, 29760, 29783, 29784, 29761, 30589, 30590, 30591, 30543
12251, 29761, 29784, 29785, 29762, 30591, 30592, 30593, 30545
12252, 29762, 29785, 29786, 29763, 30593, 30594, 30595, 30547
12253, 29763, 29786, 29787, 29764, 30595, 30596, 30597, 30549
12254, 29764, 29787, 29788, 29765, 30597, 30598, 30599, 30551
12255, 29765, 29788, 29789, 29766, 30599, 30600, 30601, 30553
12256, 29766, 29789, 29790, 29767, 30601, 30602, 30603, 30555
12257, 29767, 29790, 29791, 29768, 30603, 30604, 30605, 30557
12258, 29768, 29791, 29792, 29769, 30605, 30606, 30607, 30559
12259, 29769, 29792, 29793, 29770, 30607, 30608, 30609, 30561
12260, 29770, 29793, 3041, 3040, 30609, 30610, 3064, 30563
12261, 2994, 2995, 29794, 29771, 3018, 30611, 30612, 30564
12262, 29771, 29794, 29795, 29772, 30612, 30613, 30614, 30566
12263, 29772, 29795, 29796, 29773, 30614, 30615, 30616, 30568
12264, 29773, 29796, 29797, 29774, 30616, 30617, 30618, 30570
12265, 29774, 29797, 29798, 29775, 30618, 30619, 30620, 30572
12266, 29775, 29798, 29799, 29776, 30620, 30621, 30622, 30574
12267, 29776, 29799, 29800, 29777, 30622, 30623, 30624, 30576
12268, 29777, 29800, 29801, 29778, 30624, 30625, 30626, 30578
12269, 29778, 29801, 29802, 29779, 30626, 30627, 30628, 30580
12270, 29779, 29802, 29803, 29780, 30628, 30629, 30630, 30582
12271, 29780, 29803, 29804, 29781, 30630, 30631, 30632, 30584
12272, 29781, 29804, 29805, 29782, 30632, 30633, 30634, 30586
12273, 29782, 29805, 29806, 29783, 30634, 30635, 30636, 30588
12274, 29783, 29806, 29807, 29784, 30636, 30637, 30638, 30590
12275, 29784, 29807, 29808, 29785, 30638, 30639, 30640, 30592
12276, 29785, 29808, 29809, 29786, 30640, 30641, 30642, 30594
12277, 29786, 29809, 29810, 29787, 30642, 30643, 30644, 30596
12278, 29787, 29810, 29811, 29788, 30644, 30645, 30646, 30598
12279, 29788, 29811, 29812, 29789, 30646, 30647, 30648, 30600
12280, 29789, 29812, 29813, 29790, 30648, 30649, 30650, 30602
12281, 29790, 29813, 29814, 29791, 30650, 30651, 30652, 30604
12282, 29791, 29814, 29815, 29792, 30652, 30653, 30654, 30606
12283, 29792, 29815, 29816, 29793, 30654, 30655, 30656, 30608
12284, 29793, 29816, 3042, 3041, 30656, 30657, 3065, 30610
12285, 2995, 2996, 29817, 29794, 3019, 30658, 30659, 30611
12286, 29794, 29817, 29818, 29795, 30659, 30660, 30661, 30613
12287, 29795, 29818, 29819, 29796, 30661, 30662, 30663, 30615
12288, 29796, 29819, 29820, 29797, 30663, 30664, 30665, 30617
12289, 29797, 29820, 29821, 29798, 30665, 30666, 30667, 30619
12290, 29798, 29821, 29822, 29799, 30667, 30668, 30669, 30621
12291, 29799, 29822, 29823, 29800, 30669, 30670, 30671, 30623
12292, 29800, 29823, 29824, 29801, 30671, 30672, 30673, 30625
12293, 29801, 29824, 29825, 29802, 30673, 30674, 30675, 30627
12294, 29802, 29825, 29826, 29803, 30675, 30676, 30677, 30629
12295, 29803, 29826, 29827, 29804, 30677, 30678, 30679, 30631
12296, 29804, 29827, 29828, 29805, 30679, 30680, 30681, 30633
12297, 29805, 29828, 29829, 29806, 30681, 30682, 30683, 30635
12298, 29806, 29829, 29830, 29807, 30683, 30684, 30685, 30637
12299, 29807, 29830, 29831, 29808, 30685, 30686, 30687, 30639
12300, 29808, 29831, 29832, 29809, 30687, 30688, 30689, 30641
12301, 29809, 29832, 29833, 29810, 30689, 30690, 30691, 30643
12302, 29810, 29833, 29834, 29811, 30691, 30692, 30693, 30645
12303, 29811, 29834, 29835, 29812, 30693, 30694, 30695, 30647
12304, 29812, 29835, 29836, 29813, 30695, 30696, 30697, 30649
12305, 29813, 29836, 29837, 29814, 30697, 30698, 30699, 30651
12306, 29814, 29837, 29838, 29815, 30699, 30700, 30701, 30653
12307, 29815, 29838, 29839, 29816, 30701, 30702, 30703, 30655
12308, 29816, 29839, 3043, 3042, 30703, 30704, 3066, 30657
12309, 2996, 2997, 29840, 29817, 3020, 30705, 30706, 30658
12310, 29817, 29840, 29841, 29818, 30706, 30707, 30708, 30660
12311, 29818, 29841, 29842, 29819, 30708, 30709, 30710, 30662
12312, 29819, 29842, 29843, 29820, 30710, 30711, 30712, 30664
12313, 29820, 29843, 29844, 29821, 30712, 30713, 30714, 30666
12314, 29821, 29844, 29845, 29822, 30714, 30715, 30716, 30668
12315, 29822, 29845, 29846, 29823, 30716, 30717, 30718, 30670
12316, 29823, 29846, 29847, 29824, 30718, 30719, 30720, 30672
12317, 29824, 29847, 29848, 29825, 30720, 30721, 30722, 30674
12318, 29825, 29848, 29849, 29826, 30722, 30723, 30724, 30676
12319, 29826, 29849, 29850, 29827, 30724, 30725, 30726, 30678
12320, 29827, 29850, 29851, 29828, 30726, 30727, 30728, 30680
12321, 29828, 29851, 29852, 29829, 30728, 30729, 30730, 30682
12322, 29829, 29852, 29853, 29830, 30730, 30731, 30732, 30684
12323, 29830, 29853, 29854, 29831, 30732, 30733, 30734, 30686
12324, 29831, 29854, 29855, 29832, 30734, 30735, 30736, 30688
12325, 29832, 29855, 29856, 29833, 30736, 30737, 30738, 30690
12326, 29833, 29856, 29857, 29834, 30738, 30739, 30740, 30692
12327, 29834, 29857, 29858, 29835, 30740, 30741, 30742, 30694
12328, 29835, 29858, 29859, 29836, 30742, 30743, 30744, 30696
12329, 29836, 29859, 29860, 29837, 30744, 30745, 30746, 30698
12330, 29837, 29860, 29861, 29838, 30746, 30747, 30748, 30700
12331, 29838, 29861, 29862, 29839, 30748, 30749, 30750, 30702
12332, 29839, 29862, 3044, 3043, 30750, 30751, 3067, 30704
12333, 2997, 2998, 29863, 29840, 3021, 30752, 30753, 30705
12334, 29840, 29863, 29864, 29841, 30753, 30754, 30755, 30707
12335, 29841, 29864, 29865, 29842, 30755, 30756, 30757, 30709
12336, 29842, 29865, 29866, 29843, 30757, 30758, 30759, 30711
12337, 29843, 29866, 29867, 29844, 30759, 30760, 30761, 30713
12338, 29844, 29867, 29868, 29845, 30761, 30762, 30763, 30715
12339, 29845, 29868, 29869, 29846, 30763, 30764, 30765, 30717
12340, 29846, 29869, 29870, 29847, 30765, 30766, 30767, 30719
12341, 29847, 29870, 29871, 29848, 30767, 30768, 30769, 30721
12342, 29848, 29871, 29872, 29849, 30769, 30770, 30771, 30723
12343, 29849, 29872, 29873, 29850, 30771, 30772, 30773, 30725
12344, 29850, 29873, 29874, 29851, 30773, 30774, 30775, 30727
12345, 29851, 29874, 29875, 29852, 30775, 30776, 30777, 30729
12346, 29852, 29875, 29876, 29853, 30777, 30778, 30779, 30731
12347, 29853, 29876, 29877, 29854, 30779, 30780, 30781, 30733
12348, 29854, 29877, 29878, 29855, 30781, 30782, 30783, 30735
12349, 29855, 29878, 29879, 29856, 30783, 30784, 30785, 30737
12350, 29856, 29879, 29880, 29857, 30785, 30786, 30787, 30739
12351, 29857, 29880, 29881, 29858, 30787, 30788, 30789, 30741
12352, 29858, 29881, 29882, 29859, 30789, 30790, 30791, 30743
12353, 29859, 29882, 29883, 29860, 30791, 30792, 30793, 30745
12354, 29860, 29883, 29884, 29861, 30793, 30794, 30795, 30747
12355, 29861, 29884, 29885, 29862, 30795, 30796, 30797, 30749
12356, 29862, 29885, 3045, 3044, 30797, 30798, 3068, 30751
12357, 2998, 2999, 29886, 29863, 3022, 30799, 30800, 30752
12358, 29863, 29886, 29887, 29864, 30800, 30801, 30802, 30754
12359, 29864, 29887, 29888, 29865, 30802, 30803, 30804, 30756
12360, 29865, 29888, 29889, 29866, 30804, 30805, 30806, 30758
12361, 29866, 29889, 29890, 29867, 30806, 30807, 30808, 30760
12362, 29867, 29890, 29891, 29868, 30808, 30809, 30810, 30762
12363, 29868, 29891, 29892, 29869, 30810, 30811, 30812, 30764
12364, 29869, 29892, 29893, 29870, 30812, 30813, 30814, 30766
12365, 29870, 29893, 29894, 29871, 30814, 30815, 30816, 30768
12366, 29871, 29894, 29895, 29872, 30816, 30817, 30818, 30770
12367, 29872, 29895, 29896, 29873, 30818, 30819, 30820, 30772
12368, 29873, 29896, 29897, 29874, 30820, 30821, 30822, 30774
12369, 29874, 29897, 29898, 29875, 30822, 30823, 30824, 30776
12370, 29875, 29898, 29899, 29876, 30824, 30825, 30826, 30778
12371, 29876, 29899, 29900, 29877, 30826, 30827, 30828, 30780
12372, 29877, 29900, 29901, 29878, 30828, 30829, 30830, 30782
12373, 29878, 29901, 29902, 29879, 30830, 30831, 30832, 30784
12374, 29879, 29902, 29903, 29880, 30832, 30833, 30834, 30786
12375, 29880, 29903, 29904, 29881, 30834, 30835, 30836, 30788
12376, 29881, 29904, 29905, 29882, 30836, 30837, 30838, 30790
12377, 29882, 29905, 29906, 29883, 30838, 30839, 30840, 30792
12378, 29883, 29906, 29907, 29884, 30840, 30841, 30842, 30794
12379, 29884, 29907, 29908, 29885, 30842, 30843, 30844, 30796
12380, 29885, 29908, 3046, 3045, 30844, 30845, 3069, 30798
12381, 2999, 3000, 29909, 29886, 3023, 30846, 30847, 30799
12382, 29886, 29909, 29910, 29887, 30847, 30848, 30849, 30801
12383, 29887, 29910, 29911, 29888, 30849, 30850, 30851, 30803
12384, 29888, 29911, 29912, 29889, 30851, 30852, 30853, 30805
12385, 29889, 29912, 29913, 29890, 30853, 30854, 30855, 30807
12386, 29890, 29913, 29914, 29891, 30855, 30856, 30857, 30809
12387, 29891, 29914, 29915, 29892, 30857, 30858, 30859, 30811
12388, 29892, 29915, 29916, 29893, 30859, 30860, 30861, 30813
12389, 29893, 29916, 29917, 29894, 30861, 30862, 30863, 30815
12390, 29894, 29917, 29918, 29895, 30863, 30864, 30865, 30817
12391, 29895, 29918, 29919, 29896, 30865, 30866, 30867, 30819
12392, 29896, 29919, 29920, 29897, 30867, 30868, 30869, 30821
12393, 29897, 29920, 29921, 29898, 30869, 30870, 30871, 30823
12394, 29898, 29921, 29922, 29899, 30871, 30872, 30873, 30825
12395, 29899, 29922, 29923, 29900, 30873, 30874, 30875, 30827
12396, 29900, 29923, 29924, 29901, 30875, 30876, 30877, 30829
12397, 29901, 29924, 29925, 29902, 30877, 30878, 30879, 30831
12398, 29902, 29925, 29926, 29903, 30879, 30880, 30881, 30833
12399, 29903, 29926, 29927, 29904, 30881, 30882, 30883, 30835
12400, 29904, 29927, 29928, 29905, 30883, 30884, 30885, 30837
12401, 29905, 29928, 29929, 29906, 30885, 30886, 30887, 30839
12402, 29906, 29929, 29930, 29907, 30887, 30888, 30889, 30841
12403, 29907, 29930, 29931, 29908, 30889, 30890, 30891, 30843
12404, 29908, 29931, 3047, 3046, 30891, 30892, 3070, 30845
12405, 3000, 3001, 29932, 29909, 3024, 30893, 30894, 30846
12406, 29909, 29932, 29933, 29910, 30894, 30895, 30896, 30848
12407, 29910, 29933, 29934, 29911, 30896, 30897, 30898, 30850
12408, 29911, 29934, 29935, 29912, 30898, 30899, 30900, 30852
12409, 29912, 29935, 29936, 29913, 30900, 30901, 30902, 30854
12410, 29913, 29936, 29937, 29914, 30902, 30903, 30904, 30856
12411, 29914, 29937, 29938, 29915, 30904, 30905, 30906, 30858
12412, 29915, 29938, 29939, 29916, 30906, 30907, 30908, 30860
12413, 29916, 29939, 29940, 29917, 30908, 30909, 30910, 30862
12414, 29917, 29940, 29941, 29918, 30910, 30911, 30912, 30864
12415, 29918, 29941, 29942, 29919, 30912, 30913, 30914, 30866
12416, 29919, 29942, 29943, 29920, 30914, 30915, 30916, 30868
12417, 29920, 29943, 29944, 29921, 30916, 30917, 30918, 30870
12418, 29921, 29944, 29945, 29922, 30918, 30919, 30920, 30872
12419, 29922, 29945, 29946, 29923, 30920, 30921, 30922, 30874
12420, 29923, 29946, 29947, 29924, 30922, 30923, 30924, 30876
12421, 29924, 29947, 29948, 29925, 30924, 30925, 30926, 30878
12422, 29925, 29948, 29949, 29926, 30926, 30927, 30928, 30880
12423, 29926, 29949, 29950, 29927, 30928, 30929, 30930, 30882
12424, 29927, 29950, 29951, 29928, 30930, 30931, 30932, 30884
12425, 29928, 29951, 29952, 29929, 30932, 30933, 30934, 30886
12426, 29929, 29952, 29953, 29930, 30934, 30935, 30936, 30888
12427, 29930, 29953, 29954, 29931, 30936, 30937, 30938, 30890
12428, 29931, 29954, 3048, 3047, 30938, 30939, 3071, 30892
12429, 3001, 3002, 29955, 29932, 3025, 30940, 30941, 30893
12430, 29932, 29955, 29956, 29933, 30941, 30942, 30943, 30895
12431, 29933, 29956, 29957, 29934, 30943, 30944, 30945, 30897
12432, 29934, 29957, 29958, 29935, 30945, 30946, 30947, 30899
12433, 29935, 29958, 29959, 29936, 30947, 30948, 30949, 30901
12434, 29936, 29959, 29960, 29937, 30949, 30950, 30951, 30903
12435, 29937, 29960, 29961, 29938, 30951, 30952, 30953, 30905
12436, 29938, 29961, 29962, 29939, 30953, 30954, 30955, 30907
12437, 29939, 29962, 29963, 29940, 30955, 30956, 30957, 30909
12438, 29940, 29963, 29964, 29941, 30957, 30958, 30959, 30911
12439, 29941, 29964, 29965, 29942, 30959, 30960, 30961, 30913
12440, 29942, 29965, 29966, 29943, 30961, 30962, 30963, 30915
12441, 29943, 29966, 29967, 29944, 30963, 30964, 30965, 30917
12442, 29944, 29967, 29968, 29945, 30965, 30966, 30967, 30919
12443, 29945, 29968, 29969, 29946, 30967, 30968, 30969, 30921
12444, 29946, 29969, 29970, 29947, 30969, 30970, 30971, 30923
12445, 29947, 29970, 29971, 29948, 30971, 30972, 30973, 30925
12446, 29948, 29971, 29972, 29949, 30973, 30974, 30975, 30927
12447, 29949, 29972, 29973, 29950, 30975, 30976, 30977, 30929
12448, 29950, 29973, 29974, 29951, 30977, 30978, 30979, 30931
12449, 29951, 29974, 29975, 29952, 30979, 30980, 30981, 30933
12450, 29952, 29975, 29976, 29953, 30981, 30982, 30983, 30935
12451, 29953, 29976, 29977, 29954, 30983, 30984, 30985, 30937
12452, 29954, 29977, 3049, 3048, 30985, 30986, 3072, 30939
12453, 3002, 3003, 29978, 29955, 3026, 30987, 30988, 30940
12454, 29955, 29978, 29979, 29956, 30988, 30989, 30990, 30942
12455, 29956, 29979, 29980, 29957, 30990, 30991, 30992, 30944
12456, 29957, 29980, 29981, 29958, 30992, 30993, 30994, 30946
12457, 29958, 29981, 29982, 29959, 30994, 30995, 30996, 30948
12458, 29959, 29982, 29983, 29960, 30996, 30997, 30998, 30950
12459, 29960, 29983, 29984, 29961, 30998, 30999, 31000, 30952
12460, 29961, 29984, 29985, 29962, 31000, 31001, 31002, 30954
12461, 29962, 29985, 29986, 29963, 31002, 31003, 31004, 30956
12462, 29963, 29986, 29987, 29964, 31004, 31005, 31006, 30958
12463, 29964, 29987, 29988, 29965, 31006, 31007, 31008, 30960
12464, 29965, 29988, 29989, 29966, 31008, 31009, 31010, 30962
12465, 29966, 29989, 29990, 29967, 31010, 31011, 31012, 30964
12466, 29967, 29990, 29991, 29968, 31012, 31013, 31014, 30966
12467, 29968, 29991, 29992, 29969, 31014, 31015, 31016, 30968
12468, 29969, 29992, 29993, 29970, 31016, 31017, 31018, 30970
12469, 29970, 29993, 29994, 29971, 31018, 31019, 31020, 30972
12470, 29971, 29994, 29995, 29972, 31020, 31021, 31022, 30974
12471, 29972, 29995, 29996, 29973, 31022, 31023, 31024, 30976
12472, 29973, 29996, 29997, 29974, 31024, 31025, 31026, 30978
12473, 29974, 29997, 29998, 29975, 31026, 31027, 31028, 30980
12474, 29975, 29998, 29999, 29976, 31028, 31029, 31030, 30982
12475, 29976, 29999, 30000, 29977, 31030, 31031, 31032, 30984
12476, 29977, 30000, 3050, 3049, 31032, 31033, 3073, 30986
12477, 3003, 3004, 30001, 29978, 3027, 31034, 31035, 30987
12478, 29978, 30001, 30002, 29979, 31035, 31036, 31037, 30989
12479, 29979, 30002, 30003, 29980, 31037, 31038, 31039, 30991
12480, 29980, 30003, 30004, 29981, 31039, 31040, 31041, 30993
12481, 29981, 30004, 30005, 29982, 31041, 31042, 31043, 30995
12482, 29982, 30005, 30006, 29983, 31043, 31044, 31045, 30997
12483, 29983, 30006, 30007, 29984, 31045, 31046, 31047, 30999
12484, 29984, 30007, 30008, 29985, 31047, 31048, 31049, 31001
12485, 29985, 30008, 30009, 29986, 31049, 31050, 31051, 31003
12486, 29986, 30009, 30010, 29987, 31051, 31052, 31053, 31005
12487, 29987, 30010, 30011, 29988, 31053, 31054, 31055, 31007
12488, 29988, 30011, 30012, 29989, 31055, 31056, 31057, 31009
12489, 29989, 30012, 30013, 29990, 31057, 31058, 31059, 31011
12490, 29990, 30013, 30014, 29991, 31059, 31060, 31061, 31013
12491, 29991, 30014, 30015, 29992, 31061, 31062, 31063, 31015
12492, 29992, 30015, 30016, 29993, 31063, 31064, 31065, 31017
12493, 29993, 30016, 30017, 29994, 31065, 31066, 31067, 31019
12494, 29994, 30017, 30018, 29995, 31067, 31068, 31069, 31021
12495, 29995, 30018, 30019, 29996, 31069, 31070, 31071, 31023
12496, 29996, 30019, 30020, 29997, 31071, 31072, 31073, 31025
12497, 29997, 30020, 30021, 29998, 31073, 31074, 31075, 31027
12498, 29998, 30021, 30022, 29999, 31075, 31076, 31077, 31029
12499, 29999, 30022, 30023, 30000, 31077, 31078, 31079, 31031
12500, 30000, 30023, 3051, 3050, 31079, 31080, 3074, 31033
12501, 3004, 3005, 30024, 30001, 3028, 31081, 31082, 31034
12502, 30001, 30024, 30025, 30002, 31082, 31083, 31084, 31036
12503, 30002, 30025, 30026, 30003, 31084, 31085, 31086, 31038
12504, 30003, 30026, 30027, 30004, 31086, 31087, 31088, 31040
12505, 30004, 30027, 30028, 30005, 31088, 31089, 31090, 31042
12506, 30005, 30028, 30029, 30006, 31090, 31091, 31092, 31044
12507, 30006, 30029, 30030, 30007, 31092, 31093, 31094, 31046
12508, 30007, 30030, 30031, 30008, 31094, 31095, 31096, 31048
12509, 30008, 30031, 30032, 30009, 31096, 31097, 31098, 31050
12510, 30009, 30032, 30033, 30010, 31098, 31099, 31100, 31052
12511, 30010, 30033, 30034, 30011, 31100, 31101, 31102, 31054
12512, 30011, 30034, 30035, 30012, 31102, 31103, 31104, 31056
12513, 30012, 30035, 30036, 30013, 31104, 31105, 31106, 31058
12514, 30013, 30036, 30037, 30014, 31106, 31107, 31108, 31060
12515, 30014, 30037, 30038, 30015, 31108, 31109, 31110, 31062
12516, 30015, 30038, 30039, 30016, 31110, 31111, 31112, 31064
12517, 30016, 30039, 30040, 30017, 31112, 31113, 31114, 31066
12518, 30017, 30040, 30041, 30018, 31114, 31115, 31116, 31068
12519, 30018, 30041, 30042, 30019, 31116, 31117, 31118, 31070
12520, 30019, 30042, 30043, 30020, 31118, 31119, 31120, 31072
12521, 30020, 30043, 30044, 30021, 31120, 31121, 31122, 31074
12522, 30021, 30044, 30045, 30022, 31122, 31123, 31124, 31076
12523, 30022, 30045, 30046, 30023, 31124, 31125, 31126, 31078
12524, 30023, 30046, 3052, 3051, 31126, 31127, 3075, 31080
12525, 3005, 71, 2936, 30024, 3029, 2959, 31128, 31081
12526, 30024, 2936, 2937, 30025, 31128, 2960, 31129, 31083
12527, 30025, 2937, 2938, 30026, 31129, 2961, 31130, 31085
12528, 30026, 2938, 2939, 30027, 31130, 2962, 31131, 31087
12529, 30027, 2939, 2940, 30028, 31131, 2963, 31132, 31089
12530, 30028, 2940, 2941, 30029, 31132, 2964, 31133, 31091
12531, 30029, 2941, 2942, 30030, 31133, 2965, 31134, 31093
12532, 30030, 2942, 2943, 30031, 31134, 2966, 31135, 31095
12533, 30031, 2943, 2944, 30032, 31135, 2967, 31136, 31097
12534, 30032, 2944, 2945, 30033, 31136, 2968, 31137, 31099
12535, 30033, 2945, 2946, 30034, 31137, 2969, 31138, 31101
12536, 30034, 2946, 2947, 30035, 31138, 2970, 31139, 31103
12537, 30035, 2947, 2948, 30036, 31139, 2971, 31140, 31105
12538, 30036, 2948, 2949, 30037, 31140, 2972, 31141, 31107
12539, 30037, 2949, 2950, 30038, 31141, 2973, 31142, 31109
12540, 30038, 2950, 2951, 30039, 31142, 2974, 31143, 31111
12541, 30039, 2951, 2952, 30040, 31143, 2975, 31144, 31113
12542, 30040, 2952, 2953, 30041, 31144, 2976, 31145, 31115
12543, 30041, 2953, 2954, 30042, 31145, 2977, 31146, 31117
12544, 30042, 2954, 2955, 30043, 31146, 2978, 31147, 31119
12545, 30043, 2955, 2956, 30044, 31147, 2979, 31148, 31121
12546, 30044, 2956, 2957, 30045, 31148, 2980, 31149, 31123
12547, 30045, 2957, 2958, 30046, 31149, 2981, 31150, 31125
12548, 30046, 2958, 72, 3052, 31150, 2982, 3076, 31127
*ELEMENT, type=CPS8, ELSET=Surface97
12549, 35, 69, 73, 63, 2885, 3078, 3077, 2598
*ELEMENT, type=CPS8, ELSET=Surface98
12550, 39, 64, 74, 70, 2599, 3079, 3080, 2886
*ELEMENT, type=CPS8, ELSET=Surface99
12551, 63, 73, 3081, 2600, 3077, 3104, 31151, 2623
12552, 2600, 3081, 3082, 2601, 31151, 3105, 31152, 2624
12553, 2601, 3082, 3083, 2602, 31152, 3106, 31153, 2625
12554, 2602, 3083, 3084, 2603, 31153, 3107, 31154, 2626
12555, 2603, 3084, 3085, 2604, 31154, 3108, 31155, 2627
12556, 2604, 3085, 3086, 2605, 31155, 3109, 31156, 2628
12557, 2605, 3086, 3087, 2606, 31156, 3110, 31157, 2629
12558, 2606, 3087, 3088, 2607, 31157, 3111, 31158, 2630
12559, 2607, 3088, 3089, 2608, 31158, 3112, 31159, 2631
12560, 2608, 3089, 3090, 2609, 31159, 3113, 31160, 2632
12561, 2609, 3090, 3091, 2610, 31160, 3114, 31161, 2633
12562, 2610, 3091, 3092, 2611, 31161, 3115, 31162, 2634
12563, 2611, 3092, 3093, 2612, 31162, 3116, 31163, 2635
12564, 2612, 3093, 3094, 2613, 31163, 3117, 31164, 2636
12565, 2613, 3094, 3095, 2614, 31164, 3118, 31165, 2637
12566, 2614, 3095, 3096, 2615, 31165, 3119, 31166, 2638
12567, 2615, 3096, 3097, 2616, 31166, 3120, 31167, 2639
12568, 2616, 3097, 3098, 2617, 31167, 3121, 31168, 2640
12569, 2617, 3098, 3099, 2618, 31168, 3122, 31169, 2641
12570, 2618, 3099, 3100, 2619, 31169, 3123, 31170, 2642
12571, 2619, 3100, 3101, 2620, 31170, 3124, 31171, 2643
12572, 2620, 3101, 3102, 2621, 31171, 3125, 31172, 2644
12573, 2621, 3102, 3103, 2622, 31172, 3126, 31173, 2645
12574, 2622, 3103, 74, 64, 31173, 3127, 3079, 2646
*ELEMENT, type=CPS8, ELSET=Surface100
12575, 69, 2887, 3081, 73, 2910, 31174, 3104, 3078
12576, 2887, 2888, 3082, 3081, 2911, 31175, 3105, 31174
12577, 2888, 2889, 3083, 3082, 2912, 31176, 3106, 31175
12578, 2889, 2890, 3084, 3083, 2913, 31177, 3107, 31176
12579, 2890, 2891, 3085, 3084, 2914, 31178, 3108, 31177
12580, 2891, 2892, 3086, 3085, 2915, 31179, 3109, 31178
12581, 2892, 2893, 3087, 3086, 2916, 31180, 3110, 31179
12582, 2893, 2894, 3088, 3087, 2917, 31181, 3111, 31180
12583, 2894, 2895, 3089, 3088, 2918, 31182, 3112, 31181
12584, 2895, 2896, 3090, 3089, 2919, 31183, 3113, 31182
12585, 2896, 2897, 3091, 3090, 2920, 31184, 3114, 31183
12586, 2897, 2898, 3092, 3091, 2921, 31185, 3115, 31184
12587, 2898, 2899, 3093, 3092, 2922, 31186, 3116, 31185
12588, 2899, 2900, 3094, 3093, 2923, 31187, 3117, 31186
12589, 2900, 2901, 3095, 3094, 2924, 31188, 3118, 31187
12590, 2901, 2902, 3096, 3095, 2925, 31189, 3119, 31188
12591, 2902, 2903, 3097, 3096, 2926, 31190, 3120, 31189
12592, 2903, 2904, 3098, 3097, 2927, 31191, 3121, 31190
12593, 2904, 2905, 3099, 3098, 2928, 31192, 3122, 31191
12594, 2905, 2906, 3100, 3099, 2929, 31193, 3123, 31192
12595, 2906, 2907, 3101, 3100, 2930, 31194, 3124, 31193
12596, 2907, 2908, 3102, 3101, 2931, 31195, 3125, 31194
12597, 2908, 2909, 3103, 3102, 2932, 31196, 3126, 31195
12598, 2909, 70, 74, 3103, 2933, 3080, 3127, 31196
*ELEMENT, type=CPS8, ELSET=Surface101
12599, 9, 65, 75, 59, 2693, 3129, 3128, 2454
*ELEMENT, type=CPS8, ELSET=Surface102
12600, 13, 60, 76, 66, 2455, 3130, 3131, 2694
*ELEMENT, type=CPS8, ELSET=Surface103
12601, 59, 75, 3132, 2456, 3128, 3155, 31197, 2479
12602, 2456, 3132, 3133, 2457, 31197, 3156, 31198, 2480
12603, 2457, 3133, 3134, 2458, 31198, 3157, 31199, 2481
12604, 2458, 3134, 3135, 2459, 31199, 3158, 31200, 2482
12605, 2459, 3135, 3136, 2460, 31200, 3159, 31201, 2483
12606, 2460, 3136, 3137, 2461, 31201, 3160, 31202, 2484
12607, 2461, 3137, 3138, 2462, 31202, 3161, 31203, 2485
12608, 2462, 3138, 3139, 2463, 31203, 3162, 31204, 2486
12609, 2463, 3139, 3140, 2464, 31204, 3163, 31205, 2487
12610, 2464, 3140, 3141, 2465, 31205, 3164, 31206, 2488
12611, 2465, 3141, 3142, 2466, 31206, 3165, 31207, 2489
12612, 2466, 3142, 3143, 2467, 31207, 3166, 31208, 2490
12613, 2467, 3143, 3144, 2468, 31208, 3167, 31209, 2491
12614, 2468, 3144, 3145, 2469, 31209, 3168, 31210, 2492
12615, 2469, 3145, 3146, 2470, 31210, 3169, 31211, 2493
12616, 2470, 3146, 3147, 2471, 31211, 3170, 31212, 2494
12617, 2471, 3147, 3148, 2472, 31212, 3171, 31213, 2495
12618, 2472, 3148, 3149, 2473, 31213, 3172, 31214, 2496
12619, 2473, 3149, 3150, 2474, 31214, 3173, 31215, 2497
12620, 2474, 3150, 3151, 2475, 31215, 3174, 31216, 2498
12621, 2475, 3151, 3152, 2476, 31216, 3175, 31217, 2499
12622, 2476, 3152, 3153, 2477, 31217, 3176, 31218, 2500
12623, 2477, 3153, 3154, 2478, 31218, 3177, 31219, 2501
12624, 2478, 3154, 76, 60, 31219, 3178, 3130, 2502
*ELEMENT, type=CPS8, ELSET=Surface104
12625, 65, 2695, 3132, 75, 2718, 31220, 3155, 3129
12626, 2695, 2696, 3133, 3132, 2719, 31221, 3156, 31220
12627, 2696, 2697, 3134, 3133, 2720, 31222, 3157, 31221
12628, 2697, 2698, 3135, 3134, 2721, 31223, 3158, 31222
12629, 2698, 2699, 3136, 3135, 2722, 31224, 3159, 31223
12630, 2699, 2700, 3137, 3136, 2723, 31225, 3160, 31224
12631, 2700, 2701, 3138, 3137, 2724, 31226, 3161, 31225
12632, 2701, 2702, 3139, 3138, 2725, 31227, 3162, 31226
12633, 2702, 2703, 3140, 3139, 2726, 31228, 3163, 31227
12634, 2703, 2704, 3141, 3140, 2727, 31229, 3164, 31228
12635, 2704, 2705, 3142, 3141, 2728, 31230, 3165, 31229
12636, 2705, 2706, 3143, 3142, 2729, 31231, 3166, 31230
12637, 2706, 2707, 3144, 3143, 2730, 31232, 3167, 31231
12638, 2707, 2708, 3145, 3144, 2731, 31233, 3168, 31232
12639, 2708, 2709, 3146, 3145, 2732, 31234, 3169, 31233
12640, 2709, 2710, 3147, 3146, 2733, 31235, 3170, 31234
12641, 2710, 2711, 3148, 3147, 2734, 31236, 3171, 31235
12642, 2711, 2712, 3149, 3148, 2735, 31237, 3172, 31236
12643, 2712, 2713, 3150, 3149, 2736, 31238, 3173, 31237
12644, 2713, 2714, 3151, 3150, 2737, 31239, 3174, 31238
12645, 2714, 2715, 3152, 3151, 2738, 31240, 3175, 31239
12646, 2715, 2716, 3153, 3152, 2739, 31241, 3176, 31240
12647, 2716, 2717, 3154, 3153, 2740, 31242, 3177, 31241
12648, 2717, 66, 76, 3154, 2741, 3131, 3178, 31242
*ELEMENT, type=CPS8, ELSET=Surface105
12649, 22, 3188, 31243, 1023, 3192, 31335, 31336, 1046
12650, 3188, 3189, 31244, 31243, 3193, 31337, 31338, 31335
12651, 3189, 3190, 31245, 31244, 3194, 31339, 31340, 31337
12652, 3190, 3191, 31246, 31245, 3195, 31341, 31342, 31339
12653, 3191, 78, 3197, 31246, 3196, 3220, 31343, 31341
12654, 1023, 31243, 31247, 1024, 31336, 31344, 31345, 1047
12655, 31243, 31244, 31248, 31247, 31338, 31346, 31347, 31344
12656, 31244, 31245, 31249, 31248, 31340, 31348, 31349, 31346
12657, 31245, 31246, 31250, 31249, 31342, 31350, 31351, 31348
12658, 31246, 3197, 3198, 31250, 31343, 3221, 31352, 31350
12659, 1024, 31247, 31251, 1025, 31345, 31353, 31354, 1048
12660, 31247, 31248, 31252, 31251, 31347, 31355, 31356, 31353
12661, 31248, 31249, 31253, 31252, 31349, 31357, 31358, 31355
12662, 31249, 31250, 31254, 31253, 31351, 31359, 31360, 31357
12663, 31250, 3198, 3199, 31254, 31352, 3222, 31361, 31359
12664, 1025, 31251, 31255, 1026, 31354, 31362, 31363, 1049
12665, 31251, 31252, 31256, 31255, 31356, 31364, 31365, 31362
12666, 31252, 31253, 31257, 31256, 31358, 31366, 31367, 31364
12667, 31253, 31254, 31258, 31257, 31360, 31368, 31369, 31366
12668, 31254, 3199, 3200, 31258, 31361, 3223, 31370, 31368
12669, 1026, 31255, 31259, 1027, 31363, 31371, 31372, 1050
12670, 31255, 31256, 31260, 31259, 31365, 31373, 31374, 31371
12671, 31256, 31257, 31261, 31260, 31367, 31375, 31376, 31373
12672, 31257, 31258, 31262, 31261, 31369, 31377, 31378, 31375
12673, 31258, 3200, 3201, 31262, 31370, 3224, 31379, 31377
12674, 1027, 31259, 31263, 1028, 31372, 31380, 31381, 1051
12675, 31259, 31260, 31264, 31263, 31374, 31382, 31383, 31380
12676, 31260, 31261, 31265, 31264, 31376, 31384, 31385, 31382
12677, 31261, 31262, 31266, 31265, 31378, 31386, 31387, 31384
12678, 31262, 3201, 3202, 31266, 31379, 3225, 31388, 31386
12679, 1028, 31263, 31267, 1029, 31381, 31389, 31390, 1052
12680, 31263, 31264, 31268, 31267, 31383, 31391, 31392, 31389
12681, 31264, 31265, 31269, 31268, 31385, 31393, 31394, 31391
12682, 31265, 31266, 31270, 31269, 31387, 31395, 31396, 31393
12683, 31266, 3202, 3203, 31270, 31388, 3226, 31397, 31395
12684, 1029, 31267, 31271, 1030, 31390, 31398, 31399, 1053
12685, 31267, 31268, 31272, 31271, 31392, 31400, 31401, 31398
12686, 31268, 31269, 31273, 31272, 31394, 31402, 31403, 31400
12687, 31269, 31270, 31274, 31273, 31396, 31404, 31405, 31402
12688, 31270, 3203, 3204, 31274, 31397, 3227, 31406, 31404
12689, 1030, 31271, 31275, 1031, 31399, 31407, 31408, 1054
12690, 31271, 31272, 31276, 31275, 31401, 31409, 31410, 31407
12691, 31272, 31273, 31277, 31276, 31403, 31411, 31412, 31409
12692, 31273, 31274, 31278, 31277, 31405, 31413, 31414, 31411
12693, 31274, 3204, 3205, 31278, 31406, 3228, 31415, 31413
12694, 1031, 31275, 31279, 1032, 31408, 31416, 31417, 1055
12695, 31275, 31276, 31280, 31279, 31410, 31418, 31419, 31416
12696, 31276, 31277, 31281, 31280, 31412, 31420, 31421, 31418
12697, 31277, 31278, 31282, 31281, 31414, 31422, 31423, 31420
12698, 31278, 3205, 3206, 31282, 31415, 3229, 31424, 31422
12699, 1032, 31279, 31283, 1033, 31417, 31425, 31426, 1056
12700, 31279, 31280, 31284, 31283, 31419, 31427, 31428, 31425
12701, 31280, 31281, 31285, 31284, 31421, 31429, 31430, 31427
12702, 31281, 31282, 31286, 31285, 31423, 31431, 31432, 31429
12703, 31282, 3206, 3207, 31286, 31424, 3230, 31433, 31431
12704, 1033, 31283, 31287, 1034, 31426, 31434, 31435, 1057
12705, 31283, 31284, 31288, 31287, 31428, 31436, 31437, 31434
12706, 31284, 31285, 31289, 31288, 31430, 31438, 31439, 31436
12707, 31285, 31286, 31290, 31289, 31432, 31440, 31441, 31438
12708, 31286, 3207, 3208, 31290, 31433, 3231, 31442, 31440
12709, 1034, 31287, 31291, 1035, 31435, 31443, 31444, 1058
12710, 31287, 31288, 31292, 31291, 31437, 31445, 31446, 31443
12711, 31288, 31289, 31293, 31292, 31439, 31447, 31448, 31445
12712, 31289, 31290, 31294, 31293, 31441, 31449, 31450, 31447
12713, 31290, 3208, 3209, 31294, 31442, 3232, 31451, 31449
12714, 1035, 31291, 31295, 1036, 31444, 31452, 31453, 1059
12715, 31291, 31292, 31296, 31295, 31446, 31454, 31455, 31452
12716, 31292, 31293, 31297, 31296, 31448, 31456, 31457, 31454
12717, 31293, 31294, 31298, 31297, 31450, 31458, 31459, 31456
12718, 31294, 3209, 3210, 31298, 31451, 3233, 31460, 31458
12719, 1036, 31295, 31299, 1037, 31453, 31461, 31462, 1060
12720, 31295, 31296, 31300, 31299, 31455, 31463, 31464, 31461
12721, 31296, 31297, 31301, 31300, 31457, 31465, 31466, 31463
12722, 31297, 31298, 31302, 31301, 31459, 31467, 31468, 31465
12723, 31298, 3210, 3211, 31302, 31460, 3234, 31469, 31467
12724, 1037, 31299, 31303, 1038, 31462, 31470, 31471, 1061
12725, 31299, 31300, 31304, 31303, 31464, 31472, 31473, 31470
12726, 31300, 31301, 31305, 31304, 31466, 31474, 31475, 31472
12727, 31301, 31302, 31306, 31305, 31468, 31476, 31477, 31474
12728, 31302, 3211, 3212, 31306, 31469, 3235, 31478, 31476
12729, 1038, 31303, 31307, 1039, 31471, 31479, 31480, 1062
12730, 31303, 31304, 31308, 31307, 31473, 31481, 31482, 31479
12731, 31304, 31305, 31309, 31308, 31475, 31483, 31484, 31481
12732, 31305, 31306, 31310, 31309, 31477, 31485, 31486, 31483
12733, 31306, 3212, 3213, 31310, 31478, 3236, 31487, 31485
12734, 1039, 31307, 31311, 1040, 31480, 31488, 31489, 1063
12735, 31307, 31308, 31312, 31311, 31482, 31490, 31491, 31488
12736, 31308, 31309, 31313, 31312, 31484, 31492, 31493, 31490
12737, 31309, 31310, 31314, 31313, 31486, 31494, 31495, 31492
12738, 31310, 3213, 3214, 31314, 31487, 3237, 31496, 31494
12739, 1040, 31311, 31315, 1041, 31489, 31497, 31498, 1064
12740, 31311, 31312, 31316, 31315, 31491, 31499, 31500, 31497
12741, 31312, 31313, 31317, 31316, 31493, 31501, 31502, 31499
12742, 31313, 31314, 31318, 31317, 31495, 31503, 31504, 31501
12743, 31314, 3214, 3215, 31318, 31496, 3238, 31505, 31503
12744, 1041, 31315, 31319, 1042, 31498, 31506, 31507, 1065
12745, 31315, 31316, 31320, 31319, 31500, 31508, 31509, 31506
12746, 31316, 31317, 31321, 31320, 31502, 31510, 31511, 31508
12747, 31317, 31318, 31322, 31321, 31504, 31512, 31513, 31510
12748, 31318, 3215, 3216, 31322, 31505, 3239, 31514, 31512
12749, 1042, 31319, 31323, 1043, 31507, 31515, 31516, 1066
12750, 31319, 31320, 31324, 31323, 31509, 31517, 31518, 31515
12751, 31320, 31321, 31325, 31324, 31511, 31519, 31520, 31517
12752, 31321, 31322, 31326, 31325, 31513, 31521, 31522, 31519
12753, 31322, 3216, 3217, 31326, 31514, 3240, 31523, 31521
12754, 1043, 31323, 31327, 1044, 31516, 31524, 31525, 1067
12755, 31323, 31324, 31328, 31327, 31518, 31526, 31527, 31524
12756, 31324, 31325, 31329, 31328, 31520, 31528, 31529, 31526
12757, 31325, 31326, 31330, 31329, 31522, 31530, 31531, 31528
12758, 31326, 3217, 3218, 31330, 31523, 3241, 31532, 31530
12759, 1044, 31327, 31331, 1045, 31525, 31533, 31534, 1068
12760, 31327, 31328, 31332, 31331, 31527, 31535, 31536, 31533
12761, 31328, 31329, 31333, 31332, 31529, 31537, 31538, 31535
12762, 31329, 31330, 31334, 31333, 31531, 31539, 31540, 31537
12763, 31330, 3218, 3219, 31334, 31532, 3242, 31541, 31539
12764, 1045, 31331, 3179, 21, 31534, 31542, 3183, 1069
12765, 31331, 31332, 3180, 3179, 31536, 31543, 3184, 31542
12766, 31332, 31333, 3181, 3180, 31538, 31544, 3185, 31543
12767, 31333, 31334, 3182, 3181, 31540, 31545, 3186, 31544
12768, 31334, 3219, 77, 3182, 31541, 3243, 3187, 31545
*ELEMENT, type=CPS8, ELSET=Surface106
12769, 21, 3179, 31546, 1075, 3183, 31590, 31591, 1086
12770, 3179, 3180, 31547, 31546, 3184, 31592, 31593, 31590
12771, 3180, 3181, 31548, 31547, 3185, 31594, 31595, 31592
12772, 3181, 3182, 31549, 31548, 3186, 31596, 31597, 31594
12773, 3182, 77, 3253, 31549, 3187, 3264, 31598, 31596
12774, 1075, 31546, 31550, 1076, 31591, 31599, 31600, 1087
12775, 31546, 31547, 31551, 31550, 31593, 31601, 31602, 31599
12776, 31547, 31548, 31552, 31551, 31595, 31603, 31604, 31601
12777, 31548, 31549, 31553, 31552, 31597, 31605, 31606, 31603
12778, 31549, 3253, 3254, 31553, 31598, 3265, 31607, 31605
12779, 1076, 31550, 31554, 1077, 31600, 31608, 31609, 1088
12780, 31550, 31551, 31555, 31554, 31602, 31610, 31611, 31608
12781, 31551, 31552, 31556, 31555, 31604, 31612, 31613, 31610
12782, 31552, 31553, 31557, 31556, 31606, 31614, 31615, 31612
12783, 31553, 3254, 3255, 31557, 31607, 3266, 31616, 31614
12784, 1077, 31554, 31558, 1078, 31609, 31617, 31618, 1089
12785, 31554, 31555, 31559, 31558, 31611, 31619, 31620, 31617
12786, 31555, 31556, 31560, 31559, 31613, 31621, 31622, 31619
12787, 31556, 31557, 31561, 31560, 31615, 31623, 31624, 31621
12788, 31557, 3255, 3256, 31561, 31616, 3267, 31625, 31623
12789, 1078, 31558, 31562, 1079, 31618, 31626, 31627, 1090
12790, 31558, 31559, 31563, 31562, 31620, 31628, 31629, 31626
12791, 31559, 31560, 31564, 31563, 31622, 31630, 31631, 31628
12792, 31560, 31561, 31565, 31564, 31624, 31632, 31633, 31630
12793, 31561, 3256, 3257, 31565, 31625, 3268, 31634, 31632
12794, 1079, 31562, 31566, 1080, 31627, 31635, 31636, 1091
12795, 31562, 31563, 31567, 31566, 31629, 31637, 31638, 31635
12796, 31563, 31564, 31568, 31567, 31631, 31639, 31640, 31637
12797, 31564, 31565, 31569, 31568, 31633, 31641, 31642, 31639
12798, 31565, 3257, 3258, 31569, 31634, 3269, 31643, 31641
12799, 1080, 31566, 31570, 1081, 31636, 31644, 31645, 1092
12800, 31566, 31567, 31571, 31570, 31638, 31646, 31647, 31644
12801, 31567, 31568, 31572, 31571, 31640, 31648, 31649, 31646
12802, 31568, 31569, 31573, 31572, 31642, 31650, 31651, 31648
12803, 31569, 3258, 3259, 31573, 31643, 3270, 31652, 31650
12804, 1081, 31570, 31574, 1082, 31645, 31653, 31654, 1093
12805, 31570, 31571, 31575, 31574, 31647, 31655, 31656, 31653
12806, 31571, 31572, 31576, 31575, 31649, 31657, 31658, 31655
12807, 31572, 31573, 31577, 31576, 31651, 31659, 31660, 31657
12808, 31573, 3259, 3260, 31577, 31652, 3271, 31661, 31659
12809, 1082, 31574, 31578, 1083, 31654, 31662, 31663, 1094
12810, 31574, 31575, 31579, 31578, 31656, 31664, 31665, 31662
12811, 31575, 31576, 31580, 31579, 31658, 31666, 31667, 31664
12812, 31576, 31577, 31581, 31580, 31660, 31668, 31669, 31666
12813, 31577, 3260, 3261, 31581, 31661, 3272, 31670, 31668
12814, 1083, 31578, 31582, 1084, 31663, 31671, 31672, 1095
12815, 31578, 31579, 31583, 31582, 31665, 31673, 31674, 31671
12816, 31579, 31580, 31584, 31583, 31667, 31675, 31676, 31673
12817, 31580, 31581, 31585, 31584, 31669, 31677, 31678, 31675
12818, 31581, 3261, 3262, 31585, 31670, 3273, 31679, 31677
12819, 1084, 31582, 31586, 1085, 31672, 31680, 31681, 1096
12820, 31582, 31583, 31587, 31586, 31674, 31682, 31683, 31680
12821, 31583, 31584, 31588, 31587, 31676, 31684, 31685, 31682
12822, 31584, 31585, 31589, 31588, 31678, 31686, 31687, 31684
12823, 31585, 3262, 3263, 31589, 31679, 3274, 31688, 31686
12824, 1085, 31586, 3244, 23, 31681, 31689, 3248, 1097
12825, 31586, 31587, 3245, 3244, 31683, 31690, 3249, 31689
12826, 31587, 31588, 3246, 3245, 31685, 31691, 3250, 31690
12827, 31588, 31589, 3247, 3246, 31687, 31692, 3251, 31691
12828, 31589, 3263, 79, 3247, 31688, 3275, 3252, 31692
*ELEMENT, type=CPS8, ELSET=Surface107
12829, 24, 1103, 31693, 3276, 1126, 31785, 31786, 3280
12830, 3276, 31693, 31694, 3277, 31786, 31787, 31788, 3281
12831, 3277, 31694, 31695, 3278, 31788, 31789, 31790, 3282
12832, 3278, 31695, 31696, 3279, 31790, 31791, 31792, 3283
12833, 3279, 31696, 3285, 80, 31792, 31793, 3308, 3284
12834, 1103, 1104, 31697, 31693, 1127, 31794, 31795, 31785
12835, 31693, 31697, 31698, 31694, 31795, 31796, 31797, 31787
12836, 31694, 31698, 31699, 31695, 31797, 31798, 31799, 31789
12837, 31695, 31699, 31700, 31696, 31799, 31800, 31801, 31791
12838, 31696, 31700, 3286, 3285, 31801, 31802, 3309, 31793
12839, 1104, 1105, 31701, 31697, 1128, 31803, 31804, 31794
12840, 31697, 31701, 31702, 31698, 31804, 31805, 31806, 31796
12841, 31698, 31702, 31703, 31699, 31806, 31807, 31808, 31798
12842, 31699, 31703, 31704, 31700, 31808, 31809, 31810, 31800
12843, 31700, 31704, 3287, 3286, 31810, 31811, 3310, 31802
12844, 1105, 1106, 31705, 31701, 1129, 31812, 31813, 31803
12845, 31701, 31705, 31706, 31702, 31813, 31814, 31815, 31805
12846, 31702, 31706, 31707, 31703, 31815, 31816, 31817, 31807
12847, 31703, 31707, 31708, 31704, 31817, 31818, 31819, 31809
12848, 31704, 31708, 3288, 3287, 31819, 31820, 3311, 31811
12849, 1106, 1107, 31709, 31705, 1130, 31821, 31822, 31812
12850, 31705, 31709, 31710, 31706, 31822, 31823, 31824, 31814
12851, 31706, 31710, 31711, 31707, 31824, 31825, 31826, 31816
12852, 31707, 31711, 31712, 31708, 31826, 31827, 31828, 31818
12853, 31708, 31712, 3289, 3288, 31828, 31829, 3312, 31820
12854, 1107, 1108, 31713, 31709, 1131, 31830, 31831, 31821
12855, 31709, 31713, 31714, 31710, 31831, 31832, 31833, 31823
12856, 31710, 31714, 31715, 31711, 31833, 31834, 31835, 31825
12857, 31711, 31715, 31716, 31712, 31835, 31836, 31837, 31827
12858, 31712, 31716, 3290, 3289, 31837, 31838, 3313, 31829
12859, 1108, 1109, 31717, 31713, 1132, 31839, 31840, 31830
12860, 31713, 31717, 31718, 31714, 31840, 31841, 31842, 31832
12861, 31714, 31718, 31719, 31715, 31842, 31843, 31844, 31834
12862, 31715, 31719, 31720, 31716, 31844, 31845, 31846, 31836
12863, 31716, 31720, 3291, 3290, 31846, 31847, 3314, 31838
12864, 1109, 1110, 31721, 31717, 1133, 31848, 31849, 31839
12865, 31717, 31721, 31722, 31718, 31849, 31850, 31851, 31841
12866, 31718, 31722, 31723, 31719, 31851, 31852, 31853, 31843
12867, 31719, 31723, 31724, 31720, 31853, 31854, 31855, 31845
12868, 31720, 31724, 3292, 3291, 31855, 31856, 3315, 31847
12869, 1110, 1111, 31725, 31721, 1134, 31857, 31858, 31848
12870, 31721, 31725, 31726, 31722, 31858, 31859, 31860, 31850
12871, 31722, 31726, 31727, 31723, 31860, 31861, 31862, 31852
12872, 31723, 31727, 31728, 31724, 31862, 31863, 31864, 31854
12873, 31724, 31728, 3293, 3292, 31864, 31865, 3316, 31856
12874, 1111, 1112, 31729, 31725, 1135, 31866, 31867, 31857
12875, 31725, 31729, 31730, 31726, 31867, 31868, 31869, 31859
12876, 31726, 31730, 31731, 31727, 31869, 31870, 31871, 31861
12877, 31727, 31731, 31732, 31728, 31871, 31872, 31873, 31863
12878, 31728, 31732, 3294, 3293, 31873, 31874, 3317, 31865
12879, 1112, 1113, 31733, 31729, 1136, 31875, 31876, 31866
12880, 31729, 31733, 31734, 31730, 31876, 31877, 31878, 31868
12881, 31730, 31734, 31735, 31731, 31878, 31879, 31880, 31870
12882, 31731, 31735, 31736, 31732, 31880, 31881, 31882, 31872
12883, 31732, 31736, 3295, 3294, 31882, 31883, 3318, 31874
12884, 1113, 1114, 31737, 31733, 1137, 31884, 31885, 31875
12885, 31733, 31737, 31738, 31734, 31885, 31886, 31887, 31877
12886, 31734, 31738, 31739, 31735, 31887, 31888, 31889, 31879
12887, 31735, 31739, 31740, 31736, 31889, 31890, 31891, 31881
12888, 31736, 31740, 3296, 3295, 31891, 31892, 3319, 31883
12889, 1114, 1115, 31741, 31737, 1138, 31893, 31894, 31884
12890, 31737, 31741, 31742, 31738, 31894, 31895, 31896, 31886
12891, 31738, 31742, 31743, 31739, 31896, 31897, 31898, 31888
12892, 31739, 31743, 31744, 31740, 31898, 31899, 31900, 31890
12893, 31740, 31744, 3297, 3296, 31900, 31901, 3320, 31892
12894, 1115, 1116, 31745, 31741, 1139, 31902, 31903, 31893
12895, 31741, 31745, 31746, 31742, 31903, 31904, 31905, 31895
12896, 31742, 31746, 31747, 31743, 31905, 31906, 31907, 31897
12897, 31743, 31747, 31748, 31744, 31907, 31908, 31909, 31899
12898, 31744, 31748, 3298, 3297, 31909, 31910, 3321, 31901
12899, 1116, 1117, 31749, 31745, 1140, 31911, 31912, 31902
12900, 31745, 31749, 31750, 31746, 31912, 31913, 31914, 31904
12901, 31746, 31750, 31751, 31747, 31914, 31915, 31916, 31906
12902, 31747, 31751, 31752, 31748, 31916, 31917, 31918, 31908
12903, 31748, 31752, 3299, 3298, 31918, 31919, 3322, 31910
12904, 1117, 1118, 31753, 31749, 1141, 31920, 31921, 31911
12905, 31749, 31753, 31754, 31750, 31921, 31922, 31923, 31913
12906, 31750, 31754, 31755, 31751, 31923, 31924, 31925, 31915
12907, 31751, 31755, 31756, 31752, 31925, 31926, 31927, 31917
12908, 31752, 31756, 3300, 3299, 31927, 31928, 3323, 31919
12909, 1118, 1119, 31757, 31753, 1142, 31929, 31930, 31920
12910, 31753, 31757, 31758, 31754, 31930, 31931, 31932, 31922
12911, 31754, 31758, 31759, 31755, 31932, 31933, 31934, 31924
12912, 31755, 31759, 31760, 31756, 31934, 31935, 31936, 31926
12913, 31756, 31760, 3301, 3300, 31936, 31937, 3324, 31928
12914, 1119, 1120, 31761, 31757, 1143, 31938, 31939, 31929
12915, 31757, 31761, 31762, 31758, 31939, 31940, 31941, 31931
12916, 31758, 31762, 31763, 31759, 31941, 31942, 31943, 31933
12917, 31759, 31763, 31764, 31760, 31943, 31944, 31945, 31935
12918, 31760, 31764, 3302, 3301, 31945, 31946, 3325, 31937
12919, 1120, 1121, 31765, 31761, 1144, 31947, 31948, 31938
12920, 31761, 31765, 31766, 31762, 31948, 31949, 31950, 31940
12921, 31762, 31766, 31767, 31763, 31950, 31951, 31952, 31942
12922, 31763, 31767, 31768, 31764, 31952, 31953, 31954, 31944
12923, 31764, 31768, 3303, 3302, 31954, 31955, 3326, 31946
12924, 1121, 1122, 31769, 31765, 1145, 31956, 31957, 31947
12925, 31765, 31769, 31770, 31766, 31957, 31958, 31959, 31949
12926, 31766, 31770, 31771, 31767, 31959, 31960, 31961, 31951
12927, 31767, 31771, 31772, 31768, 31961, 31962, 31963, 31953
12928, 31768, 31772, 3304, 3303, 31963, 31964, 3327, 31955
12929, 1122, 1123, 31773, 31769, 1146, 31965, 31966, 31956
12930, 31769, 31773, 31774, 31770, 31966, 31967, 31968, 31958
12931, 31770, 31774, 31775, 31771, 31968, 31969, 31970, 31960
12932, 31771, 31775, 31776, 31772, 31970, 31971, 31972, 31962
12933, 31772, 31776, 3305, 3304, 31972, 31973, 3328, 31964
12934, 1123, 1124, 31777, 31773, 1147, 31974, 31975, 31965
12935, 31773, 31777, 31778, 31774, 31975, 31976, 31977, 31967
12936, 31774, 31778, 31779, 31775, 31977, 31978, 31979, 31969
12937, 31775, 31779, 31780, 31776, 31979, 31980, 31981, 31971
12938, 31776, 31780, 3306, 3305, 31981, 31982, 3329, 31973
12939, 1124, 1125, 31781, 31777, 1148, 31983, 31984, 31974
12940, 31777, 31781, 31782, 31778, 31984, 31985, 31986, 31976
12941, 31778, 31782, 31783, 31779, 31986, 31987, 31988, 31978
12942, 31779, 31783, 31784, 31780, 31988, 31989, 31990, 31980
12943, 31780, 31784, 3307, 3306, 31990, 31991, 3330, 31982
12944, 1125, 23, 3244, 31781, 1149, 3248, 31992, 31983
12945, 31781, 3244, 3245, 31782, 31992, 3249, 31993, 31985
12946, 31782, 3245, 3246, 31783, 31993, 3250, 31994, 31987
12947, 31783, 3246, 3247, 31784, 31994, 3251, 31995, 31989
12948, 31784, 3247, 79, 3307, 31995, 3252, 3331, 31991
*ELEMENT, type=CPS8, ELSET=Surface108
12949, 22, 1150, 31996, 3188, 1161, 32040, 32041, 3192
12950, 3188, 31996, 31997, 3189, 32041, 32042, 32043, 3193
12951, 3189, 31997, 31998, 3190, 32043, 32044, 32045, 3194
12952, 3190, 31998, 31999, 3191, 32045, 32046, 32047, 3195
12953, 3191, 31999, 3332, 78, 32047, 32048, 3343, 3196
12954, 1150, 1151, 32000, 31996, 1162, 32049, 32050, 32040
12955, 31996, 32000, 32001, 31997, 32050, 32051, 32052, 32042
12956, 31997, 32001, 32002, 31998, 32052, 32053, 32054, 32044
12957, 31998, 32002, 32003, 31999, 32054, 32055, 32056, 32046
12958, 31999, 32003, 3333, 3332, 32056, 32057, 3344, 32048
12959, 1151, 1152, 32004, 32000, 1163, 32058, 32059, 32049
12960, 32000, 32004, 32005, 32001, 32059, 32060, 32061, 32051
12961, 32001, 32005, 32006, 32002, 32061, 32062, 32063, 32053
12962, 32002, 32006, 32007, 32003, 32063, 32064, 32065, 32055
12963, 32003, 32007, 3334, 3333, 32065, 32066, 3345, 32057
12964, 1152, 1153, 32008, 32004, 1164, 32067, 32068, 32058
12965, 32004, 32008, 32009, 32005, 32068, 32069, 32070, 32060
12966, 32005, 32009, 32010, 32006, 32070, 32071, 32072, 32062
12967, 32006, 32010, 32011, 32007, 32072, 32073, 32074, 32064
12968, 32007, 32011, 3335, 3334, 32074, 32075, 3346, 32066
12969, 1153, 1154, 32012, 32008, 1165, 32076, 32077, 32067
12970, 32008, 32012, 32013, 32009, 32077, 32078, 32079, 32069
12971, 32009, 32013, 32014, 32010, 32079, 32080, 32081, 32071
12972, 32010, 32014, 32015, 32011, 32081, 32082, 32083, 32073
12973, 32011, 32015, 3336, 3335, 32083, 32084, 3347, 32075
12974, 1154, 1155, 32016, 32012, 1166, 32085, 32086, 32076
12975, 32012, 32016, 32017, 32013, 32086, 32087, 32088, 32078
12976, 32013, 32017, 32018, 32014, 32088, 32089, 32090, 32080
12977, 32014, 32018, 32019, 32015, 32090, 32091, 32092, 32082
12978, 32015, 32019, 3337, 3336, 32092, 32093, 3348, 32084
12979, 1155, 1156, 32020, 32016, 1167, 32094, 32095, 32085
12980, 32016, 32020, 32021, 32017, 32095, 32096, 32097, 32087
12981, 32017, 32021, 32022, 32018, 32097, 32098, 32099, 32089
12982, 32018, 32022, 32023, 32019, 32099, 32100, 32101, 32091
12983, 32019, 32023, 3338, 3337, 32101, 32102, 3349, 32093
12984, 1156, 1157, 32024, 32020, 1168, 32103, 32104, 32094
12985, 32020, 32024, 32025, 32021, 32104, 32105, 32106, 32096
12986, 32021, 32025, 32026, 32022, 32106, 32107, 32108, 32098
12987, 32022, 32026, 32027, 32023, 32108, 32109, 32110, 32100
12988, 32023, 32027, 3339, 3338, 32110, 32111, 3350, 32102
12989, 1157, 1158, 32028, 32024, 1169, 32112, 32113, 32103
12990, 32024, 32028, 32029, 32025, 32113, 32114, 32115, 32105
12991, 32025, 32029, 32030, 32026, 32115, 32116, 32117, 32107
12992, 32026, 32030, 32031, 32027, 32117, 32118, 32119, 32109
12993, 32027, 32031, 3340, 3339, 32119, 32120, 3351, 32111
12994, 1158, 1159, 32032, 32028, 1170, 32121, 32122, 32112
12995, 32028, 32032, 32033, 32029, 32122, 32123, 32124, 32114
12996, 32029, 32033, 32034, 32030, 32124, 32125, 32126, 32116
12997, 32030, 32034, 32035, 32031, 32126, 32127, 32128, 32118
12998, 32031, 32035, 3341, 3340, 32128, 32129, 3352, 32120
12999, 1159, 1160, 32036, 32032, 1171, 32130, 32131, 32121
13000, 32032, 32036, 32037, 32033, 32131, 32132, 32133, 32123
13001, 32033, 32037, 32038, 32034, 32133, 32134, 32135, 32125
13002, 32034, 32038, 32039, 32035, 32135, 32136, 32137, 32127
13003, 32035, 32039, 3342, 3341, 32137, 32138, 3353, 32129
13004, 1160, 24, 3276, 32036, 1172, 3280, 32139, 32130
13005, 32036, 3276, 3277, 32037, 32139, 3281, 32140, 32132
13006, 32037, 3277, 3278, 32038, 32140, 3282, 32141, 32134
13007, 32038, 3278, 3279, 32039, 32141, 3283, 32142, 32136
13008, 32039, 3279, 80, 3342, 32142, 3284, 3354, 32138
*ELEMENT, type=CPS8, ELSET=Surface109
13009, 78, 3332, 32143, 3197, 3343, 32396, 32397, 3220
13010, 3332, 3333, 32144, 32143, 3344, 32398, 32399, 32396
13011, 3333, 3334, 32145, 32144, 3345, 32400, 32401, 32398
13012, 3334, 3335, 32146, 32145, 3346, 32402, 32403, 32400
13013, 3335, 3336, 32147, 32146, 3347, 32404, 32405, 32402
13014, 3336, 3337, 32148, 32147, 3348, 32406, 32407, 32404
13015, 3337, 3338, 32149, 32148, 3349, 32408, 32409, 32406
13016, 3338, 3339, 32150, 32149, 3350, 32410, 32411, 32408
13017, 3339, 3340, 32151, 32150, 3351, 32412, 32413, 32410
13018, 3340, 3341, 32152, 32151, 3352, 32414, 32415, 32412
13019, 3341, 3342, 32153, 32152, 3353, 32416, 32417, 32414
13020, 3342, 80, 3285, 32153, 3354, 3308, 32418, 32416
13021, 3197, 32143, 32154, 3198, 32397, 32419, 32420, 3221
13022, 32143, 32144, 32155, 32154, 32399, 32421, 32422, 32419
13023, 32144, 32145, 32156, 32155, 32401, 32423, 32424, 32421
13024, 32145, 32146, 32157, 32156, 32403, 32425, 32426, 32423
13025, 32146, 32147, 32158, 32157, 32405, 32427, 32428, 32425
13026, 32147, 32148, 32159, 32158, 32407, 32429, 32430, 32427
13027, 32148, 32149, 32160, 32159, 32409, 32431, 32432, 32429
13028, 32149, 32150, 32161, 32160, 32411, 32433, 32434, 32431
13029, 32150, 32151, 32162, 32161, 32413, 32435, 32436, 32433
13030, 32151, 32152, 32163, 32162, 32415, 32437, 32438, 32435
13031, 32152, 32153, 32164, 32163, 32417, 32439, 32440, 32437
13032, 32153, 3285, 3286, 32164, 32418, 3309, 32441, 32439
13033, 3198, 32154, 32165, 3199, 32420, 32442, 32443, 3222
13034, 32154, 32155, 32166, 32165, 32422, 32444, 32445, 32442
13035, 32155, 32156, 32167, 32166, 32424, 32446, 32447, 32444
13036, 32156, 32157, 32168, 32167, 32426, 32448, 32449, 32446
13037, 32157, 32158, 32169, 32168, 32428, 32450, 32451, 32448
13038, 32158, 32159, 32170, 32169, 32430, 32452, 32453, 32450
13039, 32159, 32160, 32171, 32170, 32432, 32454, 32455, 32452
13040, 32160, 32161, 32172, 32171, 32434, 32456, 32457, 32454
13041, 32161, 32162, 32173, 32172, 32436, 32458, 32459, 32456
13042, 32162, 32163, 32174, 32173, 32438, 32460, 32461, 32458
13043, 32163, 32164, 32175, 32174, 32440, 32462, 32463, 32460
13044, 32164, 3286, 3287, 32175, 32441, 3310, 32464, 32462
13045, 3199, 32165, 32176, 3200, 32443, 32465, 32466, 3223
13046, 32165, 32166, 32177, 32176, 32445, 32467, 32468, 32465
13047, 32166, 32167, 32178, 32177, 32447, 32469, 32470, 32467
13048, 32167, 32168, 32179, 32178, 32449, 32471, 32472, 32469
13049, 32168, 32169, 32180, 32179, 32451, 32473, 32474, 32471
13050, 32169, 32170, 32181, 32180, 32453, 32475, 32476, 32473
13051, 32170, 32171, 32182, 32181, 32455, 32477, 32478, 32475
13052, 32171, 32172, 32183, 32182, 32457, 32479, 32480, 32477
13053, 32172, 32173, 32184, 32183, 32459, 32481, 32482, 32479
13054, 32173, 32174, 32185, 32184, 32461, 32483, 32484, 32481
13055, 32174, 32175, 32186, 32185, 32463, 32485, 32486, 32483
13056, 32175, 3287, 3288, 32186, 32464, 3311, 32487, 32485
13057, 3200, 32176, 32187, 3201, 32466, 32488, 32489, 3224
13058, 32176, 32177, 32188, 32187, 32468, 32490, 32491, 32488
13059, 32177, 32178, 32189, 32188, 32470, 32492, 32493, 32490
13060, 32178, 32179, 32190, 32189, 32472, 32494, 32495, 32492
13061, 32179, 32180, 32191, 32190, 32474, 32496, 32497, 32494
13062, 32180, 32181, 32192, 32191, 32476, 32498, 32499, 32496
13063, 32181, 32182, 32193, 32192, 32478, 32500, 32501, 32498
13064, 32182, 32183, 32194, 32193, 32480, 32502, 32503, 32500
13065, 32183, 32184, 32195, 32194, 32482, 32504, 32505, 32502
13066, 32184, 32185, 32196, 32195, 32484, 32506, 32507, 32504
13067, 32185, 32186, 32197, 32196, 32486, 32508, 32509, 32506
13068, 32186, 3288, 3289, 32197, 32487, 3312, 32510, 32508
13069, 3201, 32187, 32198, 3202, 32489, 32511, 32512, 3225
13070, 32187, 32188, 32199, 32198, 32491, 32513, 32514, 32511
13071, 32188, 32189, 32200, 32199, 32493, 32515, 32516, 32513
13072, 32189, 32190, 32201, 32200, 32495, 32517, 32518, 32515
13073, 32190, 32191, 32202, 32201, 32497, 32519, 32520, 32517
13074, 32191, 32192, 32203, 32202, 32499, 32521, 32522, 32519
13075, 32192, 32193, 32204, 32203, 32501, 32523, 32524, 32521
13076, 32193, 32194, 32205, 32204, 32503, 32525, 32526, 32523
13077, 32194, 32195, 32206, 32205, 32505, 32527, 32528, 32525
13078, 32195, 32196, 32207, 32206, 32507, 32529, 32530, 32527
13079, 32196, 32197, 32208, 32207, 32509, 32531, 32532, 32529
13080, 32197, 3289, 3290, 32208, 32510, 3313, 32533, 32531
13081, 3202, 32198, 32209, 3203, 32512, 32534, 32535, 3226
13082, 32198, 32199, 32210, 32209, 32514, 32536, 32537, 32534
13083, 32199, 32200, 32211, 32210, 32516, 32538, 32539, 32536
13084, 32200, 32201, 32212, 32211, 32518, 32540, 32541, 32538
13085, 32201, 32202, 32213, 32212, 32520, 32542, 32543, 32540
13086, 32202, 32203, 32214, 32213, 32522, 32544, 32545, 32542
13087, 32203, 32204, 32215, 32214, 32524, 32546, 32547, 32544
13088, 32204, 32205, 32216, 32215, 32526, 32548, 32549, 32546
13089, 32205, 32206, 32217, 32216, 32528, 32550, 32551, 32548
13090, 32206, 32207, 32218, 32217, 32530, 32552, 32553, 32550
13091, 32207, 32208, 32219, 32218, 32532, 32554, 32555, 32552
13092, 32208, 3290, 3291, 32219, 32533, 3314, 32556, 32554
13093, 3203, 32209, 32220, 3204, 32535, 32557, 32558, 3227
13094, 32209, 32210, 32221, 32220, 32537, 32559, 32560, 32557
13095, 32210, 32211, 32222, 32221, 32539, 32561, 32562, 32559
13096, 32211, 32212, 32223, 32222, 32541, 32563, 32564, 32561
13097, 32212, 32213, 32224, 32223, 32543, 32565, 32566, 32563
13098, 32213, 32214, 32225, 32224, 32545, 32567, 32568, 32565
13099, 32214, 32215, 32226, 32225, 32547, 32569, 32570, 32567
13100, 32215, 32216, 32227, 32226, 32549, 32571, 32572, 32569
13101, 32216, 32217, 32228, 32227, 32551, 32573, 32574, 32571
13102, 32217, 32218, 32229, 32228, 32553, 32575, 32576, 32573
13103, 32218, 32219, 32230, 32229, 32555, 32577, 32578, 32575
13104, 32219, 3291, 3292, 32230, 32556, 3315, 32579, 32577
13105, 3204, 32220, 32231, 3205, 32558, 32580, 32581, 3228
13106, 32220, 32221, 32232, 32231, 32560, 32582, 32583, 32580
13107, 32221, 32222, 32233, 32232, 32562, 32584, 32585, 32582
13108, 32222, 32223, 32234, 32233, 32564, 32586, 32587, 32584
13109, 32223, 32224, 32235, 32234, 32566, 32588, 32589, 32586
13110, 32224, 32225, 32236, 32235, 32568, 32590, 32591, 32588
13111, 32225, 32226, 32237, 32236, 32570, 32592, 32593, 32590
13112, 32226, 32227, 32238, 32237, 32572, 32594, 32595, 32592
13113, 32227, 32228, 32239, 32238, 32574, 32596, 32597, 32594
13114, 32228, 32229, 32240, 32239, 32576, 32598, 32599, 32596
13115, 32229, 32230, 32241, 32240, 32578, 32600, 32601, 32598
13116, 32230, 3292, 3293, 32241, 32579, 3316, 32602, 32600
13117, 3205, 32231, 32242, 3206, 32581, 32603, 32604, 3229
13118, 32231, 32232, 32243, 32242, 32583, 32605, 32606, 32603
13119, 32232, 32233, 32244, 32243, 32585, 32607, 32608, 32605
13120, 32233, 32234, 32245, 32244, 32587, 32609, 32610, 32607
13121, 32234, 32235, 32246, 32245, 32589, 32611, 32612, 32609
13122, 32235, 32236, 32247, 32246, 32591, 32613, 32614, 32611
13123, 32236, 32237, 32248, 32247, 32593, 32615, 32616, 32613
13124, 32237, 32238, 32249, 32248, 32595, 32617, 32618, 32615
13125, 32238, 32239, 32250, 32249, 32597, 32619, 32620, 32617
13126, 32239, 32240, 32251, 32250, 32599, 32621, 32622, 32619
13127, 32240, 32241, 32252, 32251, 32601, 32623, 32624, 32621
13128, 32241, 3293, 3294, 32252, 32602, 3317, 32625, 32623
13129, 3206, 32242, 32253, 3207, 32604, 32626, 32627, 3230
13130, 32242, 32243, 32254, 32253, 32606, 32628, 32629, 32626
13131, 32243, 32244, 32255, 32254, 32608, 32630, 32631, 32628
13132, 32244, 32245, 32256, 32255, 32610, 32632, 32633, 32630
13133, 32245, 32246, 32257, 32256, 32612, 32634, 32635, 32632
13134, 32246, 32247, 32258, 32257, 32614, 32636, 32637, 32634
13135, 32247, 32248, 32259, 32258, 32616, 32638, 32639, 32636
13136, 32248, 32249, 32260, 32259, 32618, 32640, 32641, 32638
13137, 32249, 32250, 32261, 32260, 32620, 32642, 32643, 32640
13138, 32250, 32251, 32262, 32261, 32622, 32644, 32645, 32642
13139, 32251, 32252, 32263, 32262, 32624, 32646, 32647, 32644
13140, 32252, 3294, 3295, 32263, 32625, 3318, 32648, 32646
13141, 3207, 32253, 32264, 3208, 32627, 32649, 32650, 3231
13142, 32253, 32254, 32265, 32264, 32629, 32651, 32652, 32649
13143, 32254, 32255, 32266, 32265, 32631, 32653, 32654, 32651
13144, 32255, 32256, 32267, 32266, 32633, 32655, 32656, 32653
13145, 32256, 32257, 32268, 32267, 32635, 32657, 32658, 32655
13146, 32257, 32258, 32269, 32268, 32637, 32659, 32660, 32657
13147, 32258, 32259, 32270, 32269, 32639, 32661, 32662, 32659
13148, 32259, 32260, 32271, 32270, 32641, 32663, 32664, 32661
13149, 32260, 32261, 32272, 32271, 32643, 32665, 32666, 32663
13150, 32261, 32262, 32273, 32272, 32645, 32667, 32668, 32665
13151, 32262, 32263, 32274, 32273, 32647, 32669, 32670, 32667
13152, 32263, 3295, 3296, 32274, 32648, 3319, 32671, 32669
13153, 3208, 32264, 32275, 3209, 32650, 32672, 32673, 3232
13154, 32264, 32265, 32276, 32275, 32652, 32674, 32675, 32672
13155, 32265, 32266, 32277, 32276, 32654, 32676, 32677, 32674
13156, 32266, 32267, 32278, 32277, 32656, 32678, 32679, 32676
13157, 32267, 32268, 32279, 32278, 32658, 32680, 32681, 32678
13158, 32268, 32269, 32280, 32279, 32660, 32682, 32683, 32680
13159, 32269, 32270, 32281, 32280, 32662, 32684, 32685, 32682
13160, 32270, 32271, 32282, 32281, 32664, 32686, 32687, 32684
13161, 32271, 32272, 32283, 32282, 32666, 32688, 32689, 32686
13162, 32272, 32273, 32284, 32283, 32668, 32690, 32691, 32688
13163, 32273, 32274, 32285, 32284, 32670, 32692, 32693, 32690
13164, 32274, 3296, 3297, 32285, 32671, 3320, 32694, 32692
13165, 3209, 32275, 32286, 3210, 32673, 32695, 32696, 3233
13166, 32275, 32276, 32287, 32286, 32675, 32697, 32698, 32695
13167, 32276, 32277, 32288, 32287, 32677, 32699, 32700, 32697
13168, 32277, 32278, 32289, 32288, 32679, 32701, 32702, 32699
13169, 32278, 32279, 32290, 32289, 32681, 32703, 32704, 32701
13170, 32279, 32280, 32291, 32290, 32683, 32705, 32706, 32703
13171, 32280, 32281, 32292, 32291, 32685, 32707, 32708, 32705
13172, 32281, 32282, 32293, 32292, 32687, 32709, 32710, 32707
13173, 32282, 32283, 32294, 32293, 32689, 32711, 32712, 32709
13174, 32283, 32284, 32295, 32294, 32691, 32713, 32714, 32711
13175, 32284, 32285, 32296, 32295, 32693, 32715, 32716, 32713
13176, 32285, 3297, 3298, 32296, 32694, 3321, 32717, 32715
13177, 3210, 32286, 32297, 3211, 32696, 32718, 32719, 3234
13178, 32286, 32287, 32298, 32297, 32698, 32720, 32721, 32718
13179, 32287, 32288, 32299, 32298, 32700, 32722, 32723, 32720
13180, 32288, 32289, 32300, 32299, 32702, 32724, 32725, 32722
13181, 32289, 32290, 32301, 32300, 32704, 32726, 32727, 32724
13182, 32290, 32291, 32302, 32301, 32706, 32728, 32729, 32726
13183, 32291, 32292, 32303, 32302, 32708, 32730, 32731, 32728
13184, 32292, 32293, 32304, 32303, 32710, 32732, 32733, 32730
13185, 32293, 32294, 32305, 32304, 32712, 32734, 32735, 32732
13186, 32294, 32295, 32306, 32305, 32714, 32736, 32737, 32734
13187, 32295, 32296, 32307, 32306, 32716, 32738, 32739, 32736
13188, 32296, 3298, 3299, 32307, 32717, 3322, 32740, 32738
13189, 3211, 32297, 32308, 3212, 32719, 32741, 32742, 3235
13190, 32297, 32298, 32309, 32308, 32721, 32743, 32744, 32741
13191, 32298, 32299, 32310, 32309, 32723, 32745, 32746, 32743
13192, 32299, 32300, 32311, 32310, 32725, 32747, 32748, 32745
13193, 32300, 32301, 32312, 32311, 32727, 32749, 32750, 32747
13194, 32301, 32302, 32313, 32312, 32729, 32751, 32752, 32749
13195, 32302, 32303, 32314, 32313, 32731, 32753, 32754, 32751
13196, 32303, 32304, 32315, 32314, 32733, 32755, 32756, 32753
13197, 32304, 32305, 32316, 32315, 32735, 32757, 32758, 32755
13198, 32305, 32306, 32317, 32316, 32737, 32759, 32760, 32757
13199, 32306, 32307, 32318, 32317, 32739, 32761, 32762, 32759
13200, 32307, 3299, 3300, 32318, 32740, 3323, 32763, 32761
13201, 3212, 32308, 32319, 3213, 32742, 32764, 32765, 3236
13202, 32308, 32309, 32320, 32319, 32744, 32766, 32767, 32764
13203, 32309, 32310, 32321, 32320, 32746, 32768, 32769, 32766
13204, 32310, 32311, 32322, 32321, 32748, 32770, 32771, 32768
13205, 32311, 32312, 32323, 32322, 32750, 32772, 32773, 32770
13206, 32312, 32313, 32324, 32323, 32752, 32774, 32775, 32772
13207, 32313, 32314, 32325, 32324, 32754, 32776, 32777, 32774
13208, 32314, 32315, 32326, 32325, 32756, 32778, 32779, 32776
13209, 32315, 32316, 32327, 32326, 32758, 32780, 32781, 32778
13210, 32316, 32317, 32328, 32327, 32760, 32782, 32783, 32780
13211, 32317, 32318, 32329, 32328, 32762, 32784, 32785, 32782
13212, 32318, 3300, 3301, 32329, 32763, 3324, 32786, 32784
13213, 3213, 32319, 32330, 3214, 32765, 32787, 32788, 3237
13214, 32319, 32320, 32331, 32330, 32767, 32789, 32790, 32787
13215, 32320, 32321, 32332, 32331, 32769, 32791, 32792, 32789
13216, 32321, 32322, 32333, 32332, 32771, 32793, 32794, 32791
13217, 32322, 32323, 32334, 32333, 32773, 32795, 32796, 32793
13218, 32323, 32324, 32335, 32334, 32775, 32797, 32798, 32795
13219, 32324, 32325, 32336, 32335, 32777, 32799, 32800, 32797
13220, 32325, 32326, 32337, 32336, 32779, 32801, 32802, 32799
13221, 32326, 32327, 32338, 32337, 32781, 32803, 32804, 32801
13222, 32327, 32328, 32339, 32338, 32783, 32805, 32806, 32803
13223, 32328, 32329, 32340, 32339, 32785, 32807, 32808, 32805
13224, 32329, 3301, 3302, 32340, 32786, 3325, 32809, 32807
13225, 3214, 32330, 32341, 3215, 32788, 32810, 32811, 3238
13226, 32330, 32331, 32342, 32341, 32790, 32812, 32813, 32810
13227, 32331, 32332, 32343, 32342, 32792, 32814, 32815, 32812
