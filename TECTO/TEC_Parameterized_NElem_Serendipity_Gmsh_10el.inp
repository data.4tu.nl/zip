33792, 95991, 95993, 96039, 96037, 95992, 95994, 96040, 96038, 97243, 97405, 97406, 97398, 97246, 97408, 97409, 
97401, 97237, 97244, 97407, 97400
33793, 95992, 95994, 96040, 96038, 25121, 25122, 25145, 25144, 97246, 97408, 97409, 97401, 25528, 25574, 25575, 
25572, 97240, 97247, 97410, 97403
33794, 23845, 23846, 23869, 23868, 95993, 95995, 96041, 96039, 24253, 24299, 24300, 24297, 97250, 97412, 97413, 
97405, 97241, 97248, 97411, 97404
33795, 95993, 95995, 96041, 96039, 95994, 95996, 96042, 96040, 97250, 97412, 97413, 97405, 97253, 97415, 97416, 
97408, 97244, 97251, 97414, 97407
33796, 95994, 95996, 96042, 96040, 25122, 25123, 25146, 25145, 97253, 97415, 97416, 97408, 25530, 25576, 25577, 
25574, 97247, 97254, 97417, 97410
33797, 23846, 23847, 23870, 23869, 95995, 95997, 96043, 96041, 24255, 24301, 24302, 24299, 97257, 97419, 97420, 
97412, 97248, 97255, 97418, 97411
33798, 95995, 95997, 96043, 96041, 95996, 95998, 96044, 96042, 97257, 97419, 97420, 97412, 97260, 97422, 97423, 
97415, 97251, 97258, 97421, 97414
33799, 95996, 95998, 96044, 96042, 25123, 25124, 25147, 25146, 97260, 97422, 97423, 97415, 25532, 25578, 25579, 
25576, 97254, 97261, 97424, 97417
33800, 23847, 23848, 23871, 23870, 95997, 95999, 96045, 96043, 24257, 24303, 24304, 24301, 97264, 97426, 97427, 
97419, 97255, 97262, 97425, 97418
33801, 95997, 95999, 96045, 96043, 95998, 96000, 96046, 96044, 97264, 97426, 97427, 97419, 97267, 97429, 97430, 
97422, 97258, 97265, 97428, 97421
33802, 95998, 96000, 96046, 96044, 25124, 25125, 25148, 25147, 97267, 97429, 97430, 97422, 25534, 25580, 25581, 
25578, 97261, 97268, 97431, 97424
33803, 23848, 23849, 23872, 23871, 95999, 96001, 96047, 96045, 24259, 24305, 24306, 24303, 97271, 97433, 97434, 
97426, 97262, 97269, 97432, 97425
33804, 95999, 96001, 96047, 96045, 96000, 96002, 96048, 96046, 97271, 97433, 97434, 97426, 97274, 97436, 97437, 
97429, 97265, 97272, 97435, 97428
33805, 96000, 96002, 96048, 96046, 25125, 25126, 25149, 25148, 97274, 97436, 97437, 97429, 25536, 25582, 25583, 
25580, 97268, 97275, 97438, 97431
33806, 23849, 23850, 23873, 23872, 96001, 96003, 96049, 96047, 24261, 24307, 24308, 24305, 97278, 97440, 97441, 
97433, 97269, 97276, 97439, 97432
33807, 96001, 96003, 96049, 96047, 96002, 96004, 96050, 96048, 97278, 97440, 97441, 97433, 97281, 97443, 97444, 
97436, 97272, 97279, 97442, 97435
33808, 96002, 96004, 96050, 96048, 25126, 25127, 25150, 25149, 97281, 97443, 97444, 97436, 25538, 25584, 25585, 
25582, 97275, 97282, 97445, 97438
33809, 23850, 23851, 23874, 23873, 96003, 96005, 96051, 96049, 24263, 24309, 24310, 24307, 97285, 97447, 97448, 
97440, 97276, 97283, 97446, 97439
33810, 96003, 96005, 96051, 96049, 96004, 96006, 96052, 96050, 97285, 97447, 97448, 97440, 97288, 97450, 97451, 
97443, 97279, 97286, 97449, 97442
33811, 96004, 96006, 96052, 96050, 25127, 25128, 25151, 25150, 97288, 97450, 97451, 97443, 25540, 25586, 25587, 
25584, 97282, 97289, 97452, 97445
33812, 23851, 23852, 23875, 23874, 96005, 96007, 96053, 96051, 24265, 24311, 24312, 24309, 97292, 97454, 97455, 
97447, 97283, 97290, 97453, 97446
33813, 96005, 96007, 96053, 96051, 96006, 96008, 96054, 96052, 97292, 97454, 97455, 97447, 97295, 97457, 97458, 
97450, 97286, 97293, 97456, 97449
33814, 96006, 96008, 96054, 96052, 25128, 25129, 25152, 25151, 97295, 97457, 97458, 97450, 25542, 25588, 25589, 
25586, 97289, 97296, 97459, 97452
33815, 23852, 23853, 23876, 23875, 96007, 96009, 96055, 96053, 24267, 24313, 24314, 24311, 97299, 97461, 97462, 
97454, 97290, 97297, 97460, 97453
33816, 96007, 96009, 96055, 96053, 96008, 96010, 96056, 96054, 97299, 97461, 97462, 97454, 97302, 97464, 97465, 
97457, 97293, 97300, 97463, 97456
33817, 96008, 96010, 96056, 96054, 25129, 25130, 25153, 25152, 97302, 97464, 97465, 97457, 25544, 25590, 25591, 
25588, 97296, 97303, 97466, 97459
33818, 23853, 23854, 23877, 23876, 96009, 96011, 96057, 96055, 24269, 24315, 24316, 24313, 97306, 97468, 97469, 
97461, 97297, 97304, 97467, 97460
33819, 96009, 96011, 96057, 96055, 96010, 96012, 96058, 96056, 97306, 97468, 97469, 97461, 97309, 97471, 97472, 
97464, 97300, 97307, 97470, 97463
33820, 96010, 96012, 96058, 96056, 25130, 25131, 25154, 25153, 97309, 97471, 97472, 97464, 25546, 25592, 25593, 
25590, 97303, 97310, 97473, 97466
33821, 23854, 23855, 23878, 23877, 96011, 96013, 96059, 96057, 24271, 24317, 24318, 24315, 97313, 97475, 97476, 
97468, 97304, 97311, 97474, 97467
33822, 96011, 96013, 96059, 96057, 96012, 96014, 96060, 96058, 97313, 97475, 97476, 97468, 97316, 97478, 97479, 
97471, 97307, 97314, 97477, 97470
33823, 96012, 96014, 96060, 96058, 25131, 25132, 25155, 25154, 97316, 97478, 97479, 97471, 25548, 25594, 25595, 
25592, 97310, 97317, 97480, 97473
33824, 23855, 23856, 23879, 23878, 96013, 96015, 96061, 96059, 24273, 24319, 24320, 24317, 97320, 97482, 97483, 
97475, 97311, 97318, 97481, 97474
33825, 96013, 96015, 96061, 96059, 96014, 96016, 96062, 96060, 97320, 97482, 97483, 97475, 97323, 97485, 97486, 
97478, 97314, 97321, 97484, 97477
33826, 96014, 96016, 96062, 96060, 25132, 25133, 25156, 25155, 97323, 97485, 97486, 97478, 25550, 25596, 25597, 
25594, 97317, 97324, 97487, 97480
33827, 23856, 23857, 23880, 23879, 96015, 96017, 96063, 96061, 24275, 24321, 24322, 24319, 97327, 97489, 97490, 
97482, 97318, 97325, 97488, 97481
33828, 96015, 96017, 96063, 96061, 96016, 96018, 96064, 96062, 97327, 97489, 97490, 97482, 97330, 97492, 97493, 
97485, 97321, 97328, 97491, 97484
33829, 96016, 96018, 96064, 96062, 25133, 25134, 25157, 25156, 97330, 97492, 97493, 97485, 25552, 25598, 25599, 
25596, 97324, 97331, 97494, 97487
33830, 23857, 23858, 23881, 23880, 96017, 96019, 96065, 96063, 24277, 24323, 24324, 24321, 97334, 97496, 97497, 
97489, 97325, 97332, 97495, 97488
33831, 96017, 96019, 96065, 96063, 96018, 96020, 96066, 96064, 97334, 97496, 97497, 97489, 97337, 97499, 97500, 
97492, 97328, 97335, 97498, 97491
33832, 96018, 96020, 96066, 96064, 25134, 25135, 25158, 25157, 97337, 97499, 97500, 97492, 25554, 25600, 25601, 
25598, 97331, 97338, 97501, 97494
33833, 23858, 23859, 23882, 23881, 96019, 96021, 96067, 96065, 24279, 24325, 24326, 24323, 97341, 97503, 97504, 
97496, 97332, 97339, 97502, 97495
33834, 96019, 96021, 96067, 96065, 96020, 96022, 96068, 96066, 97341, 97503, 97504, 97496, 97344, 97506, 97507, 
97499, 97335, 97342, 97505, 97498
33835, 96020, 96022, 96068, 96066, 25135, 25136, 25159, 25158, 97344, 97506, 97507, 97499, 25556, 25602, 25603, 
25600, 97338, 97345, 97508, 97501
33836, 23859, 2108, 2109, 23882, 96021, 24909, 24911, 96067, 24280, 2120, 24327, 24325, 97346, 24955, 97509, 
97503, 97339, 24949, 24954, 97502
33837, 96021, 24909, 24911, 96067, 96022, 24910, 24912, 96068, 97346, 24955, 97509, 97503, 97347, 24957, 97510, 
97506, 97342, 24951, 24956, 97505
33838, 96022, 24910, 24912, 96068, 25136, 2268, 2269, 25159, 97347, 24957, 97510, 97506, 25557, 2280, 25604, 
25602, 97345, 24953, 24958, 97508
33839, 2086, 23860, 23883, 2087, 24832, 96023, 96069, 24834, 24282, 24328, 24329, 2098, 97350, 97512, 97513, 
24880, 24876, 97348, 97511, 24881
33840, 24832, 96023, 96069, 24834, 24833, 96024, 96070, 24835, 97350, 97512, 97513, 24880, 97353, 97515, 97516, 
24882, 24878, 97351, 97514, 24883
33841, 24833, 96024, 96070, 24835, 2246, 25137, 25160, 2247, 97353, 97515, 97516, 24882, 25559, 25605, 25606, 
2258, 24879, 97354, 97517, 24884
33842, 23860, 23861, 23884, 23883, 96023, 96025, 96071, 96069, 24284, 24330, 24331, 24328, 97357, 97519, 97520, 
97512, 97348, 97355, 97518, 97511
33843, 96023, 96025, 96071, 96069, 96024, 96026, 96072, 96070, 97357, 97519, 97520, 97512, 97360, 97522, 97523, 
97515, 97351, 97358, 97521, 97514
33844, 96024, 96026, 96072, 96070, 25137, 25138, 25161, 25160, 97360, 97522, 97523, 97515, 25561, 25607, 25608, 
25605, 97354, 97361, 97524, 97517
33845, 23861, 23862, 23885, 23884, 96025, 96027, 96073, 96071, 24286, 24332, 24333, 24330, 97364, 97526, 97527, 
97519, 97355, 97362, 97525, 97518
33846, 96025, 96027, 96073, 96071, 96026, 96028, 96074, 96072, 97364, 97526, 97527, 97519, 97367, 97529, 97530, 
97522, 97358, 97365, 97528, 97521
33847, 96026, 96028, 96074, 96072, 25138, 25139, 25162, 25161, 97367, 97529, 97530, 97522, 25563, 25609, 25610, 
25607, 97361, 97368, 97531, 97524
33848, 23862, 23863, 23886, 23885, 96027, 96029, 96075, 96073, 24288, 24334, 24335, 24332, 97371, 97533, 97534, 
97526, 97362, 97369, 97532, 97525
33849, 96027, 96029, 96075, 96073, 96028, 96030, 96076, 96074, 97371, 97533, 97534, 97526, 97374, 97536, 97537, 
97529, 97365, 97372, 97535, 97528
33850, 96028, 96030, 96076, 96074, 25139, 25140, 25163, 25162, 97374, 97536, 97537, 97529, 25565, 25611, 25612, 
25609, 97368, 97375, 97538, 97531
33851, 23863, 23864, 23887, 23886, 96029, 96031, 96077, 96075, 24290, 24336, 24337, 24334, 97378, 97540, 97541, 
97533, 97369, 97376, 97539, 97532
33852, 96029, 96031, 96077, 96075, 96030, 96032, 96078, 96076, 97378, 97540, 97541, 97533, 97381, 97543, 97544, 
97536, 97372, 97379, 97542, 97535
33853, 96030, 96032, 96078, 96076, 25140, 25141, 25164, 25163, 97381, 97543, 97544, 97536, 25567, 25613, 25614, 
25611, 97375, 97382, 97545, 97538
33854, 23864, 23865, 23888, 23887, 96031, 96033, 96079, 96077, 24292, 24338, 24339, 24336, 97385, 97547, 97548, 
97540, 97376, 97383, 97546, 97539
33855, 96031, 96033, 96079, 96077, 96032, 96034, 96080, 96078, 97385, 97547, 97548, 97540, 97388, 97550, 97551, 
97543, 97379, 97386, 97549, 97542
33856, 96032, 96034, 96080, 96078, 25141, 25142, 25165, 25164, 97388, 97550, 97551, 97543, 25569, 25615, 25616, 
25613, 97382, 97389, 97552, 97545
33857, 23865, 23866, 23889, 23888, 96033, 96035, 96081, 96079, 24294, 24340, 24341, 24338, 97392, 97554, 97555, 
97547, 97383, 97390, 97553, 97546
33858, 96033, 96035, 96081, 96079, 96034, 96036, 96082, 96080, 97392, 97554, 97555, 97547, 97395, 97557, 97558, 
97550, 97386, 97393, 97556, 97549
33859, 96034, 96036, 96082, 96080, 25142, 25143, 25166, 25165, 97395, 97557, 97558, 97550, 25571, 25617, 25618, 
25615, 97389, 97396, 97559, 97552
33860, 23866, 23867, 23890, 23889, 96035, 96037, 96083, 96081, 24296, 24342, 24343, 24340, 97399, 97561, 97562, 
97554, 97390, 97397, 97560, 97553
33861, 96035, 96037, 96083, 96081, 96036, 96038, 96084, 96082, 97399, 97561, 97562, 97554, 97402, 97564, 97565, 
97557, 97393, 97400, 97563, 97556
33862, 96036, 96038, 96084, 96082, 25143, 25144, 25167, 25166, 97402, 97564, 97565, 97557, 25573, 25619, 25620, 
25617, 97396, 97403, 97566, 97559
33863, 23867, 23868, 23891, 23890, 96037, 96039, 96085, 96083, 24298, 24344, 24345, 24342, 97406, 97568, 97569, 
97561, 97397, 97404, 97567, 97560
33864, 96037, 96039, 96085, 96083, 96038, 96040, 96086, 96084, 97406, 97568, 97569, 97561, 97409, 97571, 97572, 
97564, 97400, 97407, 97570, 97563
33865, 96038, 96040, 96086, 96084, 25144, 25145, 25168, 25167, 97409, 97571, 97572, 97564, 25575, 25621, 25622, 
25619, 97403, 97410, 97573, 97566
33866, 23868, 23869, 23892, 23891, 96039, 96041, 96087, 96085, 24300, 24346, 24347, 24344, 97413, 97575, 97576, 
97568, 97404, 97411, 97574, 97567
33867, 96039, 96041, 96087, 96085, 96040, 96042, 96088, 96086, 97413, 97575, 97576, 97568, 97416, 97578, 97579, 
97571, 97407, 97414, 97577, 97570
33868, 96040, 96042, 96088, 96086, 25145, 25146, 25169, 25168, 97416, 97578, 97579, 97571, 25577, 25623, 25624, 
25621, 97410, 97417, 97580, 97573
33869, 23869, 23870, 23893, 23892, 96041, 96043, 96089, 96087, 24302, 24348, 24349, 24346, 97420, 97582, 97583, 
97575, 97411, 97418, 97581, 97574
33870, 96041, 96043, 96089, 96087, 96042, 96044, 96090, 96088, 97420, 97582, 97583, 97575, 97423, 97585, 97586, 
97578, 97414, 97421, 97584, 97577
33871, 96042, 96044, 96090, 96088, 25146, 25147, 25170, 25169, 97423, 97585, 97586, 97578, 25579, 25625, 25626, 
25623, 97417, 97424, 97587, 97580
33872, 23870, 23871, 23894, 23893, 96043, 96045, 96091, 96089, 24304, 24350, 24351, 24348, 97427, 97589, 97590, 
97582, 97418, 97425, 97588, 97581
33873, 96043, 96045, 96091, 96089, 96044, 96046, 96092, 96090, 97427, 97589, 97590, 97582, 97430, 97592, 97593, 
97585, 97421, 97428, 97591, 97584
33874, 96044, 96046, 96092, 96090, 25147, 25148, 25171, 25170, 97430, 97592, 97593, 97585, 25581, 25627, 25628, 
25625, 97424, 97431, 97594, 97587
33875, 23871, 23872, 23895, 23894, 96045, 96047, 96093, 96091, 24306, 24352, 24353, 24350, 97434, 97596, 97597, 
97589, 97425, 97432, 97595, 97588
33876, 96045, 96047, 96093, 96091, 96046, 96048, 96094, 96092, 97434, 97596, 97597, 97589, 97437, 97599, 97600, 
97592, 97428, 97435, 97598, 97591
33877, 96046, 96048, 96094, 96092, 25148, 25149, 25172, 25171, 97437, 97599, 97600, 97592, 25583, 25629, 25630, 
25627, 97431, 97438, 97601, 97594
33878, 23872, 23873, 23896, 23895, 96047, 96049, 96095, 96093, 24308, 24354, 24355, 24352, 97441, 97603, 97604, 
97596, 97432, 97439, 97602, 97595
33879, 96047, 96049, 96095, 96093, 96048, 96050, 96096, 96094, 97441, 97603, 97604, 97596, 97444, 97606, 97607, 
97599, 97435, 97442, 97605, 97598
33880, 96048, 96050, 96096, 96094, 25149, 25150, 25173, 25172, 97444, 97606, 97607, 97599, 25585, 25631, 25632, 
25629, 97438, 97445, 97608, 97601
33881, 23873, 23874, 23897, 23896, 96049, 96051, 96097, 96095, 24310, 24356, 24357, 24354, 97448, 97610, 97611, 
97603, 97439, 97446, 97609, 97602
33882, 96049, 96051, 96097, 96095, 96050, 96052, 96098, 96096, 97448, 97610, 97611, 97603, 97451, 97613, 97614, 
97606, 97442, 97449, 97612, 97605
33883, 96050, 96052, 96098, 96096, 25150, 25151, 25174, 25173, 97451, 97613, 97614, 97606, 25587, 25633, 25634, 
25631, 97445, 97452, 97615, 97608
33884, 23874, 23875, 23898, 23897, 96051, 96053, 96099, 96097, 24312, 24358, 24359, 24356, 97455, 97617, 97618, 
97610, 97446, 97453, 97616, 97609
33885, 96051, 96053, 96099, 96097, 96052, 96054, 96100, 96098, 97455, 97617, 97618, 97610, 97458, 97620, 97621, 
97613, 97449, 97456, 97619, 97612
33886, 96052, 96054, 96100, 96098, 25151, 25152, 25175, 25174, 97458, 97620, 97621, 97613, 25589, 25635, 25636, 
25633, 97452, 97459, 97622, 97615
33887, 23875, 23876, 23899, 23898, 96053, 96055, 96101, 96099, 24314, 24360, 24361, 24358, 97462, 97624, 97625, 
97617, 97453, 97460, 97623, 97616
33888, 96053, 96055, 96101, 96099, 96054, 96056, 96102, 96100, 97462, 97624, 97625, 97617, 97465, 97627, 97628, 
97620, 97456, 97463, 97626, 97619
33889, 96054, 96056, 96102, 96100, 25152, 25153, 25176, 25175, 97465, 97627, 97628, 97620, 25591, 25637, 25638, 
25635, 97459, 97466, 97629, 97622
33890, 23876, 23877, 23900, 23899, 96055, 96057, 96103, 96101, 24316, 24362, 24363, 24360, 97469, 97631, 97632, 
97624, 97460, 97467, 97630, 97623
33891, 96055, 96057, 96103, 96101, 96056, 96058, 96104, 96102, 97469, 97631, 97632, 97624, 97472, 97634, 97635, 
97627, 97463, 97470, 97633, 97626
33892, 96056, 96058, 96104, 96102, 25153, 25154, 25177, 25176, 97472, 97634, 97635, 97627, 25593, 25639, 25640, 
25637, 97466, 97473, 97636, 97629
33893, 23877, 23878, 23901, 23900, 96057, 96059, 96105, 96103, 24318, 24364, 24365, 24362, 97476, 97638, 97639, 
97631, 97467, 97474, 97637, 97630
33894, 96057, 96059, 96105, 96103, 96058, 96060, 96106, 96104, 97476, 97638, 97639, 97631, 97479, 97641, 97642, 
97634, 97470, 97477, 97640, 97633
33895, 96058, 96060, 96106, 96104, 25154, 25155, 25178, 25177, 97479, 97641, 97642, 97634, 25595, 25641, 25642, 
25639, 97473, 97480, 97643, 97636
33896, 23878, 23879, 23902, 23901, 96059, 96061, 96107, 96105, 24320, 24366, 24367, 24364, 97483, 97645, 97646, 
97638, 97474, 97481, 97644, 97637
33897, 96059, 96061, 96107, 96105, 96060, 96062, 96108, 96106, 97483, 97645, 97646, 97638, 97486, 97648, 97649, 
97641, 97477, 97484, 97647, 97640
33898, 96060, 96062, 96108, 96106, 25155, 25156, 25179, 25178, 97486, 97648, 97649, 97641, 25597, 25643, 25644, 
25641, 97480, 97487, 97650, 97643
33899, 23879, 23880, 23903, 23902, 96061, 96063, 96109, 96107, 24322, 24368, 24369, 24366, 97490, 97652, 97653, 
97645, 97481, 97488, 97651, 97644
33900, 96061, 96063, 96109, 96107, 96062, 96064, 96110, 96108, 97490, 97652, 97653, 97645, 97493, 97655, 97656, 
97648, 97484, 97491, 97654, 97647
33901, 96062, 96064, 96110, 96108, 25156, 25157, 25180, 25179, 97493, 97655, 97656, 97648, 25599, 25645, 25646, 
25643, 97487, 97494, 97657, 97650
33902, 23880, 23881, 23904, 23903, 96063, 96065, 96111, 96109, 24324, 24370, 24371, 24368, 97497, 97659, 97660, 
97652, 97488, 97495, 97658, 97651
33903, 96063, 96065, 96111, 96109, 96064, 96066, 96112, 96110, 97497, 97659, 97660, 97652, 97500, 97662, 97663, 
97655, 97491, 97498, 97661, 97654
33904, 96064, 96066, 96112, 96110, 25157, 25158, 25181, 25180, 97500, 97662, 97663, 97655, 25601, 25647, 25648, 
25645, 97494, 97501, 97664, 97657
33905, 23881, 23882, 23905, 23904, 96065, 96067, 96113, 96111, 24326, 24372, 24373, 24370, 97504, 97666, 97667, 
97659, 97495, 97502, 97665, 97658
33906, 96065, 96067, 96113, 96111, 96066, 96068, 96114, 96112, 97504, 97666, 97667, 97659, 97507, 97669, 97670, 
97662, 97498, 97505, 97668, 97661
33907, 96066, 96068, 96114, 96112, 25158, 25159, 25182, 25181, 97507, 97669, 97670, 97662, 25603, 25649, 25650, 
25647, 97501, 97508, 97671, 97664
33908, 23882, 2109, 2110, 23905, 96067, 24911, 24913, 96113, 24327, 2121, 24374, 24372, 97509, 24960, 97672, 
97666, 97502, 24954, 24959, 97665
33909, 96067, 24911, 24913, 96113, 96068, 24912, 24914, 96114, 97509, 24960, 97672, 97666, 97510, 24962, 97673, 
97669, 97505, 24956, 24961, 97668
33910, 96068, 24912, 24914, 96114, 25159, 2269, 2270, 25182, 97510, 24962, 97673, 97669, 25604, 2281, 25651, 
25649, 97508, 24958, 24963, 97671
33911, 2087, 23883, 23906, 2088, 24834, 96069, 96115, 24836, 24329, 24375, 24376, 2099, 97513, 97675, 97676, 
24885, 24881, 97511, 97674, 24886
33912, 24834, 96069, 96115, 24836, 24835, 96070, 96116, 24837, 97513, 97675, 97676, 24885, 97516, 97678, 97679, 
24887, 24883, 97514, 97677, 24888
33913, 24835, 96070, 96116, 24837, 2247, 25160, 25183, 2248, 97516, 97678, 97679, 24887, 25606, 25652, 25653, 
2259, 24884, 97517, 97680, 24889
33914, 23883, 23884, 23907, 23906, 96069, 96071, 96117, 96115, 24331, 24377, 24378, 24375, 97520, 97682, 97683, 
97675, 97511, 97518, 97681, 97674
33915, 96069, 96071, 96117, 96115, 96070, 96072, 96118, 96116, 97520, 97682, 97683, 97675, 97523, 97685, 97686, 
97678, 97514, 97521, 97684, 97677
33916, 96070, 96072, 96118, 96116, 25160, 25161, 25184, 25183, 97523, 97685, 97686, 97678, 25608, 25654, 25655, 
25652, 97517, 97524, 97687, 97680
33917, 23884, 23885, 23908, 23907, 96071, 96073, 96119, 96117, 24333, 24379, 24380, 24377, 97527, 97689, 97690, 
97682, 97518, 97525, 97688, 97681
33918, 96071, 96073, 96119, 96117, 96072, 96074, 96120, 96118, 97527, 97689, 97690, 97682, 97530, 97692, 97693, 
97685, 97521, 97528, 97691, 97684
33919, 96072, 96074, 96120, 96118, 25161, 25162, 25185, 25184, 97530, 97692, 97693, 97685, 25610, 25656, 25657, 
25654, 97524, 97531, 97694, 97687
33920, 23885, 23886, 23909, 23908, 96073, 96075, 96121, 96119, 24335, 24381, 24382, 24379, 97534, 97696, 97697, 
97689, 97525, 97532, 97695, 97688
33921, 96073, 96075, 96121, 96119, 96074, 96076, 96122, 96120, 97534, 97696, 97697, 97689, 97537, 97699, 97700, 
97692, 97528, 97535, 97698, 97691
33922, 96074, 96076, 96122, 96120, 25162, 25163, 25186, 25185, 97537, 97699, 97700, 97692, 25612, 25658, 25659, 
25656, 97531, 97538, 97701, 97694
33923, 23886, 23887, 23910, 23909, 96075, 96077, 96123, 96121, 24337, 24383, 24384, 24381, 97541, 97703, 97704, 
97696, 97532, 97539, 97702, 97695
33924, 96075, 96077, 96123, 96121, 96076, 96078, 96124, 96122, 97541, 97703, 97704, 97696, 97544, 97706, 97707, 
97699, 97535, 97542, 97705, 97698
33925, 96076, 96078, 96124, 96122, 25163, 25164, 25187, 25186, 97544, 97706, 97707, 97699, 25614, 25660, 25661, 
25658, 97538, 97545, 97708, 97701
33926, 23887, 23888, 23911, 23910, 96077, 96079, 96125, 96123, 24339, 24385, 24386, 24383, 97548, 97710, 97711, 
97703, 97539, 97546, 97709, 97702
33927, 96077, 96079, 96125, 96123, 96078, 96080, 96126, 96124, 97548, 97710, 97711, 97703, 97551, 97713, 97714, 
97706, 97542, 97549, 97712, 97705
33928, 96078, 96080, 96126, 96124, 25164, 25165, 25188, 25187, 97551, 97713, 97714, 97706, 25616, 25662, 25663, 
25660, 97545, 97552, 97715, 97708
33929, 23888, 23889, 23912, 23911, 96079, 96081, 96127, 96125, 24341, 24387, 24388, 24385, 97555, 97717, 97718, 
97710, 97546, 97553, 97716, 97709
33930, 96079, 96081, 96127, 96125, 96080, 96082, 96128, 96126, 97555, 97717, 97718, 97710, 97558, 97720, 97721, 
97713, 97549, 97556, 97719, 97712
33931, 96080, 96082, 96128, 96126, 25165, 25166, 25189, 25188, 97558, 97720, 97721, 97713, 25618, 25664, 25665, 
25662, 97552, 97559, 97722, 97715
33932, 23889, 23890, 23913, 23912, 96081, 96083, 96129, 96127, 24343, 24389, 24390, 24387, 97562, 97724, 97725, 
97717, 97553, 97560, 97723, 97716
33933, 96081, 96083, 96129, 96127, 96082, 96084, 96130, 96128, 97562, 97724, 97725, 97717, 97565, 97727, 97728, 
97720, 97556, 97563, 97726, 97719
33934, 96082, 96084, 96130, 96128, 25166, 25167, 25190, 25189, 97565, 97727, 97728, 97720, 25620, 25666, 25667, 
25664, 97559, 97566, 97729, 97722
33935, 23890, 23891, 23914, 23913, 96083, 96085, 96131, 96129, 24345, 24391, 24392, 24389, 97569, 97731, 97732, 
97724, 97560, 97567, 97730, 97723
33936, 96083, 96085, 96131, 96129, 96084, 96086, 96132, 96130, 97569, 97731, 97732, 97724, 97572, 97734, 97735, 
97727, 97563, 97570, 97733, 97726
33937, 96084, 96086, 96132, 96130, 25167, 25168, 25191, 25190, 97572, 97734, 97735, 97727, 25622, 25668, 25669, 
25666, 97566, 97573, 97736, 97729
33938, 23891, 23892, 23915, 23914, 96085, 96087, 96133, 96131, 24347, 24393, 24394, 24391, 97576, 97738, 97739, 
97731, 97567, 97574, 97737, 97730
33939, 96085, 96087, 96133, 96131, 96086, 96088, 96134, 96132, 97576, 97738, 97739, 97731, 97579, 97741, 97742, 
97734, 97570, 97577, 97740, 97733
33940, 96086, 96088, 96134, 96132, 25168, 25169, 25192, 25191, 97579, 97741, 97742, 97734, 25624, 25670, 25671, 
25668, 97573, 97580, 97743, 97736
33941, 23892, 23893, 23916, 23915, 96087, 96089, 96135, 96133, 24349, 24395, 24396, 24393, 97583, 97745, 97746, 
97738, 97574, 97581, 97744, 97737
33942, 96087, 96089, 96135, 96133, 96088, 96090, 96136, 96134, 97583, 97745, 97746, 97738, 97586, 97748, 97749, 
97741, 97577, 97584, 97747, 97740
33943, 96088, 96090, 96136, 96134, 25169, 25170, 25193, 25192, 97586, 97748, 97749, 97741, 25626, 25672, 25673, 
25670, 97580, 97587, 97750, 97743
33944, 23893, 23894, 23917, 23916, 96089, 96091, 96137, 96135, 24351, 24397, 24398, 24395, 97590, 97752, 97753, 
97745, 97581, 97588, 97751, 97744
33945, 96089, 96091, 96137, 96135, 96090, 96092, 96138, 96136, 97590, 97752, 97753, 97745, 97593, 97755, 97756, 
97748, 97584, 97591, 97754, 97747
33946, 96090, 96092, 96138, 96136, 25170, 25171, 25194, 25193, 97593, 97755, 97756, 97748, 25628, 25674, 25675, 
25672, 97587, 97594, 97757, 97750
33947, 23894, 23895, 23918, 23917, 96091, 96093, 96139, 96137, 24353, 24399, 24400, 24397, 97597, 97759, 97760, 
97752, 97588, 97595, 97758, 97751
33948, 96091, 96093, 96139, 96137, 96092, 96094, 96140, 96138, 97597, 97759, 97760, 97752, 97600, 97762, 97763, 
97755, 97591, 97598, 97761, 97754
33949, 96092, 96094, 96140, 96138, 25171, 25172, 25195, 25194, 97600, 97762, 97763, 97755, 25630, 25676, 25677, 
25674, 97594, 97601, 97764, 97757
33950, 23895, 23896, 23919, 23918, 96093, 96095, 96141, 96139, 24355, 24401, 24402, 24399, 97604, 97766, 97767, 
97759, 97595, 97602, 97765, 97758
33951, 96093, 96095, 96141, 96139, 96094, 96096, 96142, 96140, 97604, 97766, 97767, 97759, 97607, 97769, 97770, 
97762, 97598, 97605, 97768, 97761
33952, 96094, 96096, 96142, 96140, 25172, 25173, 25196, 25195, 97607, 97769, 97770, 97762, 25632, 25678, 25679, 
25676, 97601, 97608, 97771, 97764
33953, 23896, 23897, 23920, 23919, 96095, 96097, 96143, 96141, 24357, 24403, 24404, 24401, 97611, 97773, 97774, 
97766, 97602, 97609, 97772, 97765
33954, 96095, 96097, 96143, 96141, 96096, 96098, 96144, 96142, 97611, 97773, 97774, 97766, 97614, 97776, 97777, 
97769, 97605, 97612, 97775, 97768
33955, 96096, 96098, 96144, 96142, 25173, 25174, 25197, 25196, 97614, 97776, 97777, 97769, 25634, 25680, 25681, 
25678, 97608, 97615, 97778, 97771
33956, 23897, 23898, 23921, 23920, 96097, 96099, 96145, 96143, 24359, 24405, 24406, 24403, 97618, 97780, 97781, 
97773, 97609, 97616, 97779, 97772
33957, 96097, 96099, 96145, 96143, 96098, 96100, 96146, 96144, 97618, 97780, 97781, 97773, 97621, 97783, 97784, 
97776, 97612, 97619, 97782, 97775
33958, 96098, 96100, 96146, 96144, 25174, 25175, 25198, 25197, 97621, 97783, 97784, 97776, 25636, 25682, 25683, 
25680, 97615, 97622, 97785, 97778
33959, 23898, 23899, 23922, 23921, 96099, 96101, 96147, 96145, 24361, 24407, 24408, 24405, 97625, 97787, 97788, 
97780, 97616, 97623, 97786, 97779
33960, 96099, 96101, 96147, 96145, 96100, 96102, 96148, 96146, 97625, 97787, 97788, 97780, 97628, 97790, 97791, 
97783, 97619, 97626, 97789, 97782
33961, 96100, 96102, 96148, 96146, 25175, 25176, 25199, 25198, 97628, 97790, 97791, 97783, 25638, 25684, 25685, 
25682, 97622, 97629, 97792, 97785
33962, 23899, 23900, 23923, 23922, 96101, 96103, 96149, 96147, 24363, 24409, 24410, 24407, 97632, 97794, 97795, 
97787, 97623, 97630, 97793, 97786
33963, 96101, 96103, 96149, 96147, 96102, 96104, 96150, 96148, 97632, 97794, 97795, 97787, 97635, 97797, 97798, 
97790, 97626, 97633, 97796, 97789
33964, 96102, 96104, 96150, 96148, 25176, 25177, 25200, 25199, 97635, 97797, 97798, 97790, 25640, 25686, 25687, 
25684, 97629, 97636, 97799, 97792
33965, 23900, 23901, 23924, 23923, 96103, 96105, 96151, 96149, 24365, 24411, 24412, 24409, 97639, 97801, 97802, 
97794, 97630, 97637, 97800, 97793
33966, 96103, 96105, 96151, 96149, 96104, 96106, 96152, 96150, 97639, 97801, 97802, 97794, 97642, 97804, 97805, 
97797, 97633, 97640, 97803, 97796
33967, 96104, 96106, 96152, 96150, 25177, 25178, 25201, 25200, 97642, 97804, 97805, 97797, 25642, 25688, 25689, 
25686, 97636, 97643, 97806, 97799
33968, 23901, 23902, 23925, 23924, 96105, 96107, 96153, 96151, 24367, 24413, 24414, 24411, 97646, 97808, 97809, 
97801, 97637, 97644, 97807, 97800
33969, 96105, 96107, 96153, 96151, 96106, 96108, 96154, 96152, 97646, 97808, 97809, 97801, 97649, 97811, 97812, 
97804, 97640, 97647, 97810, 97803
33970, 96106, 96108, 96154, 96152, 25178, 25179, 25202, 25201, 97649, 97811, 97812, 97804, 25644, 25690, 25691, 
25688, 97643, 97650, 97813, 97806
33971, 23902, 23903, 23926, 23925, 96107, 96109, 96155, 96153, 24369, 24415, 24416, 24413, 97653, 97815, 97816, 
97808, 97644, 97651, 97814, 97807
33972, 96107, 96109, 96155, 96153, 96108, 96110, 96156, 96154, 97653, 97815, 97816, 97808, 97656, 97818, 97819, 
97811, 97647, 97654, 97817, 97810
33973, 96108, 96110, 96156, 96154, 25179, 25180, 25203, 25202, 97656, 97818, 97819, 97811, 25646, 25692, 25693, 
25690, 97650, 97657, 97820, 97813
33974, 23903, 23904, 23927, 23926, 96109, 96111, 96157, 96155, 24371, 24417, 24418, 24415, 97660, 97822, 97823, 
97815, 97651, 97658, 97821, 97814
33975, 96109, 96111, 96157, 96155, 96110, 96112, 96158, 96156, 97660, 97822, 97823, 97815, 97663, 97825, 97826, 
97818, 97654, 97661, 97824, 97817
33976, 96110, 96112, 96158, 96156, 25180, 25181, 25204, 25203, 97663, 97825, 97826, 97818, 25648, 25694, 25695, 
25692, 97657, 97664, 97827, 97820
33977, 23904, 23905, 23928, 23927, 96111, 96113, 96159, 96157, 24373, 24419, 24420, 24417, 97667, 97829, 97830, 
97822, 97658, 97665, 97828, 97821
33978, 96111, 96113, 96159, 96157, 96112, 96114, 96160, 96158, 97667, 97829, 97830, 97822, 97670, 97832, 97833, 
97825, 97661, 97668, 97831, 97824
33979, 96112, 96114, 96160, 96158, 25181, 25182, 25205, 25204, 97670, 97832, 97833, 97825, 25650, 25696, 25697, 
25694, 97664, 97671, 97834, 97827
33980, 23905, 2110, 2111, 23928, 96113, 24913, 24915, 96159, 24374, 2122, 24421, 24419, 97672, 24965, 97835, 
97829, 97665, 24959, 24964, 97828
33981, 96113, 24913, 24915, 96159, 96114, 24914, 24916, 96160, 97672, 24965, 97835, 97829, 97673, 24967, 97836, 
97832, 97668, 24961, 24966, 97831
33982, 96114, 24914, 24916, 96160, 25182, 2270, 2271, 25205, 97673, 24967, 97836, 97832, 25651, 2282, 25698, 
25696, 97671, 24963, 24968, 97834
33983, 2088, 23906, 23929, 2089, 24836, 96115, 96161, 24838, 24376, 24422, 24423, 2100, 97676, 97838, 97839, 
24890, 24886, 97674, 97837, 24891
33984, 24836, 96115, 96161, 24838, 24837, 96116, 96162, 24839, 97676, 97838, 97839, 24890, 97679, 97841, 97842, 
24892, 24888, 97677, 97840, 24893
33985, 24837, 96116, 96162, 24839, 2248, 25183, 25206, 2249, 97679, 97841, 97842, 24892, 25653, 25699, 25700, 
2260, 24889, 97680, 97843, 24894
33986, 23906, 23907, 23930, 23929, 96115, 96117, 96163, 96161, 24378, 24424, 24425, 24422, 97683, 97845, 97846, 
97838, 97674, 97681, 97844, 97837
33987, 96115, 96117, 96163, 96161, 96116, 96118, 96164, 96162, 97683, 97845, 97846, 97838, 97686, 97848, 97849, 
97841, 97677, 97684, 97847, 97840
33988, 96116, 96118, 96164, 96162, 25183, 25184, 25207, 25206, 97686, 97848, 97849, 97841, 25655, 25701, 25702, 
25699, 97680, 97687, 97850, 97843
33989, 23907, 23908, 23931, 23930, 96117, 96119, 96165, 96163, 24380, 24426, 24427, 24424, 97690, 97852, 97853, 
97845, 97681, 97688, 97851, 97844
33990, 96117, 96119, 96165, 96163, 96118, 96120, 96166, 96164, 97690, 97852, 97853, 97845, 97693, 97855, 97856, 
97848, 97684, 97691, 97854, 97847
33991, 96118, 96120, 96166, 96164, 25184, 25185, 25208, 25207, 97693, 97855, 97856, 97848, 25657, 25703, 25704, 
25701, 97687, 97694, 97857, 97850
33992, 23908, 23909, 23932, 23931, 96119, 96121, 96167, 96165, 24382, 24428, 24429, 24426, 97697, 97859, 97860, 
97852, 97688, 97695, 97858, 97851
33993, 96119, 96121, 96167, 96165, 96120, 96122, 96168, 96166, 97697, 97859, 97860, 97852, 97700, 97862, 97863, 
97855, 97691, 97698, 97861, 97854
33994, 96120, 96122, 96168, 96166, 25185, 25186, 25209, 25208, 97700, 97862, 97863, 97855, 25659, 25705, 25706, 
25703, 97694, 97701, 97864, 97857
33995, 23909, 23910, 23933, 23932, 96121, 96123, 96169, 96167, 24384, 24430, 24431, 24428, 97704, 97866, 97867, 
97859, 97695, 97702, 97865, 97858
33996, 96121, 96123, 96169, 96167, 96122, 96124, 96170, 96168, 97704, 97866, 97867, 97859, 97707, 97869, 97870, 
97862, 97698, 97705, 97868, 97861
33997, 96122, 96124, 96170, 96168, 25186, 25187, 25210, 25209, 97707, 97869, 97870, 97862, 25661, 25707, 25708, 
25705, 97701, 97708, 97871, 97864
33998, 23910, 23911, 23934, 23933, 96123, 96125, 96171, 96169, 24386, 24432, 24433, 24430, 97711, 97873, 97874, 
97866, 97702, 97709, 97872, 97865
33999, 96123, 96125, 96171, 96169, 96124, 96126, 96172, 96170, 97711, 97873, 97874, 97866, 97714, 97876, 97877, 
97869, 97705, 97712, 97875, 97868
34000, 96124, 96126, 96172, 96170, 25187, 25188, 25211, 25210, 97714, 97876, 97877, 97869, 25663, 25709, 25710, 
25707, 97708, 97715, 97878, 97871
34001, 23911, 23912, 23935, 23934, 96125, 96127, 96173, 96171, 24388, 24434, 24435, 24432, 97718, 97880, 97881, 
97873, 97709, 97716, 97879, 97872
34002, 96125, 96127, 96173, 96171, 96126, 96128, 96174, 96172, 97718, 97880, 97881, 97873, 97721, 97883, 97884, 
97876, 97712, 97719, 97882, 97875
34003, 96126, 96128, 96174, 96172, 25188, 25189, 25212, 25211, 97721, 97883, 97884, 97876, 25665, 25711, 25712, 
25709, 97715, 97722, 97885, 97878
34004, 23912, 23913, 23936, 23935, 96127, 96129, 96175, 96173, 24390, 24436, 24437, 24434, 97725, 97887, 97888, 
97880, 97716, 97723, 97886, 97879
34005, 96127, 96129, 96175, 96173, 96128, 96130, 96176, 96174, 97725, 97887, 97888, 97880, 97728, 97890, 97891, 
97883, 97719, 97726, 97889, 97882
34006, 96128, 96130, 96176, 96174, 25189, 25190, 25213, 25212, 97728, 97890, 97891, 97883, 25667, 25713, 25714, 
25711, 97722, 97729, 97892, 97885
34007, 23913, 23914, 23937, 23936, 96129, 96131, 96177, 96175, 24392, 24438, 24439, 24436, 97732, 97894, 97895, 
97887, 97723, 97730, 97893, 97886
34008, 96129, 96131, 96177, 96175, 96130, 96132, 96178, 96176, 97732, 97894, 97895, 97887, 97735, 97897, 97898, 
97890, 97726, 97733, 97896, 97889
34009, 96130, 96132, 96178, 96176, 25190, 25191, 25214, 25213, 97735, 97897, 97898, 97890, 25669, 25715, 25716, 
25713, 97729, 97736, 97899, 97892
34010, 23914, 23915, 23938, 23937, 96131, 96133, 96179, 96177, 24394, 24440, 24441, 24438, 97739, 97901, 97902, 
97894, 97730, 97737, 97900, 97893
34011, 96131, 96133, 96179, 96177, 96132, 96134, 96180, 96178, 97739, 97901, 97902, 97894, 97742, 97904, 97905, 
97897, 97733, 97740, 97903, 97896
34012, 96132, 96134, 96180, 96178, 25191, 25192, 25215, 25214, 97742, 97904, 97905, 97897, 25671, 25717, 25718, 
25715, 97736, 97743, 97906, 97899
34013, 23915, 23916, 23939, 23938, 96133, 96135, 96181, 96179, 24396, 24442, 24443, 24440, 97746, 97908, 97909, 
97901, 97737, 97744, 97907, 97900
34014, 96133, 96135, 96181, 96179, 96134, 96136, 96182, 96180, 97746, 97908, 97909, 97901, 97749, 97911, 97912, 
97904, 97740, 97747, 97910, 97903
34015, 96134, 96136, 96182, 96180, 25192, 25193, 25216, 25215, 97749, 97911, 97912, 97904, 25673, 25719, 25720, 
25717, 97743, 97750, 97913, 97906
34016, 23916, 23917, 23940, 23939, 96135, 96137, 96183, 96181, 24398, 24444, 24445, 24442, 97753, 97915, 97916, 
97908, 97744, 97751, 97914, 97907
34017, 96135, 96137, 96183, 96181, 96136, 96138, 96184, 96182, 97753, 97915, 97916, 97908, 97756, 97918, 97919, 
97911, 97747, 97754, 97917, 97910
34018, 96136, 96138, 96184, 96182, 25193, 25194, 25217, 25216, 97756, 97918, 97919, 97911, 25675, 25721, 25722, 
25719, 97750, 97757, 97920, 97913
34019, 23917, 23918, 23941, 23940, 96137, 96139, 96185, 96183, 24400, 24446, 24447, 24444, 97760, 97922, 97923, 
97915, 97751, 97758, 97921, 97914
34020, 96137, 96139, 96185, 96183, 96138, 96140, 96186, 96184, 97760, 97922, 97923, 97915, 97763, 97925, 97926, 
97918, 97754, 97761, 97924, 97917
34021, 96138, 96140, 96186, 96184, 25194, 25195, 25218, 25217, 97763, 97925, 97926, 97918, 25677, 25723, 25724, 
25721, 97757, 97764, 97927, 97920
34022, 23918, 23919, 23942, 23941, 96139, 96141, 96187, 96185, 24402, 24448, 24449, 24446, 97767, 97929, 97930, 
97922, 97758, 97765, 97928, 97921
34023, 96139, 96141, 96187, 96185, 96140, 96142, 96188, 96186, 97767, 97929, 97930, 97922, 97770, 97932, 97933, 
97925, 97761, 97768, 97931, 97924
34024, 96140, 96142, 96188, 96186, 25195, 25196, 25219, 25218, 97770, 97932, 97933, 97925, 25679, 25725, 25726, 
25723, 97764, 97771, 97934, 97927
34025, 23919, 23920, 23943, 23942, 96141, 96143, 96189, 96187, 24404, 24450, 24451, 24448, 97774, 97936, 97937, 
97929, 97765, 97772, 97935, 97928
34026, 96141, 96143, 96189, 96187, 96142, 96144, 96190, 96188, 97774, 97936, 97937, 97929, 97777, 97939, 97940, 
97932, 97768, 97775, 97938, 97931
34027, 96142, 96144, 96190, 96188, 25196, 25197, 25220, 25219, 97777, 97939, 97940, 97932, 25681, 25727, 25728, 
25725, 97771, 97778, 97941, 97934
34028, 23920, 23921, 23944, 23943, 96143, 96145, 96191, 96189, 24406, 24452, 24453, 24450, 97781, 97943, 97944, 
97936, 97772, 97779, 97942, 97935
34029, 96143, 96145, 96191, 96189, 96144, 96146, 96192, 96190, 97781, 97943, 97944, 97936, 97784, 97946, 97947, 
97939, 97775, 97782, 97945, 97938
34030, 96144, 96146, 96192, 96190, 25197, 25198, 25221, 25220, 97784, 97946, 97947, 97939, 25683, 25729, 25730, 
25727, 97778, 97785, 97948, 97941
34031, 23921, 23922, 23945, 23944, 96145, 96147, 96193, 96191, 24408, 24454, 24455, 24452, 97788, 97950, 97951, 
97943, 97779, 97786, 97949, 97942
34032, 96145, 96147, 96193, 96191, 96146, 96148, 96194, 96192, 97788, 97950, 97951, 97943, 97791, 97953, 97954, 
97946, 97782, 97789, 97952, 97945
34033, 96146, 96148, 96194, 96192, 25198, 25199, 25222, 25221, 97791, 97953, 97954, 97946, 25685, 25731, 25732, 
25729, 97785, 97792, 97955, 97948
34034, 23922, 23923, 23946, 23945, 96147, 96149, 96195, 96193, 24410, 24456, 24457, 24454, 97795, 97957, 97958, 
97950, 97786, 97793, 97956, 97949
34035, 96147, 96149, 96195, 96193, 96148, 96150, 96196, 96194, 97795, 97957, 97958, 97950, 97798, 97960, 97961, 
97953, 97789, 97796, 97959, 97952
34036, 96148, 96150, 96196, 96194, 25199, 25200, 25223, 25222, 97798, 97960, 97961, 97953, 25687, 25733, 25734, 
25731, 97792, 97799, 97962, 97955
34037, 23923, 23924, 23947, 23946, 96149, 96151, 96197, 96195, 24412, 24458, 24459, 24456, 97802, 97964, 97965, 
97957, 97793, 97800, 97963, 97956
34038, 96149, 96151, 96197, 96195, 96150, 96152, 96198, 96196, 97802, 97964, 97965, 97957, 97805, 97967, 97968, 
97960, 97796, 97803, 97966, 97959
34039, 96150, 96152, 96198, 96196, 25200, 25201, 25224, 25223, 97805, 97967, 97968, 97960, 25689, 25735, 25736, 
25733, 97799, 97806, 97969, 97962
34040, 23924, 23925, 23948, 23947, 96151, 96153, 96199, 96197, 24414, 24460, 24461, 24458, 97809, 97971, 97972, 
97964, 97800, 97807, 97970, 97963
34041, 96151, 96153, 96199, 96197, 96152, 96154, 96200, 96198, 97809, 97971, 97972, 97964, 97812, 97974, 97975, 
97967, 97803, 97810, 97973, 97966
34042, 96152, 96154, 96200, 96198, 25201, 25202, 25225, 25224, 97812, 97974, 97975, 97967, 25691, 25737, 25738, 
25735, 97806, 97813, 97976, 97969
34043, 23925, 23926, 23949, 23948, 96153, 96155, 96201, 96199, 24416, 24462, 24463, 24460, 97816, 97978, 97979, 
97971, 97807, 97814, 97977, 97970
34044, 96153, 96155, 96201, 96199, 96154, 96156, 96202, 96200, 97816, 97978, 97979, 97971, 97819, 97981, 97982, 
97974, 97810, 97817, 97980, 97973
34045, 96154, 96156, 96202, 96200, 25202, 25203, 25226, 25225, 97819, 97981, 97982, 97974, 25693, 25739, 25740, 
25737, 97813, 97820, 97983, 97976
34046, 23926, 23927, 23950, 23949, 96155, 96157, 96203, 96201, 24418, 24464, 24465, 24462, 97823, 97985, 97986, 
97978, 97814, 97821, 97984, 97977
34047, 96155, 96157, 96203, 96201, 96156, 96158, 96204, 96202, 97823, 97985, 97986, 97978, 97826, 97988, 97989, 
97981, 97817, 97824, 97987, 97980
34048, 96156, 96158, 96204, 96202, 25203, 25204, 25227, 25226, 97826, 97988, 97989, 97981, 25695, 25741, 25742, 
25739, 97820, 97827, 97990, 97983
34049, 23927, 23928, 23951, 23950, 96157, 96159, 96205, 96203, 24420, 24466, 24467, 24464, 97830, 97992, 97993, 
97985, 97821, 97828, 97991, 97984
34050, 96157, 96159, 96205, 96203, 96158, 96160, 96206, 96204, 97830, 97992, 97993, 97985, 97833, 97995, 97996, 
97988, 97824, 97831, 97994, 97987
34051, 96158, 96160, 96206, 96204, 25204, 25205, 25228, 25227, 97833, 97995, 97996, 97988, 25697, 25743, 25744, 
25741, 97827, 97834, 97997, 97990
34052, 23928, 2111, 2112, 23951, 96159, 24915, 24917, 96205, 24421, 2123, 24468, 24466, 97835, 24970, 97998, 
97992, 97828, 24964, 24969, 97991
34053, 96159, 24915, 24917, 96205, 96160, 24916, 24918, 96206, 97835, 24970, 97998, 97992, 97836, 24972, 97999, 
97995, 97831, 24966, 24971, 97994
34054, 96160, 24916, 24918, 96206, 25205, 2271, 2272, 25228, 97836, 24972, 97999, 97995, 25698, 2283, 25745, 
25743, 97834, 24968, 24973, 97997
34055, 2089, 23929, 1983, 41, 24838, 96161, 24492, 2125, 24423, 24469, 2006, 2101, 97839, 98000, 24538, 
24895, 24891, 97837, 24539, 2127
34056, 24838, 96161, 24492, 2125, 24839, 96162, 24493, 2126, 97839, 98000, 24538, 24895, 97842, 98001, 24540, 
24896, 24893, 97840, 24541, 2128
34057, 24839, 96162, 24493, 2126, 2249, 25206, 2135, 45, 97842, 98001, 24540, 24896, 25700, 25746, 2158, 
2261, 24894, 97843, 24542, 2129
34058, 23929, 23930, 1984, 1983, 96161, 96163, 24494, 24492, 24425, 24470, 2007, 24469, 97846, 98002, 24543, 
98000, 97837, 97844, 24544, 24539
34059, 96161, 96163, 24494, 24492, 96162, 96164, 24495, 24493, 97846, 98002, 24543, 98000, 97849, 98003, 24545, 
98001, 97840, 97847, 24546, 24541
34060, 96162, 96164, 24495, 24493, 25206, 25207, 2136, 2135, 97849, 98003, 24545, 98001, 25702, 25747, 2159, 
25746, 97843, 97850, 24547, 24542
34061, 23930, 23931, 1985, 1984, 96163, 96165, 24496, 24494, 24427, 24471, 2008, 24470, 97853, 98004, 24548, 
98002, 97844, 97851, 24549, 24544
34062, 96163, 96165, 24496, 24494, 96164, 96166, 24497, 24495, 97853, 98004, 24548, 98002, 97856, 98005, 24550, 
98003, 97847, 97854, 24551, 24546
34063, 96164, 96166, 24497, 24495, 25207, 25208, 2137, 2136, 97856, 98005, 24550, 98003, 25704, 25748, 2160, 
25747, 97850, 97857, 24552, 24547
34064, 23931, 23932, 1986, 1985, 96165, 96167, 24498, 24496, 24429, 24472, 2009, 24471, 97860, 98006, 24553, 
98004, 97851, 97858, 24554, 24549
34065, 96165, 96167, 24498, 24496, 96166, 96168, 24499, 24497, 97860, 98006, 24553, 98004, 97863, 98007, 24555, 
98005, 97854, 97861, 24556, 24551
34066, 96166, 96168, 24499, 24497, 25208, 25209, 2138, 2137, 97863, 98007, 24555, 98005, 25706, 25749, 2161, 
25748, 97857, 97864, 24557, 24552
34067, 23932, 23933, 1987, 1986, 96167, 96169, 24500, 24498, 24431, 24473, 2010, 24472, 97867, 98008, 24558, 
98006, 97858, 97865, 24559, 24554
34068, 96167, 96169, 24500, 24498, 96168, 96170, 24501, 24499, 97867, 98008, 24558, 98006, 97870, 98009, 24560, 
98007, 97861, 97868, 24561, 24556
34069, 96168, 96170, 24501, 24499, 25209, 25210, 2139, 2138, 97870, 98009, 24560, 98007, 25708, 25750, 2162, 
25749, 97864, 97871, 24562, 24557
34070, 23933, 23934, 1988, 1987, 96169, 96171, 24502, 24500, 24433, 24474, 2011, 24473, 97874, 98010, 24563, 
98008, 97865, 97872, 24564, 24559
34071, 96169, 96171, 24502, 24500, 96170, 96172, 24503, 24501, 97874, 98010, 24563, 98008, 97877, 98011, 24565, 
98009, 97868, 97875, 24566, 24561
34072, 96170, 96172, 24503, 24501, 25210, 25211, 2140, 2139, 97877, 98011, 24565, 98009, 25710, 25751, 2163, 
25750, 97871, 97878, 24567, 24562
34073, 23934, 23935, 1989, 1988, 96171, 96173, 24504, 24502, 24435, 24475, 2012, 24474, 97881, 98012, 24568, 
98010, 97872, 97879, 24569, 24564
34074, 96171, 96173, 24504, 24502, 96172, 96174, 24505, 24503, 97881, 98012, 24568, 98010, 97884, 98013, 24570, 
98011, 97875, 97882, 24571, 24566
34075, 96172, 96174, 24505, 24503, 25211, 25212, 2141, 2140, 97884, 98013, 24570, 98011, 25712, 25752, 2164, 
25751, 97878, 97885, 24572, 24567
34076, 23935, 23936, 1990, 1989, 96173, 96175, 24506, 24504, 24437, 24476, 2013, 24475, 97888, 98014, 24573, 
98012, 97879, 97886, 24574, 24569
34077, 96173, 96175, 24506, 24504, 96174, 96176, 24507, 24505, 97888, 98014, 24573, 98012, 97891, 98015, 24575, 
98013, 97882, 97889, 24576, 24571
34078, 96174, 96176, 24507, 24505, 25212, 25213, 2142, 2141, 97891, 98015, 24575, 98013, 25714, 25753, 2165, 
25752, 97885, 97892, 24577, 24572
34079, 23936, 23937, 1991, 1990, 96175, 96177, 24508, 24506, 24439, 24477, 2014, 24476, 97895, 98016, 24578, 
98014, 97886, 97893, 24579, 24574
34080, 96175, 96177, 24508, 24506, 96176, 96178, 24509, 24507, 97895, 98016, 24578, 98014, 97898, 98017, 24580, 
98015, 97889, 97896, 24581, 24576
34081, 96176, 96178, 24509, 24507, 25213, 25214, 2143, 2142, 97898, 98017, 24580, 98015, 25716, 25754, 2166, 
25753, 97892, 97899, 24582, 24577
34082, 23937, 23938, 1992, 1991, 96177, 96179, 24510, 24508, 24441, 24478, 2015, 24477, 97902, 98018, 24583, 
98016, 97893, 97900, 24584, 24579
34083, 96177, 96179, 24510, 24508, 96178, 96180, 24511, 24509, 97902, 98018, 24583, 98016, 97905, 98019, 24585, 
98017, 97896, 97903, 24586, 24581
34084, 96178, 96180, 24511, 24509, 25214, 25215, 2144, 2143, 97905, 98019, 24585, 98017, 25718, 25755, 2167, 
25754, 97899, 97906, 24587, 24582
34085, 23938, 23939, 1993, 1992, 96179, 96181, 24512, 24510, 24443, 24479, 2016, 24478, 97909, 98020, 24588, 
98018, 97900, 97907, 24589, 24584
34086, 96179, 96181, 24512, 24510, 96180, 96182, 24513, 24511, 97909, 98020, 24588, 98018, 97912, 98021, 24590, 
98019, 97903, 97910, 24591, 24586
34087, 96180, 96182, 24513, 24511, 25215, 25216, 2145, 2144, 97912, 98021, 24590, 98019, 25720, 25756, 2168, 
25755, 97906, 97913, 24592, 24587
34088, 23939, 23940, 1994, 1993, 96181, 96183, 24514, 24512, 24445, 24480, 2017, 24479, 97916, 98022, 24593, 
98020, 97907, 97914, 24594, 24589
34089, 96181, 96183, 24514, 24512, 96182, 96184, 24515, 24513, 97916, 98022, 24593, 98020, 97919, 98023, 24595, 
98021, 97910, 97917, 24596, 24591
34090, 96182, 96184, 24515, 24513, 25216, 25217, 2146, 2145, 97919, 98023, 24595, 98021, 25722, 25757, 2169, 
25756, 97913, 97920, 24597, 24592
34091, 23940, 23941, 1995, 1994, 96183, 96185, 24516, 24514, 24447, 24481, 2018, 24480, 97923, 98024, 24598, 
98022, 97914, 97921, 24599, 24594
34092, 96183, 96185, 24516, 24514, 96184, 96186, 24517, 24515, 97923, 98024, 24598, 98022, 97926, 98025, 24600, 
98023, 97917, 97924, 24601, 24596
34093, 96184, 96186, 24517, 24515, 25217, 25218, 2147, 2146, 97926, 98025, 24600, 98023, 25724, 25758, 2170, 
25757, 97920, 97927, 24602, 24597
34094, 23941, 23942, 1996, 1995, 96185, 96187, 24518, 24516, 24449, 24482, 2019, 24481, 97930, 98026, 24603, 
98024, 97921, 97928, 24604, 24599
34095, 96185, 96187, 24518, 24516, 96186, 96188, 24519, 24517, 97930, 98026, 24603, 98024, 97933, 98027, 24605, 
98025, 97924, 97931, 24606, 24601
34096, 96186, 96188, 24519, 24517, 25218, 25219, 2148, 2147, 97933, 98027, 24605, 98025, 25726, 25759, 2171, 
25758, 97927, 97934, 24607, 24602
34097, 23942, 23943, 1997, 1996, 96187, 96189, 24520, 24518, 24451, 24483, 2020, 24482, 97937, 98028, 24608, 
98026, 97928, 97935, 24609, 24604
34098, 96187, 96189, 24520, 24518, 96188, 96190, 24521, 24519, 97937, 98028, 24608, 98026, 97940, 98029, 24610, 
98027, 97931, 97938, 24611, 24606
34099, 96188, 96190, 24521, 24519, 25219, 25220, 2149, 2148, 97940, 98029, 24610, 98027, 25728, 25760, 2172, 
25759, 97934, 97941, 24612, 24607
34100, 23943, 23944, 1998, 1997, 96189, 96191, 24522, 24520, 24453, 24484, 2021, 24483, 97944, 98030, 24613, 
98028, 97935, 97942, 24614, 24609
34101, 96189, 96191, 24522, 24520, 96190, 96192, 24523, 24521, 97944, 98030, 24613, 98028, 97947, 98031, 24615, 
98029, 97938, 97945, 24616, 24611
34102, 96190, 96192, 24523, 24521, 25220, 25221, 2150, 2149, 97947, 98031, 24615, 98029, 25730, 25761, 2173, 
25760, 97941, 97948, 24617, 24612
34103, 23944, 23945, 1999, 1998, 96191, 96193, 24524, 24522, 24455, 24485, 2022, 24484, 97951, 98032, 24618, 
98030, 97942, 97949, 24619, 24614
34104, 96191, 96193, 24524, 24522, 96192, 96194, 24525, 24523, 97951, 98032, 24618, 98030, 97954, 98033, 24620, 
98031, 97945, 97952, 24621, 24616
34105, 96192, 96194, 24525, 24523, 25221, 25222, 2151, 2150, 97954, 98033, 24620, 98031, 25732, 25762, 2174, 
25761, 97948, 97955, 24622, 24617
34106, 23945, 23946, 2000, 1999, 96193, 96195, 24526, 24524, 24457, 24486, 2023, 24485, 97958, 98034, 24623, 
98032, 97949, 97956, 24624, 24619
34107, 96193, 96195, 24526, 24524, 96194, 96196, 24527, 24525, 97958, 98034, 24623, 98032, 97961, 98035, 24625, 
98033, 97952, 97959, 24626, 24621
34108, 96194, 96196, 24527, 24525, 25222, 25223, 2152, 2151, 97961, 98035, 24625, 98033, 25734, 25763, 2175, 
25762, 97955, 97962, 24627, 24622
34109, 23946, 23947, 2001, 2000, 96195, 96197, 24528, 24526, 24459, 24487, 2024, 24486, 97965, 98036, 24628, 
98034, 97956, 97963, 24629, 24624
34110, 96195, 96197, 24528, 24526, 96196, 96198, 24529, 24527, 97965, 98036, 24628, 98034, 97968, 98037, 24630, 
98035, 97959, 97966, 24631, 24626
34111, 96196, 96198, 24529, 24527, 25223, 25224, 2153, 2152, 97968, 98037, 24630, 98035, 25736, 25764, 2176, 
25763, 97962, 97969, 24632, 24627
34112, 23947, 23948, 2002, 2001, 96197, 96199, 24530, 24528, 24461, 24488, 2025, 24487, 97972, 98038, 24633, 
98036, 97963, 97970, 24634, 24629
34113, 96197, 96199, 24530, 24528, 96198, 96200, 24531, 24529, 97972, 98038, 24633, 98036, 97975, 98039, 24635, 
98037, 97966, 97973, 24636, 24631
34114, 96198, 96200, 24531, 24529, 25224, 25225, 2154, 2153, 97975, 98039, 24635, 98037, 25738, 25765, 2177, 
25764, 97969, 97976, 24637, 24632
34115, 23948, 23949, 2003, 2002, 96199, 96201, 24532, 24530, 24463, 24489, 2026, 24488, 97979, 98040, 24638, 
98038, 97970, 97977, 24639, 24634
34116, 96199, 96201, 24532, 24530, 96200, 96202, 24533, 24531, 97979, 98040, 24638, 98038, 97982, 98041, 24640, 
98039, 97973, 97980, 24641, 24636
34117, 96200, 96202, 24533, 24531, 25225, 25226, 2155, 2154, 97982, 98041, 24640, 98039, 25740, 25766, 2178, 
25765, 97976, 97983, 24642, 24637
34118, 23949, 23950, 2004, 2003, 96201, 96203, 24534, 24532, 24465, 24490, 2027, 24489, 97986, 98042, 24643, 
98040, 97977, 97984, 24644, 24639
34119, 96201, 96203, 24534, 24532, 96202, 96204, 24535, 24533, 97986, 98042, 24643, 98040, 97989, 98043, 24645, 
98041, 97980, 97987, 24646, 24641
34120, 96202, 96204, 24535, 24533, 25226, 25227, 2156, 2155, 97989, 98043, 24645, 98041, 25742, 25767, 2179, 
25766, 97983, 97990, 24647, 24642
34121, 23950, 23951, 2005, 2004, 96203, 96205, 24536, 24534, 24467, 24491, 2028, 24490, 97993, 98044, 24648, 
98042, 97984, 97991, 24649, 24644
34122, 96203, 96205, 24536, 24534, 96204, 96206, 24537, 24535, 97993, 98044, 24648, 98042, 97996, 98045, 24650, 
98043, 97987, 97994, 24651, 24646
34123, 96204, 96206, 24537, 24535, 25227, 25228, 2157, 2156, 97996, 98045, 24650, 98043, 25744, 25768, 2180, 
25767, 97990, 97997, 24652, 24647
34124, 23951, 2112, 42, 2005, 96205, 24917, 2130, 24536, 24468, 2124, 2029, 24491, 97998, 24974, 24653, 
98044, 97991, 24969, 2132, 24649
34125, 96205, 24917, 2130, 24536, 96206, 24918, 2131, 24537, 97998, 24974, 24653, 98044, 97999, 24975, 24654, 
98045, 97994, 24971, 2133, 24651
34126, 96206, 24918, 2131, 24537, 25228, 2272, 46, 2157, 97999, 24975, 24654, 98045, 25745, 2284, 2181, 
25768, 97997, 24973, 2134, 24652
*ELEMENT, type=C3D20, ELSET=Volume12
34127, 44, 2102, 24897, 2187, 51, 2299, 25795, 2294, 2113, 24919, 24920, 2189, 2310, 25817, 25818, 
2296, 2292, 25773, 98046, 25771
34128, 2187, 24897, 24898, 2188, 2294, 25795, 25796, 2295, 24920, 24921, 24922, 2190, 25818, 25819, 25820, 
2297, 25771, 98046, 98047, 25772
34129, 2188, 24898, 2262, 48, 2295, 25796, 2322, 52, 24922, 24923, 2273, 2191, 25820, 25821, 2333, 
2298, 25772, 98047, 25784, 2293
34130, 2102, 2103, 24899, 24897, 2299, 2300, 25797, 25795, 2114, 24924, 24925, 24919, 2311, 25822, 25823, 
25817, 25773, 25774, 98048, 98046
34131, 24897, 24899, 24900, 24898, 25795, 25797, 25798, 25796, 24925, 24926, 24927, 24921, 25823, 25824, 25825, 
25819, 98046, 98048, 98049, 98047
34132, 24898, 24900, 2263, 2262, 25796, 25798, 2323, 2322, 24927, 24928, 2274, 24923, 25825, 25826, 2334, 
25821, 98047, 98049, 25785, 25784
34133, 2103, 2104, 24901, 24899, 2300, 2301, 25799, 25797, 2115, 24929, 24930, 24924, 2312, 25827, 25828, 
25822, 25774, 25775, 98050, 98048
34134, 24899, 24901, 24902, 24900, 25797, 25799, 25800, 25798, 24930, 24931, 24932, 24926, 25828, 25829, 25830, 
25824, 98048, 98050, 98051, 98049
34135, 24900, 24902, 2264, 2263, 25798, 25800, 2324, 2323, 24932, 24933, 2275, 24928, 25830, 25831, 2335, 
25826, 98049, 98051, 25786, 25785
34136, 2104, 2105, 24903, 24901, 2301, 2302, 25801, 25799, 2116, 24934, 24935, 24929, 2313, 25832, 25833, 
25827, 25775, 25776, 98052, 98050
34137, 24901, 24903, 24904, 24902, 25799, 25801, 25802, 25800, 24935, 24936, 24937, 24931, 25833, 25834, 25835, 
25829, 98050, 98052, 98053, 98051
34138, 24902, 24904, 2265, 2264, 25800, 25802, 2325, 2324, 24937, 24938, 2276, 24933, 25835, 25836, 2336, 
25831, 98051, 98053, 25787, 25786
34139, 2105, 2106, 24905, 24903, 2302, 2303, 25803, 25801, 2117, 24939, 24940, 24934, 2314, 25837, 25838, 
25832, 25776, 25777, 98054, 98052
34140, 24903, 24905, 24906, 24904, 25801, 25803, 25804, 25802, 24940, 24941, 24942, 24936, 25838, 25839, 25840, 
25834, 98052, 98054, 98055, 98053
34141, 24904, 24906, 2266, 2265, 25802, 25804, 2326, 2325, 24942, 24943, 2277, 24938, 25840, 25841, 2337, 
25836, 98053, 98055, 25788, 25787
34142, 2106, 2107, 24907, 24905, 2303, 2304, 25805, 25803, 2118, 24944, 24945, 24939, 2315, 25842, 25843, 
25837, 25777, 25778, 98056, 98054
34143, 24905, 24907, 24908, 24906, 25803, 25805, 25806, 25804, 24945, 24946, 24947, 24941, 25843, 25844, 25845, 
25839, 98054, 98056, 98057, 98055
34144, 24906, 24908, 2267, 2266, 25804, 25806, 2327, 2326, 24947, 24948, 2278, 24943, 25845, 25846, 2338, 
25841, 98055, 98057, 25789, 25788
34145, 2107, 2108, 24909, 24907, 2304, 2305, 25807, 25805, 2119, 24949, 24950, 24944, 2316, 25847, 25848, 
25842, 25778, 25779, 98058, 98056
34146, 24907, 24909, 24910, 24908, 25805, 25807, 25808, 25806, 24950, 24951, 24952, 24946, 25848, 25849, 25850, 
25844, 98056, 98058, 98059, 98057
34147, 24908, 24910, 2268, 2267, 25806, 25808, 2328, 2327, 24952, 24953, 2279, 24948, 25850, 25851, 2339, 
25846, 98057, 98059, 25790, 25789
34148, 2108, 2109, 24911, 24909, 2305, 2306, 25809, 25807, 2120, 24954, 24955, 24949, 2317, 25852, 25853, 
25847, 25779, 25780, 98060, 98058
34149, 24909, 24911, 24912, 24910, 25807, 25809, 25810, 25808, 24955, 24956, 24957, 24951, 25853, 25854, 25855, 
25849, 98058, 98060, 98061, 98059
34150, 24910, 24912, 2269, 2268, 25808, 25810, 2329, 2328, 24957, 24958, 2280, 24953, 25855, 25856, 2340, 
25851, 98059, 98061, 25791, 25790
34151, 2109, 2110, 24913, 24911, 2306, 2307, 25811, 25809, 2121, 24959, 24960, 24954, 2318, 25857, 25858, 
25852, 25780, 25781, 98062, 98060
34152, 24911, 24913, 24914, 24912, 25809, 25811, 25812, 25810, 24960, 24961, 24962, 24956, 25858, 25859, 25860, 
25854, 98060, 98062, 98063, 98061
34153, 24912, 24914, 2270, 2269, 25810, 25812, 2330, 2329, 24962, 24963, 2281, 24958, 25860, 25861, 2341, 
25856, 98061, 98063, 25792, 25791
34154, 2110, 2111, 24915, 24913, 2307, 2308, 25813, 25811, 2122, 24964, 24965, 24959, 2319, 25862, 25863, 
25857, 25781, 25782, 98064, 98062
34155, 24913, 24915, 24916, 24914, 25811, 25813, 25814, 25812, 24965, 24966, 24967, 24961, 25863, 25864, 25865, 
25859, 98062, 98064, 98065, 98063
34156, 24914, 24916, 2271, 2270, 25812, 25814, 2331, 2330, 24967, 24968, 2282, 24963, 25865, 25866, 2342, 
25861, 98063, 98065, 25793, 25792
34157, 2111, 2112, 24917, 24915, 2308, 2309, 25815, 25813, 2123, 24969, 24970, 24964, 2320, 25867, 25868, 
25862, 25782, 25783, 98066, 98064
34158, 24915, 24917, 24918, 24916, 25813, 25815, 25816, 25814, 24970, 24971, 24972, 24966, 25868, 25869, 25870, 
25864, 98064, 98066, 98067, 98065
34159, 24916, 24918, 2272, 2271, 25814, 25816, 2332, 2331, 24972, 24973, 2283, 24968, 25870, 25871, 2343, 
25866, 98065, 98067, 25794, 25793
34160, 2112, 42, 2130, 24917, 2309, 49, 2287, 25815, 2124, 2132, 24974, 24969, 2321, 2289, 25872, 
25867, 25783, 2285, 25769, 98066
34161, 24917, 2130, 2131, 24918, 25815, 2287, 2288, 25816, 24974, 2133, 24975, 24971, 25872, 2290, 25873, 
25869, 98066, 25769, 25770, 98067
34162, 24918, 2131, 46, 2272, 25816, 2288, 50, 2332, 24975, 2134, 2284, 24973, 25873, 2291, 2344, 
25871, 98067, 25770, 2286, 25794
*ELEMENT, type=C3D20, ELSET=Volume13
34163, 2, 97, 3987, 148, 54, 2347, 25900, 2400, 108, 4009, 4010, 150, 2358, 25922, 25923, 
2402, 2346, 25874, 98068, 25898
34164, 148, 3987, 3988, 149, 2400, 25900, 25901, 2401, 4010, 4011, 4012, 151, 25923, 25924, 25925, 
2403, 25898, 98068, 98069, 25899
34165, 149, 3988, 125, 4, 2401, 25901, 2377, 56, 4012, 4013, 136, 152, 25925, 25926, 2388, 
2404, 25899, 98069, 25887, 2376
34166, 97, 98, 3989, 3987, 2347, 2348, 25902, 25900, 109, 4014, 4015, 4009, 2359, 25927, 25928, 
25922, 25874, 25875, 98070, 98068
34167, 3987, 3989, 3990, 3988, 25900, 25902, 25903, 25901, 4015, 4016, 4017, 4011, 25928, 25929, 25930, 
25924, 98068, 98070, 98071, 98069
34168, 3988, 3990, 126, 125, 25901, 25903, 2378, 2377, 4017, 4018, 137, 4013, 25930, 25931, 2389, 
25926, 98069, 98071, 25888, 25887
34169, 98, 99, 3991, 3989, 2348, 2349, 25904, 25902, 110, 4019, 4020, 4014, 2360, 25932, 25933, 
25927, 25875, 25876, 98072, 98070
34170, 3989, 3991, 3992, 3990, 25902, 25904, 25905, 25903, 4020, 4021, 4022, 4016, 25933, 25934, 25935, 
25929, 98070, 98072, 98073, 98071
34171, 3990, 3992, 127, 126, 25903, 25905, 2379, 2378, 4022, 4023, 138, 4018, 25935, 25936, 2390, 
25931, 98071, 98073, 25889, 25888
34172, 99, 100, 3993, 3991, 2349, 2350, 25906, 25904, 111, 4024, 4025, 4019, 2361, 25937, 25938, 
25932, 25876, 25877, 98074, 98072
34173, 3991, 3993, 3994, 3992, 25904, 25906, 25907, 25905, 4025, 4026, 4027, 4021, 25938, 25939, 25940, 
25934, 98072, 98074, 98075, 98073
34174, 3992, 3994, 128, 127, 25905, 25907, 2380, 2379, 4027, 4028, 139, 4023, 25940, 25941, 2391, 
25936, 98073, 98075, 25890, 25889
34175, 100, 101, 3995, 3993, 2350, 2351, 25908, 25906, 112, 4029, 4030, 4024, 2362, 25942, 25943, 
25937, 25877, 25878, 98076, 98074
34176, 3993, 3995, 3996, 3994, 25906, 25908, 25909, 25907, 4030, 4031, 4032, 4026, 25943, 25944, 25945, 
25939, 98074, 98076, 98077, 98075
34177, 3994, 3996, 129, 128, 25907, 25909, 2381, 2380, 4032, 4033, 140, 4028, 25945, 25946, 2392, 
25941, 98075, 98077, 25891, 25890
34178, 101, 102, 3997, 3995, 2351, 2352, 25910, 25908, 113, 4034, 4035, 4029, 2363, 25947, 25948, 
25942, 25878, 25879, 98078, 98076
34179, 3995, 3997, 3998, 3996, 25908, 25910, 25911, 25909, 4035, 4036, 4037, 4031, 25948, 25949, 25950, 
25944, 98076, 98078, 98079, 98077
34180, 3996, 3998, 130, 129, 25909, 25911, 2382, 2381, 4037, 4038, 141, 4033, 25950, 25951, 2393, 
25946, 98077, 98079, 25892, 25891
34181, 102, 103, 3999, 3997, 2352, 2353, 25912, 25910, 114, 4039, 4040, 4034, 2364, 25952, 25953, 
25947, 25879, 25880, 98080, 98078
34182, 3997, 3999, 4000, 3998, 25910, 25912, 25913, 25911, 4040, 4041, 4042, 4036, 25953, 25954, 25955, 
25949, 98078, 98080, 98081, 98079
34183, 3998, 4000, 131, 130, 25911, 25913, 2383, 2382, 4042, 4043, 142, 4038, 25955, 25956, 2394, 
25951, 98079, 98081, 25893, 25892
34184, 103, 104, 4001, 3999, 2353, 2354, 25914, 25912, 115, 4044, 4045, 4039, 2365, 25957, 25958, 
25952, 25880, 25881, 98082, 98080
34185, 3999, 4001, 4002, 4000, 25912, 25914, 25915, 25913, 4045, 4046, 4047, 4041, 25958, 25959, 25960, 
25954, 98080, 98082, 98083, 98081
34186, 4000, 4002, 132, 131, 25913, 25915, 2384, 2383, 4047, 4048, 143, 4043, 25960, 25961, 2395, 
25956, 98081, 98083, 25894, 25893
34187, 104, 105, 4003, 4001, 2354, 2355, 25916, 25914, 116, 4049, 4050, 4044, 2366, 25962, 25963, 
25957, 25881, 25882, 98084, 98082
34188, 4001, 4003, 4004, 4002, 25914, 25916, 25917, 25915, 4050, 4051, 4052, 4046, 25963, 25964, 25965, 
25959, 98082, 98084, 98085, 98083
34189, 4002, 4004, 133, 132, 25915, 25917, 2385, 2384, 4052, 4053, 144, 4048, 25965, 25966, 2396, 
25961, 98083, 98085, 25895, 25894
34190, 105, 106, 4005, 4003, 2355, 2356, 25918, 25916, 117, 4054, 4055, 4049, 2367, 25967, 25968, 
25962, 25882, 25883, 98086, 98084
34191, 4003, 4005, 4006, 4004, 25916, 25918, 25919, 25917, 4055, 4056, 4057, 4051, 25968, 25969, 25970, 
25964, 98084, 98086, 98087, 98085
34192, 4004, 4006, 134, 133, 25917, 25919, 2386, 2385, 4057, 4058, 145, 4053, 25970, 25971, 2397, 
25966, 98085, 98087, 25896, 25895
34193, 106, 107, 4007, 4005, 2356, 2357, 25920, 25918, 118, 4059, 4060, 4054, 2368, 25972, 25973, 
25967, 25883, 25884, 98088, 98086
34194, 4005, 4007, 4008, 4006, 25918, 25920, 25921, 25919, 4060, 4061, 4062, 4056, 25973, 25974, 25975, 
25969, 98086, 98088, 98089, 98087
34195, 4006, 4008, 135, 134, 25919, 25921, 2387, 2386, 4062, 4063, 146, 4058, 25975, 25976, 2398, 
25971, 98087, 98089, 25897, 25896
34196, 107, 1, 120, 4007, 2357, 53, 2371, 25920, 119, 122, 4064, 4059, 2369, 2373, 25977, 
25972, 25884, 2345, 25885, 98088
34197, 4007, 120, 121, 4008, 25920, 2371, 2372, 25921, 4064, 123, 4065, 4061, 25977, 2374, 25978, 
25974, 98088, 25885, 25886, 98089
34198, 4008, 121, 3, 135, 25921, 2372, 55, 2387, 4065, 124, 147, 4063, 25978, 2375, 2399, 
25976, 98089, 25886, 2370, 25897
*ELEMENT, type=C3D20, ELSET=Volume14
34199, 10, 588, 6918, 399, 67, 2744, 27793, 2791, 611, 7447, 7448, 422, 2767, 28322, 28323, 
2814, 2742, 27724, 98090, 27747
34200, 588, 589, 6919, 6918, 2744, 2745, 27794, 27793, 612, 7449, 7450, 7447, 2768, 28324, 28325, 
28322, 27724, 27725, 98091, 98090
34201, 589, 590, 6920, 6919, 2745, 2746, 27795, 27794, 613, 7451, 7452, 7449, 2769, 28326, 28327, 
28324, 27725, 27726, 98092, 98091
34202, 590, 591, 6921, 6920, 2746, 2747, 27796, 27795, 614, 7453, 7454, 7451, 2770, 28328, 28329, 
28326, 27726, 27727, 98093, 98092
34203, 591, 592, 6922, 6921, 2747, 2748, 27797, 27796, 615, 7455, 7456, 7453, 2771, 28330, 28331, 
28328, 27727, 27728, 98094, 98093
34204, 592, 593, 6923, 6922, 2748, 2749, 27798, 27797, 616, 7457, 7458, 7455, 2772, 28332, 28333, 
28330, 27728, 27729, 98095, 98094
34205, 593, 594, 6924, 6923, 2749, 2750, 27799, 27798, 617, 7459, 7460, 7457, 2773, 28334, 28335, 
28332, 27729, 27730, 98096, 98095
34206, 594, 595, 6925, 6924, 2750, 2751, 27800, 27799, 618, 7461, 7462, 7459, 2774, 28336, 28337, 
28334, 27730, 27731, 98097, 98096
34207, 595, 596, 6926, 6925, 2751, 2752, 27801, 27800, 619, 7463, 7464, 7461, 2775, 28338, 28339, 
28336, 27731, 27732, 98098, 98097
34208, 596, 597, 6927, 6926, 2752, 2753, 27802, 27801, 620, 7465, 7466, 7463, 2776, 28340, 28341, 
28338, 27732, 27733, 98099, 98098
34209, 597, 598, 6928, 6927, 2753, 2754, 27803, 27802, 621, 7467, 7468, 7465, 2777, 28342, 28343, 
28340, 27733, 27734, 98100, 98099
34210, 598, 599, 6929, 6928, 2754, 2755, 27804, 27803, 622, 7469, 7470, 7467, 2778, 28344, 28345, 
28342, 27734, 27735, 98101, 98100
34211, 599, 600, 6930, 6929, 2755, 2756, 27805, 27804, 623, 7471, 7472, 7469, 2779, 28346, 28347, 
28344, 27735, 27736, 98102, 98101
34212, 600, 601, 6931, 6930, 2756, 2757, 27806, 27805, 624, 7473, 7474, 7471, 2780, 28348, 28349, 
28346, 27736, 27737, 98103, 98102
34213, 601, 602, 6932, 6931, 2757, 2758, 27807, 27806, 625, 7475, 7476, 7473, 2781, 28350, 28351, 
28348, 27737, 27738, 98104, 98103
34214, 602, 603, 6933, 6932, 2758, 2759, 27808, 27807, 626, 7477, 7478, 7475, 2782, 28352, 28353, 
28350, 27738, 27739, 98105, 98104
34215, 603, 604, 6934, 6933, 2759, 2760, 27809, 27808, 627, 7479, 7480, 7477, 2783, 28354, 28355, 
28352, 27739, 27740, 98106, 98105
34216, 604, 605, 6935, 6934, 2760, 2761, 27810, 27809, 628, 7481, 7482, 7479, 2784, 28356, 28357, 
28354, 27740, 27741, 98107, 98106
34217, 605, 606, 6936, 6935, 2761, 2762, 27811, 27810, 629, 7483, 7484, 7481, 2785, 28358, 28359, 
28356, 27741, 27742, 98108, 98107
34218, 606, 607, 6937, 6936, 2762, 2763, 27812, 27811, 630, 7485, 7486, 7483, 2786, 28360, 28361, 
28358, 27742, 27743, 98109, 98108
34219, 607, 608, 6938, 6937, 2763, 2764, 27813, 27812, 631, 7487, 7488, 7485, 2787, 28362, 28363, 
28360, 27743, 27744, 98110, 98109
34220, 608, 609, 6939, 6938, 2764, 2765, 27814, 27813, 632, 7489, 7490, 7487, 2788, 28364, 28365, 
28362, 27744, 27745, 98111, 98110
34221, 609, 610, 6940, 6939, 2765, 2766, 27815, 27814, 633, 7491, 7492, 7489, 2789, 28366, 28367, 
28364, 27745, 27746, 98112, 98111
34222, 610, 14, 635, 6940, 2766, 68, 2838, 27815, 634, 658, 7493, 7491, 2790, 2861, 28368, 
28366, 27746, 2743, 27770, 98112
34223, 399, 6918, 6941, 400, 2791, 27793, 27816, 2792, 7448, 7494, 7495, 423, 28323, 28369, 28370, 
2815, 27747, 98090, 98113, 27748
34224, 6918, 6919, 6942, 6941, 27793, 27794, 27817, 27816, 7450, 7496, 7497, 7494, 28325, 28371, 28372, 
28369, 98090, 98091, 98114, 98113
34225, 6919, 6920, 6943, 6942, 27794, 27795, 27818, 27817, 7452, 7498, 7499, 7496, 28327, 28373, 28374, 
28371, 98091, 98092, 98115, 98114
34226, 6920, 6921, 6944, 6943, 27795, 27796, 27819, 27818, 7454, 7500, 7501, 7498, 28329, 28375, 28376, 
28373, 98092, 98093, 98116, 98115
34227, 6921, 6922, 6945, 6944, 27796, 27797, 27820, 27819, 7456, 7502, 7503, 7500, 28331, 28377, 28378, 
28375, 98093, 98094, 98117, 98116
34228, 6922, 6923, 6946, 6945, 27797, 27798, 27821, 27820, 7458, 7504, 7505, 7502, 28333, 28379, 28380, 
28377, 98094, 98095, 98118, 98117
34229, 6923, 6924, 6947, 6946, 27798, 27799, 27822, 27821, 7460, 7506, 7507, 7504, 28335, 28381, 28382, 
28379, 98095, 98096, 98119, 98118
34230, 6924, 6925, 6948, 6947, 27799, 27800, 27823, 27822, 7462, 7508, 7509, 7506, 28337, 28383, 28384, 
28381, 98096, 98097, 98120, 98119
34231, 6925, 6926, 6949, 6948, 27800, 27801, 27824, 27823, 7464, 7510, 7511, 7508, 28339, 28385, 28386, 
28383, 98097, 98098, 98121, 98120
34232, 6926, 6927, 6950, 6949, 27801, 27802, 27825, 27824, 7466, 7512, 7513, 7510, 28341, 28387, 28388, 
28385, 98098, 98099, 98122, 98121
34233, 6927, 6928, 6951, 6950, 27802, 27803, 27826, 27825, 7468, 7514, 7515, 7512, 28343, 28389, 28390, 
28387, 98099, 98100, 98123, 98122
34234, 6928, 6929, 6952, 6951, 27803, 27804, 27827, 27826, 7470, 7516, 7517, 7514, 28345, 28391, 28392, 
28389, 98100, 98101, 98124, 98123
34235, 6929, 6930, 6953, 6952, 27804, 27805, 27828, 27827, 7472, 7518, 7519, 7516, 28347, 28393, 28394, 
28391, 98101, 98102, 98125, 98124
34236, 6930, 6931, 6954, 6953, 27805, 27806, 27829, 27828, 7474, 7520, 7521, 7518, 28349, 28395, 28396, 
28393, 98102, 98103, 98126, 98125
34237, 6931, 6932, 6955, 6954, 27806, 27807, 27830, 27829, 7476, 7522, 7523, 7520, 28351, 28397, 28398, 
28395, 98103, 98104, 98127, 98126
34238, 6932, 6933, 6956, 6955, 27807, 27808, 27831, 27830, 7478, 7524, 7525, 7522, 28353, 28399, 28400, 
28397, 98104, 98105, 98128, 98127
34239, 6933, 6934, 6957, 6956, 27808, 27809, 27832, 27831, 7480, 7526, 7527, 7524, 28355, 28401, 28402, 
28399, 98105, 98106, 98129, 98128
34240, 6934, 6935, 6958, 6957, 27809, 27810, 27833, 27832, 7482, 7528, 7529, 7526, 28357, 28403, 28404, 
28401, 98106, 98107, 98130, 98129
34241, 6935, 6936, 6959, 6958, 27810, 27811, 27834, 27833, 7484, 7530, 7531, 7528, 28359, 28405, 28406, 
28403, 98107, 98108, 98131, 98130
34242, 6936, 6937, 6960, 6959, 27811, 27812, 27835, 27834, 7486, 7532, 7533, 7530, 28361, 28407, 28408, 
28405, 98108, 98109, 98132, 98131
34243, 6937, 6938, 6961, 6960, 27812, 27813, 27836, 27835, 7488, 7534, 7535, 7532, 28363, 28409, 28410, 
28407, 98109, 98110, 98133, 98132
34244, 6938, 6939, 6962, 6961, 27813, 27814, 27837, 27836, 7490, 7536, 7537, 7534, 28365, 28411, 28412, 
28409, 98110, 98111, 98134, 98133
34245, 6939, 6940, 6963, 6962, 27814, 27815, 27838, 27837, 7492, 7538, 7539, 7536, 28367, 28413, 28414, 
28411, 98111, 98112, 98135, 98134
34246, 6940, 635, 636, 6963, 27815, 2838, 2839, 27838, 7493, 659, 7540, 7538, 28368, 2862, 28415, 
28413, 98112, 27770, 27771, 98135
34247, 400, 6941, 6964, 401, 2792, 27816, 27839, 2793, 7495, 7541, 7542, 424, 28370, 28416, 28417, 
2816, 27748, 98113, 98136, 27749
34248, 6941, 6942, 6965, 6964, 27816, 27817, 27840, 27839, 7497, 7543, 7544, 7541, 28372, 28418, 28419, 
28416, 98113, 98114, 98137, 98136
34249, 6942, 6943, 6966, 6965, 27817, 27818, 27841, 27840, 7499, 7545, 7546, 7543, 28374, 28420, 28421, 
28418, 98114, 98115, 98138, 98137
34250, 6943, 6944, 6967, 6966, 27818, 27819, 27842, 27841, 7501, 7547, 7548, 7545, 28376, 28422, 28423, 
28420, 98115, 98116, 98139, 98138
34251, 6944, 6945, 6968, 6967, 27819, 27820, 27843, 27842, 7503, 7549, 7550, 7547, 28378, 28424, 28425, 
28422, 98116, 98117, 98140, 98139
34252, 6945, 6946, 6969, 6968, 27820, 27821, 27844, 27843, 7505, 7551, 7552, 7549, 28380, 28426, 28427, 
28424, 98117, 98118, 98141, 98140
34253, 6946, 6947, 6970, 6969, 27821, 27822, 27845, 27844, 7507, 7553, 7554, 7551, 28382, 28428, 28429, 
28426, 98118, 98119, 98142, 98141
34254, 6947, 6948, 6971, 6970, 27822, 27823, 27846, 27845, 7509, 7555, 7556, 7553, 28384, 28430, 28431, 
28428, 98119, 98120, 98143, 98142
34255, 6948, 6949, 6972, 6971, 27823, 27824, 27847, 27846, 7511, 7557, 7558, 7555, 28386, 28432, 28433, 
28430, 98120, 98121, 98144, 98143
34256, 6949, 6950, 6973, 6972, 27824, 27825, 27848, 27847, 7513, 7559, 7560, 7557, 28388, 28434, 28435, 
28432, 98121, 98122, 98145, 98144
34257, 6950, 6951, 6974, 6973, 27825, 27826, 27849, 27848, 7515, 7561, 7562, 7559, 28390, 28436, 28437, 
28434, 98122, 98123, 98146, 98145
34258, 6951, 6952, 6975, 6974, 27826, 27827, 27850, 27849, 7517, 7563, 7564, 7561, 28392, 28438, 28439, 
28436, 98123, 98124, 98147, 98146
34259, 6952, 6953, 6976, 6975, 27827, 27828, 27851, 27850, 7519, 7565, 7566, 7563, 28394, 28440, 28441, 
28438, 98124, 98125, 98148, 98147
34260, 6953, 6954, 6977, 6976, 27828, 27829, 27852, 27851, 7521, 7567, 7568, 7565, 28396, 28442, 28443, 
28440, 98125, 98126, 98149, 98148
34261, 6954, 6955, 6978, 6977, 27829, 27830, 27853, 27852, 7523, 7569, 7570, 7567, 28398, 28444, 28445, 
28442, 98126, 98127, 98150, 98149
34262, 6955, 6956, 6979, 6978, 27830, 27831, 27854, 27853, 7525, 7571, 7572, 7569, 28400, 28446, 28447, 
28444, 98127, 98128, 98151, 98150
34263, 6956, 6957, 6980, 6979, 27831, 27832, 27855, 27854, 7527, 7573, 7574, 7571, 28402, 28448, 28449, 
28446, 98128, 98129, 98152, 98151
34264, 6957, 6958, 6981, 6980, 27832, 27833, 27856, 27855, 7529, 7575, 7576, 7573, 28404, 28450, 28451, 
28448, 98129, 98130, 98153, 98152
34265, 6958, 6959, 6982, 6981, 27833, 27834, 27857, 27856, 7531, 7577, 7578, 7575, 28406, 28452, 28453, 
28450, 98130, 98131, 98154, 98153
34266, 6959, 6960, 6983, 6982, 27834, 27835, 27858, 27857, 7533, 7579, 7580, 7577, 28408, 28454, 28455, 
28452, 98131, 98132, 98155, 98154
34267, 6960, 6961, 6984, 6983, 27835, 27836, 27859, 27858, 7535, 7581, 7582, 7579, 28410, 28456, 28457, 
28454, 98132, 98133, 98156, 98155
34268, 6961, 6962, 6985, 6984, 27836, 27837, 27860, 27859, 7537, 7583, 7584, 7581, 28412, 28458, 28459, 
28456, 98133, 98134, 98157, 98156
34269, 6962, 6963, 6986, 6985, 27837, 27838, 27861, 27860, 7539, 7585, 7586, 7583, 28414, 28460, 28461, 
28458, 98134, 98135, 98158, 98157
34270, 6963, 636, 637, 6986, 27838, 2839, 2840, 27861, 7540, 660, 7587, 7585, 28415, 2863, 28462, 
28460, 98135, 27771, 27772, 98158
34271, 401, 6964, 6987, 402, 2793, 27839, 27862, 2794, 7542, 7588, 7589, 425, 28417, 28463, 28464, 
2817, 27749, 98136, 98159, 27750
34272, 6964, 6965, 6988, 6987, 27839, 27840, 27863, 27862, 7544, 7590, 7591, 7588, 28419, 28465, 28466, 
28463, 98136, 98137, 98160, 98159
34273, 6965, 6966, 6989, 6988, 27840, 27841, 27864, 27863, 7546, 7592, 7593, 7590, 28421, 28467, 28468, 
28465, 98137, 98138, 98161, 98160
34274, 6966, 6967, 6990, 6989, 27841, 27842, 27865, 27864, 7548, 7594, 7595, 7592, 28423, 28469, 28470, 
28467, 98138, 98139, 98162, 98161
34275, 6967, 6968, 6991, 6990, 27842, 27843, 27866, 27865, 7550, 7596, 7597, 7594, 28425, 28471, 28472, 
28469, 98139, 98140, 98163, 98162
34276, 6968, 6969, 6992, 6991, 27843, 27844, 27867, 27866, 7552, 7598, 7599, 7596, 28427, 28473, 28474, 
28471, 98140, 98141, 98164, 98163
34277, 6969, 6970, 6993, 6992, 27844, 27845, 27868, 27867, 7554, 7600, 7601, 7598, 28429, 28475, 28476, 
28473, 98141, 98142, 98165, 98164
34278, 6970, 6971, 6994, 6993, 27845, 27846, 27869, 27868, 7556, 7602, 7603, 7600, 28431, 28477, 28478, 
28475, 98142, 98143, 98166, 98165
34279, 6971, 6972, 6995, 6994, 27846, 27847, 27870, 27869, 7558, 7604, 7605, 7602, 28433, 28479, 28480, 
28477, 98143, 98144, 98167, 98166
34280, 6972, 6973, 6996, 6995, 27847, 27848, 27871, 27870, 7560, 7606, 7607, 7604, 28435, 28481, 28482, 
28479, 98144, 98145, 98168, 98167
34281, 6973, 6974, 6997, 6996, 27848, 27849, 27872, 27871, 7562, 7608, 7609, 7606, 28437, 28483, 28484, 
28481, 98145, 98146, 98169, 98168
34282, 6974, 6975, 6998, 6997, 27849, 27850, 27873, 27872, 7564, 7610, 7611, 7608, 28439, 28485, 28486, 
28483, 98146, 98147, 98170, 98169
34283, 6975, 6976, 6999, 6998, 27850, 27851, 27874, 27873, 7566, 7612, 7613, 7610, 28441, 28487, 28488, 
28485, 98147, 98148, 98171, 98170
34284, 6976, 6977, 7000, 6999, 27851, 27852, 27875, 27874, 7568, 7614, 7615, 7612, 28443, 28489, 28490, 
28487, 98148, 98149, 98172, 98171
34285, 6977, 6978, 7001, 7000, 27852, 27853, 27876, 27875, 7570, 7616, 7617, 7614, 28445, 28491, 28492, 
28489, 98149, 98150, 98173, 98172
34286, 6978, 6979, 7002, 7001, 27853, 27854, 27877, 27876, 7572, 7618, 7619, 7616, 28447, 28493, 28494, 
28491, 98150, 98151, 98174, 98173
34287, 6979, 6980, 7003, 7002, 27854, 27855, 27878, 27877, 7574, 7620, 7621, 7618, 28449, 28495, 28496, 
28493, 98151, 98152, 98175, 98174
34288, 6980, 6981, 7004, 7003, 27855, 27856, 27879, 27878, 7576, 7622, 7623, 7620, 28451, 28497, 28498, 
28495, 98152, 98153, 98176, 98175
34289, 6981, 6982, 7005, 7004, 27856, 27857, 27880, 27879, 7578, 7624, 7625, 7622, 28453, 28499, 28500, 
28497, 98153, 98154, 98177, 98176
34290, 6982, 6983, 7006, 7005, 27857, 27858, 27881, 27880, 7580, 7626, 7627, 7624, 28455, 28501, 28502, 
28499, 98154, 98155, 98178, 98177
34291, 6983, 6984, 7007, 7006, 27858, 27859, 27882, 27881, 7582, 7628, 7629, 7626, 28457, 28503, 28504, 
28501, 98155, 98156, 98179, 98178
34292, 6984, 6985, 7008, 7007, 27859, 27860, 27883, 27882, 7584, 7630, 7631, 7628, 28459, 28505, 28506, 
28503, 98156, 98157, 98180, 98179
34293, 6985, 6986, 7009, 7008, 27860, 27861, 27884, 27883, 7586, 7632, 7633, 7630, 28461, 28507, 28508, 
28505, 98157, 98158, 98181, 98180
34294, 6986, 637, 638, 7009, 27861, 2840, 2841, 27884, 7587, 661, 7634, 7632, 28462, 2864, 28509, 
28507, 98158, 27772, 27773, 98181
34295, 402, 6987, 7010, 403, 2794, 27862, 27885, 2795, 7589, 7635, 7636, 426, 28464, 28510, 28511, 
2818, 27750, 98159, 98182, 27751
34296, 6987, 6988, 7011, 7010, 27862, 27863, 27886, 27885, 7591, 7637, 7638, 7635, 28466, 28512, 28513, 
28510, 98159, 98160, 98183, 98182
34297, 6988, 6989, 7012, 7011, 27863, 27864, 27887, 27886, 7593, 7639, 7640, 7637, 28468, 28514, 28515, 
28512, 98160, 98161, 98184, 98183
34298, 6989, 6990, 7013, 7012, 27864, 27865, 27888, 27887, 7595, 7641, 7642, 7639, 28470, 28516, 28517, 
28514, 98161, 98162, 98185, 98184
34299, 6990, 6991, 7014, 7013, 27865, 27866, 27889, 27888, 7597, 7643, 7644, 7641, 28472, 28518, 28519, 
28516, 98162, 98163, 98186, 98185
34300, 6991, 6992, 7015, 7014, 27866, 27867, 27890, 27889, 7599, 7645, 7646, 7643, 28474, 28520, 28521, 
28518, 98163, 98164, 98187, 98186
34301, 6992, 6993, 7016, 7015, 27867, 27868, 27891, 27890, 7601, 7647, 7648, 7645, 28476, 28522, 28523, 
28520, 98164, 98165, 98188, 98187
34302, 6993, 6994, 7017, 7016, 27868, 27869, 27892, 27891, 7603, 7649, 7650, 7647, 28478, 28524, 28525, 
28522, 98165, 98166, 98189, 98188
34303, 6994, 6995, 7018, 7017, 27869, 27870, 27893, 27892, 7605, 7651, 7652, 7649, 28480, 28526, 28527, 
28524, 98166, 98167, 98190, 98189
34304, 6995, 6996, 7019, 7018, 27870, 27871, 27894, 27893, 7607, 7653, 7654, 7651, 28482, 28528, 28529, 
28526, 98167, 98168, 98191, 98190
34305, 6996, 6997, 7020, 7019, 27871, 27872, 27895, 27894, 7609, 7655, 7656, 7653, 28484, 28530, 28531, 
28528, 98168, 98169, 98192, 98191
34306, 6997, 6998, 7021, 7020, 27872, 27873, 27896, 27895, 7611, 7657, 7658, 7655, 28486, 28532, 28533, 
28530, 98169, 98170, 98193, 98192
34307, 6998, 6999, 7022, 7021, 27873, 27874, 27897, 27896, 7613, 7659, 7660, 7657, 28488, 28534, 28535, 
28532, 98170, 98171, 98194, 98193
34308, 6999, 7000, 7023, 7022, 27874, 27875, 27898, 27897, 7615, 7661, 7662, 7659, 28490, 28536, 28537, 
28534, 98171, 98172, 98195, 98194
34309, 7000, 7001, 7024, 7023, 27875, 27876, 27899, 27898, 7617, 7663, 7664, 7661, 28492, 28538, 28539, 
28536, 98172, 98173, 98196, 98195
34310, 7001, 7002, 7025, 7024, 27876, 27877, 27900, 27899, 7619, 7665, 7666, 7663, 28494, 28540, 28541, 
28538, 98173, 98174, 98197, 98196
34311, 7002, 7003, 7026, 7025, 27877, 27878, 27901, 27900, 7621, 7667, 7668, 7665, 28496, 28542, 28543, 
28540, 98174, 98175, 98198, 98197
34312, 7003, 7004, 7027, 7026, 27878, 27879, 27902, 27901, 7623, 7669, 7670, 7667, 28498, 28544, 28545, 
28542, 98175, 98176, 98199, 98198
34313, 7004, 7005, 7028, 7027, 27879, 27880, 27903, 27902, 7625, 7671, 7672, 7669, 28500, 28546, 28547, 
28544, 98176, 98177, 98200, 98199
34314, 7005, 7006, 7029, 7028, 27880, 27881, 27904, 27903, 7627, 7673, 7674, 7671, 28502, 28548, 28549, 
28546, 98177, 98178, 98201, 98200
34315, 7006, 7007, 7030, 7029, 27881, 27882, 27905, 27904, 7629, 7675, 7676, 7673, 28504, 28550, 28551, 
28548, 98178, 98179, 98202, 98201
34316, 7007, 7008, 7031, 7030, 27882, 27883, 27906, 27905, 7631, 7677, 7678, 7675, 28506, 28552, 28553, 
28550, 98179, 98180, 98203, 98202
34317, 7008, 7009, 7032, 7031, 27883, 27884, 27907, 27906, 7633, 7679, 7680, 7677, 28508, 28554, 28555, 
28552, 98180, 98181, 98204, 98203
34318, 7009, 638, 639, 7032, 27884, 2841, 2842, 27907, 7634, 662, 7681, 7679, 28509, 2865, 28556, 
28554, 98181, 27773, 27774, 98204
34319, 403, 7010, 7033, 404, 2795, 27885, 27908, 2796, 7636, 7682, 7683, 427, 28511, 28557, 28558, 
2819, 27751, 98182, 98205, 27752
34320, 7010, 7011, 7034, 7033, 27885, 27886, 27909, 27908, 7638, 7684, 7685, 7682, 28513, 28559, 28560, 
28557, 98182, 98183, 98206, 98205
34321, 7011, 7012, 7035, 7034, 27886, 27887, 27910, 27909, 7640, 7686, 7687, 7684, 28515, 28561, 28562, 
28559, 98183, 98184, 98207, 98206
34322, 7012, 7013, 7036, 7035, 27887, 27888, 27911, 27910, 7642, 7688, 7689, 7686, 28517, 28563, 28564, 
28561, 98184, 98185, 98208, 98207
34323, 7013, 7014, 7037, 7036, 27888, 27889, 27912, 27911, 7644, 7690, 7691, 7688, 28519, 28565, 28566, 
28563, 98185, 98186, 98209, 98208
34324, 7014, 7015, 7038, 7037, 27889, 27890, 27913, 27912, 7646, 7692, 7693, 7690, 28521, 28567, 28568, 
28565, 98186, 98187, 98210, 98209
34325, 7015, 7016, 7039, 7038, 27890, 27891, 27914, 27913, 7648, 7694, 7695, 7692, 28523, 28569, 28570, 
28567, 98187, 98188, 98211, 98210
34326, 7016, 7017, 7040, 7039, 27891, 27892, 27915, 27914, 7650, 7696, 7697, 7694, 28525, 28571, 28572, 
28569, 98188, 98189, 98212, 98211
34327, 7017, 7018, 7041, 7040, 27892, 27893, 27916, 27915, 7652, 7698, 7699, 7696, 28527, 28573, 28574, 
28571, 98189, 98190, 98213, 98212
34328, 7018, 7019, 7042, 7041, 27893, 27894, 27917, 27916, 7654, 7700, 7701, 7698, 28529, 28575, 28576, 
28573, 98190, 98191, 98214, 98213
34329, 7019, 7020, 7043, 7042, 27894, 27895, 27918, 27917, 7656, 7702, 7703, 7700, 28531, 28577, 28578, 
28575, 98191, 98192, 98215, 98214
34330, 7020, 7021, 7044, 7043, 27895, 27896, 27919, 27918, 7658, 7704, 7705, 7702, 28533, 28579, 28580, 
28577, 98192, 98193, 98216, 98215
34331, 7021, 7022, 7045, 7044, 27896, 27897, 27920, 27919, 7660, 7706, 7707, 7704, 28535, 28581, 28582, 
28579, 98193, 98194, 98217, 98216
34332, 7022, 7023, 7046, 7045, 27897, 27898, 27921, 27920, 7662, 7708, 7709, 7706, 28537, 28583, 28584, 
28581, 98194, 98195, 98218, 98217
34333, 7023, 7024, 7047, 7046, 27898, 27899, 27922, 27921, 7664, 7710, 7711, 7708, 28539, 28585, 28586, 
28583, 98195, 98196, 98219, 98218
34334, 7024, 7025, 7048, 7047, 27899, 27900, 27923, 27922, 7666, 7712, 7713, 7710, 28541, 28587, 28588, 
28585, 98196, 98197, 98220, 98219
34335, 7025, 7026, 7049, 7048, 27900, 27901, 27924, 27923, 7668, 7714, 7715, 7712, 28543, 28589, 28590, 
28587, 98197, 98198, 98221, 98220
34336, 7026, 7027, 7050, 7049, 27901, 27902, 27925, 27924, 7670, 7716, 7717, 7714, 28545, 28591, 28592, 
28589, 98198, 98199, 98222, 98221
34337, 7027, 7028, 7051, 7050, 27902, 27903, 27926, 27925, 7672, 7718, 7719, 7716, 28547, 28593, 28594, 
28591, 98199, 98200, 98223, 98222
34338, 7028, 7029, 7052, 7051, 27903, 27904, 27927, 27926, 7674, 7720, 7721, 7718, 28549, 28595, 28596, 
28593, 98200, 98201, 98224, 98223
34339, 7029, 7030, 7053, 7052, 27904, 27905, 27928, 27927, 7676, 7722, 7723, 7720, 28551, 28597, 28598, 
28595, 98201, 98202, 98225, 98224
34340, 7030, 7031, 7054, 7053, 27905, 27906, 27929, 27928, 7678, 7724, 7725, 7722, 28553, 28599, 28600, 
28597, 98202, 98203, 98226, 98225
34341, 7031, 7032, 7055, 7054, 27906, 27907, 27930, 27929, 7680, 7726, 7727, 7724, 28555, 28601, 28602, 
28599, 98203, 98204, 98227, 98226
34342, 7032, 639, 640, 7055, 27907, 2842, 2843, 27930, 7681, 663, 7728, 7726, 28556, 2866, 28603, 
28601, 98204, 27774, 27775, 98227
34343, 404, 7033, 7056, 405, 2796, 27908, 27931, 2797, 7683, 7729, 7730, 428, 28558, 28604, 28605, 
2820, 27752, 98205, 98228, 27753
34344, 7033, 7034, 7057, 7056, 27908, 27909, 27932, 27931, 7685, 7731, 7732, 7729, 28560, 28606, 28607, 
28604, 98205, 98206, 98229, 98228
34345, 7034, 7035, 7058, 7057, 27909, 27910, 27933, 27932, 7687, 7733, 7734, 7731, 28562, 28608, 28609, 
28606, 98206, 98207, 98230, 98229
34346, 7035, 7036, 7059, 7058, 27910, 27911, 27934, 27933, 7689, 7735, 7736, 7733, 28564, 28610, 28611, 
28608, 98207, 98208, 98231, 98230
34347, 7036, 7037, 7060, 7059, 27911, 27912, 27935, 27934, 7691, 7737, 7738, 7735, 28566, 28612, 28613, 
28610, 98208, 98209, 98232, 98231
34348, 7037, 7038, 7061, 7060, 27912, 27913, 27936, 27935, 7693, 7739, 7740, 7737, 28568, 28614, 28615, 
28612, 98209, 98210, 98233, 98232
34349, 7038, 7039, 7062, 7061, 27913, 27914, 27937, 27936, 7695, 7741, 7742, 7739, 28570, 28616, 28617, 
28614, 98210, 98211, 98234, 98233
34350, 7039, 7040, 7063, 7062, 27914, 27915, 27938, 27937, 7697, 7743, 7744, 7741, 28572, 28618, 28619, 
28616, 98211, 98212, 98235, 98234
34351, 7040, 7041, 7064, 7063, 27915, 27916, 27939, 27938, 7699, 7745, 7746, 7743, 28574, 28620, 28621, 
28618, 98212, 98213, 98236, 98235
34352, 7041, 7042, 7065, 7064, 27916, 27917, 27940, 27939, 7701, 7747, 7748, 7745, 28576, 28622, 28623, 
28620, 98213, 98214, 98237, 98236
34353, 7042, 7043, 7066, 7065, 27917, 27918, 27941, 27940, 7703, 7749, 7750, 7747, 28578, 28624, 28625, 
28622, 98214, 98215, 98238, 98237
34354, 7043, 7044, 7067, 7066, 27918, 27919, 27942, 27941, 7705, 7751, 7752, 7749, 28580, 28626, 28627, 
28624, 98215, 98216, 98239, 98238
34355, 7044, 7045, 7068, 7067, 27919, 27920, 27943, 27942, 7707, 7753, 7754, 7751, 28582, 28628, 28629, 
28626, 98216, 98217, 98240, 98239
34356, 7045, 7046, 7069, 7068, 27920, 27921, 27944, 27943, 7709, 7755, 7756, 7753, 28584, 28630, 28631, 
28628, 98217, 98218, 98241, 98240
34357, 7046, 7047, 7070, 7069, 27921, 27922, 27945, 27944, 7711, 7757, 7758, 7755, 28586, 28632, 28633, 
28630, 98218, 98219, 98242, 98241
34358, 7047, 7048, 7071, 7070, 27922, 27923, 27946, 27945, 7713, 7759, 7760, 7757, 28588, 28634, 28635, 
28632, 98219, 98220, 98243, 98242
34359, 7048, 7049, 7072, 7071, 27923, 27924, 27947, 27946, 7715, 7761, 7762, 7759, 28590, 28636, 28637, 
28634, 98220, 98221, 98244, 98243
34360, 7049, 7050, 7073, 7072, 27924, 27925, 27948, 27947, 7717, 7763, 7764, 7761, 28592, 28638, 28639, 
28636, 98221, 98222, 98245, 98244
34361, 7050, 7051, 7074, 7073, 27925, 27926, 27949, 27948, 7719, 7765, 7766, 7763, 28594, 28640, 28641, 
28638, 98222, 98223, 98246, 98245
34362, 7051, 7052, 7075, 7074, 27926, 27927, 27950, 27949, 7721, 7767, 7768, 7765, 28596, 28642, 28643, 
28640, 98223, 98224, 98247, 98246
34363, 7052, 7053, 7076, 7075, 27927, 27928, 27951, 27950, 7723, 7769, 7770, 7767, 28598, 28644, 28645, 
28642, 98224, 98225, 98248, 98247
34364, 7053, 7054, 7077, 7076, 27928, 27929, 27952, 27951, 7725, 7771, 7772, 7769, 28600, 28646, 28647, 
28644, 98225, 98226, 98249, 98248
34365, 7054, 7055, 7078, 7077, 27929, 27930, 27953, 27952, 7727, 7773, 7774, 7771, 28602, 28648, 28649, 
28646, 98226, 98227, 98250, 98249
34366, 7055, 640, 641, 7078, 27930, 2843, 2844, 27953, 7728, 664, 7775, 7773, 28603, 2867, 28650, 
28648, 98227, 27775, 27776, 98250
34367, 405, 7056, 7079, 406, 2797, 27931, 27954, 2798, 7730, 7776, 7777, 429, 28605, 28651, 28652, 
2821, 27753, 98228, 98251, 27754
34368, 7056, 7057, 7080, 7079, 27931, 27932, 27955, 27954, 7732, 7778, 7779, 7776, 28607, 28653, 28654, 
28651, 98228, 98229, 98252, 98251
34369, 7057, 7058, 7081, 7080, 27932, 27933, 27956, 27955, 7734, 7780, 7781, 7778, 28609, 28655, 28656, 
28653, 98229, 98230, 98253, 98252
34370, 7058, 7059, 7082, 7081, 27933, 27934, 27957, 27956, 7736, 7782, 7783, 7780, 28611, 28657, 28658, 
28655, 98230, 98231, 98254, 98253
34371, 7059, 7060, 7083, 7082, 27934, 27935, 27958, 27957, 7738, 7784, 7785, 7782, 28613, 28659, 28660, 
28657, 98231, 98232, 98255, 98254
34372, 7060, 7061, 7084, 7083, 27935, 27936, 27959, 27958, 7740, 7786, 7787, 7784, 28615, 28661, 28662, 
28659, 98232, 98233, 98256, 98255
34373, 7061, 7062, 7085, 7084, 27936, 27937, 27960, 27959, 7742, 7788, 7789, 7786, 28617, 28663, 28664, 
28661, 98233, 98234, 98257, 98256
34374, 7062, 7063, 7086, 7085, 27937, 27938, 27961, 27960, 7744, 7790, 7791, 7788, 28619, 28665, 28666, 
28663, 98234, 98235, 98258, 98257
34375, 7063, 7064, 7087, 7086, 27938, 27939, 27962, 27961, 7746, 7792, 7793, 7790, 28621, 28667, 28668, 
28665, 98235, 98236, 98259, 98258
34376, 7064, 7065, 7088, 7087, 27939, 27940, 27963, 27962, 7748, 7794, 7795, 7792, 28623, 28669, 28670, 
28667, 98236, 98237, 98260, 98259
34377, 7065, 7066, 7089, 7088, 27940, 27941, 27964, 27963, 7750, 7796, 7797, 7794, 28625, 28671, 28672, 
28669, 98237, 98238, 98261, 98260
34378, 7066, 7067, 7090, 7089, 27941, 27942, 27965, 27964, 7752, 7798, 7799, 7796, 28627, 28673, 28674, 
28671, 98238, 98239, 98262, 98261
34379, 7067, 7068, 7091, 7090, 27942, 27943, 27966, 27965, 7754, 7800, 7801, 7798, 28629, 28675, 28676, 
28673, 98239, 98240, 98263, 98262
34380, 7068, 7069, 7092, 7091, 27943, 27944, 27967, 27966, 7756, 7802, 7803, 7800, 28631, 28677, 28678, 
28675, 98240, 98241, 98264, 98263
34381, 7069, 7070, 7093, 7092, 27944, 27945, 27968, 27967, 7758, 7804, 7805, 7802, 28633, 28679, 28680, 
28677, 98241, 98242, 98265, 98264
34382, 7070, 7071, 7094, 7093, 27945, 27946, 27969, 27968, 7760, 7806, 7807, 7804, 28635, 28681, 28682, 
28679, 98242, 98243, 98266, 98265
34383, 7071, 7072, 7095, 7094, 27946, 27947, 27970, 27969, 7762, 7808, 7809, 7806, 28637, 28683, 28684, 
28681, 98243, 98244, 98267, 98266
34384, 7072, 7073, 7096, 7095, 27947, 27948, 27971, 27970, 7764, 7810, 7811, 7808, 28639, 28685, 28686, 
28683, 98244, 98245, 98268, 98267
34385, 7073, 7074, 7097, 7096, 27948, 27949, 27972, 27971, 7766, 7812, 7813, 7810, 28641, 28687, 28688, 
28685, 98245, 98246, 98269, 98268
34386, 7074, 7075, 7098, 7097, 27949, 27950, 27973, 27972, 7768, 7814, 7815, 7812, 28643, 28689, 28690, 
28687, 98246, 98247, 98270, 98269
34387, 7075, 7076, 7099, 7098, 27950, 27951, 27974, 27973, 7770, 7816, 7817, 7814, 28645, 28691, 28692, 
28689, 98247, 98248, 98271, 98270
34388, 7076, 7077, 7100, 7099, 27951, 27952, 27975, 27974, 7772, 7818, 7819, 7816, 28647, 28693, 28694, 
28691, 98248, 98249, 98272, 98271
34389, 7077, 7078, 7101, 7100, 27952, 27953, 27976, 27975, 7774, 7820, 7821, 7818, 28649, 28695, 28696, 
28693, 98249, 98250, 98273, 98272
34390, 7078, 641, 642, 7101, 27953, 2844, 2845, 27976, 7775, 665, 7822, 7820, 28650, 2868, 28697, 
28695, 98250, 27776, 27777, 98273
34391, 406, 7079, 7102, 407, 2798, 27954, 27977, 2799, 7777, 7823, 7824, 430, 28652, 28698, 28699, 
2822, 27754, 98251, 98274, 27755
34392, 7079, 7080, 7103, 7102, 27954, 27955, 27978, 27977, 7779, 7825, 7826, 7823, 28654, 28700, 28701, 
28698, 98251, 98252, 98275, 98274
34393, 7080, 7081, 7104, 7103, 27955, 27956, 27979, 27978, 7781, 7827, 7828, 7825, 28656, 28702, 28703, 
28700, 98252, 98253, 98276, 98275
34394, 7081, 7082, 7105, 7104, 27956, 27957, 27980, 27979, 7783, 7829, 7830, 7827, 28658, 28704, 28705, 
28702, 98253, 98254, 98277, 98276
34395, 7082, 7083, 7106, 7105, 27957, 27958, 27981, 27980, 7785, 7831, 7832, 7829, 28660, 28706, 28707, 
28704, 98254, 98255, 98278, 98277
34396, 7083, 7084, 7107, 7106, 27958, 27959, 27982, 27981, 7787, 7833, 7834, 7831, 28662, 28708, 28709, 
28706, 98255, 98256, 98279, 98278
34397, 7084, 7085, 7108, 7107, 27959, 27960, 27983, 27982, 7789, 7835, 7836, 7833, 28664, 28710, 28711, 
28708, 98256, 98257, 98280, 98279
34398, 7085, 7086, 7109, 7108, 27960, 27961, 27984, 27983, 7791, 7837, 7838, 7835, 28666, 28712, 28713, 
28710, 98257, 98258, 98281, 98280
34399, 7086, 7087, 7110, 7109, 27961, 27962, 27985, 27984, 7793, 7839, 7840, 7837, 28668, 28714, 28715, 
28712, 98258, 98259, 98282, 98281
34400, 7087, 7088, 7111, 7110, 27962, 27963, 27986, 27985, 7795, 7841, 7842, 7839, 28670, 28716, 28717, 
28714, 98259, 98260, 98283, 98282
34401, 7088, 7089, 7112, 7111, 27963, 27964, 27987, 27986, 7797, 7843, 7844, 7841, 28672, 28718, 28719, 
28716, 98260, 98261, 98284, 98283
34402, 7089, 7090, 7113, 7112, 27964, 27965, 27988, 27987, 7799, 7845, 7846, 7843, 28674, 28720, 28721, 
28718, 98261, 98262, 98285, 98284
34403, 7090, 7091, 7114, 7113, 27965, 27966, 27989, 27988, 7801, 7847, 7848, 7845, 28676, 28722, 28723, 
28720, 98262, 98263, 98286, 98285
34404, 7091, 7092, 7115, 7114, 27966, 27967, 27990, 27989, 7803, 7849, 7850, 7847, 28678, 28724, 28725, 
28722, 98263, 98264, 98287, 98286
34405, 7092, 7093, 7116, 7115, 27967, 27968, 27991, 27990, 7805, 7851, 7852, 7849, 28680, 28726, 28727, 
28724, 98264, 98265, 98288, 98287
34406, 7093, 7094, 7117, 7116, 27968, 27969, 27992, 27991, 7807, 7853, 7854, 7851, 28682, 28728, 28729, 
28726, 98265, 98266, 98289, 98288
34407, 7094, 7095, 7118, 7117, 27969, 27970, 27993, 27992, 7809, 7855, 7856, 7853, 28684, 28730, 28731, 
28728, 98266, 98267, 98290, 98289
34408, 7095, 7096, 7119, 7118, 27970, 27971, 27994, 27993, 7811, 7857, 7858, 7855, 28686, 28732, 28733, 
28730, 98267, 98268, 98291, 98290
34409, 7096, 7097, 7120, 7119, 27971, 27972, 27995, 27994, 7813, 7859, 7860, 7857, 28688, 28734, 28735, 
28732, 98268, 98269, 98292, 98291
34410, 7097, 7098, 7121, 7120, 27972, 27973, 27996, 27995, 7815, 7861, 7862, 7859, 28690, 28736, 28737, 
28734, 98269, 98270, 98293, 98292
34411, 7098, 7099, 7122, 7121, 27973, 27974, 27997, 27996, 7817, 7863, 7864, 7861, 28692, 28738, 28739, 
28736, 98270, 98271, 98294, 98293
34412, 7099, 7100, 7123, 7122, 27974, 27975, 27998, 27997, 7819, 7865, 7866, 7863, 28694, 28740, 28741, 
28738, 98271, 98272, 98295, 98294
34413, 7100, 7101, 7124, 7123, 27975, 27976, 27999, 27998, 7821, 7867, 7868, 7865, 28696, 28742, 28743, 
28740, 98272, 98273, 98296, 98295
34414, 7101, 642, 643, 7124, 27976, 2845, 2846, 27999, 7822, 666, 7869, 7867, 28697, 2869, 28744, 
28742, 98273, 27777, 27778, 98296
34415, 407, 7102, 7125, 408, 2799, 27977, 28000, 2800, 7824, 7870, 7871, 431, 28699, 28745, 28746, 
2823, 27755, 98274, 98297, 27756
34416, 7102, 7103, 7126, 7125, 27977, 27978, 28001, 28000, 7826, 7872, 7873, 7870, 28701, 28747, 28748, 
28745, 98274, 98275, 98298, 98297
34417, 7103, 7104, 7127, 7126, 27978, 27979, 28002, 28001, 7828, 7874, 7875, 7872, 28703, 28749, 28750, 
28747, 98275, 98276, 98299, 98298
34418, 7104, 7105, 7128, 7127, 27979, 27980, 28003, 28002, 7830, 7876, 7877, 7874, 28705, 28751, 28752, 
28749, 98276, 98277, 98300, 98299
34419, 7105, 7106, 7129, 7128, 27980, 27981, 28004, 28003, 7832, 7878, 7879, 7876, 28707, 28753, 28754, 
28751, 98277, 98278, 98301, 98300
34420, 7106, 7107, 7130, 7129, 27981, 27982, 28005, 28004, 7834, 7880, 7881, 7878, 28709, 28755, 28756, 
28753, 98278, 98279, 98302, 98301
34421, 7107, 7108, 7131, 7130, 27982, 27983, 28006, 28005, 7836, 7882, 7883, 7880, 28711, 28757, 28758, 
28755, 98279, 98280, 98303, 98302
34422, 7108, 7109, 7132, 7131, 27983, 27984, 28007, 28006, 7838, 7884, 7885, 7882, 28713, 28759, 28760, 
28757, 98280, 98281, 98304, 98303
34423, 7109, 7110, 7133, 7132, 27984, 27985, 28008, 28007, 7840, 7886, 7887, 7884, 28715, 28761, 28762, 
28759, 98281, 98282, 98305, 98304
34424, 7110, 7111, 7134, 7133, 27985, 27986, 28009, 28008, 7842, 7888, 7889, 7886, 28717, 28763, 28764, 
28761, 98282, 98283, 98306, 98305
34425, 7111, 7112, 7135, 7134, 27986, 27987, 28010, 28009, 7844, 7890, 7891, 7888, 28719, 28765, 28766, 
28763, 98283, 98284, 98307, 98306
34426, 7112, 7113, 7136, 7135, 27987, 27988, 28011, 28010, 7846, 7892, 7893, 7890, 28721, 28767, 28768, 
28765, 98284, 98285, 98308, 98307
34427, 7113, 7114, 7137, 7136, 27988, 27989, 28012, 28011, 7848, 7894, 7895, 7892, 28723, 28769, 28770, 
28767, 98285, 98286, 98309, 98308
34428, 7114, 7115, 7138, 7137, 27989, 27990, 28013, 28012, 7850, 7896, 7897, 7894, 28725, 28771, 28772, 
28769, 98286, 98287, 98310, 98309
34429, 7115, 7116, 7139, 7138, 27990, 27991, 28014, 28013, 7852, 7898, 7899, 7896, 28727, 28773, 28774, 
28771, 98287, 98288, 98311, 98310
34430, 7116, 7117, 7140, 7139, 27991, 27992, 28015, 28014, 7854, 7900, 7901, 7898, 28729, 28775, 28776, 
28773, 98288, 98289, 98312, 98311
34431, 7117, 7118, 7141, 7140, 27992, 27993, 28016, 28015, 7856, 7902, 7903, 7900, 28731, 28777, 28778, 
28775, 98289, 98290, 98313, 98312
34432, 7118, 7119, 7142, 7141, 27993, 27994, 28017, 28016, 7858, 7904, 7905, 7902, 28733, 28779, 28780, 
28777, 98290, 98291, 98314, 98313
34433, 7119, 7120, 7143, 7142, 27994, 27995, 28018, 28017, 7860, 7906, 7907, 7904, 28735, 28781, 28782, 
28779, 98291, 98292, 98315, 98314
34434, 7120, 7121, 7144, 7143, 27995, 27996, 28019, 28018, 7862, 7908, 7909, 7906, 28737, 28783, 28784, 
28781, 98292, 98293, 98316, 98315
34435, 7121, 7122, 7145, 7144, 27996, 27997, 28020, 28019, 7864, 7910, 7911, 7908, 28739, 28785, 28786, 
28783, 98293, 98294, 98317, 98316
34436, 7122, 7123, 7146, 7145, 27997, 27998, 28021, 28020, 7866, 7912, 7913, 7910, 28741, 28787, 28788, 
28785, 98294, 98295, 98318, 98317
34437, 7123, 7124, 7147, 7146, 27998, 27999, 28022, 28021, 7868, 7914, 7915, 7912, 28743, 28789, 28790, 
28787, 98295, 98296, 98319, 98318
34438, 7124, 643, 644, 7147, 27999, 2846, 2847, 28022, 7869, 667, 7916, 7914, 28744, 2870, 28791, 
28789, 98296, 27778, 27779, 98319
34439, 408, 7125, 7148, 409, 2800, 28000, 28023, 2801, 7871, 7917, 7918, 432, 28746, 28792, 28793, 
2824, 27756, 98297, 98320, 27757
34440, 7125, 7126, 7149, 7148, 28000, 28001, 28024, 28023, 7873, 7919, 7920, 7917, 28748, 28794, 28795, 
28792, 98297, 98298, 98321, 98320
34441, 7126, 7127, 7150, 7149, 28001, 28002, 28025, 28024, 7875, 7921, 7922, 7919, 28750, 28796, 28797, 
28794, 98298, 98299, 98322, 98321
34442, 7127, 7128, 7151, 7150, 28002, 28003, 28026, 28025, 7877, 7923, 7924, 7921, 28752, 28798, 28799, 
28796, 98299, 98300, 98323, 98322
34443, 7128, 7129, 7152, 7151, 28003, 28004, 28027, 28026, 7879, 7925, 7926, 7923, 28754, 28800, 28801, 
28798, 98300, 98301, 98324, 98323
34444, 7129, 7130, 7153, 7152, 28004, 28005, 28028, 28027, 7881, 7927, 7928, 7925, 28756, 28802, 28803, 
28800, 98301, 98302, 98325, 98324
34445, 7130, 7131, 7154, 7153, 28005, 28006, 28029, 28028, 7883, 7929, 7930, 7927, 28758, 28804, 28805, 
28802, 98302, 98303, 98326, 98325
34446, 7131, 7132, 7155, 7154, 28006, 28007, 28030, 28029, 7885, 7931, 7932, 7929, 28760, 28806, 28807, 
28804, 98303, 98304, 98327, 98326
34447, 7132, 7133, 7156, 7155, 28007, 28008, 28031, 28030, 7887, 7933, 7934, 7931, 28762, 28808, 28809, 
28806, 98304, 98305, 98328, 98327
34448, 7133, 7134, 7157, 7156, 28008, 28009, 28032, 28031, 7889, 7935, 7936, 7933, 28764, 28810, 28811, 
28808, 98305, 98306, 98329, 98328
34449, 7134, 7135, 7158, 7157, 28009, 28010, 28033, 28032, 7891, 7937, 7938, 7935, 28766, 28812, 28813, 
28810, 98306, 98307, 98330, 98329
34450, 7135, 7136, 7159, 7158, 28010, 28011, 28034, 28033, 7893, 7939, 7940, 7937, 28768, 28814, 28815, 
28812, 98307, 98308, 98331, 98330
34451, 7136, 7137, 7160, 7159, 28011, 28012, 28035, 28034, 7895, 7941, 7942, 7939, 28770, 28816, 28817, 
28814, 98308, 98309, 98332, 98331
34452, 7137, 7138, 7161, 7160, 28012, 28013, 28036, 28035, 7897, 7943, 7944, 7941, 28772, 28818, 28819, 
28816, 98309, 98310, 98333, 98332
34453, 7138, 7139, 7162, 7161, 28013, 28014, 28037, 28036, 7899, 7945, 7946, 7943, 28774, 28820, 28821, 
28818, 98310, 98311, 98334, 98333
34454, 7139, 7140, 7163, 7162, 28014, 28015, 28038, 28037, 7901, 7947, 7948, 7945, 28776, 28822, 28823, 
28820, 98311, 98312, 98335, 98334
34455, 7140, 7141, 7164, 7163, 28015, 28016, 28039, 28038, 7903, 7949, 7950, 7947, 28778, 28824, 28825, 
28822, 98312, 98313, 98336, 98335
34456, 7141, 7142, 7165, 7164, 28016, 28017, 28040, 28039, 7905, 7951, 7952, 7949, 28780, 28826, 28827, 
28824, 98313, 98314, 98337, 98336
34457, 7142, 7143, 7166, 7165, 28017, 28018, 28041, 28040, 7907, 7953, 7954, 7951, 28782, 28828, 28829, 
28826, 98314, 98315, 98338, 98337
34458, 7143, 7144, 7167, 7166, 28018, 28019, 28042, 28041, 7909, 7955, 7956, 7953, 28784, 28830, 28831, 
28828, 98315, 98316, 98339, 98338
34459, 7144, 7145, 7168, 7167, 28019, 28020, 28043, 28042, 7911, 7957, 7958, 7955, 28786, 28832, 28833, 
28830, 98316, 98317, 98340, 98339
34460, 7145, 7146, 7169, 7168, 28020, 28021, 28044, 28043, 7913, 7959, 7960, 7957, 28788, 28834, 28835, 
28832, 98317, 98318, 98341, 98340
34461, 7146, 7147, 7170, 7169, 28021, 28022, 28045, 28044, 7915, 7961, 7962, 7959, 28790, 28836, 28837, 
28834, 98318, 98319, 98342, 98341
34462, 7147, 644, 645, 7170, 28022, 2847, 2848, 28045, 7916, 668, 7963, 7961, 28791, 2871, 28838, 
28836, 98319, 27779, 27780, 98342
34463, 409, 7148, 7171, 410, 2801, 28023, 28046, 2802, 7918, 7964, 7965, 433, 28793, 28839, 28840, 
2825, 27757, 98320, 98343, 27758
34464, 7148, 7149, 7172, 7171, 28023, 28024, 28047, 28046, 7920, 7966, 7967, 7964, 28795, 28841, 28842, 
28839, 98320, 98321, 98344, 98343
34465, 7149, 7150, 7173, 7172, 28024, 28025, 28048, 28047, 7922, 7968, 7969, 7966, 28797, 28843, 28844, 
28841, 98321, 98322, 98345, 98344
34466, 7150, 7151, 7174, 7173, 28025, 28026, 28049, 28048, 7924, 7970, 7971, 7968, 28799, 28845, 28846, 
28843, 98322, 98323, 98346, 98345
34467, 7151, 7152, 7175, 7174, 28026, 28027, 28050, 28049, 7926, 7972, 7973, 7970, 28801, 28847, 28848, 
28845, 98323, 98324, 98347, 98346
34468, 7152, 7153, 7176, 7175, 28027, 28028, 28051, 28050, 7928, 7974, 7975, 7972, 28803, 28849, 28850, 
28847, 98324, 98325, 98348, 98347
34469, 7153, 7154, 7177, 7176, 28028, 28029, 28052, 28051, 7930, 7976, 7977, 7974, 28805, 28851, 28852, 
28849, 98325, 98326, 98349, 98348
34470, 7154, 7155, 7178, 7177, 28029, 28030, 28053, 28052, 7932, 7978, 7979, 7976, 28807, 28853, 28854, 
28851, 98326, 98327, 98350, 98349
34471, 7155, 7156, 7179, 7178, 28030, 28031, 28054, 28053, 7934, 7980, 7981, 7978, 28809, 28855, 28856, 
28853, 98327, 98328, 98351, 98350
34472, 7156, 7157, 7180, 7179, 28031, 28032, 28055, 28054, 7936, 7982, 7983, 7980, 28811, 28857, 28858, 
28855, 98328, 98329, 98352, 98351
34473, 7157, 7158, 7181, 7180, 28032, 28033, 28056, 28055, 7938, 7984, 7985, 7982, 28813, 28859, 28860, 
28857, 98329, 98330, 98353, 98352
34474, 7158, 7159, 7182, 7181, 28033, 28034, 28057, 28056, 7940, 7986, 7987, 7984, 28815, 28861, 28862, 
28859, 98330, 98331, 98354, 98353
34475, 7159, 7160, 7183, 7182, 28034, 28035, 28058, 28057, 7942, 7988, 7989, 7986, 28817, 28863, 28864, 
28861, 98331, 98332, 98355, 98354
34476, 7160, 7161, 7184, 7183, 28035, 28036, 28059, 28058, 7944, 7990, 7991, 7988, 28819, 28865, 28866, 
28863, 98332, 98333, 98356, 98355
34477, 7161, 7162, 7185, 7184, 28036, 28037, 28060, 28059, 7946, 7992, 7993, 7990, 28821, 28867, 28868, 
28865, 98333, 98334, 98357, 98356
34478, 7162, 7163, 7186, 7185, 28037, 28038, 28061, 28060, 7948, 7994, 7995, 7992, 28823, 28869, 28870, 
28867, 98334, 98335, 98358, 98357
34479, 7163, 7164, 7187, 7186, 28038, 28039, 28062, 28061, 7950, 7996, 7997, 7994, 28825, 28871, 28872, 
28869, 98335, 98336, 98359, 98358
34480, 7164, 7165, 7188, 7187, 28039, 28040, 28063, 28062, 7952, 7998, 7999, 7996, 28827, 28873, 28874, 
28871, 98336, 98337, 98360, 98359
34481, 7165, 7166, 7189, 7188, 28040, 28041, 28064, 28063, 7954, 8000, 8001, 7998, 28829, 28875, 28876, 
28873, 98337, 98338, 98361, 98360
34482, 7166, 7167, 7190, 7189, 28041, 28042, 28065, 28064, 7956, 8002, 8003, 8000, 28831, 28877, 28878, 
28875, 98338, 98339, 98362, 98361
34483, 7167, 7168, 7191, 7190, 28042, 28043, 28066, 28065, 7958, 8004, 8005, 8002, 28833, 28879, 28880, 
28877, 98339, 98340, 98363, 98362
34484, 7168, 7169, 7192, 7191, 28043, 28044, 28067, 28066, 7960, 8006, 8007, 8004, 28835, 28881, 28882, 
28879, 98340, 98341, 98364, 98363
34485, 7169, 7170, 7193, 7192, 28044, 28045, 28068, 28067, 7962, 8008, 8009, 8006, 28837, 28883, 28884, 
28881, 98341, 98342, 98365, 98364
34486, 7170, 645, 646, 7193, 28045, 2848, 2849, 28068, 7963, 669, 8010, 8008, 28838, 2872, 28885, 
28883, 98342, 27780, 27781, 98365
34487, 410, 7171, 7194, 411, 2802, 28046, 28069, 2803, 7965, 8011, 8012, 434, 28840, 28886, 28887, 
2826, 27758, 98343, 98366, 27759
34488, 7171, 7172, 7195, 7194, 28046, 28047, 28070, 28069, 7967, 8013, 8014, 8011, 28842, 28888, 28889, 
28886, 98343, 98344, 98367, 98366
34489, 7172, 7173, 7196, 7195, 28047, 28048, 28071, 28070, 7969, 8015, 8016, 8013, 28844, 28890, 28891, 
28888, 98344, 98345, 98368, 98367
34490, 7173, 7174, 7197, 7196, 28048, 28049, 28072, 28071, 7971, 8017, 8018, 8015, 28846, 28892, 28893, 
28890, 98345, 98346, 98369, 98368
34491, 7174, 7175, 7198, 7197, 28049, 28050, 28073, 28072, 7973, 8019, 8020, 8017, 28848, 28894, 28895, 
28892, 98346, 98347, 98370, 98369
34492, 7175, 7176, 7199, 7198, 28050, 28051, 28074, 28073, 7975, 8021, 8022, 8019, 28850, 28896, 28897, 
28894, 98347, 98348, 98371, 98370
34493, 7176, 7177, 7200, 7199, 28051, 28052, 28075, 28074, 7977, 8023, 8024, 8021, 28852, 28898, 28899, 
28896, 98348, 98349, 98372, 98371
34494, 7177, 7178, 7201, 7200, 28052, 28053, 28076, 28075, 7979, 8025, 8026, 8023, 28854, 28900, 28901, 
28898, 98349, 98350, 98373, 98372
34495, 7178, 7179, 7202, 7201, 28053, 28054, 28077, 28076, 7981, 8027, 8028, 8025, 28856, 28902, 28903, 
