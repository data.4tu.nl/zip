99260, 1.025, 1.2, 0.20833333333333
99261, 1.025, 1.25, 0.20833333333333
99262, 1.025, 1.3, 0.20833333333333
99263, 1.025, 0.2, 0.25
99264, 1.025, 0.25, 0.25
99265, 1.025, 0.3, 0.25
99266, 1.025, 0.35, 0.25
99267, 1.025, 0.4, 0.25
99268, 1.025, 0.45, 0.25
99269, 1.025, 0.5, 0.25
99270, 1.025, 0.55, 0.25
99271, 1.025, 0.6, 0.25
99272, 1.025, 0.65, 0.25
99273, 1.025, 0.7, 0.25
99274, 1.025, 0.75, 0.25
99275, 1.025, 0.8, 0.25
99276, 1.025, 0.85, 0.25
99277, 1.025, 0.9, 0.25
99278, 1.025, 0.95, 0.25
99279, 1.025, 1, 0.25
99280, 1.025, 1.05, 0.25
99281, 1.025, 1.1, 0.25
99282, 1.025, 1.15, 0.25
99283, 1.025, 1.2, 0.25
99284, 1.025, 1.25, 0.25
99285, 1.025, 1.3, 0.25
99286, 1.025, 0.2, 0.29166666666667
99287, 1.025, 0.25, 0.29166666666667
99288, 1.025, 0.3, 0.29166666666667
99289, 1.025, 0.35, 0.29166666666667
99290, 1.025, 0.4, 0.29166666666667
99291, 1.025, 0.45, 0.29166666666667
99292, 1.025, 0.5, 0.29166666666667
99293, 1.025, 0.55, 0.29166666666667
99294, 1.025, 0.6, 0.29166666666667
99295, 1.025, 0.65, 0.29166666666667
99296, 1.025, 0.7, 0.29166666666667
99297, 1.025, 0.75, 0.29166666666667
99298, 1.025, 0.8, 0.29166666666667
99299, 1.025, 0.85, 0.29166666666667
99300, 1.025, 0.9, 0.29166666666667
99301, 1.025, 0.95, 0.29166666666667
99302, 1.025, 1, 0.29166666666667
99303, 1.025, 1.05, 0.29166666666667
99304, 1.025, 1.1, 0.29166666666667
99305, 1.025, 1.15, 0.29166666666667
99306, 1.025, 1.2, 0.29166666666667
99307, 1.025, 1.25, 0.29166666666667
99308, 1.025, 1.3, 0.29166666666667
99309, 1.025, 0.2, 0.33333333333333
99310, 1.025, 0.25, 0.33333333333333
99311, 1.025, 0.3, 0.33333333333333
99312, 1.025, 0.35, 0.33333333333333
99313, 1.025, 0.4, 0.33333333333333
99314, 1.025, 0.45, 0.33333333333333
99315, 1.025, 0.5, 0.33333333333333
99316, 1.025, 0.55, 0.33333333333333
99317, 1.025, 0.6, 0.33333333333333
99318, 1.025, 0.65, 0.33333333333333
99319, 1.025, 0.7, 0.33333333333333
99320, 1.025, 0.75, 0.33333333333333
99321, 1.025, 0.8, 0.33333333333333
99322, 1.025, 0.85, 0.33333333333333
99323, 1.025, 0.9, 0.33333333333333
99324, 1.025, 0.95, 0.33333333333333
99325, 1.025, 1, 0.33333333333333
99326, 1.025, 1.05, 0.33333333333333
99327, 1.025, 1.1, 0.33333333333333
99328, 1.025, 1.15, 0.33333333333333
99329, 1.025, 1.2, 0.33333333333333
99330, 1.025, 1.25, 0.33333333333333
99331, 1.025, 1.3, 0.33333333333333
99332, 1.025, 0.2, 0.375
99333, 1.025, 0.25, 0.375
99334, 1.025, 0.3, 0.375
99335, 1.025, 0.35, 0.375
99336, 1.025, 0.4, 0.375
99337, 1.025, 0.45, 0.375
99338, 1.025, 0.5, 0.375
99339, 1.025, 0.55, 0.375
99340, 1.025, 0.6, 0.375
99341, 1.025, 0.65, 0.375
99342, 1.025, 0.7, 0.375
99343, 1.025, 0.75, 0.375
99344, 1.025, 0.8, 0.375
99345, 1.025, 0.85, 0.375
99346, 1.025, 0.9, 0.375
99347, 1.025, 0.95, 0.375
99348, 1.025, 1, 0.375
99349, 1.025, 1.05, 0.375
99350, 1.025, 1.1, 0.375
99351, 1.025, 1.15, 0.375
99352, 1.025, 1.2, 0.375
99353, 1.025, 1.25, 0.375
99354, 1.025, 1.3, 0.375
99355, 1.025, 0.2, 0.41666666666667
99356, 1.025, 0.25, 0.41666666666667
99357, 1.025, 0.3, 0.41666666666667
99358, 1.025, 0.35, 0.41666666666667
99359, 1.025, 0.4, 0.41666666666667
99360, 1.025, 0.45, 0.41666666666667
99361, 1.025, 0.5, 0.41666666666667
99362, 1.025, 0.55, 0.41666666666667
99363, 1.025, 0.6, 0.41666666666667
99364, 1.025, 0.65, 0.41666666666667
99365, 1.025, 0.7, 0.41666666666667
99366, 1.025, 0.75, 0.41666666666667
99367, 1.025, 0.8, 0.41666666666667
99368, 1.025, 0.85, 0.41666666666667
99369, 1.025, 0.9, 0.41666666666667
99370, 1.025, 0.95, 0.41666666666667
99371, 1.025, 1, 0.41666666666667
99372, 1.025, 1.05, 0.41666666666667
99373, 1.025, 1.1, 0.41666666666667
99374, 1.025, 1.15, 0.41666666666667
99375, 1.025, 1.2, 0.41666666666667
99376, 1.025, 1.25, 0.41666666666667
99377, 1.025, 1.3, 0.41666666666667
99378, 1.025, 0.2, 0.45833333333333
99379, 1.025, 0.25, 0.45833333333333
99380, 1.025, 0.3, 0.45833333333333
99381, 1.025, 0.35, 0.45833333333333
99382, 1.025, 0.4, 0.45833333333333
99383, 1.025, 0.45, 0.45833333333333
99384, 1.025, 0.5, 0.45833333333333
99385, 1.025, 0.55, 0.45833333333333
99386, 1.025, 0.6, 0.45833333333333
99387, 1.025, 0.65, 0.45833333333333
99388, 1.025, 0.7, 0.45833333333333
99389, 1.025, 0.75, 0.45833333333333
99390, 1.025, 0.8, 0.45833333333333
99391, 1.025, 0.85, 0.45833333333333
99392, 1.025, 0.9, 0.45833333333333
99393, 1.025, 0.95, 0.45833333333333
99394, 1.025, 1, 0.45833333333333
99395, 1.025, 1.05, 0.45833333333333
99396, 1.025, 1.1, 0.45833333333333
99397, 1.025, 1.15, 0.45833333333333
99398, 1.025, 1.2, 0.45833333333333
99399, 1.025, 1.25, 0.45833333333333
99400, 1.025, 1.3, 0.45833333333333
99401, 1.175, 1.3, 0.041666666666667
99402, 1.175, 1.25, 0.041666666666667
99403, 1.175, 1.2, 0.041666666666667
99404, 1.175, 1.15, 0.041666666666667
99405, 1.175, 1.1, 0.041666666666667
99406, 1.175, 1.05, 0.041666666666667
99407, 1.175, 1, 0.041666666666667
99408, 1.175, 0.95, 0.041666666666667
99409, 1.175, 0.9, 0.041666666666667
99410, 1.175, 0.85, 0.041666666666667
99411, 1.175, 0.8, 0.041666666666667
99412, 1.175, 0.75, 0.041666666666667
99413, 1.175, 0.7, 0.041666666666667
99414, 1.175, 0.65, 0.041666666666667
99415, 1.175, 0.6, 0.041666666666667
99416, 1.175, 0.55, 0.041666666666667
99417, 1.175, 0.5, 0.041666666666667
99418, 1.175, 0.45, 0.041666666666667
99419, 1.175, 0.4, 0.041666666666667
99420, 1.175, 0.35, 0.041666666666667
99421, 1.175, 0.3, 0.041666666666667
99422, 1.175, 0.25, 0.041666666666667
99423, 1.175, 0.2, 0.041666666666667
99424, 1.175, 1.3, 0.083333333333333
99425, 1.175, 1.25, 0.083333333333333
99426, 1.175, 1.2, 0.083333333333333
99427, 1.175, 1.15, 0.083333333333333
99428, 1.175, 1.1, 0.083333333333333
99429, 1.175, 1.05, 0.083333333333333
99430, 1.175, 1, 0.083333333333333
99431, 1.175, 0.95, 0.083333333333333
99432, 1.175, 0.9, 0.083333333333333
99433, 1.175, 0.85, 0.083333333333333
99434, 1.175, 0.8, 0.083333333333333
99435, 1.175, 0.75, 0.083333333333333
99436, 1.175, 0.7, 0.083333333333333
99437, 1.175, 0.65, 0.083333333333333
99438, 1.175, 0.6, 0.083333333333333
99439, 1.175, 0.55, 0.083333333333333
99440, 1.175, 0.5, 0.083333333333333
99441, 1.175, 0.45, 0.083333333333333
99442, 1.175, 0.4, 0.083333333333333
99443, 1.175, 0.35, 0.083333333333333
99444, 1.175, 0.3, 0.083333333333333
99445, 1.175, 0.25, 0.083333333333333
99446, 1.175, 0.2, 0.083333333333333
99447, 1.175, 1.3, 0.125
99448, 1.175, 1.25, 0.125
99449, 1.175, 1.2, 0.125
99450, 1.175, 1.15, 0.125
99451, 1.175, 1.1, 0.125
99452, 1.175, 1.05, 0.125
99453, 1.175, 1, 0.125
99454, 1.175, 0.95, 0.125
99455, 1.175, 0.9, 0.125
99456, 1.175, 0.85, 0.125
99457, 1.175, 0.8, 0.125
99458, 1.175, 0.75, 0.125
99459, 1.175, 0.7, 0.125
99460, 1.175, 0.65, 0.125
99461, 1.175, 0.6, 0.125
99462, 1.175, 0.55, 0.125
99463, 1.175, 0.5, 0.125
99464, 1.175, 0.45, 0.125
99465, 1.175, 0.4, 0.125
99466, 1.175, 0.35, 0.125
99467, 1.175, 0.3, 0.125
99468, 1.175, 0.25, 0.125
99469, 1.175, 0.2, 0.125
99470, 1.175, 1.3, 0.16666666666667
99471, 1.175, 1.25, 0.16666666666667
99472, 1.175, 1.2, 0.16666666666667
99473, 1.175, 1.15, 0.16666666666667
99474, 1.175, 1.1, 0.16666666666667
99475, 1.175, 1.05, 0.16666666666667
99476, 1.175, 1, 0.16666666666667
99477, 1.175, 0.95, 0.16666666666667
99478, 1.175, 0.9, 0.16666666666667
99479, 1.175, 0.85, 0.16666666666667
99480, 1.175, 0.8, 0.16666666666667
99481, 1.175, 0.75, 0.16666666666667
99482, 1.175, 0.7, 0.16666666666667
99483, 1.175, 0.65, 0.16666666666667
99484, 1.175, 0.6, 0.16666666666667
99485, 1.175, 0.55, 0.16666666666667
99486, 1.175, 0.5, 0.16666666666667
99487, 1.175, 0.45, 0.16666666666667
99488, 1.175, 0.4, 0.16666666666667
99489, 1.175, 0.35, 0.16666666666667
99490, 1.175, 0.3, 0.16666666666667
99491, 1.175, 0.25, 0.16666666666667
99492, 1.175, 0.2, 0.16666666666667
99493, 1.175, 1.3, 0.20833333333333
99494, 1.175, 1.25, 0.20833333333333
99495, 1.175, 1.2, 0.20833333333333
99496, 1.175, 1.15, 0.20833333333333
99497, 1.175, 1.1, 0.20833333333333
99498, 1.175, 1.05, 0.20833333333333
99499, 1.175, 1, 0.20833333333333
99500, 1.175, 0.95, 0.20833333333333
99501, 1.175, 0.9, 0.20833333333333
99502, 1.175, 0.85, 0.20833333333333
99503, 1.175, 0.8, 0.20833333333333
99504, 1.175, 0.75, 0.20833333333333
99505, 1.175, 0.7, 0.20833333333333
99506, 1.175, 0.65, 0.20833333333333
99507, 1.175, 0.6, 0.20833333333333
99508, 1.175, 0.55, 0.20833333333333
99509, 1.175, 0.5, 0.20833333333333
99510, 1.175, 0.45, 0.20833333333333
99511, 1.175, 0.4, 0.20833333333333
99512, 1.175, 0.35, 0.20833333333333
99513, 1.175, 0.3, 0.20833333333333
99514, 1.175, 0.25, 0.20833333333333
99515, 1.175, 0.2, 0.20833333333333
99516, 1.175, 1.3, 0.25
99517, 1.175, 1.25, 0.25
99518, 1.175, 1.2, 0.25
99519, 1.175, 1.15, 0.25
99520, 1.175, 1.1, 0.25
99521, 1.175, 1.05, 0.25
99522, 1.175, 1, 0.25
99523, 1.175, 0.95, 0.25
99524, 1.175, 0.9, 0.25
99525, 1.175, 0.85, 0.25
99526, 1.175, 0.8, 0.25
99527, 1.175, 0.75, 0.25
99528, 1.175, 0.7, 0.25
99529, 1.175, 0.65, 0.25
99530, 1.175, 0.6, 0.25
99531, 1.175, 0.55, 0.25
99532, 1.175, 0.5, 0.25
99533, 1.175, 0.45, 0.25
99534, 1.175, 0.4, 0.25
99535, 1.175, 0.35, 0.25
99536, 1.175, 0.3, 0.25
99537, 1.175, 0.25, 0.25
99538, 1.175, 0.2, 0.25
99539, 1.175, 1.3, 0.29166666666667
99540, 1.175, 1.25, 0.29166666666667
99541, 1.175, 1.2, 0.29166666666667
99542, 1.175, 1.15, 0.29166666666667
99543, 1.175, 1.1, 0.29166666666667
99544, 1.175, 1.05, 0.29166666666667
99545, 1.175, 1, 0.29166666666667
99546, 1.175, 0.95, 0.29166666666667
99547, 1.175, 0.9, 0.29166666666667
99548, 1.175, 0.85, 0.29166666666667
99549, 1.175, 0.8, 0.29166666666667
99550, 1.175, 0.75, 0.29166666666667
99551, 1.175, 0.7, 0.29166666666667
99552, 1.175, 0.65, 0.29166666666667
99553, 1.175, 0.6, 0.29166666666667
99554, 1.175, 0.55, 0.29166666666667
99555, 1.175, 0.5, 0.29166666666667
99556, 1.175, 0.45, 0.29166666666667
99557, 1.175, 0.4, 0.29166666666667
99558, 1.175, 0.35, 0.29166666666667
99559, 1.175, 0.3, 0.29166666666667
99560, 1.175, 0.25, 0.29166666666667
99561, 1.175, 0.2, 0.29166666666667
99562, 1.175, 1.3, 0.33333333333333
99563, 1.175, 1.25, 0.33333333333333
99564, 1.175, 1.2, 0.33333333333333
99565, 1.175, 1.15, 0.33333333333333
99566, 1.175, 1.1, 0.33333333333333
99567, 1.175, 1.05, 0.33333333333333
99568, 1.175, 1, 0.33333333333333
99569, 1.175, 0.95, 0.33333333333333
99570, 1.175, 0.9, 0.33333333333333
99571, 1.175, 0.85, 0.33333333333333
99572, 1.175, 0.8, 0.33333333333333
99573, 1.175, 0.75, 0.33333333333333
99574, 1.175, 0.7, 0.33333333333333
99575, 1.175, 0.65, 0.33333333333333
99576, 1.175, 0.6, 0.33333333333333
99577, 1.175, 0.55, 0.33333333333333
99578, 1.175, 0.5, 0.33333333333333
99579, 1.175, 0.45, 0.33333333333333
99580, 1.175, 0.4, 0.33333333333333
99581, 1.175, 0.35, 0.33333333333333
99582, 1.175, 0.3, 0.33333333333333
99583, 1.175, 0.25, 0.33333333333333
99584, 1.175, 0.2, 0.33333333333333
99585, 1.175, 1.3, 0.375
99586, 1.175, 1.25, 0.375
99587, 1.175, 1.2, 0.375
99588, 1.175, 1.15, 0.375
99589, 1.175, 1.1, 0.375
99590, 1.175, 1.05, 0.375
99591, 1.175, 1, 0.375
99592, 1.175, 0.95, 0.375
99593, 1.175, 0.9, 0.375
99594, 1.175, 0.85, 0.375
99595, 1.175, 0.8, 0.375
99596, 1.175, 0.75, 0.375
99597, 1.175, 0.7, 0.375
99598, 1.175, 0.65, 0.375
99599, 1.175, 0.6, 0.375
99600, 1.175, 0.55, 0.375
99601, 1.175, 0.5, 0.375
99602, 1.175, 0.45, 0.375
99603, 1.175, 0.4, 0.375
99604, 1.175, 0.35, 0.375
99605, 1.175, 0.3, 0.375
99606, 1.175, 0.25, 0.375
99607, 1.175, 0.2, 0.375
99608, 1.175, 1.3, 0.41666666666667
99609, 1.175, 1.25, 0.41666666666667
99610, 1.175, 1.2, 0.41666666666667
99611, 1.175, 1.15, 0.41666666666667
99612, 1.175, 1.1, 0.41666666666667
99613, 1.175, 1.05, 0.41666666666667
99614, 1.175, 1, 0.41666666666667
99615, 1.175, 0.95, 0.41666666666667
99616, 1.175, 0.9, 0.41666666666667
99617, 1.175, 0.85, 0.41666666666667
99618, 1.175, 0.8, 0.41666666666667
99619, 1.175, 0.75, 0.41666666666667
99620, 1.175, 0.7, 0.41666666666667
99621, 1.175, 0.65, 0.41666666666667
99622, 1.175, 0.6, 0.41666666666667
99623, 1.175, 0.55, 0.41666666666667
99624, 1.175, 0.5, 0.41666666666667
99625, 1.175, 0.45, 0.41666666666667
99626, 1.175, 0.4, 0.41666666666667
99627, 1.175, 0.35, 0.41666666666667
99628, 1.175, 0.3, 0.41666666666667
99629, 1.175, 0.25, 0.41666666666667
99630, 1.175, 0.2, 0.41666666666667
99631, 1.175, 1.3, 0.45833333333333
99632, 1.175, 1.25, 0.45833333333333
99633, 1.175, 1.2, 0.45833333333333
99634, 1.175, 1.15, 0.45833333333333
99635, 1.175, 1.1, 0.45833333333333
99636, 1.175, 1.05, 0.45833333333333
99637, 1.175, 1, 0.45833333333333
99638, 1.175, 0.95, 0.45833333333333
99639, 1.175, 0.9, 0.45833333333333
99640, 1.175, 0.85, 0.45833333333333
99641, 1.175, 0.8, 0.45833333333333
99642, 1.175, 0.75, 0.45833333333333
99643, 1.175, 0.7, 0.45833333333333
99644, 1.175, 0.65, 0.45833333333333
99645, 1.175, 0.6, 0.45833333333333
99646, 1.175, 0.55, 0.45833333333333
99647, 1.175, 0.5, 0.45833333333333
99648, 1.175, 0.45, 0.45833333333333
99649, 1.175, 0.4, 0.45833333333333
99650, 1.175, 0.35, 0.45833333333333
99651, 1.175, 0.3, 0.45833333333333
99652, 1.175, 0.25, 0.45833333333333
99653, 1.175, 0.2, 0.45833333333333
99654, 0.041666666666667, 1.54, 0.041666666666667
99655, 0.041666666666667, 1.58, 0.041666666666667
99656, 0.041666666666667, 1.62, 0.041666666666667
99657, 0.041666666666667, 1.66, 0.041666666666667
99658, 0.041666666666667, 1.54, 0.083333333333333
99659, 0.041666666666667, 1.58, 0.083333333333333
99660, 0.041666666666667, 1.62, 0.083333333333333
99661, 0.041666666666667, 1.66, 0.083333333333333
99662, 0.041666666666667, 1.54, 0.125
99663, 0.041666666666667, 1.58, 0.125
99664, 0.041666666666667, 1.62, 0.125
99665, 0.041666666666667, 1.66, 0.125
99666, 0.041666666666667, 1.54, 0.16666666666667
99667, 0.041666666666667, 1.58, 0.16666666666667
99668, 0.041666666666667, 1.62, 0.16666666666667
99669, 0.041666666666667, 1.66, 0.16666666666667
99670, 0.041666666666667, 1.54, 0.20833333333333
99671, 0.041666666666667, 1.58, 0.20833333333333
99672, 0.041666666666667, 1.62, 0.20833333333333
99673, 0.041666666666667, 1.66, 0.20833333333333
99674, 0.041666666666667, 1.54, 0.25
99675, 0.041666666666667, 1.58, 0.25
99676, 0.041666666666667, 1.62, 0.25
99677, 0.041666666666667, 1.66, 0.25
99678, 0.041666666666667, 1.54, 0.29166666666667
99679, 0.041666666666667, 1.58, 0.29166666666667
99680, 0.041666666666667, 1.62, 0.29166666666667
99681, 0.041666666666667, 1.66, 0.29166666666667
99682, 0.041666666666667, 1.54, 0.33333333333333
99683, 0.041666666666667, 1.58, 0.33333333333333
99684, 0.041666666666667, 1.62, 0.33333333333333
99685, 0.041666666666667, 1.66, 0.33333333333333
99686, 0.041666666666667, 1.54, 0.375
99687, 0.041666666666667, 1.58, 0.375
99688, 0.041666666666667, 1.62, 0.375
99689, 0.041666666666667, 1.66, 0.375
99690, 0.041666666666667, 1.54, 0.41666666666667
99691, 0.041666666666667, 1.58, 0.41666666666667
99692, 0.041666666666667, 1.62, 0.41666666666667
99693, 0.041666666666667, 1.66, 0.41666666666667
99694, 0.041666666666667, 1.54, 0.45833333333333
99695, 0.041666666666667, 1.58, 0.45833333333333
99696, 0.041666666666667, 1.62, 0.45833333333333
99697, 0.041666666666667, 1.66, 0.45833333333333
99698, 0.083333333333333, 1.54, 0.041666666666667
99699, 0.083333333333333, 1.58, 0.041666666666667
99700, 0.083333333333333, 1.62, 0.041666666666667
99701, 0.083333333333333, 1.66, 0.041666666666667
99702, 0.083333333333333, 1.54, 0.083333333333333
99703, 0.083333333333333, 1.58, 0.083333333333333
99704, 0.083333333333333, 1.62, 0.083333333333333
99705, 0.083333333333333, 1.66, 0.083333333333333
99706, 0.083333333333333, 1.54, 0.125
99707, 0.083333333333333, 1.58, 0.125
99708, 0.083333333333333, 1.62, 0.125
99709, 0.083333333333333, 1.66, 0.125
99710, 0.083333333333333, 1.54, 0.16666666666667
99711, 0.083333333333333, 1.58, 0.16666666666667
99712, 0.083333333333333, 1.62, 0.16666666666667
99713, 0.083333333333333, 1.66, 0.16666666666667
99714, 0.083333333333333, 1.54, 0.20833333333333
99715, 0.083333333333333, 1.58, 0.20833333333333
99716, 0.083333333333333, 1.62, 0.20833333333333
99717, 0.083333333333333, 1.66, 0.20833333333333
99718, 0.083333333333333, 1.54, 0.25
99719, 0.083333333333333, 1.58, 0.25
99720, 0.083333333333333, 1.62, 0.25
99721, 0.083333333333333, 1.66, 0.25
99722, 0.083333333333333, 1.54, 0.29166666666667
99723, 0.083333333333333, 1.58, 0.29166666666667
99724, 0.083333333333333, 1.62, 0.29166666666667
99725, 0.083333333333333, 1.66, 0.29166666666667
99726, 0.083333333333333, 1.54, 0.33333333333333
99727, 0.083333333333333, 1.58, 0.33333333333333
99728, 0.083333333333333, 1.62, 0.33333333333333
99729, 0.083333333333333, 1.66, 0.33333333333333
99730, 0.083333333333333, 1.54, 0.375
99731, 0.083333333333333, 1.58, 0.375
99732, 0.083333333333333, 1.62, 0.375
99733, 0.083333333333333, 1.66, 0.375
99734, 0.083333333333333, 1.54, 0.41666666666667
99735, 0.083333333333333, 1.58, 0.41666666666667
99736, 0.083333333333333, 1.62, 0.41666666666667
99737, 0.083333333333333, 1.66, 0.41666666666667
99738, 0.083333333333333, 1.54, 0.45833333333333
99739, 0.083333333333333, 1.58, 0.45833333333333
99740, 0.083333333333333, 1.62, 0.45833333333333
99741, 0.083333333333333, 1.66, 0.45833333333333
99742, 0.125, 1.54, 0.041666666666667
99743, 0.125, 1.58, 0.041666666666667
99744, 0.125, 1.62, 0.041666666666667
99745, 0.125, 1.66, 0.041666666666667
99746, 0.125, 1.54, 0.083333333333333
99747, 0.125, 1.58, 0.083333333333333
99748, 0.125, 1.62, 0.083333333333333
99749, 0.125, 1.66, 0.083333333333333
99750, 0.125, 1.54, 0.125
99751, 0.125, 1.58, 0.125
99752, 0.125, 1.62, 0.125
99753, 0.125, 1.66, 0.125
99754, 0.125, 1.54, 0.16666666666667
99755, 0.125, 1.58, 0.16666666666667
99756, 0.125, 1.62, 0.16666666666667
99757, 0.125, 1.66, 0.16666666666667
99758, 0.125, 1.54, 0.20833333333333
99759, 0.125, 1.58, 0.20833333333333
99760, 0.125, 1.62, 0.20833333333333
99761, 0.125, 1.66, 0.20833333333333
99762, 0.125, 1.54, 0.25
99763, 0.125, 1.58, 0.25
99764, 0.125, 1.62, 0.25
99765, 0.125, 1.66, 0.25
99766, 0.125, 1.54, 0.29166666666667
99767, 0.125, 1.58, 0.29166666666667
99768, 0.125, 1.62, 0.29166666666667
99769, 0.125, 1.66, 0.29166666666667
99770, 0.125, 1.54, 0.33333333333333
99771, 0.125, 1.58, 0.33333333333333
99772, 0.125, 1.62, 0.33333333333333
99773, 0.125, 1.66, 0.33333333333333
99774, 0.125, 1.54, 0.375
99775, 0.125, 1.58, 0.375
99776, 0.125, 1.62, 0.375
99777, 0.125, 1.66, 0.375
99778, 0.125, 1.54, 0.41666666666667
99779, 0.125, 1.58, 0.41666666666667
99780, 0.125, 1.62, 0.41666666666667
99781, 0.125, 1.66, 0.41666666666667
99782, 0.125, 1.54, 0.45833333333333
99783, 0.125, 1.58, 0.45833333333333
99784, 0.125, 1.62, 0.45833333333333
99785, 0.125, 1.66, 0.45833333333333
99786, 0.16666666666667, 1.54, 0.041666666666667
99787, 0.16666666666667, 1.58, 0.041666666666667
99788, 0.16666666666667, 1.62, 0.041666666666667
99789, 0.16666666666667, 1.66, 0.041666666666667
99790, 0.16666666666667, 1.54, 0.083333333333333
99791, 0.16666666666667, 1.58, 0.083333333333333
99792, 0.16666666666667, 1.62, 0.083333333333333
99793, 0.16666666666667, 1.66, 0.083333333333333
99794, 0.16666666666667, 1.54, 0.125
99795, 0.16666666666667, 1.58, 0.125
99796, 0.16666666666667, 1.62, 0.125
99797, 0.16666666666667, 1.66, 0.125
99798, 0.16666666666667, 1.54, 0.16666666666667
99799, 0.16666666666667, 1.58, 0.16666666666667
99800, 0.16666666666667, 1.62, 0.16666666666667
99801, 0.16666666666667, 1.66, 0.16666666666667
99802, 0.16666666666667, 1.54, 0.20833333333333
99803, 0.16666666666667, 1.58, 0.20833333333333
99804, 0.16666666666667, 1.62, 0.20833333333333
99805, 0.16666666666667, 1.66, 0.20833333333333
99806, 0.16666666666667, 1.54, 0.25
99807, 0.16666666666667, 1.58, 0.25
99808, 0.16666666666667, 1.62, 0.25
99809, 0.16666666666667, 1.66, 0.25
99810, 0.16666666666667, 1.54, 0.29166666666667
99811, 0.16666666666667, 1.58, 0.29166666666667
99812, 0.16666666666667, 1.62, 0.29166666666667
99813, 0.16666666666667, 1.66, 0.29166666666667
99814, 0.16666666666667, 1.54, 0.33333333333333
99815, 0.16666666666667, 1.58, 0.33333333333333
99816, 0.16666666666667, 1.62, 0.33333333333333
99817, 0.16666666666667, 1.66, 0.33333333333333
99818, 0.16666666666667, 1.54, 0.375
99819, 0.16666666666667, 1.58, 0.375
99820, 0.16666666666667, 1.62, 0.375
99821, 0.16666666666667, 1.66, 0.375
99822, 0.16666666666667, 1.54, 0.41666666666667
99823, 0.16666666666667, 1.58, 0.41666666666667
99824, 0.16666666666667, 1.62, 0.41666666666667
99825, 0.16666666666667, 1.66, 0.41666666666667
99826, 0.16666666666667, 1.54, 0.45833333333333
99827, 0.16666666666667, 1.58, 0.45833333333333
99828, 0.16666666666667, 1.62, 0.45833333333333
99829, 0.16666666666667, 1.66, 0.45833333333333
99830, 0.20833333333333, 1.54, 0.041666666666667
99831, 0.20833333333333, 1.58, 0.041666666666667
99832, 0.20833333333333, 1.62, 0.041666666666667
99833, 0.20833333333333, 1.66, 0.041666666666667
99834, 0.20833333333333, 1.54, 0.083333333333333
99835, 0.20833333333333, 1.58, 0.083333333333333
99836, 0.20833333333333, 1.62, 0.083333333333333
99837, 0.20833333333333, 1.66, 0.083333333333333
99838, 0.20833333333333, 1.54, 0.125
99839, 0.20833333333333, 1.58, 0.125
99840, 0.20833333333333, 1.62, 0.125
99841, 0.20833333333333, 1.66, 0.125
99842, 0.20833333333333, 1.54, 0.16666666666667
99843, 0.20833333333333, 1.58, 0.16666666666667
99844, 0.20833333333333, 1.62, 0.16666666666667
99845, 0.20833333333333, 1.66, 0.16666666666667
99846, 0.20833333333333, 1.54, 0.20833333333333
99847, 0.20833333333333, 1.58, 0.20833333333333
99848, 0.20833333333333, 1.62, 0.20833333333333
99849, 0.20833333333333, 1.66, 0.20833333333333
99850, 0.20833333333333, 1.54, 0.25
99851, 0.20833333333333, 1.58, 0.25
99852, 0.20833333333333, 1.62, 0.25
99853, 0.20833333333333, 1.66, 0.25
99854, 0.20833333333333, 1.54, 0.29166666666667
99855, 0.20833333333333, 1.58, 0.29166666666667
99856, 0.20833333333333, 1.62, 0.29166666666667
99857, 0.20833333333333, 1.66, 0.29166666666667
99858, 0.20833333333333, 1.54, 0.33333333333333
99859, 0.20833333333333, 1.58, 0.33333333333333
99860, 0.20833333333333, 1.62, 0.33333333333333
99861, 0.20833333333333, 1.66, 0.33333333333333
99862, 0.20833333333333, 1.54, 0.375
99863, 0.20833333333333, 1.58, 0.375
99864, 0.20833333333333, 1.62, 0.375
99865, 0.20833333333333, 1.66, 0.375
99866, 0.20833333333333, 1.54, 0.41666666666667
99867, 0.20833333333333, 1.58, 0.41666666666667
99868, 0.20833333333333, 1.62, 0.41666666666667
99869, 0.20833333333333, 1.66, 0.41666666666667
99870, 0.20833333333333, 1.54, 0.45833333333333
99871, 0.20833333333333, 1.58, 0.45833333333333
99872, 0.20833333333333, 1.62, 0.45833333333333
99873, 0.20833333333333, 1.66, 0.45833333333333
99874, 0.25, 1.54, 0.041666666666667
99875, 0.25, 1.58, 0.041666666666667
99876, 0.25, 1.62, 0.041666666666667
99877, 0.25, 1.66, 0.041666666666667
99878, 0.25, 1.54, 0.083333333333333
99879, 0.25, 1.58, 0.083333333333333
99880, 0.25, 1.62, 0.083333333333333
99881, 0.25, 1.66, 0.083333333333333
99882, 0.25, 1.54, 0.125
99883, 0.25, 1.58, 0.125
99884, 0.25, 1.62, 0.125
99885, 0.25, 1.66, 0.125
99886, 0.25, 1.54, 0.16666666666667
99887, 0.25, 1.58, 0.16666666666667
99888, 0.25, 1.62, 0.16666666666667
99889, 0.25, 1.66, 0.16666666666667
99890, 0.25, 1.54, 0.20833333333333
99891, 0.25, 1.58, 0.20833333333333
99892, 0.25, 1.62, 0.20833333333333
99893, 0.25, 1.66, 0.20833333333333
99894, 0.25, 1.54, 0.25
99895, 0.25, 1.58, 0.25
99896, 0.25, 1.62, 0.25
99897, 0.25, 1.66, 0.25
99898, 0.25, 1.54, 0.29166666666667
99899, 0.25, 1.58, 0.29166666666667
99900, 0.25, 1.62, 0.29166666666667
99901, 0.25, 1.66, 0.29166666666667
99902, 0.25, 1.54, 0.33333333333333
99903, 0.25, 1.58, 0.33333333333333
99904, 0.25, 1.62, 0.33333333333333
99905, 0.25, 1.66, 0.33333333333333
99906, 0.25, 1.54, 0.375
99907, 0.25, 1.58, 0.375
99908, 0.25, 1.62, 0.375
99909, 0.25, 1.66, 0.375
99910, 0.25, 1.54, 0.41666666666667
99911, 0.25, 1.58, 0.41666666666667
99912, 0.25, 1.62, 0.41666666666667
99913, 0.25, 1.66, 0.41666666666667
99914, 0.25, 1.54, 0.45833333333333
99915, 0.25, 1.58, 0.45833333333333
99916, 0.25, 1.62, 0.45833333333333
99917, 0.25, 1.66, 0.45833333333333
99918, 0.29166666666667, 1.54, 0.041666666666667
99919, 0.29166666666667, 1.58, 0.041666666666667
99920, 0.29166666666667, 1.62, 0.041666666666667
99921, 0.29166666666667, 1.66, 0.041666666666667
99922, 0.29166666666667, 1.54, 0.083333333333333
99923, 0.29166666666667, 1.58, 0.083333333333333
99924, 0.29166666666667, 1.62, 0.083333333333333
99925, 0.29166666666667, 1.66, 0.083333333333333
99926, 0.29166666666667, 1.54, 0.125
99927, 0.29166666666667, 1.58, 0.125
99928, 0.29166666666667, 1.62, 0.125
99929, 0.29166666666667, 1.66, 0.125
99930, 0.29166666666667, 1.54, 0.16666666666667
99931, 0.29166666666667, 1.58, 0.16666666666667
99932, 0.29166666666667, 1.62, 0.16666666666667
99933, 0.29166666666667, 1.66, 0.16666666666667
99934, 0.29166666666667, 1.54, 0.20833333333333
99935, 0.29166666666667, 1.58, 0.20833333333333
99936, 0.29166666666667, 1.62, 0.20833333333333
99937, 0.29166666666667, 1.66, 0.20833333333333
99938, 0.29166666666667, 1.54, 0.25
99939, 0.29166666666667, 1.58, 0.25
99940, 0.29166666666667, 1.62, 0.25
99941, 0.29166666666667, 1.66, 0.25
99942, 0.29166666666667, 1.54, 0.29166666666667
99943, 0.29166666666667, 1.58, 0.29166666666667
99944, 0.29166666666667, 1.62, 0.29166666666667
99945, 0.29166666666667, 1.66, 0.29166666666667
99946, 0.29166666666667, 1.54, 0.33333333333333
99947, 0.29166666666667, 1.58, 0.33333333333333
99948, 0.29166666666667, 1.62, 0.33333333333333
99949, 0.29166666666667, 1.66, 0.33333333333333
99950, 0.29166666666667, 1.54, 0.375
99951, 0.29166666666667, 1.58, 0.375
99952, 0.29166666666667, 1.62, 0.375
99953, 0.29166666666667, 1.66, 0.375
99954, 0.29166666666667, 1.54, 0.41666666666667
99955, 0.29166666666667, 1.58, 0.41666666666667
99956, 0.29166666666667, 1.62, 0.41666666666667
99957, 0.29166666666667, 1.66, 0.41666666666667
99958, 0.29166666666667, 1.54, 0.45833333333333
99959, 0.29166666666667, 1.58, 0.45833333333333
99960, 0.29166666666667, 1.62, 0.45833333333333
99961, 0.29166666666667, 1.66, 0.45833333333333
99962, 0.33333333333333, 1.54, 0.041666666666667
99963, 0.33333333333333, 1.58, 0.041666666666667
99964, 0.33333333333333, 1.62, 0.041666666666667
99965, 0.33333333333333, 1.66, 0.041666666666667
99966, 0.33333333333333, 1.54, 0.083333333333333
99967, 0.33333333333333, 1.58, 0.083333333333333
99968, 0.33333333333333, 1.62, 0.083333333333333
99969, 0.33333333333333, 1.66, 0.083333333333333
99970, 0.33333333333333, 1.54, 0.125
99971, 0.33333333333333, 1.58, 0.125
99972, 0.33333333333333, 1.62, 0.125
99973, 0.33333333333333, 1.66, 0.125
99974, 0.33333333333333, 1.54, 0.16666666666667
99975, 0.33333333333333, 1.58, 0.16666666666667
99976, 0.33333333333333, 1.62, 0.16666666666667
99977, 0.33333333333333, 1.66, 0.16666666666667
99978, 0.33333333333333, 1.54, 0.20833333333333
99979, 0.33333333333333, 1.58, 0.20833333333333
99980, 0.33333333333333, 1.62, 0.20833333333333
99981, 0.33333333333333, 1.66, 0.20833333333333
99982, 0.33333333333333, 1.54, 0.25
99983, 0.33333333333333, 1.58, 0.25
99984, 0.33333333333333, 1.62, 0.25
99985, 0.33333333333333, 1.66, 0.25
99986, 0.33333333333333, 1.54, 0.29166666666667
99987, 0.33333333333333, 1.58, 0.29166666666667
99988, 0.33333333333333, 1.62, 0.29166666666667
99989, 0.33333333333333, 1.66, 0.29166666666667
99990, 0.33333333333333, 1.54, 0.33333333333333
99991, 0.33333333333333, 1.58, 0.33333333333333
99992, 0.33333333333333, 1.62, 0.33333333333333
99993, 0.33333333333333, 1.66, 0.33333333333333
99994, 0.33333333333333, 1.54, 0.375
99995, 0.33333333333333, 1.58, 0.375
99996, 0.33333333333333, 1.62, 0.375
99997, 0.33333333333333, 1.66, 0.375
99998, 0.33333333333333, 1.54, 0.41666666666667
99999, 0.33333333333333, 1.58, 0.41666666666667
100000, 0.33333333333333, 1.62, 0.41666666666667
100001, 0.33333333333333, 1.66, 0.41666666666667
100002, 0.33333333333333, 1.54, 0.45833333333333
100003, 0.33333333333333, 1.58, 0.45833333333333
100004, 0.33333333333333, 1.62, 0.45833333333333
100005, 0.33333333333333, 1.66, 0.45833333333333
100006, 0.375, 1.54, 0.041666666666667
100007, 0.375, 1.58, 0.041666666666667
100008, 0.375, 1.62, 0.041666666666667
100009, 0.375, 1.66, 0.041666666666667
100010, 0.375, 1.54, 0.083333333333333
100011, 0.375, 1.58, 0.083333333333333
100012, 0.375, 1.62, 0.083333333333333
100013, 0.375, 1.66, 0.083333333333333
100014, 0.375, 1.54, 0.125
100015, 0.375, 1.58, 0.125
100016, 0.375, 1.62, 0.125
100017, 0.375, 1.66, 0.125
100018, 0.375, 1.54, 0.16666666666667
100019, 0.375, 1.58, 0.16666666666667
100020, 0.375, 1.62, 0.16666666666667
100021, 0.375, 1.66, 0.16666666666667
100022, 0.375, 1.54, 0.20833333333333
100023, 0.375, 1.58, 0.20833333333333
100024, 0.375, 1.62, 0.20833333333333
100025, 0.375, 1.66, 0.20833333333333
100026, 0.375, 1.54, 0.25
100027, 0.375, 1.58, 0.25
100028, 0.375, 1.62, 0.25
100029, 0.375, 1.66, 0.25
100030, 0.375, 1.54, 0.29166666666667
100031, 0.375, 1.58, 0.29166666666667
100032, 0.375, 1.62, 0.29166666666667
100033, 0.375, 1.66, 0.29166666666667
100034, 0.375, 1.54, 0.33333333333333
100035, 0.375, 1.58, 0.33333333333333
100036, 0.375, 1.62, 0.33333333333333
100037, 0.375, 1.66, 0.33333333333333
100038, 0.375, 1.54, 0.375
100039, 0.375, 1.58, 0.375
100040, 0.375, 1.62, 0.375
100041, 0.375, 1.66, 0.375
100042, 0.375, 1.54, 0.41666666666667
100043, 0.375, 1.58, 0.41666666666667
100044, 0.375, 1.62, 0.41666666666667
100045, 0.375, 1.66, 0.41666666666667
100046, 0.375, 1.54, 0.45833333333333
100047, 0.375, 1.58, 0.45833333333333
100048, 0.375, 1.62, 0.45833333333333
100049, 0.375, 1.66, 0.45833333333333
100050, 0.41666666666667, 1.54, 0.041666666666667
100051, 0.41666666666667, 1.58, 0.041666666666667
100052, 0.41666666666667, 1.62, 0.041666666666667
100053, 0.41666666666667, 1.66, 0.041666666666667
100054, 0.41666666666667, 1.54, 0.083333333333333
100055, 0.41666666666667, 1.58, 0.083333333333333
100056, 0.41666666666667, 1.62, 0.083333333333333
100057, 0.41666666666667, 1.66, 0.083333333333333
100058, 0.41666666666667, 1.54, 0.125
100059, 0.41666666666667, 1.58, 0.125
100060, 0.41666666666667, 1.62, 0.125
100061, 0.41666666666667, 1.66, 0.125
100062, 0.41666666666667, 1.54, 0.16666666666667
100063, 0.41666666666667, 1.58, 0.16666666666667
100064, 0.41666666666667, 1.62, 0.16666666666667
100065, 0.41666666666667, 1.66, 0.16666666666667
100066, 0.41666666666667, 1.54, 0.20833333333333
100067, 0.41666666666667, 1.58, 0.20833333333333
100068, 0.41666666666667, 1.62, 0.20833333333333
100069, 0.41666666666667, 1.66, 0.20833333333333
100070, 0.41666666666667, 1.54, 0.25
100071, 0.41666666666667, 1.58, 0.25
100072, 0.41666666666667, 1.62, 0.25
100073, 0.41666666666667, 1.66, 0.25
100074, 0.41666666666667, 1.54, 0.29166666666667
100075, 0.41666666666667, 1.58, 0.29166666666667
100076, 0.41666666666667, 1.62, 0.29166666666667
100077, 0.41666666666667, 1.66, 0.29166666666667
100078, 0.41666666666667, 1.54, 0.33333333333333
100079, 0.41666666666667, 1.58, 0.33333333333333
100080, 0.41666666666667, 1.62, 0.33333333333333
100081, 0.41666666666667, 1.66, 0.33333333333333
100082, 0.41666666666667, 1.54, 0.375
100083, 0.41666666666667, 1.58, 0.375
100084, 0.41666666666667, 1.62, 0.375
100085, 0.41666666666667, 1.66, 0.375
100086, 0.41666666666667, 1.54, 0.41666666666667
100087, 0.41666666666667, 1.58, 0.41666666666667
100088, 0.41666666666667, 1.62, 0.41666666666667
100089, 0.41666666666667, 1.66, 0.41666666666667
100090, 0.41666666666667, 1.54, 0.45833333333333
100091, 0.41666666666667, 1.58, 0.45833333333333
100092, 0.41666666666667, 1.62, 0.45833333333333
100093, 0.41666666666667, 1.66, 0.45833333333333
100094, 0.45833333333333, 1.54, 0.041666666666667
100095, 0.45833333333333, 1.58, 0.041666666666667
100096, 0.45833333333333, 1.62, 0.041666666666667
100097, 0.45833333333333, 1.66, 0.041666666666667
100098, 0.45833333333333, 1.54, 0.083333333333333
100099, 0.45833333333333, 1.58, 0.083333333333333
100100, 0.45833333333333, 1.62, 0.083333333333333
100101, 0.45833333333333, 1.66, 0.083333333333333
100102, 0.45833333333333, 1.54, 0.125
100103, 0.45833333333333, 1.58, 0.125
100104, 0.45833333333333, 1.62, 0.125
100105, 0.45833333333333, 1.66, 0.125
100106, 0.45833333333333, 1.54, 0.16666666666667
100107, 0.45833333333333, 1.58, 0.16666666666667
100108, 0.45833333333333, 1.62, 0.16666666666667
100109, 0.45833333333333, 1.66, 0.16666666666667
100110, 0.45833333333333, 1.54, 0.20833333333333
100111, 0.45833333333333, 1.58, 0.20833333333333
100112, 0.45833333333333, 1.62, 0.20833333333333
100113, 0.45833333333333, 1.66, 0.20833333333333
100114, 0.45833333333333, 1.54, 0.25
100115, 0.45833333333333, 1.58, 0.25
100116, 0.45833333333333, 1.62, 0.25
100117, 0.45833333333333, 1.66, 0.25
100118, 0.45833333333333, 1.54, 0.29166666666667
100119, 0.45833333333333, 1.58, 0.29166666666667
100120, 0.45833333333333, 1.62, 0.29166666666667
100121, 0.45833333333333, 1.66, 0.29166666666667
100122, 0.45833333333333, 1.54, 0.33333333333333
100123, 0.45833333333333, 1.58, 0.33333333333333
100124, 0.45833333333333, 1.62, 0.33333333333333
100125, 0.45833333333333, 1.66, 0.33333333333333
100126, 0.45833333333333, 1.54, 0.375
100127, 0.45833333333333, 1.58, 0.375
100128, 0.45833333333333, 1.62, 0.375
100129, 0.45833333333333, 1.66, 0.375
100130, 0.45833333333333, 1.54, 0.41666666666667
100131, 0.45833333333333, 1.58, 0.41666666666667
100132, 0.45833333333333, 1.62, 0.41666666666667
100133, 0.45833333333333, 1.66, 0.41666666666667
100134, 0.45833333333333, 1.54, 0.45833333333333
100135, 0.45833333333333, 1.58, 0.45833333333333
100136, 0.45833333333333, 1.62, 0.45833333333333
100137, 0.45833333333333, 1.66, 0.45833333333333
100138, 0.5, 1.54, 0.041666666666667
100139, 0.5, 1.58, 0.041666666666667
100140, 0.5, 1.62, 0.041666666666667
100141, 0.5, 1.66, 0.041666666666667
100142, 0.5, 1.54, 0.083333333333333
100143, 0.5, 1.58, 0.083333333333333
100144, 0.5, 1.62, 0.083333333333333
100145, 0.5, 1.66, 0.083333333333333
100146, 0.5, 1.54, 0.125
100147, 0.5, 1.58, 0.125
100148, 0.5, 1.62, 0.125
100149, 0.5, 1.66, 0.125
100150, 0.5, 1.54, 0.16666666666667
100151, 0.5, 1.58, 0.16666666666667
100152, 0.5, 1.62, 0.16666666666667
100153, 0.5, 1.66, 0.16666666666667
100154, 0.5, 1.54, 0.20833333333333
100155, 0.5, 1.58, 0.20833333333333
100156, 0.5, 1.62, 0.20833333333333
100157, 0.5, 1.66, 0.20833333333333
100158, 0.5, 1.54, 0.25
100159, 0.5, 1.58, 0.25
100160, 0.5, 1.62, 0.25
100161, 0.5, 1.66, 0.25
100162, 0.5, 1.54, 0.29166666666667
100163, 0.5, 1.58, 0.29166666666667
100164, 0.5, 1.62, 0.29166666666667
100165, 0.5, 1.66, 0.29166666666667
100166, 0.5, 1.54, 0.33333333333333
100167, 0.5, 1.58, 0.33333333333333
100168, 0.5, 1.62, 0.33333333333333
100169, 0.5, 1.66, 0.33333333333333
100170, 0.5, 1.54, 0.375
100171, 0.5, 1.58, 0.375
100172, 0.5, 1.62, 0.375
100173, 0.5, 1.66, 0.375
100174, 0.5, 1.54, 0.41666666666667
100175, 0.5, 1.58, 0.41666666666667
100176, 0.5, 1.62, 0.41666666666667
100177, 0.5, 1.66, 0.41666666666667
100178, 0.5, 1.54, 0.45833333333333
100179, 0.5, 1.58, 0.45833333333333
100180, 0.5, 1.62, 0.45833333333333
100181, 0.5, 1.66, 0.45833333333333
100182, 0.54166666666667, 1.54, 0.041666666666667
100183, 0.54166666666667, 1.58, 0.041666666666667
100184, 0.54166666666667, 1.62, 0.041666666666667
100185, 0.54166666666667, 1.66, 0.041666666666667
100186, 0.54166666666667, 1.54, 0.083333333333333
100187, 0.54166666666667, 1.58, 0.083333333333333
100188, 0.54166666666667, 1.62, 0.083333333333333
100189, 0.54166666666667, 1.66, 0.083333333333333
100190, 0.54166666666667, 1.54, 0.125
100191, 0.54166666666667, 1.58, 0.125
100192, 0.54166666666667, 1.62, 0.125
100193, 0.54166666666667, 1.66, 0.125
100194, 0.54166666666667, 1.54, 0.16666666666667
100195, 0.54166666666667, 1.58, 0.16666666666667
100196, 0.54166666666667, 1.62, 0.16666666666667
100197, 0.54166666666667, 1.66, 0.16666666666667
100198, 0.54166666666667, 1.54, 0.20833333333333
100199, 0.54166666666667, 1.58, 0.20833333333333
100200, 0.54166666666667, 1.62, 0.20833333333333
100201, 0.54166666666667, 1.66, 0.20833333333333
100202, 0.54166666666667, 1.54, 0.25
100203, 0.54166666666667, 1.58, 0.25
100204, 0.54166666666667, 1.62, 0.25
100205, 0.54166666666667, 1.66, 0.25
100206, 0.54166666666667, 1.54, 0.29166666666667
100207, 0.54166666666667, 1.58, 0.29166666666667
100208, 0.54166666666667, 1.62, 0.29166666666667
100209, 0.54166666666667, 1.66, 0.29166666666667
100210, 0.54166666666667, 1.54, 0.33333333333333
100211, 0.54166666666667, 1.58, 0.33333333333333
100212, 0.54166666666667, 1.62, 0.33333333333333
100213, 0.54166666666667, 1.66, 0.33333333333333
100214, 0.54166666666667, 1.54, 0.375
100215, 0.54166666666667, 1.58, 0.375
100216, 0.54166666666667, 1.62, 0.375
100217, 0.54166666666667, 1.66, 0.375
100218, 0.54166666666667, 1.54, 0.41666666666667
100219, 0.54166666666667, 1.58, 0.41666666666667
100220, 0.54166666666667, 1.62, 0.41666666666667
100221, 0.54166666666667, 1.66, 0.41666666666667
100222, 0.54166666666667, 1.54, 0.45833333333333
100223, 0.54166666666667, 1.58, 0.45833333333333
100224, 0.54166666666667, 1.62, 0.45833333333333
100225, 0.54166666666667, 1.66, 0.45833333333333
100226, 0.58333333333333, 1.54, 0.041666666666667
100227, 0.58333333333333, 1.58, 0.041666666666667
100228, 0.58333333333333, 1.62, 0.041666666666667
100229, 0.58333333333333, 1.66, 0.041666666666667
100230, 0.58333333333333, 1.54, 0.083333333333333
100231, 0.58333333333333, 1.58, 0.083333333333333
100232, 0.58333333333333, 1.62, 0.083333333333333
100233, 0.58333333333333, 1.66, 0.083333333333333
100234, 0.58333333333333, 1.54, 0.125
100235, 0.58333333333333, 1.58, 0.125
100236, 0.58333333333333, 1.62, 0.125
100237, 0.58333333333333, 1.66, 0.125
100238, 0.58333333333333, 1.54, 0.16666666666667
100239, 0.58333333333333, 1.58, 0.16666666666667
100240, 0.58333333333333, 1.62, 0.16666666666667
100241, 0.58333333333333, 1.66, 0.16666666666667
100242, 0.58333333333333, 1.54, 0.20833333333333
100243, 0.58333333333333, 1.58, 0.20833333333333
100244, 0.58333333333333, 1.62, 0.20833333333333
100245, 0.58333333333333, 1.66, 0.20833333333333
100246, 0.58333333333333, 1.54, 0.25
100247, 0.58333333333333, 1.58, 0.25
100248, 0.58333333333333, 1.62, 0.25
100249, 0.58333333333333, 1.66, 0.25
100250, 0.58333333333333, 1.54, 0.29166666666667
100251, 0.58333333333333, 1.58, 0.29166666666667
100252, 0.58333333333333, 1.62, 0.29166666666667
100253, 0.58333333333333, 1.66, 0.29166666666667
100254, 0.58333333333333, 1.54, 0.33333333333333
100255, 0.58333333333333, 1.58, 0.33333333333333
100256, 0.58333333333333, 1.62, 0.33333333333333
100257, 0.58333333333333, 1.66, 0.33333333333333
100258, 0.58333333333333, 1.54, 0.375
100259, 0.58333333333333, 1.58, 0.375
100260, 0.58333333333333, 1.62, 0.375
100261, 0.58333333333333, 1.66, 0.375
100262, 0.58333333333333, 1.54, 0.41666666666667
100263, 0.58333333333333, 1.58, 0.41666666666667
100264, 0.58333333333333, 1.62, 0.41666666666667
100265, 0.58333333333333, 1.66, 0.41666666666667
100266, 0.58333333333333, 1.54, 0.45833333333333
100267, 0.58333333333333, 1.58, 0.45833333333333
100268, 0.58333333333333, 1.62, 0.45833333333333
100269, 0.58333333333333, 1.66, 0.45833333333333
100270, 0.625, 1.54, 0.041666666666667
100271, 0.625, 1.58, 0.041666666666667
100272, 0.625, 1.62, 0.041666666666667
100273, 0.625, 1.66, 0.041666666666667
100274, 0.625, 1.54, 0.083333333333333
100275, 0.625, 1.58, 0.083333333333333
100276, 0.625, 1.62, 0.083333333333333
100277, 0.625, 1.66, 0.083333333333333
100278, 0.625, 1.54, 0.125
100279, 0.625, 1.58, 0.125
100280, 0.625, 1.62, 0.125
100281, 0.625, 1.66, 0.125
100282, 0.625, 1.54, 0.16666666666667
100283, 0.625, 1.58, 0.16666666666667
100284, 0.625, 1.62, 0.16666666666667
100285, 0.625, 1.66, 0.16666666666667
100286, 0.625, 1.54, 0.20833333333333
100287, 0.625, 1.58, 0.20833333333333
100288, 0.625, 1.62, 0.20833333333333
100289, 0.625, 1.66, 0.20833333333333
100290, 0.625, 1.54, 0.25
100291, 0.625, 1.58, 0.25
100292, 0.625, 1.62, 0.25
100293, 0.625, 1.66, 0.25
100294, 0.625, 1.54, 0.29166666666667
100295, 0.625, 1.58, 0.29166666666667
100296, 0.625, 1.62, 0.29166666666667
100297, 0.625, 1.66, 0.29166666666667
100298, 0.625, 1.54, 0.33333333333333
100299, 0.625, 1.58, 0.33333333333333
100300, 0.625, 1.62, 0.33333333333333
100301, 0.625, 1.66, 0.33333333333333
100302, 0.625, 1.54, 0.375
100303, 0.625, 1.58, 0.375
100304, 0.625, 1.62, 0.375
100305, 0.625, 1.66, 0.375
100306, 0.625, 1.54, 0.41666666666667
100307, 0.625, 1.58, 0.41666666666667
100308, 0.625, 1.62, 0.41666666666667
100309, 0.625, 1.66, 0.41666666666667
100310, 0.625, 1.54, 0.45833333333333
100311, 0.625, 1.58, 0.45833333333333
100312, 0.625, 1.62, 0.45833333333333
100313, 0.625, 1.66, 0.45833333333333
100314, 0.66666666666667, 1.54, 0.041666666666667
100315, 0.66666666666667, 1.58, 0.041666666666667
100316, 0.66666666666667, 1.62, 0.041666666666667
100317, 0.66666666666667, 1.66, 0.041666666666667
100318, 0.66666666666667, 1.54, 0.083333333333333
100319, 0.66666666666667, 1.58, 0.083333333333333
100320, 0.66666666666667, 1.62, 0.083333333333333
100321, 0.66666666666667, 1.66, 0.083333333333333
100322, 0.66666666666667, 1.54, 0.125
100323, 0.66666666666667, 1.58, 0.125
100324, 0.66666666666667, 1.62, 0.125
100325, 0.66666666666667, 1.66, 0.125
100326, 0.66666666666667, 1.54, 0.16666666666667
100327, 0.66666666666667, 1.58, 0.16666666666667
100328, 0.66666666666667, 1.62, 0.16666666666667
100329, 0.66666666666667, 1.66, 0.16666666666667
100330, 0.66666666666667, 1.54, 0.20833333333333
100331, 0.66666666666667, 1.58, 0.20833333333333
100332, 0.66666666666667, 1.62, 0.20833333333333
100333, 0.66666666666667, 1.66, 0.20833333333333
100334, 0.66666666666667, 1.54, 0.25
100335, 0.66666666666667, 1.58, 0.25
100336, 0.66666666666667, 1.62, 0.25
100337, 0.66666666666667, 1.66, 0.25
100338, 0.66666666666667, 1.54, 0.29166666666667
100339, 0.66666666666667, 1.58, 0.29166666666667
100340, 0.66666666666667, 1.62, 0.29166666666667
100341, 0.66666666666667, 1.66, 0.29166666666667
100342, 0.66666666666667, 1.54, 0.33333333333333
100343, 0.66666666666667, 1.58, 0.33333333333333
100344, 0.66666666666667, 1.62, 0.33333333333333
100345, 0.66666666666667, 1.66, 0.33333333333333
100346, 0.66666666666667, 1.54, 0.375
100347, 0.66666666666667, 1.58, 0.375
100348, 0.66666666666667, 1.62, 0.375
100349, 0.66666666666667, 1.66, 0.375
100350, 0.66666666666667, 1.54, 0.41666666666667
100351, 0.66666666666667, 1.58, 0.41666666666667
100352, 0.66666666666667, 1.62, 0.41666666666667
100353, 0.66666666666667, 1.66, 0.41666666666667
100354, 0.66666666666667, 1.54, 0.45833333333333
100355, 0.66666666666667, 1.58, 0.45833333333333
100356, 0.66666666666667, 1.62, 0.45833333333333
100357, 0.66666666666667, 1.66, 0.45833333333333
100358, 0.70833333333333, 1.54, 0.041666666666667
100359, 0.70833333333333, 1.58, 0.041666666666667
100360, 0.70833333333333, 1.62, 0.041666666666667
100361, 0.70833333333333, 1.66, 0.041666666666667
100362, 0.70833333333333, 1.54, 0.083333333333333
100363, 0.70833333333333, 1.58, 0.083333333333333
100364, 0.70833333333333, 1.62, 0.083333333333333
100365, 0.70833333333333, 1.66, 0.083333333333333
100366, 0.70833333333333, 1.54, 0.125
100367, 0.70833333333333, 1.58, 0.125
100368, 0.70833333333333, 1.62, 0.125
100369, 0.70833333333333, 1.66, 0.125
100370, 0.70833333333333, 1.54, 0.16666666666667
100371, 0.70833333333333, 1.58, 0.16666666666667
100372, 0.70833333333333, 1.62, 0.16666666666667
100373, 0.70833333333333, 1.66, 0.16666666666667
100374, 0.70833333333333, 1.54, 0.20833333333333
100375, 0.70833333333333, 1.58, 0.20833333333333
100376, 0.70833333333333, 1.62, 0.20833333333333
100377, 0.70833333333333, 1.66, 0.20833333333333
100378, 0.70833333333333, 1.54, 0.25
100379, 0.70833333333333, 1.58, 0.25
100380, 0.70833333333333, 1.62, 0.25
100381, 0.70833333333333, 1.66, 0.25
100382, 0.70833333333333, 1.54, 0.29166666666667
100383, 0.70833333333333, 1.58, 0.29166666666667
100384, 0.70833333333333, 1.62, 0.29166666666667
100385, 0.70833333333333, 1.66, 0.29166666666667
100386, 0.70833333333333, 1.54, 0.33333333333333
100387, 0.70833333333333, 1.58, 0.33333333333333
100388, 0.70833333333333, 1.62, 0.33333333333333
100389, 0.70833333333333, 1.66, 0.33333333333333
100390, 0.70833333333333, 1.54, 0.375
100391, 0.70833333333333, 1.58, 0.375
100392, 0.70833333333333, 1.62, 0.375
100393, 0.70833333333333, 1.66, 0.375
100394, 0.70833333333333, 1.54, 0.41666666666667
100395, 0.70833333333333, 1.58, 0.41666666666667
100396, 0.70833333333333, 1.62, 0.41666666666667
100397, 0.70833333333333, 1.66, 0.41666666666667
100398, 0.70833333333333, 1.54, 0.45833333333333
100399, 0.70833333333333, 1.58, 0.45833333333333
100400, 0.70833333333333, 1.62, 0.45833333333333
100401, 0.70833333333333, 1.66, 0.45833333333333
100402, 0.75, 1.54, 0.041666666666667
100403, 0.75, 1.58, 0.041666666666667
100404, 0.75, 1.62, 0.041666666666667
100405, 0.75, 1.66, 0.041666666666667
100406, 0.75, 1.54, 0.083333333333333
100407, 0.75, 1.58, 0.083333333333333
100408, 0.75, 1.62, 0.083333333333333
100409, 0.75, 1.66, 0.083333333333333
100410, 0.75, 1.54, 0.125
100411, 0.75, 1.58, 0.125
100412, 0.75, 1.62, 0.125
100413, 0.75, 1.66, 0.125
100414, 0.75, 1.54, 0.16666666666667
100415, 0.75, 1.58, 0.16666666666667
100416, 0.75, 1.62, 0.16666666666667
100417, 0.75, 1.66, 0.16666666666667
100418, 0.75, 1.54, 0.20833333333333
100419, 0.75, 1.58, 0.20833333333333
100420, 0.75, 1.62, 0.20833333333333
100421, 0.75, 1.66, 0.20833333333333
100422, 0.75, 1.54, 0.25
100423, 0.75, 1.58, 0.25
100424, 0.75, 1.62, 0.25
100425, 0.75, 1.66, 0.25
100426, 0.75, 1.54, 0.29166666666667
100427, 0.75, 1.58, 0.29166666666667
100428, 0.75, 1.62, 0.29166666666667
100429, 0.75, 1.66, 0.29166666666667
100430, 0.75, 1.54, 0.33333333333333
100431, 0.75, 1.58, 0.33333333333333
100432, 0.75, 1.62, 0.33333333333333
100433, 0.75, 1.66, 0.33333333333333
100434, 0.75, 1.54, 0.375
100435, 0.75, 1.58, 0.375
100436, 0.75, 1.62, 0.375
100437, 0.75, 1.66, 0.375
100438, 0.75, 1.54, 0.41666666666667
100439, 0.75, 1.58, 0.41666666666667
100440, 0.75, 1.62, 0.41666666666667
100441, 0.75, 1.66, 0.41666666666667
100442, 0.75, 1.54, 0.45833333333333
100443, 0.75, 1.58, 0.45833333333333
100444, 0.75, 1.62, 0.45833333333333
100445, 0.75, 1.66, 0.45833333333333
100446, 0.79166666666667, 1.54, 0.041666666666667
100447, 0.79166666666667, 1.58, 0.041666666666667
100448, 0.79166666666667, 1.62, 0.041666666666667
100449, 0.79166666666667, 1.66, 0.041666666666667
100450, 0.79166666666667, 1.54, 0.083333333333333
100451, 0.79166666666667, 1.58, 0.083333333333333
100452, 0.79166666666667, 1.62, 0.083333333333333
100453, 0.79166666666667, 1.66, 0.083333333333333
100454, 0.79166666666667, 1.54, 0.125
100455, 0.79166666666667, 1.58, 0.125
100456, 0.79166666666667, 1.62, 0.125
100457, 0.79166666666667, 1.66, 0.125
100458, 0.79166666666667, 1.54, 0.16666666666667
100459, 0.79166666666667, 1.58, 0.16666666666667
100460, 0.79166666666667, 1.62, 0.16666666666667
100461, 0.79166666666667, 1.66, 0.16666666666667
100462, 0.79166666666667, 1.54, 0.20833333333333
100463, 0.79166666666667, 1.58, 0.20833333333333
100464, 0.79166666666667, 1.62, 0.20833333333333
100465, 0.79166666666667, 1.66, 0.20833333333333
100466, 0.79166666666667, 1.54, 0.25
100467, 0.79166666666667, 1.58, 0.25
100468, 0.79166666666667, 1.62, 0.25
100469, 0.79166666666667, 1.66, 0.25
100470, 0.79166666666667, 1.54, 0.29166666666667
100471, 0.79166666666667, 1.58, 0.29166666666667
100472, 0.79166666666667, 1.62, 0.29166666666667
100473, 0.79166666666667, 1.66, 0.29166666666667
100474, 0.79166666666667, 1.54, 0.33333333333333
100475, 0.79166666666667, 1.58, 0.33333333333333
100476, 0.79166666666667, 1.62, 0.33333333333333
100477, 0.79166666666667, 1.66, 0.33333333333333
100478, 0.79166666666667, 1.54, 0.375
100479, 0.79166666666667, 1.58, 0.375
100480, 0.79166666666667, 1.62, 0.375
100481, 0.79166666666667, 1.66, 0.375
100482, 0.79166666666667, 1.54, 0.41666666666667
100483, 0.79166666666667, 1.58, 0.41666666666667
100484, 0.79166666666667, 1.62, 0.41666666666667
100485, 0.79166666666667, 1.66, 0.41666666666667
100486, 0.79166666666667, 1.54, 0.45833333333333
100487, 0.79166666666667, 1.58, 0.45833333333333
100488, 0.79166666666667, 1.62, 0.45833333333333
100489, 0.79166666666667, 1.66, 0.45833333333333
100490, 0.83333333333333, 1.54, 0.041666666666667
100491, 0.83333333333333, 1.58, 0.041666666666667
100492, 0.83333333333333, 1.62, 0.041666666666667
100493, 0.83333333333333, 1.66, 0.041666666666667
100494, 0.83333333333333, 1.54, 0.083333333333333
100495, 0.83333333333333, 1.58, 0.083333333333333
100496, 0.83333333333333, 1.62, 0.083333333333333
100497, 0.83333333333333, 1.66, 0.083333333333333
100498, 0.83333333333333, 1.54, 0.125
100499, 0.83333333333333, 1.58, 0.125
100500, 0.83333333333333, 1.62, 0.125
100501, 0.83333333333333, 1.66, 0.125
100502, 0.83333333333333, 1.54, 0.16666666666667
100503, 0.83333333333333, 1.58, 0.16666666666667
100504, 0.83333333333333, 1.62, 0.16666666666667
100505, 0.83333333333333, 1.66, 0.16666666666667
100506, 0.83333333333333, 1.54, 0.20833333333333
100507, 0.83333333333333, 1.58, 0.20833333333333
100508, 0.83333333333333, 1.62, 0.20833333333333
100509, 0.83333333333333, 1.66, 0.20833333333333
100510, 0.83333333333333, 1.54, 0.25
100511, 0.83333333333333, 1.58, 0.25
100512, 0.83333333333333, 1.62, 0.25
100513, 0.83333333333333, 1.66, 0.25
100514, 0.83333333333333, 1.54, 0.29166666666667
100515, 0.83333333333333, 1.58, 0.29166666666667
100516, 0.83333333333333, 1.62, 0.29166666666667
100517, 0.83333333333333, 1.66, 0.29166666666667
100518, 0.83333333333333, 1.54, 0.33333333333333
100519, 0.83333333333333, 1.58, 0.33333333333333
100520, 0.83333333333333, 1.62, 0.33333333333333
100521, 0.83333333333333, 1.66, 0.33333333333333
100522, 0.83333333333333, 1.54, 0.375
100523, 0.83333333333333, 1.58, 0.375
100524, 0.83333333333333, 1.62, 0.375
100525, 0.83333333333333, 1.66, 0.375
100526, 0.83333333333333, 1.54, 0.41666666666667
100527, 0.83333333333333, 1.58, 0.41666666666667
100528, 0.83333333333333, 1.62, 0.41666666666667
100529, 0.83333333333333, 1.66, 0.41666666666667
100530, 0.83333333333333, 1.54, 0.45833333333333
100531, 0.83333333333333, 1.58, 0.45833333333333
100532, 0.83333333333333, 1.62, 0.45833333333333
100533, 0.83333333333333, 1.66, 0.45833333333333
100534, 0.875, 1.54, 0.041666666666667
100535, 0.875, 1.58, 0.041666666666667
100536, 0.875, 1.62, 0.041666666666667
100537, 0.875, 1.66, 0.041666666666667
100538, 0.875, 1.54, 0.083333333333333
100539, 0.875, 1.58, 0.083333333333333
100540, 0.875, 1.62, 0.083333333333333
100541, 0.875, 1.66, 0.083333333333333
100542, 0.875, 1.54, 0.125
100543, 0.875, 1.58, 0.125
100544, 0.875, 1.62, 0.125
100545, 0.875, 1.66, 0.125
100546, 0.875, 1.54, 0.16666666666667
100547, 0.875, 1.58, 0.16666666666667
100548, 0.875, 1.62, 0.16666666666667
100549, 0.875, 1.66, 0.16666666666667
100550, 0.875, 1.54, 0.20833333333333
100551, 0.875, 1.58, 0.20833333333333
100552, 0.875, 1.62, 0.20833333333333
100553, 0.875, 1.66, 0.20833333333333
100554, 0.875, 1.54, 0.25
100555, 0.875, 1.58, 0.25
100556, 0.875, 1.62, 0.25
100557, 0.875, 1.66, 0.25
100558, 0.875, 1.54, 0.29166666666667
100559, 0.875, 1.58, 0.29166666666667
100560, 0.875, 1.62, 0.29166666666667
100561, 0.875, 1.66, 0.29166666666667
100562, 0.875, 1.54, 0.33333333333333
100563, 0.875, 1.58, 0.33333333333333
100564, 0.875, 1.62, 0.33333333333333
100565, 0.875, 1.66, 0.33333333333333
100566, 0.875, 1.54, 0.375
100567, 0.875, 1.58, 0.375
100568, 0.875, 1.62, 0.375
100569, 0.875, 1.66, 0.375
100570, 0.875, 1.54, 0.41666666666667
100571, 0.875, 1.58, 0.41666666666667
100572, 0.875, 1.62, 0.41666666666667
100573, 0.875, 1.66, 0.41666666666667
100574, 0.875, 1.54, 0.45833333333333
100575, 0.875, 1.58, 0.45833333333333
100576, 0.875, 1.62, 0.45833333333333
100577, 0.875, 1.66, 0.45833333333333
100578, 0.91666666666667, 1.54, 0.041666666666667
100579, 0.91666666666667, 1.58, 0.041666666666667
100580, 0.91666666666667, 1.62, 0.041666666666667
100581, 0.91666666666667, 1.66, 0.041666666666667
100582, 0.91666666666667, 1.54, 0.083333333333333
100583, 0.91666666666667, 1.58, 0.083333333333333
100584, 0.91666666666667, 1.62, 0.083333333333333
100585, 0.91666666666667, 1.66, 0.083333333333333
100586, 0.91666666666667, 1.54, 0.125
100587, 0.91666666666667, 1.58, 0.125
100588, 0.91666666666667, 1.62, 0.125
100589, 0.91666666666667, 1.66, 0.125
100590, 0.91666666666667, 1.54, 0.16666666666667
100591, 0.91666666666667, 1.58, 0.16666666666667
100592, 0.91666666666667, 1.62, 0.16666666666667
100593, 0.91666666666667, 1.66, 0.16666666666667
100594, 0.91666666666667, 1.54, 0.20833333333333
100595, 0.91666666666667, 1.58, 0.20833333333333
100596, 0.91666666666667, 1.62, 0.20833333333333
100597, 0.91666666666667, 1.66, 0.20833333333333
100598, 0.91666666666667, 1.54, 0.25
100599, 0.91666666666667, 1.58, 0.25
100600, 0.91666666666667, 1.62, 0.25
100601, 0.91666666666667, 1.66, 0.25
100602, 0.91666666666667, 1.54, 0.29166666666667
100603, 0.91666666666667, 1.58, 0.29166666666667
100604, 0.91666666666667, 1.62, 0.29166666666667
100605, 0.91666666666667, 1.66, 0.29166666666667
100606, 0.91666666666667, 1.54, 0.33333333333333
100607, 0.91666666666667, 1.58, 0.33333333333333
100608, 0.91666666666667, 1.62, 0.33333333333333
100609, 0.91666666666667, 1.66, 0.33333333333333
100610, 0.91666666666667, 1.54, 0.375
100611, 0.91666666666667, 1.58, 0.375
100612, 0.91666666666667, 1.62, 0.375
100613, 0.91666666666667, 1.66, 0.375
100614, 0.91666666666667, 1.54, 0.41666666666667
100615, 0.91666666666667, 1.58, 0.41666666666667
100616, 0.91666666666667, 1.62, 0.41666666666667
100617, 0.91666666666667, 1.66, 0.41666666666667
100618, 0.91666666666667, 1.54, 0.45833333333333
100619, 0.91666666666667, 1.58, 0.45833333333333
100620, 0.91666666666667, 1.62, 0.45833333333333
100621, 0.91666666666667, 1.66, 0.45833333333333
100622, 0.95833333333333, 1.54, 0.041666666666667
100623, 0.95833333333333, 1.58, 0.041666666666667
100624, 0.95833333333333, 1.62, 0.041666666666667
100625, 0.95833333333333, 1.66, 0.041666666666667
100626, 0.95833333333333, 1.54, 0.083333333333333
100627, 0.95833333333333, 1.58, 0.083333333333333
100628, 0.95833333333333, 1.62, 0.083333333333333
100629, 0.95833333333333, 1.66, 0.083333333333333
100630, 0.95833333333333, 1.54, 0.125
100631, 0.95833333333333, 1.58, 0.125
100632, 0.95833333333333, 1.62, 0.125
100633, 0.95833333333333, 1.66, 0.125
100634, 0.95833333333333, 1.54, 0.16666666666667
100635, 0.95833333333333, 1.58, 0.16666666666667
100636, 0.95833333333333, 1.62, 0.16666666666667
100637, 0.95833333333333, 1.66, 0.16666666666667
100638, 0.95833333333333, 1.54, 0.20833333333333
100639, 0.95833333333333, 1.58, 0.20833333333333
100640, 0.95833333333333, 1.62, 0.20833333333333
100641, 0.95833333333333, 1.66, 0.20833333333333
100642, 0.95833333333333, 1.54, 0.25
100643, 0.95833333333333, 1.58, 0.25
100644, 0.95833333333333, 1.62, 0.25
100645, 0.95833333333333, 1.66, 0.25
100646, 0.95833333333333, 1.54, 0.29166666666667
100647, 0.95833333333333, 1.58, 0.29166666666667
100648, 0.95833333333333, 1.62, 0.29166666666667
100649, 0.95833333333333, 1.66, 0.29166666666667
100650, 0.95833333333333, 1.54, 0.33333333333333
100651, 0.95833333333333, 1.58, 0.33333333333333
100652, 0.95833333333333, 1.62, 0.33333333333333
100653, 0.95833333333333, 1.66, 0.33333333333333
100654, 0.95833333333333, 1.54, 0.375
100655, 0.95833333333333, 1.58, 0.375
100656, 0.95833333333333, 1.62, 0.375
100657, 0.95833333333333, 1.66, 0.375
100658, 0.95833333333333, 1.54, 0.41666666666667
100659, 0.95833333333333, 1.58, 0.41666666666667
100660, 0.95833333333333, 1.62, 0.41666666666667
100661, 0.95833333333333, 1.66, 0.41666666666667
100662, 0.95833333333333, 1.54, 0.45833333333333
100663, 0.95833333333333, 1.58, 0.45833333333333
100664, 0.95833333333333, 1.62, 0.45833333333333
100665, 0.95833333333333, 1.66, 0.45833333333333
100666, 0.041666666666667, 1.52, 0.041666666666667
100667, 0.020833333333333, 1.54, 0.041666666666667
100668, 0.041666666666667, 1.54, 0.020833333333333
100669, 0.041666666666667, 1.56, 0.041666666666667
100670, 0.020833333333333, 1.58, 0.041666666666667
100671, 0.041666666666667, 1.58, 0.020833333333333
100672, 0.041666666666667, 1.6, 0.041666666666667
100673, 0.020833333333333, 1.62, 0.041666666666667
100674, 0.041666666666667, 1.62, 0.020833333333333
100675, 0.041666666666667, 1.64, 0.041666666666667
100676, 0.020833333333333, 1.66, 0.041666666666667
100677, 0.041666666666667, 1.66, 0.020833333333333
100678, 0.041666666666667, 1.68, 0.041666666666667
100679, 0.041666666666667, 1.52, 0.083333333333333
100680, 0.020833333333333, 1.54, 0.083333333333333
100681, 0.041666666666667, 1.54, 0.0625
100682, 0.041666666666667, 1.56, 0.083333333333333
100683, 0.020833333333333, 1.58, 0.083333333333333
100684, 0.041666666666667, 1.58, 0.0625
100685, 0.041666666666667, 1.6, 0.083333333333333
100686, 0.020833333333333, 1.62, 0.083333333333333
100687, 0.041666666666667, 1.62, 0.0625
100688, 0.041666666666667, 1.64, 0.083333333333333
100689, 0.020833333333333, 1.66, 0.083333333333333
100690, 0.041666666666667, 1.66, 0.0625
100691, 0.041666666666667, 1.68, 0.083333333333333
100692, 0.041666666666667, 1.52, 0.125
100693, 0.020833333333333, 1.54, 0.125
100694, 0.041666666666667, 1.54, 0.10416666666667
100695, 0.041666666666667, 1.56, 0.125
100696, 0.020833333333333, 1.58, 0.125
100697, 0.041666666666667, 1.58, 0.10416666666667
100698, 0.041666666666667, 1.6, 0.125
100699, 0.020833333333333, 1.62, 0.125
100700, 0.041666666666667, 1.62, 0.10416666666667
100701, 0.041666666666667, 1.64, 0.125
100702, 0.020833333333333, 1.66, 0.125
100703, 0.041666666666667, 1.66, 0.10416666666667
100704, 0.041666666666667, 1.68, 0.125
100705, 0.041666666666667, 1.52, 0.16666666666667
100706, 0.020833333333333, 1.54, 0.16666666666667
100707, 0.041666666666667, 1.54, 0.14583333333333
100708, 0.041666666666667, 1.56, 0.16666666666667
100709, 0.020833333333333, 1.58, 0.16666666666667
100710, 0.041666666666667, 1.58, 0.14583333333333
100711, 0.041666666666667, 1.6, 0.16666666666667
100712, 0.020833333333333, 1.62, 0.16666666666667
100713, 0.041666666666667, 1.62, 0.14583333333333
100714, 0.041666666666667, 1.64, 0.16666666666667
100715, 0.020833333333333, 1.66, 0.16666666666667
100716, 0.041666666666667, 1.66, 0.14583333333333
100717, 0.041666666666667, 1.68, 0.16666666666667
100718, 0.041666666666667, 1.52, 0.20833333333333
100719, 0.020833333333333, 1.54, 0.20833333333333
100720, 0.041666666666667, 1.54, 0.1875
100721, 0.041666666666667, 1.56, 0.20833333333333
100722, 0.020833333333333, 1.58, 0.20833333333333
100723, 0.041666666666667, 1.58, 0.1875
100724, 0.041666666666667, 1.6, 0.20833333333333
100725, 0.020833333333333, 1.62, 0.20833333333333
100726, 0.041666666666667, 1.62, 0.1875
100727, 0.041666666666667, 1.64, 0.20833333333333
100728, 0.020833333333333, 1.66, 0.20833333333333
100729, 0.041666666666667, 1.66, 0.1875
100730, 0.041666666666667, 1.68, 0.20833333333333
100731, 0.041666666666667, 1.52, 0.25
100732, 0.020833333333333, 1.54, 0.25
100733, 0.041666666666667, 1.54, 0.22916666666667
100734, 0.041666666666667, 1.56, 0.25
100735, 0.020833333333333, 1.58, 0.25
100736, 0.041666666666667, 1.58, 0.22916666666667
100737, 0.041666666666667, 1.6, 0.25
100738, 0.020833333333333, 1.62, 0.25
100739, 0.041666666666667, 1.62, 0.22916666666667
100740, 0.041666666666667, 1.64, 0.25
100741, 0.020833333333333, 1.66, 0.25
100742, 0.041666666666667, 1.66, 0.22916666666667
100743, 0.041666666666667, 1.68, 0.25
100744, 0.041666666666667, 1.52, 0.29166666666667
100745, 0.020833333333333, 1.54, 0.29166666666667
100746, 0.041666666666667, 1.54, 0.27083333333333
100747, 0.041666666666667, 1.56, 0.29166666666667
100748, 0.020833333333333, 1.58, 0.29166666666667
100749, 0.041666666666667, 1.58, 0.27083333333333
100750, 0.041666666666667, 1.6, 0.29166666666667
100751, 0.020833333333333, 1.62, 0.29166666666667
100752, 0.041666666666667, 1.62, 0.27083333333333
100753, 0.041666666666667, 1.64, 0.29166666666667
100754, 0.020833333333333, 1.66, 0.29166666666667
100755, 0.041666666666667, 1.66, 0.27083333333333
100756, 0.041666666666667, 1.68, 0.29166666666667
100757, 0.041666666666667, 1.52, 0.33333333333333
100758, 0.020833333333333, 1.54, 0.33333333333333
100759, 0.041666666666667, 1.54, 0.3125
100760, 0.041666666666667, 1.56, 0.33333333333333
100761, 0.020833333333333, 1.58, 0.33333333333333
100762, 0.041666666666667, 1.58, 0.3125
100763, 0.041666666666667, 1.6, 0.33333333333333
100764, 0.020833333333333, 1.62, 0.33333333333333
100765, 0.041666666666667, 1.62, 0.3125
100766, 0.041666666666667, 1.64, 0.33333333333333
100767, 0.020833333333333, 1.66, 0.33333333333333
100768, 0.041666666666667, 1.66, 0.3125
100769, 0.041666666666667, 1.68, 0.33333333333333
100770, 0.041666666666667, 1.52, 0.375
100771, 0.020833333333333, 1.54, 0.375
100772, 0.041666666666667, 1.54, 0.35416666666667
100773, 0.041666666666667, 1.56, 0.375
100774, 0.020833333333333, 1.58, 0.375
100775, 0.041666666666667, 1.58, 0.35416666666667
100776, 0.041666666666667, 1.6, 0.375
100777, 0.020833333333333, 1.62, 0.375
100778, 0.041666666666667, 1.62, 0.35416666666667
100779, 0.041666666666667, 1.64, 0.375
100780, 0.020833333333333, 1.66, 0.375
100781, 0.041666666666667, 1.66, 0.35416666666667
100782, 0.041666666666667, 1.68, 0.375
100783, 0.041666666666667, 1.52, 0.41666666666667
100784, 0.020833333333333, 1.54, 0.41666666666667
100785, 0.041666666666667, 1.54, 0.39583333333333
100786, 0.041666666666667, 1.56, 0.41666666666667
100787, 0.020833333333333, 1.58, 0.41666666666667
100788, 0.041666666666667, 1.58, 0.39583333333333
100789, 0.041666666666667, 1.6, 0.41666666666667
100790, 0.020833333333333, 1.62, 0.41666666666667
100791, 0.041666666666667, 1.62, 0.39583333333333
100792, 0.041666666666667, 1.64, 0.41666666666667
100793, 0.020833333333333, 1.66, 0.41666666666667
100794, 0.041666666666667, 1.66, 0.39583333333333
100795, 0.041666666666667, 1.68, 0.41666666666667
100796, 0.041666666666667, 1.52, 0.45833333333333
100797, 0.020833333333333, 1.54, 0.45833333333333
100798, 0.041666666666667, 1.54, 0.4375
100799, 0.041666666666667, 1.56, 0.45833333333333
100800, 0.020833333333333, 1.58, 0.45833333333333
100801, 0.041666666666667, 1.58, 0.4375
100802, 0.041666666666667, 1.6, 0.45833333333333
100803, 0.020833333333333, 1.62, 0.45833333333333
100804, 0.041666666666667, 1.62, 0.4375
100805, 0.041666666666667, 1.64, 0.45833333333333
100806, 0.020833333333333, 1.66, 0.45833333333333
100807, 0.041666666666667, 1.66, 0.4375
100808, 0.041666666666667, 1.68, 0.45833333333333
100809, 0.041666666666667, 1.54, 0.47916666666667
100810, 0.041666666666667, 1.58, 0.47916666666667
100811, 0.041666666666667, 1.62, 0.47916666666667
100812, 0.041666666666667, 1.66, 0.47916666666667
100813, 0.083333333333333, 1.52, 0.041666666666667
100814, 0.0625, 1.54, 0.041666666666667
100815, 0.083333333333333, 1.54, 0.020833333333333
100816, 0.083333333333333, 1.56, 0.041666666666667
100817, 0.0625, 1.58, 0.041666666666667
100818, 0.083333333333333, 1.58, 0.020833333333333
100819, 0.083333333333333, 1.6, 0.041666666666667
100820, 0.0625, 1.62, 0.041666666666667
100821, 0.083333333333333, 1.62, 0.020833333333333
100822, 0.083333333333333, 1.64, 0.041666666666667
100823, 0.0625, 1.66, 0.041666666666667
100824, 0.083333333333333, 1.66, 0.020833333333333
100825, 0.083333333333333, 1.68, 0.041666666666667
100826, 0.083333333333333, 1.52, 0.083333333333333
100827, 0.0625, 1.54, 0.083333333333333
100828, 0.083333333333333, 1.54, 0.0625
100829, 0.083333333333333, 1.56, 0.083333333333333
100830, 0.0625, 1.58, 0.083333333333333
100831, 0.083333333333333, 1.58, 0.0625
100832, 0.083333333333333, 1.6, 0.083333333333333
100833, 0.0625, 1.62, 0.083333333333333
100834, 0.083333333333333, 1.62, 0.0625
100835, 0.083333333333333, 1.64, 0.083333333333333
100836, 0.0625, 1.66, 0.083333333333333
100837, 0.083333333333333, 1.66, 0.0625
100838, 0.083333333333333, 1.68, 0.083333333333333
100839, 0.083333333333333, 1.52, 0.125
100840, 0.0625, 1.54, 0.125
100841, 0.083333333333333, 1.54, 0.10416666666667
100842, 0.083333333333333, 1.56, 0.125
100843, 0.0625, 1.58, 0.125
100844, 0.083333333333333, 1.58, 0.10416666666667
100845, 0.083333333333333, 1.6, 0.125
100846, 0.0625, 1.62, 0.125
100847, 0.083333333333333, 1.62, 0.10416666666667
100848, 0.083333333333333, 1.64, 0.125
100849, 0.0625, 1.66, 0.125
100850, 0.083333333333333, 1.66, 0.10416666666667
100851, 0.083333333333333, 1.68, 0.125
100852, 0.083333333333333, 1.52, 0.16666666666667
100853, 0.0625, 1.54, 0.16666666666667
100854, 0.083333333333333, 1.54, 0.14583333333333
100855, 0.083333333333333, 1.56, 0.16666666666667
100856, 0.0625, 1.58, 0.16666666666667
100857, 0.083333333333333, 1.58, 0.14583333333333
100858, 0.083333333333333, 1.6, 0.16666666666667
100859, 0.0625, 1.62, 0.16666666666667
100860, 0.083333333333333, 1.62, 0.14583333333333
100861, 0.083333333333333, 1.64, 0.16666666666667
100862, 0.0625, 1.66, 0.16666666666667
100863, 0.083333333333333, 1.66, 0.14583333333333
100864, 0.083333333333333, 1.68, 0.16666666666667
100865, 0.083333333333333, 1.52, 0.20833333333333
100866, 0.0625, 1.54, 0.20833333333333
100867, 0.083333333333333, 1.54, 0.1875
100868, 0.083333333333333, 1.56, 0.20833333333333
100869, 0.0625, 1.58, 0.20833333333333
100870, 0.083333333333333, 1.58, 0.1875
100871, 0.083333333333333, 1.6, 0.20833333333333
100872, 0.0625, 1.62, 0.20833333333333
100873, 0.083333333333333, 1.62, 0.1875
100874, 0.083333333333333, 1.64, 0.20833333333333
100875, 0.0625, 1.66, 0.20833333333333
100876, 0.083333333333333, 1.66, 0.1875
100877, 0.083333333333333, 1.68, 0.20833333333333
100878, 0.083333333333333, 1.52, 0.25
100879, 0.0625, 1.54, 0.25
100880, 0.083333333333333, 1.54, 0.22916666666667
100881, 0.083333333333333, 1.56, 0.25
100882, 0.0625, 1.58, 0.25
100883, 0.083333333333333, 1.58, 0.22916666666667
100884, 0.083333333333333, 1.6, 0.25
100885, 0.0625, 1.62, 0.25
100886, 0.083333333333333, 1.62, 0.22916666666667
100887, 0.083333333333333, 1.64, 0.25
100888, 0.0625, 1.66, 0.25
100889, 0.083333333333333, 1.66, 0.22916666666667
100890, 0.083333333333333, 1.68, 0.25
100891, 0.083333333333333, 1.52, 0.29166666666667
100892, 0.0625, 1.54, 0.29166666666667
100893, 0.083333333333333, 1.54, 0.27083333333333
100894, 0.083333333333333, 1.56, 0.29166666666667
100895, 0.0625, 1.58, 0.29166666666667
100896, 0.083333333333333, 1.58, 0.27083333333333
100897, 0.083333333333333, 1.6, 0.29166666666667
100898, 0.0625, 1.62, 0.29166666666667
100899, 0.083333333333333, 1.62, 0.27083333333333
100900, 0.083333333333333, 1.64, 0.29166666666667
100901, 0.0625, 1.66, 0.29166666666667
100902, 0.083333333333333, 1.66, 0.27083333333333
100903, 0.083333333333333, 1.68, 0.29166666666667
100904, 0.083333333333333, 1.52, 0.33333333333333
100905, 0.0625, 1.54, 0.33333333333333
100906, 0.083333333333333, 1.54, 0.3125
100907, 0.083333333333333, 1.56, 0.33333333333333
100908, 0.0625, 1.58, 0.33333333333333
100909, 0.083333333333333, 1.58, 0.3125
100910, 0.083333333333333, 1.6, 0.33333333333333
100911, 0.0625, 1.62, 0.33333333333333
100912, 0.083333333333333, 1.62, 0.3125
100913, 0.083333333333333, 1.64, 0.33333333333333
100914, 0.0625, 1.66, 0.33333333333333
100915, 0.083333333333333, 1.66, 0.3125
100916, 0.083333333333333, 1.68, 0.33333333333333
100917, 0.083333333333333, 1.52, 0.375
100918, 0.0625, 1.54, 0.375
100919, 0.083333333333333, 1.54, 0.35416666666667
100920, 0.083333333333333, 1.56, 0.375
100921, 0.0625, 1.58, 0.375
100922, 0.083333333333333, 1.58, 0.35416666666667
100923, 0.083333333333333, 1.6, 0.375
100924, 0.0625, 1.62, 0.375
100925, 0.083333333333333, 1.62, 0.35416666666667
100926, 0.083333333333333, 1.64, 0.375
100927, 0.0625, 1.66, 0.375
100928, 0.083333333333333, 1.66, 0.35416666666667
100929, 0.083333333333333, 1.68, 0.375
100930, 0.083333333333333, 1.52, 0.41666666666667
100931, 0.0625, 1.54, 0.41666666666667
100932, 0.083333333333333, 1.54, 0.39583333333333
100933, 0.083333333333333, 1.56, 0.41666666666667
100934, 0.0625, 1.58, 0.41666666666667
100935, 0.083333333333333, 1.58, 0.39583333333333
100936, 0.083333333333333, 1.6, 0.41666666666667
100937, 0.0625, 1.62, 0.41666666666667
100938, 0.083333333333333, 1.62, 0.39583333333333
100939, 0.083333333333333, 1.64, 0.41666666666667
100940, 0.0625, 1.66, 0.41666666666667
100941, 0.083333333333333, 1.66, 0.39583333333333
100942, 0.083333333333333, 1.68, 0.41666666666667
100943, 0.083333333333333, 1.52, 0.45833333333333
100944, 0.0625, 1.54, 0.45833333333333
100945, 0.083333333333333, 1.54, 0.4375
100946, 0.083333333333333, 1.56, 0.45833333333333
100947, 0.0625, 1.58, 0.45833333333333
100948, 0.083333333333333, 1.58, 0.4375
100949, 0.083333333333333, 1.6, 0.45833333333333
100950, 0.0625, 1.62, 0.45833333333333
100951, 0.083333333333333, 1.62, 0.4375
100952, 0.083333333333333, 1.64, 0.45833333333333
100953, 0.0625, 1.66, 0.45833333333333
100954, 0.083333333333333, 1.66, 0.4375
100955, 0.083333333333333, 1.68, 0.45833333333333
100956, 0.083333333333333, 1.54, 0.47916666666667
100957, 0.083333333333333, 1.58, 0.47916666666667
100958, 0.083333333333333, 1.62, 0.47916666666667
100959, 0.083333333333333, 1.66, 0.47916666666667
100960, 0.125, 1.52, 0.041666666666667
100961, 0.10416666666667, 1.54, 0.041666666666667
100962, 0.125, 1.54, 0.020833333333333
100963, 0.125, 1.56, 0.041666666666667
100964, 0.10416666666667, 1.58, 0.041666666666667
100965, 0.125, 1.58, 0.020833333333333
100966, 0.125, 1.6, 0.041666666666667
100967, 0.10416666666667, 1.62, 0.041666666666667
100968, 0.125, 1.62, 0.020833333333333
100969, 0.125, 1.64, 0.041666666666667
100970, 0.10416666666667, 1.66, 0.041666666666667
100971, 0.125, 1.66, 0.020833333333333
100972, 0.125, 1.68, 0.041666666666667
100973, 0.125, 1.52, 0.083333333333333
100974, 0.10416666666667, 1.54, 0.083333333333333
100975, 0.125, 1.54, 0.0625
100976, 0.125, 1.56, 0.083333333333333
100977, 0.10416666666667, 1.58, 0.083333333333333
100978, 0.125, 1.58, 0.0625
100979, 0.125, 1.6, 0.083333333333333
100980, 0.10416666666667, 1.62, 0.083333333333333
100981, 0.125, 1.62, 0.0625
100982, 0.125, 1.64, 0.083333333333333
100983, 0.10416666666667, 1.66, 0.083333333333333
100984, 0.125, 1.66, 0.0625
100985, 0.125, 1.68, 0.083333333333333
100986, 0.125, 1.52, 0.125
100987, 0.10416666666667, 1.54, 0.125
100988, 0.125, 1.54, 0.10416666666667
100989, 0.125, 1.56, 0.125
100990, 0.10416666666667, 1.58, 0.125
100991, 0.125, 1.58, 0.10416666666667
100992, 0.125, 1.6, 0.125
100993, 0.10416666666667, 1.62, 0.125
100994, 0.125, 1.62, 0.10416666666667
100995, 0.125, 1.64, 0.125
100996, 0.10416666666667, 1.66, 0.125
100997, 0.125, 1.66, 0.10416666666667
100998, 0.125, 1.68, 0.125
100999, 0.125, 1.52, 0.16666666666667
101000, 0.10416666666667, 1.54, 0.16666666666667
101001, 0.125, 1.54, 0.14583333333333
101002, 0.125, 1.56, 0.16666666666667
101003, 0.10416666666667, 1.58, 0.16666666666667
101004, 0.125, 1.58, 0.14583333333333
101005, 0.125, 1.6, 0.16666666666667
101006, 0.10416666666667, 1.62, 0.16666666666667
101007, 0.125, 1.62, 0.14583333333333
101008, 0.125, 1.64, 0.16666666666667
101009, 0.10416666666667, 1.66, 0.16666666666667
101010, 0.125, 1.66, 0.14583333333333
101011, 0.125, 1.68, 0.16666666666667
101012, 0.125, 1.52, 0.20833333333333
101013, 0.10416666666667, 1.54, 0.20833333333333
101014, 0.125, 1.54, 0.1875
101015, 0.125, 1.56, 0.20833333333333
101016, 0.10416666666667, 1.58, 0.20833333333333
101017, 0.125, 1.58, 0.1875
101018, 0.125, 1.6, 0.20833333333333
101019, 0.10416666666667, 1.62, 0.20833333333333
101020, 0.125, 1.62, 0.1875
101021, 0.125, 1.64, 0.20833333333333
101022, 0.10416666666667, 1.66, 0.20833333333333
101023, 0.125, 1.66, 0.1875
101024, 0.125, 1.68, 0.20833333333333
101025, 0.125, 1.52, 0.25
101026, 0.10416666666667, 1.54, 0.25
101027, 0.125, 1.54, 0.22916666666667
101028, 0.125, 1.56, 0.25
101029, 0.10416666666667, 1.58, 0.25
101030, 0.125, 1.58, 0.22916666666667
101031, 0.125, 1.6, 0.25
101032, 0.10416666666667, 1.62, 0.25
101033, 0.125, 1.62, 0.22916666666667
101034, 0.125, 1.64, 0.25
101035, 0.10416666666667, 1.66, 0.25
101036, 0.125, 1.66, 0.22916666666667
101037, 0.125, 1.68, 0.25
101038, 0.125, 1.52, 0.29166666666667
101039, 0.10416666666667, 1.54, 0.29166666666667
101040, 0.125, 1.54, 0.27083333333333
101041, 0.125, 1.56, 0.29166666666667
101042, 0.10416666666667, 1.58, 0.29166666666667
101043, 0.125, 1.58, 0.27083333333333
101044, 0.125, 1.6, 0.29166666666667
101045, 0.10416666666667, 1.62, 0.29166666666667
101046, 0.125, 1.62, 0.27083333333333
101047, 0.125, 1.64, 0.29166666666667
101048, 0.10416666666667, 1.66, 0.29166666666667
101049, 0.125, 1.66, 0.27083333333333
101050, 0.125, 1.68, 0.29166666666667
101051, 0.125, 1.52, 0.33333333333333
101052, 0.10416666666667, 1.54, 0.33333333333333
101053, 0.125, 1.54, 0.3125
101054, 0.125, 1.56, 0.33333333333333
101055, 0.10416666666667, 1.58, 0.33333333333333
101056, 0.125, 1.58, 0.3125
101057, 0.125, 1.6, 0.33333333333333
101058, 0.10416666666667, 1.62, 0.33333333333333
101059, 0.125, 1.62, 0.3125
101060, 0.125, 1.64, 0.33333333333333
101061, 0.10416666666667, 1.66, 0.33333333333333
101062, 0.125, 1.66, 0.3125
101063, 0.125, 1.68, 0.33333333333333
101064, 0.125, 1.52, 0.375
101065, 0.10416666666667, 1.54, 0.375
101066, 0.125, 1.54, 0.35416666666667
101067, 0.125, 1.56, 0.375
101068, 0.10416666666667, 1.58, 0.375
101069, 0.125, 1.58, 0.35416666666667
101070, 0.125, 1.6, 0.375
101071, 0.10416666666667, 1.62, 0.375
101072, 0.125, 1.62, 0.35416666666667
101073, 0.125, 1.64, 0.375
101074, 0.10416666666667, 1.66, 0.375
101075, 0.125, 1.66, 0.35416666666667
101076, 0.125, 1.68, 0.375
101077, 0.125, 1.52, 0.41666666666667
101078, 0.10416666666667, 1.54, 0.41666666666667
101079, 0.125, 1.54, 0.39583333333333
101080, 0.125, 1.56, 0.41666666666667
101081, 0.10416666666667, 1.58, 0.41666666666667
101082, 0.125, 1.58, 0.39583333333333
101083, 0.125, 1.6, 0.41666666666667
101084, 0.10416666666667, 1.62, 0.41666666666667
101085, 0.125, 1.62, 0.39583333333333
101086, 0.125, 1.64, 0.41666666666667
101087, 0.10416666666667, 1.66, 0.41666666666667
101088, 0.125, 1.66, 0.39583333333333
101089, 0.125, 1.68, 0.41666666666667
101090, 0.125, 1.52, 0.45833333333333
101091, 0.10416666666667, 1.54, 0.45833333333333
101092, 0.125, 1.54, 0.4375
101093, 0.125, 1.56, 0.45833333333333
101094, 0.10416666666667, 1.58, 0.45833333333333
101095, 0.125, 1.58, 0.4375
101096, 0.125, 1.6, 0.45833333333333
101097, 0.10416666666667, 1.62, 0.45833333333333
101098, 0.125, 1.62, 0.4375
101099, 0.125, 1.64, 0.45833333333333
101100, 0.10416666666667, 1.66, 0.45833333333333
101101, 0.125, 1.66, 0.4375
101102, 0.125, 1.68, 0.45833333333333
101103, 0.125, 1.54, 0.47916666666667
101104, 0.125, 1.58, 0.47916666666667
101105, 0.125, 1.62, 0.47916666666667
101106, 0.125, 1.66, 0.47916666666667
101107, 0.16666666666667, 1.52, 0.041666666666667
101108, 0.14583333333333, 1.54, 0.041666666666667
101109, 0.16666666666667, 1.54, 0.020833333333333
101110, 0.16666666666667, 1.56, 0.041666666666667
101111, 0.14583333333333, 1.58, 0.041666666666667
101112, 0.16666666666667, 1.58, 0.020833333333333
101113, 0.16666666666667, 1.6, 0.041666666666667
101114, 0.14583333333333, 1.62, 0.041666666666667
101115, 0.16666666666667, 1.62, 0.020833333333333
101116, 0.16666666666667, 1.64, 0.041666666666667
101117, 0.14583333333333, 1.66, 0.041666666666667
101118, 0.16666666666667, 1.66, 0.020833333333333
101119, 0.16666666666667, 1.68, 0.041666666666667
101120, 0.16666666666667, 1.52, 0.083333333333333
101121, 0.14583333333333, 1.54, 0.083333333333333
101122, 0.16666666666667, 1.54, 0.0625
101123, 0.16666666666667, 1.56, 0.083333333333333
101124, 0.14583333333333, 1.58, 0.083333333333333
101125, 0.16666666666667, 1.58, 0.0625
101126, 0.16666666666667, 1.6, 0.083333333333333
101127, 0.14583333333333, 1.62, 0.083333333333333
101128, 0.16666666666667, 1.62, 0.0625
101129, 0.16666666666667, 1.64, 0.083333333333333
101130, 0.14583333333333, 1.66, 0.083333333333333
101131, 0.16666666666667, 1.66, 0.0625
101132, 0.16666666666667, 1.68, 0.083333333333333
101133, 0.16666666666667, 1.52, 0.125
101134, 0.14583333333333, 1.54, 0.125
101135, 0.16666666666667, 1.54, 0.10416666666667
101136, 0.16666666666667, 1.56, 0.125
101137, 0.14583333333333, 1.58, 0.125
101138, 0.16666666666667, 1.58, 0.10416666666667
101139, 0.16666666666667, 1.6, 0.125
101140, 0.14583333333333, 1.62, 0.125
101141, 0.16666666666667, 1.62, 0.10416666666667
101142, 0.16666666666667, 1.64, 0.125
101143, 0.14583333333333, 1.66, 0.125
101144, 0.16666666666667, 1.66, 0.10416666666667
101145, 0.16666666666667, 1.68, 0.125
101146, 0.16666666666667, 1.52, 0.16666666666667
101147, 0.14583333333333, 1.54, 0.16666666666667
101148, 0.16666666666667, 1.54, 0.14583333333333
101149, 0.16666666666667, 1.56, 0.16666666666667
101150, 0.14583333333333, 1.58, 0.16666666666667
101151, 0.16666666666667, 1.58, 0.14583333333333
101152, 0.16666666666667, 1.6, 0.16666666666667
101153, 0.14583333333333, 1.62, 0.16666666666667
101154, 0.16666666666667, 1.62, 0.14583333333333
101155, 0.16666666666667, 1.64, 0.16666666666667
101156, 0.14583333333333, 1.66, 0.16666666666667
101157, 0.16666666666667, 1.66, 0.14583333333333
101158, 0.16666666666667, 1.68, 0.16666666666667
101159, 0.16666666666667, 1.52, 0.20833333333333
101160, 0.14583333333333, 1.54, 0.20833333333333
101161, 0.16666666666667, 1.54, 0.1875
101162, 0.16666666666667, 1.56, 0.20833333333333
101163, 0.14583333333333, 1.58, 0.20833333333333
101164, 0.16666666666667, 1.58, 0.1875
101165, 0.16666666666667, 1.6, 0.20833333333333
101166, 0.14583333333333, 1.62, 0.20833333333333
101167, 0.16666666666667, 1.62, 0.1875
101168, 0.16666666666667, 1.64, 0.20833333333333
101169, 0.14583333333333, 1.66, 0.20833333333333
101170, 0.16666666666667, 1.66, 0.1875
101171, 0.16666666666667, 1.68, 0.20833333333333
101172, 0.16666666666667, 1.52, 0.25
101173, 0.14583333333333, 1.54, 0.25
101174, 0.16666666666667, 1.54, 0.22916666666667
101175, 0.16666666666667, 1.56, 0.25
101176, 0.14583333333333, 1.58, 0.25
101177, 0.16666666666667, 1.58, 0.22916666666667
101178, 0.16666666666667, 1.6, 0.25
101179, 0.14583333333333, 1.62, 0.25
101180, 0.16666666666667, 1.62, 0.22916666666667
101181, 0.16666666666667, 1.64, 0.25
101182, 0.14583333333333, 1.66, 0.25
101183, 0.16666666666667, 1.66, 0.22916666666667
101184, 0.16666666666667, 1.68, 0.25
101185, 0.16666666666667, 1.52, 0.29166666666667
101186, 0.14583333333333, 1.54, 0.29166666666667
101187, 0.16666666666667, 1.54, 0.27083333333333
101188, 0.16666666666667, 1.56, 0.29166666666667
101189, 0.14583333333333, 1.58, 0.29166666666667
101190, 0.16666666666667, 1.58, 0.27083333333333
101191, 0.16666666666667, 1.6, 0.29166666666667
101192, 0.14583333333333, 1.62, 0.29166666666667
101193, 0.16666666666667, 1.62, 0.27083333333333
101194, 0.16666666666667, 1.64, 0.29166666666667
101195, 0.14583333333333, 1.66, 0.29166666666667
101196, 0.16666666666667, 1.66, 0.27083333333333
101197, 0.16666666666667, 1.68, 0.29166666666667
101198, 0.16666666666667, 1.52, 0.33333333333333
101199, 0.14583333333333, 1.54, 0.33333333333333
101200, 0.16666666666667, 1.54, 0.3125
101201, 0.16666666666667, 1.56, 0.33333333333333
101202, 0.14583333333333, 1.58, 0.33333333333333
101203, 0.16666666666667, 1.58, 0.3125
101204, 0.16666666666667, 1.6, 0.33333333333333
101205, 0.14583333333333, 1.62, 0.33333333333333
101206, 0.16666666666667, 1.62, 0.3125
101207, 0.16666666666667, 1.64, 0.33333333333333
101208, 0.14583333333333, 1.66, 0.33333333333333
101209, 0.16666666666667, 1.66, 0.3125
101210, 0.16666666666667, 1.68, 0.33333333333333
101211, 0.16666666666667, 1.52, 0.375
101212, 0.14583333333333, 1.54, 0.375
101213, 0.16666666666667, 1.54, 0.35416666666667
101214, 0.16666666666667, 1.56, 0.375
101215, 0.14583333333333, 1.58, 0.375
101216, 0.16666666666667, 1.58, 0.35416666666667
101217, 0.16666666666667, 1.6, 0.375
101218, 0.14583333333333, 1.62, 0.375
101219, 0.16666666666667, 1.62, 0.35416666666667
101220, 0.16666666666667, 1.64, 0.375
101221, 0.14583333333333, 1.66, 0.375
101222, 0.16666666666667, 1.66, 0.35416666666667
101223, 0.16666666666667, 1.68, 0.375
101224, 0.16666666666667, 1.52, 0.41666666666667
101225, 0.14583333333333, 1.54, 0.41666666666667
101226, 0.16666666666667, 1.54, 0.39583333333333
101227, 0.16666666666667, 1.56, 0.41666666666667
101228, 0.14583333333333, 1.58, 0.41666666666667
101229, 0.16666666666667, 1.58, 0.39583333333333
101230, 0.16666666666667, 1.6, 0.41666666666667
101231, 0.14583333333333, 1.62, 0.41666666666667
101232, 0.16666666666667, 1.62, 0.39583333333333
101233, 0.16666666666667, 1.64, 0.41666666666667
101234, 0.14583333333333, 1.66, 0.41666666666667
101235, 0.16666666666667, 1.66, 0.39583333333333
101236, 0.16666666666667, 1.68, 0.41666666666667
101237, 0.16666666666667, 1.52, 0.45833333333333
101238, 0.14583333333333, 1.54, 0.45833333333333
101239, 0.16666666666667, 1.54, 0.4375
101240, 0.16666666666667, 1.56, 0.45833333333333
101241, 0.14583333333333, 1.58, 0.45833333333333
101242, 0.16666666666667, 1.58, 0.4375
101243, 0.16666666666667, 1.6, 0.45833333333333
101244, 0.14583333333333, 1.62, 0.45833333333333
101245, 0.16666666666667, 1.62, 0.4375
101246, 0.16666666666667, 1.64, 0.45833333333333
101247, 0.14583333333333, 1.66, 0.45833333333333
101248, 0.16666666666667, 1.66, 0.4375
101249, 0.16666666666667, 1.68, 0.45833333333333
101250, 0.16666666666667, 1.54, 0.47916666666667
101251, 0.16666666666667, 1.58, 0.47916666666667
101252, 0.16666666666667, 1.62, 0.47916666666667
101253, 0.16666666666667, 1.66, 0.47916666666667
101254, 0.20833333333333, 1.52, 0.041666666666667
101255, 0.1875, 1.54, 0.041666666666667
101256, 0.20833333333333, 1.54, 0.020833333333333
101257, 0.20833333333333, 1.56, 0.041666666666667
101258, 0.1875, 1.58, 0.041666666666667
101259, 0.20833333333333, 1.58, 0.020833333333333
101260, 0.20833333333333, 1.6, 0.041666666666667
101261, 0.1875, 1.62, 0.041666666666667
101262, 0.20833333333333, 1.62, 0.020833333333333
101263, 0.20833333333333, 1.64, 0.041666666666667
101264, 0.1875, 1.66, 0.041666666666667
101265, 0.20833333333333, 1.66, 0.020833333333333
101266, 0.20833333333333, 1.68, 0.041666666666667
101267, 0.20833333333333, 1.52, 0.083333333333333
101268, 0.1875, 1.54, 0.083333333333333
101269, 0.20833333333333, 1.54, 0.0625
101270, 0.20833333333333, 1.56, 0.083333333333333
101271, 0.1875, 1.58, 0.083333333333333
101272, 0.20833333333333, 1.58, 0.0625
101273, 0.20833333333333, 1.6, 0.083333333333333
101274, 0.1875, 1.62, 0.083333333333333
101275, 0.20833333333333, 1.62, 0.0625
101276, 0.20833333333333, 1.64, 0.083333333333333
101277, 0.1875, 1.66, 0.083333333333333
101278, 0.20833333333333, 1.66, 0.0625
101279, 0.20833333333333, 1.68, 0.083333333333333
101280, 0.20833333333333, 1.52, 0.125
101281, 0.1875, 1.54, 0.125
101282, 0.20833333333333, 1.54, 0.10416666666667
101283, 0.20833333333333, 1.56, 0.125
101284, 0.1875, 1.58, 0.125
101285, 0.20833333333333, 1.58, 0.10416666666667
101286, 0.20833333333333, 1.6, 0.125
101287, 0.1875, 1.62, 0.125
101288, 0.20833333333333, 1.62, 0.10416666666667
101289, 0.20833333333333, 1.64, 0.125
101290, 0.1875, 1.66, 0.125
101291, 0.20833333333333, 1.66, 0.10416666666667
101292, 0.20833333333333, 1.68, 0.125
101293, 0.20833333333333, 1.52, 0.16666666666667
101294, 0.1875, 1.54, 0.16666666666667
101295, 0.20833333333333, 1.54, 0.14583333333333
101296, 0.20833333333333, 1.56, 0.16666666666667
101297, 0.1875, 1.58, 0.16666666666667
101298, 0.20833333333333, 1.58, 0.14583333333333
101299, 0.20833333333333, 1.6, 0.16666666666667
101300, 0.1875, 1.62, 0.16666666666667
101301, 0.20833333333333, 1.62, 0.14583333333333
101302, 0.20833333333333, 1.64, 0.16666666666667
101303, 0.1875, 1.66, 0.16666666666667
101304, 0.20833333333333, 1.66, 0.14583333333333
101305, 0.20833333333333, 1.68, 0.16666666666667
101306, 0.20833333333333, 1.52, 0.20833333333333
101307, 0.1875, 1.54, 0.20833333333333
101308, 0.20833333333333, 1.54, 0.1875
101309, 0.20833333333333, 1.56, 0.20833333333333
101310, 0.1875, 1.58, 0.20833333333333
101311, 0.20833333333333, 1.58, 0.1875
101312, 0.20833333333333, 1.6, 0.20833333333333
101313, 0.1875, 1.62, 0.20833333333333
101314, 0.20833333333333, 1.62, 0.1875
101315, 0.20833333333333, 1.64, 0.20833333333333
101316, 0.1875, 1.66, 0.20833333333333
101317, 0.20833333333333, 1.66, 0.1875
101318, 0.20833333333333, 1.68, 0.20833333333333
101319, 0.20833333333333, 1.52, 0.25
101320, 0.1875, 1.54, 0.25
101321, 0.20833333333333, 1.54, 0.22916666666667
101322, 0.20833333333333, 1.56, 0.25
101323, 0.1875, 1.58, 0.25
101324, 0.20833333333333, 1.58, 0.22916666666667
101325, 0.20833333333333, 1.6, 0.25
101326, 0.1875, 1.62, 0.25
101327, 0.20833333333333, 1.62, 0.22916666666667
101328, 0.20833333333333, 1.64, 0.25
101329, 0.1875, 1.66, 0.25
101330, 0.20833333333333, 1.66, 0.22916666666667
101331, 0.20833333333333, 1.68, 0.25
101332, 0.20833333333333, 1.52, 0.29166666666667
101333, 0.1875, 1.54, 0.29166666666667
101334, 0.20833333333333, 1.54, 0.27083333333333
101335, 0.20833333333333, 1.56, 0.29166666666667
101336, 0.1875, 1.58, 0.29166666666667
101337, 0.20833333333333, 1.58, 0.27083333333333
101338, 0.20833333333333, 1.6, 0.29166666666667
101339, 0.1875, 1.62, 0.29166666666667
101340, 0.20833333333333, 1.62, 0.27083333333333
101341, 0.20833333333333, 1.64, 0.29166666666667
101342, 0.1875, 1.66, 0.29166666666667
101343, 0.20833333333333, 1.66, 0.27083333333333
101344, 0.20833333333333, 1.68, 0.29166666666667
101345, 0.20833333333333, 1.52, 0.33333333333333
101346, 0.1875, 1.54, 0.33333333333333
101347, 0.20833333333333, 1.54, 0.3125
101348, 0.20833333333333, 1.56, 0.33333333333333
101349, 0.1875, 1.58, 0.33333333333333
101350, 0.20833333333333, 1.58, 0.3125
101351, 0.20833333333333, 1.6, 0.33333333333333
101352, 0.1875, 1.62, 0.33333333333333
101353, 0.20833333333333, 1.62, 0.3125
101354, 0.20833333333333, 1.64, 0.33333333333333
101355, 0.1875, 1.66, 0.33333333333333
101356, 0.20833333333333, 1.66, 0.3125
101357, 0.20833333333333, 1.68, 0.33333333333333
101358, 0.20833333333333, 1.52, 0.375
101359, 0.1875, 1.54, 0.375
101360, 0.20833333333333, 1.54, 0.35416666666667
101361, 0.20833333333333, 1.56, 0.375
101362, 0.1875, 1.58, 0.375
101363, 0.20833333333333, 1.58, 0.35416666666667
101364, 0.20833333333333, 1.6, 0.375
101365, 0.1875, 1.62, 0.375
101366, 0.20833333333333, 1.62, 0.35416666666667
101367, 0.20833333333333, 1.64, 0.375
101368, 0.1875, 1.66, 0.375
101369, 0.20833333333333, 1.66, 0.35416666666667
101370, 0.20833333333333, 1.68, 0.375
101371, 0.20833333333333, 1.52, 0.41666666666667
101372, 0.1875, 1.54, 0.41666666666667
101373, 0.20833333333333, 1.54, 0.39583333333333
101374, 0.20833333333333, 1.56, 0.41666666666667
101375, 0.1875, 1.58, 0.41666666666667
101376, 0.20833333333333, 1.58, 0.39583333333333
101377, 0.20833333333333, 1.6, 0.41666666666667
101378, 0.1875, 1.62, 0.41666666666667
101379, 0.20833333333333, 1.62, 0.39583333333333
101380, 0.20833333333333, 1.64, 0.41666666666667
101381, 0.1875, 1.66, 0.41666666666667
101382, 0.20833333333333, 1.66, 0.39583333333333
101383, 0.20833333333333, 1.68, 0.41666666666667
101384, 0.20833333333333, 1.52, 0.45833333333333
101385, 0.1875, 1.54, 0.45833333333333
101386, 0.20833333333333, 1.54, 0.4375
101387, 0.20833333333333, 1.56, 0.45833333333333
101388, 0.1875, 1.58, 0.45833333333333
101389, 0.20833333333333, 1.58, 0.4375
101390, 0.20833333333333, 1.6, 0.45833333333333
101391, 0.1875, 1.62, 0.45833333333333
101392, 0.20833333333333, 1.62, 0.4375
101393, 0.20833333333333, 1.64, 0.45833333333333
101394, 0.1875, 1.66, 0.45833333333333
101395, 0.20833333333333, 1.66, 0.4375
101396, 0.20833333333333, 1.68, 0.45833333333333
101397, 0.20833333333333, 1.54, 0.47916666666667
101398, 0.20833333333333, 1.58, 0.47916666666667
101399, 0.20833333333333, 1.62, 0.47916666666667
101400, 0.20833333333333, 1.66, 0.47916666666667
101401, 0.25, 1.52, 0.041666666666667
101402, 0.22916666666667, 1.54, 0.041666666666667
101403, 0.25, 1.54, 0.020833333333333
101404, 0.25, 1.56, 0.041666666666667
101405, 0.22916666666667, 1.58, 0.041666666666667
101406, 0.25, 1.58, 0.020833333333333
101407, 0.25, 1.6, 0.041666666666667
101408, 0.22916666666667, 1.62, 0.041666666666667
101409, 0.25, 1.62, 0.020833333333333
101410, 0.25, 1.64, 0.041666666666667
101411, 0.22916666666667, 1.66, 0.041666666666667
101412, 0.25, 1.66, 0.020833333333333
101413, 0.25, 1.68, 0.041666666666667
101414, 0.25, 1.52, 0.083333333333333
101415, 0.22916666666667, 1.54, 0.083333333333333
101416, 0.25, 1.54, 0.0625
101417, 0.25, 1.56, 0.083333333333333
101418, 0.22916666666667, 1.58, 0.083333333333333
101419, 0.25, 1.58, 0.0625
101420, 0.25, 1.6, 0.083333333333333
101421, 0.22916666666667, 1.62, 0.083333333333333
101422, 0.25, 1.62, 0.0625
101423, 0.25, 1.64, 0.083333333333333
101424, 0.22916666666667, 1.66, 0.083333333333333
101425, 0.25, 1.66, 0.0625
101426, 0.25, 1.68, 0.083333333333333
101427, 0.25, 1.52, 0.125
101428, 0.22916666666667, 1.54, 0.125
101429, 0.25, 1.54, 0.10416666666667
101430, 0.25, 1.56, 0.125
101431, 0.22916666666667, 1.58, 0.125
101432, 0.25, 1.58, 0.10416666666667
101433, 0.25, 1.6, 0.125
101434, 0.22916666666667, 1.62, 0.125
101435, 0.25, 1.62, 0.10416666666667
101436, 0.25, 1.64, 0.125
101437, 0.22916666666667, 1.66, 0.125
101438, 0.25, 1.66, 0.10416666666667
101439, 0.25, 1.68, 0.125
101440, 0.25, 1.52, 0.16666666666667
101441, 0.22916666666667, 1.54, 0.16666666666667
101442, 0.25, 1.54, 0.14583333333333
101443, 0.25, 1.56, 0.16666666666667
101444, 0.22916666666667, 1.58, 0.16666666666667
101445, 0.25, 1.58, 0.14583333333333
101446, 0.25, 1.6, 0.16666666666667
101447, 0.22916666666667, 1.62, 0.16666666666667
101448, 0.25, 1.62, 0.14583333333333
101449, 0.25, 1.64, 0.16666666666667
101450, 0.22916666666667, 1.66, 0.16666666666667
101451, 0.25, 1.66, 0.14583333333333
101452, 0.25, 1.68, 0.16666666666667
101453, 0.25, 1.52, 0.20833333333333
101454, 0.22916666666667, 1.54, 0.20833333333333
101455, 0.25, 1.54, 0.1875
101456, 0.25, 1.56, 0.20833333333333
101457, 0.22916666666667, 1.58, 0.20833333333333
101458, 0.25, 1.58, 0.1875
101459, 0.25, 1.6, 0.20833333333333
101460, 0.22916666666667, 1.62, 0.20833333333333
101461, 0.25, 1.62, 0.1875
101462, 0.25, 1.64, 0.20833333333333
101463, 0.22916666666667, 1.66, 0.20833333333333
101464, 0.25, 1.66, 0.1875
101465, 0.25, 1.68, 0.20833333333333
101466, 0.25, 1.52, 0.25
101467, 0.22916666666667, 1.54, 0.25
101468, 0.25, 1.54, 0.22916666666667
101469, 0.25, 1.56, 0.25
101470, 0.22916666666667, 1.58, 0.25
101471, 0.25, 1.58, 0.22916666666667
101472, 0.25, 1.6, 0.25
101473, 0.22916666666667, 1.62, 0.25
101474, 0.25, 1.62, 0.22916666666667
101475, 0.25, 1.64, 0.25
101476, 0.22916666666667, 1.66, 0.25
101477, 0.25, 1.66, 0.22916666666667
101478, 0.25, 1.68, 0.25
101479, 0.25, 1.52, 0.29166666666667
101480, 0.22916666666667, 1.54, 0.29166666666667
101481, 0.25, 1.54, 0.27083333333333
101482, 0.25, 1.56, 0.29166666666667
101483, 0.22916666666667, 1.58, 0.29166666666667
101484, 0.25, 1.58, 0.27083333333333
101485, 0.25, 1.6, 0.29166666666667
101486, 0.22916666666667, 1.62, 0.29166666666667
101487, 0.25, 1.62, 0.27083333333333
101488, 0.25, 1.64, 0.29166666666667
101489, 0.22916666666667, 1.66, 0.29166666666667
101490, 0.25, 1.66, 0.27083333333333
101491, 0.25, 1.68, 0.29166666666667
101492, 0.25, 1.52, 0.33333333333333
101493, 0.22916666666667, 1.54, 0.33333333333333
101494, 0.25, 1.54, 0.3125
101495, 0.25, 1.56, 0.33333333333333
101496, 0.22916666666667, 1.58, 0.33333333333333
101497, 0.25, 1.58, 0.3125
101498, 0.25, 1.6, 0.33333333333333
101499, 0.22916666666667, 1.62, 0.33333333333333
101500, 0.25, 1.62, 0.3125
101501, 0.25, 1.64, 0.33333333333333
101502, 0.22916666666667, 1.66, 0.33333333333333
101503, 0.25, 1.66, 0.3125
101504, 0.25, 1.68, 0.33333333333333
101505, 0.25, 1.52, 0.375
101506, 0.22916666666667, 1.54, 0.375
101507, 0.25, 1.54, 0.35416666666667
101508, 0.25, 1.56, 0.375
101509, 0.22916666666667, 1.58, 0.375
101510, 0.25, 1.58, 0.35416666666667
101511, 0.25, 1.6, 0.375
101512, 0.22916666666667, 1.62, 0.375
101513, 0.25, 1.62, 0.35416666666667
101514, 0.25, 1.64, 0.375
101515, 0.22916666666667, 1.66, 0.375
101516, 0.25, 1.66, 0.35416666666667
101517, 0.25, 1.68, 0.375
101518, 0.25, 1.52, 0.41666666666667
101519, 0.22916666666667, 1.54, 0.41666666666667
101520, 0.25, 1.54, 0.39583333333333
101521, 0.25, 1.56, 0.41666666666667
101522, 0.22916666666667, 1.58, 0.41666666666667
101523, 0.25, 1.58, 0.39583333333333
101524, 0.25, 1.6, 0.41666666666667
101525, 0.22916666666667, 1.62, 0.41666666666667
101526, 0.25, 1.62, 0.39583333333333
101527, 0.25, 1.64, 0.41666666666667
101528, 0.22916666666667, 1.66, 0.41666666666667
101529, 0.25, 1.66, 0.39583333333333
101530, 0.25, 1.68, 0.41666666666667
101531, 0.25, 1.52, 0.45833333333333
101532, 0.22916666666667, 1.54, 0.45833333333333
101533, 0.25, 1.54, 0.4375
101534, 0.25, 1.56, 0.45833333333333
101535, 0.22916666666667, 1.58, 0.45833333333333
101536, 0.25, 1.58, 0.4375
101537, 0.25, 1.6, 0.45833333333333
101538, 0.22916666666667, 1.62, 0.45833333333333
101539, 0.25, 1.62, 0.4375
101540, 0.25, 1.64, 0.45833333333333
101541, 0.22916666666667, 1.66, 0.45833333333333
101542, 0.25, 1.66, 0.4375
101543, 0.25, 1.68, 0.45833333333333
101544, 0.25, 1.54, 0.47916666666667
101545, 0.25, 1.58, 0.47916666666667
101546, 0.25, 1.62, 0.47916666666667
101547, 0.25, 1.66, 0.47916666666667
101548, 0.29166666666667, 1.52, 0.041666666666667
101549, 0.27083333333333, 1.54, 0.041666666666667
101550, 0.29166666666667, 1.54, 0.020833333333333
101551, 0.29166666666667, 1.56, 0.041666666666667
101552, 0.27083333333333, 1.58, 0.041666666666667
101553, 0.29166666666667, 1.58, 0.020833333333333
101554, 0.29166666666667, 1.6, 0.041666666666667
101555, 0.27083333333333, 1.62, 0.041666666666667
101556, 0.29166666666667, 1.62, 0.020833333333333
101557, 0.29166666666667, 1.64, 0.041666666666667
101558, 0.27083333333333, 1.66, 0.041666666666667
101559, 0.29166666666667, 1.66, 0.020833333333333
101560, 0.29166666666667, 1.68, 0.041666666666667
101561, 0.29166666666667, 1.52, 0.083333333333333
101562, 0.27083333333333, 1.54, 0.083333333333333
101563, 0.29166666666667, 1.54, 0.0625
101564, 0.29166666666667, 1.56, 0.083333333333333
101565, 0.27083333333333, 1.58, 0.083333333333333
101566, 0.29166666666667, 1.58, 0.0625
101567, 0.29166666666667, 1.6, 0.083333333333333
101568, 0.27083333333333, 1.62, 0.083333333333333
101569, 0.29166666666667, 1.62, 0.0625
101570, 0.29166666666667, 1.64, 0.083333333333333
101571, 0.27083333333333, 1.66, 0.083333333333333
101572, 0.29166666666667, 1.66, 0.0625
101573, 0.29166666666667, 1.68, 0.083333333333333
101574, 0.29166666666667, 1.52, 0.125
101575, 0.27083333333333, 1.54, 0.125
101576, 0.29166666666667, 1.54, 0.10416666666667
101577, 0.29166666666667, 1.56, 0.125
101578, 0.27083333333333, 1.58, 0.125
101579, 0.29166666666667, 1.58, 0.10416666666667
101580, 0.29166666666667, 1.6, 0.125
101581, 0.27083333333333, 1.62, 0.125
101582, 0.29166666666667, 1.62, 0.10416666666667
101583, 0.29166666666667, 1.64, 0.125
101584, 0.27083333333333, 1.66, 0.125
101585, 0.29166666666667, 1.66, 0.10416666666667
101586, 0.29166666666667, 1.68, 0.125
101587, 0.29166666666667, 1.52, 0.16666666666667
101588, 0.27083333333333, 1.54, 0.16666666666667
101589, 0.29166666666667, 1.54, 0.14583333333333
101590, 0.29166666666667, 1.56, 0.16666666666667
101591, 0.27083333333333, 1.58, 0.16666666666667
101592, 0.29166666666667, 1.58, 0.14583333333333
101593, 0.29166666666667, 1.6, 0.16666666666667
101594, 0.27083333333333, 1.62, 0.16666666666667
101595, 0.29166666666667, 1.62, 0.14583333333333
101596, 0.29166666666667, 1.64, 0.16666666666667
101597, 0.27083333333333, 1.66, 0.16666666666667
101598, 0.29166666666667, 1.66, 0.14583333333333
101599, 0.29166666666667, 1.68, 0.16666666666667
101600, 0.29166666666667, 1.52, 0.20833333333333
101601, 0.27083333333333, 1.54, 0.20833333333333
101602, 0.29166666666667, 1.54, 0.1875
101603, 0.29166666666667, 1.56, 0.20833333333333
101604, 0.27083333333333, 1.58, 0.20833333333333
101605, 0.29166666666667, 1.58, 0.1875
101606, 0.29166666666667, 1.6, 0.20833333333333
101607, 0.27083333333333, 1.62, 0.20833333333333
101608, 0.29166666666667, 1.62, 0.1875
101609, 0.29166666666667, 1.64, 0.20833333333333
101610, 0.27083333333333, 1.66, 0.20833333333333
101611, 0.29166666666667, 1.66, 0.1875
101612, 0.29166666666667, 1.68, 0.20833333333333
101613, 0.29166666666667, 1.52, 0.25
101614, 0.27083333333333, 1.54, 0.25
101615, 0.29166666666667, 1.54, 0.22916666666667
101616, 0.29166666666667, 1.56, 0.25
101617, 0.27083333333333, 1.58, 0.25
101618, 0.29166666666667, 1.58, 0.22916666666667
101619, 0.29166666666667, 1.6, 0.25
101620, 0.27083333333333, 1.62, 0.25
101621, 0.29166666666667, 1.62, 0.22916666666667
101622, 0.29166666666667, 1.64, 0.25
101623, 0.27083333333333, 1.66, 0.25
101624, 0.29166666666667, 1.66, 0.22916666666667
101625, 0.29166666666667, 1.68, 0.25
101626, 0.29166666666667, 1.52, 0.29166666666667
101627, 0.27083333333333, 1.54, 0.29166666666667
101628, 0.29166666666667, 1.54, 0.27083333333333
101629, 0.29166666666667, 1.56, 0.29166666666667
101630, 0.27083333333333, 1.58, 0.29166666666667
101631, 0.29166666666667, 1.58, 0.27083333333333
101632, 0.29166666666667, 1.6, 0.29166666666667
101633, 0.27083333333333, 1.62, 0.29166666666667
101634, 0.29166666666667, 1.62, 0.27083333333333
101635, 0.29166666666667, 1.64, 0.29166666666667
101636, 0.27083333333333, 1.66, 0.29166666666667
101637, 0.29166666666667, 1.66, 0.27083333333333
101638, 0.29166666666667, 1.68, 0.29166666666667
101639, 0.29166666666667, 1.52, 0.33333333333333
101640, 0.27083333333333, 1.54, 0.33333333333333
101641, 0.29166666666667, 1.54, 0.3125
101642, 0.29166666666667, 1.56, 0.33333333333333
101643, 0.27083333333333, 1.58, 0.33333333333333
101644, 0.29166666666667, 1.58, 0.3125
101645, 0.29166666666667, 1.6, 0.33333333333333
101646, 0.27083333333333, 1.62, 0.33333333333333
101647, 0.29166666666667, 1.62, 0.3125
101648, 0.29166666666667, 1.64, 0.33333333333333
101649, 0.27083333333333, 1.66, 0.33333333333333
101650, 0.29166666666667, 1.66, 0.3125
101651, 0.29166666666667, 1.68, 0.33333333333333
101652, 0.29166666666667, 1.52, 0.375
101653, 0.27083333333333, 1.54, 0.375
101654, 0.29166666666667, 1.54, 0.35416666666667
101655, 0.29166666666667, 1.56, 0.375
101656, 0.27083333333333, 1.58, 0.375
101657, 0.29166666666667, 1.58, 0.35416666666667
101658, 0.29166666666667, 1.6, 0.375
101659, 0.27083333333333, 1.62, 0.375
101660, 0.29166666666667, 1.62, 0.35416666666667
101661, 0.29166666666667, 1.64, 0.375
101662, 0.27083333333333, 1.66, 0.375
101663, 0.29166666666667, 1.66, 0.35416666666667
101664, 0.29166666666667, 1.68, 0.375
101665, 0.29166666666667, 1.52, 0.41666666666667
101666, 0.27083333333333, 1.54, 0.41666666666667
101667, 0.29166666666667, 1.54, 0.39583333333333
101668, 0.29166666666667, 1.56, 0.41666666666667
101669, 0.27083333333333, 1.58, 0.41666666666667
101670, 0.29166666666667, 1.58, 0.39583333333333
101671, 0.29166666666667, 1.6, 0.41666666666667
101672, 0.27083333333333, 1.62, 0.41666666666667
101673, 0.29166666666667, 1.62, 0.39583333333333
101674, 0.29166666666667, 1.64, 0.41666666666667
101675, 0.27083333333333, 1.66, 0.41666666666667
101676, 0.29166666666667, 1.66, 0.39583333333333
101677, 0.29166666666667, 1.68, 0.41666666666667
101678, 0.29166666666667, 1.52, 0.45833333333333
101679, 0.27083333333333, 1.54, 0.45833333333333
101680, 0.29166666666667, 1.54, 0.4375
101681, 0.29166666666667, 1.56, 0.45833333333333
101682, 0.27083333333333, 1.58, 0.45833333333333
101683, 0.29166666666667, 1.58, 0.4375
101684, 0.29166666666667, 1.6, 0.45833333333333
101685, 0.27083333333333, 1.62, 0.45833333333333
101686, 0.29166666666667, 1.62, 0.4375
101687, 0.29166666666667, 1.64, 0.45833333333333
101688, 0.27083333333333, 1.66, 0.45833333333333
101689, 0.29166666666667, 1.66, 0.4375
101690, 0.29166666666667, 1.68, 0.45833333333333
101691, 0.29166666666667, 1.54, 0.47916666666667
