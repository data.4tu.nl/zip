28346, 72703, 22093, 22116, 73232, 72704, 22094, 22117, 73233, 81834, 22444, 83467, 83402, 81835, 22446, 83468, 
83405, 81771, 22398, 22445, 83404
28347, 72704, 22094, 22117, 73233, 72705, 22095, 22118, 73234, 81835, 22446, 83468, 83405, 81836, 22448, 83469, 
83408, 81774, 22400, 22447, 83407
28348, 72705, 22095, 22118, 73234, 72706, 22096, 22119, 73235, 81836, 22448, 83469, 83408, 81837, 22450, 83470, 
83411, 81777, 22402, 22449, 83410
28349, 72706, 22096, 22119, 73235, 72707, 22097, 22120, 73236, 81837, 22450, 83470, 83411, 81838, 22452, 83471, 
83414, 81780, 22404, 22451, 83413
28350, 72707, 22097, 22120, 73236, 72708, 22098, 22121, 73237, 81838, 22452, 83471, 83414, 81839, 22454, 83472, 
83417, 81783, 22406, 22453, 83416
28351, 72708, 22098, 22121, 73237, 72709, 22099, 22122, 73238, 81839, 22454, 83472, 83417, 81840, 22456, 83473, 
83420, 81786, 22408, 22455, 83419
28352, 72709, 22099, 22122, 73238, 72710, 22100, 22123, 73239, 81840, 22456, 83473, 83420, 81841, 22458, 83474, 
83423, 81789, 22410, 22457, 83422
28353, 72710, 22100, 22123, 73239, 72711, 22101, 22124, 73240, 81841, 22458, 83474, 83423, 81842, 22460, 83475, 
83426, 81792, 22412, 22459, 83425
28354, 72711, 22101, 22124, 73240, 72712, 22102, 22125, 73241, 81842, 22460, 83475, 83426, 81843, 22462, 83476, 
83429, 81795, 22414, 22461, 83428
28355, 72712, 22102, 22125, 73241, 72713, 22103, 22126, 73242, 81843, 22462, 83476, 83429, 81844, 22464, 83477, 
83432, 81798, 22416, 22463, 83431
28356, 72713, 22103, 22126, 73242, 72714, 22104, 22127, 73243, 81844, 22464, 83477, 83432, 81845, 22466, 83478, 
83435, 81801, 22418, 22465, 83434
28357, 72714, 22104, 22127, 73243, 72715, 22105, 22128, 73244, 81845, 22466, 83478, 83435, 81846, 22468, 83479, 
83438, 81804, 22420, 22467, 83437
28358, 72715, 22105, 22128, 73244, 72716, 22106, 22129, 73245, 81846, 22468, 83479, 83438, 81847, 22470, 83480, 
83441, 81807, 22422, 22469, 83440
28359, 72716, 22106, 22129, 73245, 72717, 22107, 22130, 73246, 81847, 22470, 83480, 83441, 81848, 22472, 83481, 
83444, 81810, 22424, 22471, 83443
28360, 72717, 22107, 22130, 73246, 72718, 22108, 22131, 73247, 81848, 22472, 83481, 83444, 81849, 22474, 83482, 
83447, 81813, 22426, 22473, 83446
28361, 72718, 22108, 22131, 73247, 72719, 22109, 22132, 73248, 81849, 22474, 83482, 83447, 81850, 22476, 83483, 
83450, 81816, 22428, 22475, 83449
28362, 72719, 22109, 22132, 73248, 72720, 22110, 22133, 73249, 81850, 22476, 83483, 83450, 81851, 22478, 83484, 
83453, 81819, 22430, 22477, 83452
28363, 72720, 22110, 22133, 73249, 72721, 22111, 22134, 73250, 81851, 22478, 83484, 83453, 81852, 22480, 83485, 
83456, 81822, 22432, 22479, 83455
28364, 72721, 22111, 22134, 73250, 72722, 22112, 22135, 73251, 81852, 22480, 83485, 83456, 81853, 22482, 83486, 
83459, 81825, 22434, 22481, 83458
28365, 72722, 22112, 22135, 73251, 72723, 22113, 22136, 73252, 81853, 22482, 83486, 83459, 81854, 22484, 83487, 
83462, 81828, 22436, 22483, 83461
28366, 72723, 22113, 22136, 73252, 22906, 1960, 1961, 22929, 81854, 22484, 83487, 83462, 23231, 1972, 23278, 
23276, 81831, 22438, 22485, 83464
28367, 1610, 17262, 17285, 1611, 21321, 72724, 73253, 21344, 17588, 17634, 17635, 1622, 81857, 83489, 83490, 
21693, 21647, 81855, 83488, 21694
28368, 21321, 72724, 73253, 21344, 21322, 72725, 73254, 21345, 81857, 83489, 83490, 21693, 81860, 83492, 83493, 
21695, 21649, 81858, 83491, 21696
28369, 21322, 72725, 73254, 21345, 21323, 72726, 73255, 21346, 81860, 83492, 83493, 21695, 81863, 83495, 83496, 
21697, 21651, 81861, 83494, 21698
28370, 21323, 72726, 73255, 21346, 21324, 72727, 73256, 21347, 81863, 83495, 83496, 21697, 81866, 83498, 83499, 
21699, 21653, 81864, 83497, 21700
28371, 21324, 72727, 73256, 21347, 21325, 72728, 73257, 21348, 81866, 83498, 83499, 21699, 81869, 83501, 83502, 
21701, 21655, 81867, 83500, 21702
28372, 21325, 72728, 73257, 21348, 21326, 72729, 73258, 21349, 81869, 83501, 83502, 21701, 81872, 83504, 83505, 
21703, 21657, 81870, 83503, 21704
28373, 21326, 72729, 73258, 21349, 21327, 72730, 73259, 21350, 81872, 83504, 83505, 21703, 81875, 83507, 83508, 
21705, 21659, 81873, 83506, 21706
28374, 21327, 72730, 73259, 21350, 21328, 72731, 73260, 21351, 81875, 83507, 83508, 21705, 81878, 83510, 83511, 
21707, 21661, 81876, 83509, 21708
28375, 21328, 72731, 73260, 21351, 21329, 72732, 73261, 21352, 81878, 83510, 83511, 21707, 81881, 83513, 83514, 
21709, 21663, 81879, 83512, 21710
28376, 21329, 72732, 73261, 21352, 21330, 72733, 73262, 21353, 81881, 83513, 83514, 21709, 81884, 83516, 83517, 
21711, 21665, 81882, 83515, 21712
28377, 21330, 72733, 73262, 21353, 21331, 72734, 73263, 21354, 81884, 83516, 83517, 21711, 81887, 83519, 83520, 
21713, 21667, 81885, 83518, 21714
28378, 21331, 72734, 73263, 21354, 21332, 72735, 73264, 21355, 81887, 83519, 83520, 21713, 81890, 83522, 83523, 
21715, 21669, 81888, 83521, 21716
28379, 21332, 72735, 73264, 21355, 21333, 72736, 73265, 21356, 81890, 83522, 83523, 21715, 81893, 83525, 83526, 
21717, 21671, 81891, 83524, 21718
28380, 21333, 72736, 73265, 21356, 21334, 72737, 73266, 21357, 81893, 83525, 83526, 21717, 81896, 83528, 83529, 
21719, 21673, 81894, 83527, 21720
28381, 21334, 72737, 73266, 21357, 21335, 72738, 73267, 21358, 81896, 83528, 83529, 21719, 81899, 83531, 83532, 
21721, 21675, 81897, 83530, 21722
28382, 21335, 72738, 73267, 21358, 21336, 72739, 73268, 21359, 81899, 83531, 83532, 21721, 81902, 83534, 83535, 
21723, 21677, 81900, 83533, 21724
28383, 21336, 72739, 73268, 21359, 21337, 72740, 73269, 21360, 81902, 83534, 83535, 21723, 81905, 83537, 83538, 
21725, 21679, 81903, 83536, 21726
28384, 21337, 72740, 73269, 21360, 21338, 72741, 73270, 21361, 81905, 83537, 83538, 21725, 81908, 83540, 83541, 
21727, 21681, 81906, 83539, 21728
28385, 21338, 72741, 73270, 21361, 21339, 72742, 73271, 21362, 81908, 83540, 83541, 21727, 81911, 83543, 83544, 
21729, 21683, 81909, 83542, 21730
28386, 21339, 72742, 73271, 21362, 21340, 72743, 73272, 21363, 81911, 83543, 83544, 21729, 81914, 83546, 83547, 
21731, 21685, 81912, 83545, 21732
28387, 21340, 72743, 73272, 21363, 21341, 72744, 73273, 21364, 81914, 83546, 83547, 21731, 81917, 83549, 83550, 
21733, 21687, 81915, 83548, 21734
28388, 21341, 72744, 73273, 21364, 21342, 72745, 73274, 21365, 81917, 83549, 83550, 21733, 81920, 83552, 83553, 
21735, 21689, 81918, 83551, 21736
28389, 21342, 72745, 73274, 21365, 21343, 72746, 73275, 21366, 81920, 83552, 83553, 21735, 81923, 83555, 83556, 
21737, 21691, 81921, 83554, 21738
28390, 21343, 72746, 73275, 21366, 1938, 22907, 22930, 1939, 81923, 83555, 83556, 21737, 23233, 23279, 23280, 
1950, 21692, 81924, 83557, 21739
28391, 17262, 17263, 17286, 17285, 72724, 72747, 73276, 73253, 17590, 17636, 17637, 17634, 81927, 83559, 83560, 
83489, 81855, 81925, 83558, 83488
28392, 72724, 72747, 73276, 73253, 72725, 72748, 73277, 73254, 81927, 83559, 83560, 83489, 81930, 83562, 83563, 
83492, 81858, 81928, 83561, 83491
28393, 72725, 72748, 73277, 73254, 72726, 72749, 73278, 73255, 81930, 83562, 83563, 83492, 81933, 83565, 83566, 
83495, 81861, 81931, 83564, 83494
28394, 72726, 72749, 73278, 73255, 72727, 72750, 73279, 73256, 81933, 83565, 83566, 83495, 81936, 83568, 83569, 
83498, 81864, 81934, 83567, 83497
28395, 72727, 72750, 73279, 73256, 72728, 72751, 73280, 73257, 81936, 83568, 83569, 83498, 81939, 83571, 83572, 
83501, 81867, 81937, 83570, 83500
28396, 72728, 72751, 73280, 73257, 72729, 72752, 73281, 73258, 81939, 83571, 83572, 83501, 81942, 83574, 83575, 
83504, 81870, 81940, 83573, 83503
28397, 72729, 72752, 73281, 73258, 72730, 72753, 73282, 73259, 81942, 83574, 83575, 83504, 81945, 83577, 83578, 
83507, 81873, 81943, 83576, 83506
28398, 72730, 72753, 73282, 73259, 72731, 72754, 73283, 73260, 81945, 83577, 83578, 83507, 81948, 83580, 83581, 
83510, 81876, 81946, 83579, 83509
28399, 72731, 72754, 73283, 73260, 72732, 72755, 73284, 73261, 81948, 83580, 83581, 83510, 81951, 83583, 83584, 
83513, 81879, 81949, 83582, 83512
28400, 72732, 72755, 73284, 73261, 72733, 72756, 73285, 73262, 81951, 83583, 83584, 83513, 81954, 83586, 83587, 
83516, 81882, 81952, 83585, 83515
28401, 72733, 72756, 73285, 73262, 72734, 72757, 73286, 73263, 81954, 83586, 83587, 83516, 81957, 83589, 83590, 
83519, 81885, 81955, 83588, 83518
28402, 72734, 72757, 73286, 73263, 72735, 72758, 73287, 73264, 81957, 83589, 83590, 83519, 81960, 83592, 83593, 
83522, 81888, 81958, 83591, 83521
28403, 72735, 72758, 73287, 73264, 72736, 72759, 73288, 73265, 81960, 83592, 83593, 83522, 81963, 83595, 83596, 
83525, 81891, 81961, 83594, 83524
28404, 72736, 72759, 73288, 73265, 72737, 72760, 73289, 73266, 81963, 83595, 83596, 83525, 81966, 83598, 83599, 
83528, 81894, 81964, 83597, 83527
28405, 72737, 72760, 73289, 73266, 72738, 72761, 73290, 73267, 81966, 83598, 83599, 83528, 81969, 83601, 83602, 
83531, 81897, 81967, 83600, 83530
28406, 72738, 72761, 73290, 73267, 72739, 72762, 73291, 73268, 81969, 83601, 83602, 83531, 81972, 83604, 83605, 
83534, 81900, 81970, 83603, 83533
28407, 72739, 72762, 73291, 73268, 72740, 72763, 73292, 73269, 81972, 83604, 83605, 83534, 81975, 83607, 83608, 
83537, 81903, 81973, 83606, 83536
28408, 72740, 72763, 73292, 73269, 72741, 72764, 73293, 73270, 81975, 83607, 83608, 83537, 81978, 83610, 83611, 
83540, 81906, 81976, 83609, 83539
28409, 72741, 72764, 73293, 73270, 72742, 72765, 73294, 73271, 81978, 83610, 83611, 83540, 81981, 83613, 83614, 
83543, 81909, 81979, 83612, 83542
28410, 72742, 72765, 73294, 73271, 72743, 72766, 73295, 73272, 81981, 83613, 83614, 83543, 81984, 83616, 83617, 
83546, 81912, 81982, 83615, 83545
28411, 72743, 72766, 73295, 73272, 72744, 72767, 73296, 73273, 81984, 83616, 83617, 83546, 81987, 83619, 83620, 
83549, 81915, 81985, 83618, 83548
28412, 72744, 72767, 73296, 73273, 72745, 72768, 73297, 73274, 81987, 83619, 83620, 83549, 81990, 83622, 83623, 
83552, 81918, 81988, 83621, 83551
28413, 72745, 72768, 73297, 73274, 72746, 72769, 73298, 73275, 81990, 83622, 83623, 83552, 81993, 83625, 83626, 
83555, 81921, 81991, 83624, 83554
28414, 72746, 72769, 73298, 73275, 22907, 22908, 22931, 22930, 81993, 83625, 83626, 83555, 23235, 23281, 23282, 
23279, 81924, 81994, 83627, 83557
28415, 17263, 17264, 17287, 17286, 72747, 72770, 73299, 73276, 17592, 17638, 17639, 17636, 81997, 83629, 83630, 
83559, 81925, 81995, 83628, 83558
28416, 72747, 72770, 73299, 73276, 72748, 72771, 73300, 73277, 81997, 83629, 83630, 83559, 82000, 83632, 83633, 
83562, 81928, 81998, 83631, 83561
28417, 72748, 72771, 73300, 73277, 72749, 72772, 73301, 73278, 82000, 83632, 83633, 83562, 82003, 83635, 83636, 
83565, 81931, 82001, 83634, 83564
28418, 72749, 72772, 73301, 73278, 72750, 72773, 73302, 73279, 82003, 83635, 83636, 83565, 82006, 83638, 83639, 
83568, 81934, 82004, 83637, 83567
28419, 72750, 72773, 73302, 73279, 72751, 72774, 73303, 73280, 82006, 83638, 83639, 83568, 82009, 83641, 83642, 
83571, 81937, 82007, 83640, 83570
28420, 72751, 72774, 73303, 73280, 72752, 72775, 73304, 73281, 82009, 83641, 83642, 83571, 82012, 83644, 83645, 
83574, 81940, 82010, 83643, 83573
28421, 72752, 72775, 73304, 73281, 72753, 72776, 73305, 73282, 82012, 83644, 83645, 83574, 82015, 83647, 83648, 
83577, 81943, 82013, 83646, 83576
28422, 72753, 72776, 73305, 73282, 72754, 72777, 73306, 73283, 82015, 83647, 83648, 83577, 82018, 83650, 83651, 
83580, 81946, 82016, 83649, 83579
28423, 72754, 72777, 73306, 73283, 72755, 72778, 73307, 73284, 82018, 83650, 83651, 83580, 82021, 83653, 83654, 
83583, 81949, 82019, 83652, 83582
28424, 72755, 72778, 73307, 73284, 72756, 72779, 73308, 73285, 82021, 83653, 83654, 83583, 82024, 83656, 83657, 
83586, 81952, 82022, 83655, 83585
28425, 72756, 72779, 73308, 73285, 72757, 72780, 73309, 73286, 82024, 83656, 83657, 83586, 82027, 83659, 83660, 
83589, 81955, 82025, 83658, 83588
28426, 72757, 72780, 73309, 73286, 72758, 72781, 73310, 73287, 82027, 83659, 83660, 83589, 82030, 83662, 83663, 
83592, 81958, 82028, 83661, 83591
28427, 72758, 72781, 73310, 73287, 72759, 72782, 73311, 73288, 82030, 83662, 83663, 83592, 82033, 83665, 83666, 
83595, 81961, 82031, 83664, 83594
28428, 72759, 72782, 73311, 73288, 72760, 72783, 73312, 73289, 82033, 83665, 83666, 83595, 82036, 83668, 83669, 
83598, 81964, 82034, 83667, 83597
28429, 72760, 72783, 73312, 73289, 72761, 72784, 73313, 73290, 82036, 83668, 83669, 83598, 82039, 83671, 83672, 
83601, 81967, 82037, 83670, 83600
28430, 72761, 72784, 73313, 73290, 72762, 72785, 73314, 73291, 82039, 83671, 83672, 83601, 82042, 83674, 83675, 
83604, 81970, 82040, 83673, 83603
28431, 72762, 72785, 73314, 73291, 72763, 72786, 73315, 73292, 82042, 83674, 83675, 83604, 82045, 83677, 83678, 
83607, 81973, 82043, 83676, 83606
28432, 72763, 72786, 73315, 73292, 72764, 72787, 73316, 73293, 82045, 83677, 83678, 83607, 82048, 83680, 83681, 
83610, 81976, 82046, 83679, 83609
28433, 72764, 72787, 73316, 73293, 72765, 72788, 73317, 73294, 82048, 83680, 83681, 83610, 82051, 83683, 83684, 
83613, 81979, 82049, 83682, 83612
28434, 72765, 72788, 73317, 73294, 72766, 72789, 73318, 73295, 82051, 83683, 83684, 83613, 82054, 83686, 83687, 
83616, 81982, 82052, 83685, 83615
28435, 72766, 72789, 73318, 73295, 72767, 72790, 73319, 73296, 82054, 83686, 83687, 83616, 82057, 83689, 83690, 
83619, 81985, 82055, 83688, 83618
28436, 72767, 72790, 73319, 73296, 72768, 72791, 73320, 73297, 82057, 83689, 83690, 83619, 82060, 83692, 83693, 
83622, 81988, 82058, 83691, 83621
28437, 72768, 72791, 73320, 73297, 72769, 72792, 73321, 73298, 82060, 83692, 83693, 83622, 82063, 83695, 83696, 
83625, 81991, 82061, 83694, 83624
28438, 72769, 72792, 73321, 73298, 22908, 22909, 22932, 22931, 82063, 83695, 83696, 83625, 23237, 23283, 23284, 
23281, 81994, 82064, 83697, 83627
28439, 17264, 17265, 17288, 17287, 72770, 72793, 73322, 73299, 17594, 17640, 17641, 17638, 82067, 83699, 83700, 
83629, 81995, 82065, 83698, 83628
28440, 72770, 72793, 73322, 73299, 72771, 72794, 73323, 73300, 82067, 83699, 83700, 83629, 82070, 83702, 83703, 
83632, 81998, 82068, 83701, 83631
28441, 72771, 72794, 73323, 73300, 72772, 72795, 73324, 73301, 82070, 83702, 83703, 83632, 82073, 83705, 83706, 
83635, 82001, 82071, 83704, 83634
28442, 72772, 72795, 73324, 73301, 72773, 72796, 73325, 73302, 82073, 83705, 83706, 83635, 82076, 83708, 83709, 
83638, 82004, 82074, 83707, 83637
28443, 72773, 72796, 73325, 73302, 72774, 72797, 73326, 73303, 82076, 83708, 83709, 83638, 82079, 83711, 83712, 
83641, 82007, 82077, 83710, 83640
28444, 72774, 72797, 73326, 73303, 72775, 72798, 73327, 73304, 82079, 83711, 83712, 83641, 82082, 83714, 83715, 
83644, 82010, 82080, 83713, 83643
28445, 72775, 72798, 73327, 73304, 72776, 72799, 73328, 73305, 82082, 83714, 83715, 83644, 82085, 83717, 83718, 
83647, 82013, 82083, 83716, 83646
28446, 72776, 72799, 73328, 73305, 72777, 72800, 73329, 73306, 82085, 83717, 83718, 83647, 82088, 83720, 83721, 
83650, 82016, 82086, 83719, 83649
28447, 72777, 72800, 73329, 73306, 72778, 72801, 73330, 73307, 82088, 83720, 83721, 83650, 82091, 83723, 83724, 
83653, 82019, 82089, 83722, 83652
28448, 72778, 72801, 73330, 73307, 72779, 72802, 73331, 73308, 82091, 83723, 83724, 83653, 82094, 83726, 83727, 
83656, 82022, 82092, 83725, 83655
28449, 72779, 72802, 73331, 73308, 72780, 72803, 73332, 73309, 82094, 83726, 83727, 83656, 82097, 83729, 83730, 
83659, 82025, 82095, 83728, 83658
28450, 72780, 72803, 73332, 73309, 72781, 72804, 73333, 73310, 82097, 83729, 83730, 83659, 82100, 83732, 83733, 
83662, 82028, 82098, 83731, 83661
28451, 72781, 72804, 73333, 73310, 72782, 72805, 73334, 73311, 82100, 83732, 83733, 83662, 82103, 83735, 83736, 
83665, 82031, 82101, 83734, 83664
28452, 72782, 72805, 73334, 73311, 72783, 72806, 73335, 73312, 82103, 83735, 83736, 83665, 82106, 83738, 83739, 
83668, 82034, 82104, 83737, 83667
28453, 72783, 72806, 73335, 73312, 72784, 72807, 73336, 73313, 82106, 83738, 83739, 83668, 82109, 83741, 83742, 
83671, 82037, 82107, 83740, 83670
28454, 72784, 72807, 73336, 73313, 72785, 72808, 73337, 73314, 82109, 83741, 83742, 83671, 82112, 83744, 83745, 
83674, 82040, 82110, 83743, 83673
28455, 72785, 72808, 73337, 73314, 72786, 72809, 73338, 73315, 82112, 83744, 83745, 83674, 82115, 83747, 83748, 
83677, 82043, 82113, 83746, 83676
28456, 72786, 72809, 73338, 73315, 72787, 72810, 73339, 73316, 82115, 83747, 83748, 83677, 82118, 83750, 83751, 
83680, 82046, 82116, 83749, 83679
28457, 72787, 72810, 73339, 73316, 72788, 72811, 73340, 73317, 82118, 83750, 83751, 83680, 82121, 83753, 83754, 
83683, 82049, 82119, 83752, 83682
28458, 72788, 72811, 73340, 73317, 72789, 72812, 73341, 73318, 82121, 83753, 83754, 83683, 82124, 83756, 83757, 
83686, 82052, 82122, 83755, 83685
28459, 72789, 72812, 73341, 73318, 72790, 72813, 73342, 73319, 82124, 83756, 83757, 83686, 82127, 83759, 83760, 
83689, 82055, 82125, 83758, 83688
28460, 72790, 72813, 73342, 73319, 72791, 72814, 73343, 73320, 82127, 83759, 83760, 83689, 82130, 83762, 83763, 
83692, 82058, 82128, 83761, 83691
28461, 72791, 72814, 73343, 73320, 72792, 72815, 73344, 73321, 82130, 83762, 83763, 83692, 82133, 83765, 83766, 
83695, 82061, 82131, 83764, 83694
28462, 72792, 72815, 73344, 73321, 22909, 22910, 22933, 22932, 82133, 83765, 83766, 83695, 23239, 23285, 23286, 
23283, 82064, 82134, 83767, 83697
28463, 17265, 17266, 17289, 17288, 72793, 72816, 73345, 73322, 17596, 17642, 17643, 17640, 82137, 83769, 83770, 
83699, 82065, 82135, 83768, 83698
28464, 72793, 72816, 73345, 73322, 72794, 72817, 73346, 73323, 82137, 83769, 83770, 83699, 82140, 83772, 83773, 
83702, 82068, 82138, 83771, 83701
28465, 72794, 72817, 73346, 73323, 72795, 72818, 73347, 73324, 82140, 83772, 83773, 83702, 82143, 83775, 83776, 
83705, 82071, 82141, 83774, 83704
28466, 72795, 72818, 73347, 73324, 72796, 72819, 73348, 73325, 82143, 83775, 83776, 83705, 82146, 83778, 83779, 
83708, 82074, 82144, 83777, 83707
28467, 72796, 72819, 73348, 73325, 72797, 72820, 73349, 73326, 82146, 83778, 83779, 83708, 82149, 83781, 83782, 
83711, 82077, 82147, 83780, 83710
28468, 72797, 72820, 73349, 73326, 72798, 72821, 73350, 73327, 82149, 83781, 83782, 83711, 82152, 83784, 83785, 
83714, 82080, 82150, 83783, 83713
28469, 72798, 72821, 73350, 73327, 72799, 72822, 73351, 73328, 82152, 83784, 83785, 83714, 82155, 83787, 83788, 
83717, 82083, 82153, 83786, 83716
28470, 72799, 72822, 73351, 73328, 72800, 72823, 73352, 73329, 82155, 83787, 83788, 83717, 82158, 83790, 83791, 
83720, 82086, 82156, 83789, 83719
28471, 72800, 72823, 73352, 73329, 72801, 72824, 73353, 73330, 82158, 83790, 83791, 83720, 82161, 83793, 83794, 
83723, 82089, 82159, 83792, 83722
28472, 72801, 72824, 73353, 73330, 72802, 72825, 73354, 73331, 82161, 83793, 83794, 83723, 82164, 83796, 83797, 
83726, 82092, 82162, 83795, 83725
28473, 72802, 72825, 73354, 73331, 72803, 72826, 73355, 73332, 82164, 83796, 83797, 83726, 82167, 83799, 83800, 
83729, 82095, 82165, 83798, 83728
28474, 72803, 72826, 73355, 73332, 72804, 72827, 73356, 73333, 82167, 83799, 83800, 83729, 82170, 83802, 83803, 
83732, 82098, 82168, 83801, 83731
28475, 72804, 72827, 73356, 73333, 72805, 72828, 73357, 73334, 82170, 83802, 83803, 83732, 82173, 83805, 83806, 
83735, 82101, 82171, 83804, 83734
28476, 72805, 72828, 73357, 73334, 72806, 72829, 73358, 73335, 82173, 83805, 83806, 83735, 82176, 83808, 83809, 
83738, 82104, 82174, 83807, 83737
28477, 72806, 72829, 73358, 73335, 72807, 72830, 73359, 73336, 82176, 83808, 83809, 83738, 82179, 83811, 83812, 
83741, 82107, 82177, 83810, 83740
28478, 72807, 72830, 73359, 73336, 72808, 72831, 73360, 73337, 82179, 83811, 83812, 83741, 82182, 83814, 83815, 
83744, 82110, 82180, 83813, 83743
28479, 72808, 72831, 73360, 73337, 72809, 72832, 73361, 73338, 82182, 83814, 83815, 83744, 82185, 83817, 83818, 
83747, 82113, 82183, 83816, 83746
28480, 72809, 72832, 73361, 73338, 72810, 72833, 73362, 73339, 82185, 83817, 83818, 83747, 82188, 83820, 83821, 
83750, 82116, 82186, 83819, 83749
28481, 72810, 72833, 73362, 73339, 72811, 72834, 73363, 73340, 82188, 83820, 83821, 83750, 82191, 83823, 83824, 
83753, 82119, 82189, 83822, 83752
28482, 72811, 72834, 73363, 73340, 72812, 72835, 73364, 73341, 82191, 83823, 83824, 83753, 82194, 83826, 83827, 
83756, 82122, 82192, 83825, 83755
28483, 72812, 72835, 73364, 73341, 72813, 72836, 73365, 73342, 82194, 83826, 83827, 83756, 82197, 83829, 83830, 
83759, 82125, 82195, 83828, 83758
28484, 72813, 72836, 73365, 73342, 72814, 72837, 73366, 73343, 82197, 83829, 83830, 83759, 82200, 83832, 83833, 
83762, 82128, 82198, 83831, 83761
28485, 72814, 72837, 73366, 73343, 72815, 72838, 73367, 73344, 82200, 83832, 83833, 83762, 82203, 83835, 83836, 
83765, 82131, 82201, 83834, 83764
28486, 72815, 72838, 73367, 73344, 22910, 22911, 22934, 22933, 82203, 83835, 83836, 83765, 23241, 23287, 23288, 
23285, 82134, 82204, 83837, 83767
28487, 17266, 17267, 17290, 17289, 72816, 72839, 73368, 73345, 17598, 17644, 17645, 17642, 82207, 83839, 83840, 
83769, 82135, 82205, 83838, 83768
28488, 72816, 72839, 73368, 73345, 72817, 72840, 73369, 73346, 82207, 83839, 83840, 83769, 82210, 83842, 83843, 
83772, 82138, 82208, 83841, 83771
28489, 72817, 72840, 73369, 73346, 72818, 72841, 73370, 73347, 82210, 83842, 83843, 83772, 82213, 83845, 83846, 
83775, 82141, 82211, 83844, 83774
28490, 72818, 72841, 73370, 73347, 72819, 72842, 73371, 73348, 82213, 83845, 83846, 83775, 82216, 83848, 83849, 
83778, 82144, 82214, 83847, 83777
28491, 72819, 72842, 73371, 73348, 72820, 72843, 73372, 73349, 82216, 83848, 83849, 83778, 82219, 83851, 83852, 
83781, 82147, 82217, 83850, 83780
28492, 72820, 72843, 73372, 73349, 72821, 72844, 73373, 73350, 82219, 83851, 83852, 83781, 82222, 83854, 83855, 
83784, 82150, 82220, 83853, 83783
28493, 72821, 72844, 73373, 73350, 72822, 72845, 73374, 73351, 82222, 83854, 83855, 83784, 82225, 83857, 83858, 
83787, 82153, 82223, 83856, 83786
28494, 72822, 72845, 73374, 73351, 72823, 72846, 73375, 73352, 82225, 83857, 83858, 83787, 82228, 83860, 83861, 
83790, 82156, 82226, 83859, 83789
28495, 72823, 72846, 73375, 73352, 72824, 72847, 73376, 73353, 82228, 83860, 83861, 83790, 82231, 83863, 83864, 
83793, 82159, 82229, 83862, 83792
28496, 72824, 72847, 73376, 73353, 72825, 72848, 73377, 73354, 82231, 83863, 83864, 83793, 82234, 83866, 83867, 
83796, 82162, 82232, 83865, 83795
28497, 72825, 72848, 73377, 73354, 72826, 72849, 73378, 73355, 82234, 83866, 83867, 83796, 82237, 83869, 83870, 
83799, 82165, 82235, 83868, 83798
28498, 72826, 72849, 73378, 73355, 72827, 72850, 73379, 73356, 82237, 83869, 83870, 83799, 82240, 83872, 83873, 
83802, 82168, 82238, 83871, 83801
28499, 72827, 72850, 73379, 73356, 72828, 72851, 73380, 73357, 82240, 83872, 83873, 83802, 82243, 83875, 83876, 
83805, 82171, 82241, 83874, 83804
28500, 72828, 72851, 73380, 73357, 72829, 72852, 73381, 73358, 82243, 83875, 83876, 83805, 82246, 83878, 83879, 
83808, 82174, 82244, 83877, 83807
28501, 72829, 72852, 73381, 73358, 72830, 72853, 73382, 73359, 82246, 83878, 83879, 83808, 82249, 83881, 83882, 
83811, 82177, 82247, 83880, 83810
28502, 72830, 72853, 73382, 73359, 72831, 72854, 73383, 73360, 82249, 83881, 83882, 83811, 82252, 83884, 83885, 
83814, 82180, 82250, 83883, 83813
28503, 72831, 72854, 73383, 73360, 72832, 72855, 73384, 73361, 82252, 83884, 83885, 83814, 82255, 83887, 83888, 
83817, 82183, 82253, 83886, 83816
28504, 72832, 72855, 73384, 73361, 72833, 72856, 73385, 73362, 82255, 83887, 83888, 83817, 82258, 83890, 83891, 
83820, 82186, 82256, 83889, 83819
28505, 72833, 72856, 73385, 73362, 72834, 72857, 73386, 73363, 82258, 83890, 83891, 83820, 82261, 83893, 83894, 
83823, 82189, 82259, 83892, 83822
28506, 72834, 72857, 73386, 73363, 72835, 72858, 73387, 73364, 82261, 83893, 83894, 83823, 82264, 83896, 83897, 
83826, 82192, 82262, 83895, 83825
28507, 72835, 72858, 73387, 73364, 72836, 72859, 73388, 73365, 82264, 83896, 83897, 83826, 82267, 83899, 83900, 
83829, 82195, 82265, 83898, 83828
28508, 72836, 72859, 73388, 73365, 72837, 72860, 73389, 73366, 82267, 83899, 83900, 83829, 82270, 83902, 83903, 
83832, 82198, 82268, 83901, 83831
28509, 72837, 72860, 73389, 73366, 72838, 72861, 73390, 73367, 82270, 83902, 83903, 83832, 82273, 83905, 83906, 
83835, 82201, 82271, 83904, 83834
28510, 72838, 72861, 73390, 73367, 22911, 22912, 22935, 22934, 82273, 83905, 83906, 83835, 23243, 23289, 23290, 
23287, 82204, 82274, 83907, 83837
28511, 17267, 17268, 17291, 17290, 72839, 72862, 73391, 73368, 17600, 17646, 17647, 17644, 82277, 83909, 83910, 
83839, 82205, 82275, 83908, 83838
28512, 72839, 72862, 73391, 73368, 72840, 72863, 73392, 73369, 82277, 83909, 83910, 83839, 82280, 83912, 83913, 
83842, 82208, 82278, 83911, 83841
28513, 72840, 72863, 73392, 73369, 72841, 72864, 73393, 73370, 82280, 83912, 83913, 83842, 82283, 83915, 83916, 
83845, 82211, 82281, 83914, 83844
28514, 72841, 72864, 73393, 73370, 72842, 72865, 73394, 73371, 82283, 83915, 83916, 83845, 82286, 83918, 83919, 
83848, 82214, 82284, 83917, 83847
28515, 72842, 72865, 73394, 73371, 72843, 72866, 73395, 73372, 82286, 83918, 83919, 83848, 82289, 83921, 83922, 
83851, 82217, 82287, 83920, 83850
28516, 72843, 72866, 73395, 73372, 72844, 72867, 73396, 73373, 82289, 83921, 83922, 83851, 82292, 83924, 83925, 
83854, 82220, 82290, 83923, 83853
28517, 72844, 72867, 73396, 73373, 72845, 72868, 73397, 73374, 82292, 83924, 83925, 83854, 82295, 83927, 83928, 
83857, 82223, 82293, 83926, 83856
28518, 72845, 72868, 73397, 73374, 72846, 72869, 73398, 73375, 82295, 83927, 83928, 83857, 82298, 83930, 83931, 
83860, 82226, 82296, 83929, 83859
28519, 72846, 72869, 73398, 73375, 72847, 72870, 73399, 73376, 82298, 83930, 83931, 83860, 82301, 83933, 83934, 
83863, 82229, 82299, 83932, 83862
28520, 72847, 72870, 73399, 73376, 72848, 72871, 73400, 73377, 82301, 83933, 83934, 83863, 82304, 83936, 83937, 
83866, 82232, 82302, 83935, 83865
28521, 72848, 72871, 73400, 73377, 72849, 72872, 73401, 73378, 82304, 83936, 83937, 83866, 82307, 83939, 83940, 
83869, 82235, 82305, 83938, 83868
28522, 72849, 72872, 73401, 73378, 72850, 72873, 73402, 73379, 82307, 83939, 83940, 83869, 82310, 83942, 83943, 
83872, 82238, 82308, 83941, 83871
28523, 72850, 72873, 73402, 73379, 72851, 72874, 73403, 73380, 82310, 83942, 83943, 83872, 82313, 83945, 83946, 
83875, 82241, 82311, 83944, 83874
28524, 72851, 72874, 73403, 73380, 72852, 72875, 73404, 73381, 82313, 83945, 83946, 83875, 82316, 83948, 83949, 
83878, 82244, 82314, 83947, 83877
28525, 72852, 72875, 73404, 73381, 72853, 72876, 73405, 73382, 82316, 83948, 83949, 83878, 82319, 83951, 83952, 
83881, 82247, 82317, 83950, 83880
28526, 72853, 72876, 73405, 73382, 72854, 72877, 73406, 73383, 82319, 83951, 83952, 83881, 82322, 83954, 83955, 
83884, 82250, 82320, 83953, 83883
28527, 72854, 72877, 73406, 73383, 72855, 72878, 73407, 73384, 82322, 83954, 83955, 83884, 82325, 83957, 83958, 
83887, 82253, 82323, 83956, 83886
28528, 72855, 72878, 73407, 73384, 72856, 72879, 73408, 73385, 82325, 83957, 83958, 83887, 82328, 83960, 83961, 
83890, 82256, 82326, 83959, 83889
28529, 72856, 72879, 73408, 73385, 72857, 72880, 73409, 73386, 82328, 83960, 83961, 83890, 82331, 83963, 83964, 
83893, 82259, 82329, 83962, 83892
28530, 72857, 72880, 73409, 73386, 72858, 72881, 73410, 73387, 82331, 83963, 83964, 83893, 82334, 83966, 83967, 
83896, 82262, 82332, 83965, 83895
28531, 72858, 72881, 73410, 73387, 72859, 72882, 73411, 73388, 82334, 83966, 83967, 83896, 82337, 83969, 83970, 
83899, 82265, 82335, 83968, 83898
28532, 72859, 72882, 73411, 73388, 72860, 72883, 73412, 73389, 82337, 83969, 83970, 83899, 82340, 83972, 83973, 
83902, 82268, 82338, 83971, 83901
28533, 72860, 72883, 73412, 73389, 72861, 72884, 73413, 73390, 82340, 83972, 83973, 83902, 82343, 83975, 83976, 
83905, 82271, 82341, 83974, 83904
28534, 72861, 72884, 73413, 73390, 22912, 22913, 22936, 22935, 82343, 83975, 83976, 83905, 23245, 23291, 23292, 
23289, 82274, 82344, 83977, 83907
28535, 17268, 17269, 17292, 17291, 72862, 72885, 73414, 73391, 17602, 17648, 17649, 17646, 82347, 83979, 83980, 
83909, 82275, 82345, 83978, 83908
28536, 72862, 72885, 73414, 73391, 72863, 72886, 73415, 73392, 82347, 83979, 83980, 83909, 82350, 83982, 83983, 
83912, 82278, 82348, 83981, 83911
28537, 72863, 72886, 73415, 73392, 72864, 72887, 73416, 73393, 82350, 83982, 83983, 83912, 82353, 83985, 83986, 
83915, 82281, 82351, 83984, 83914
28538, 72864, 72887, 73416, 73393, 72865, 72888, 73417, 73394, 82353, 83985, 83986, 83915, 82356, 83988, 83989, 
83918, 82284, 82354, 83987, 83917
28539, 72865, 72888, 73417, 73394, 72866, 72889, 73418, 73395, 82356, 83988, 83989, 83918, 82359, 83991, 83992, 
83921, 82287, 82357, 83990, 83920
28540, 72866, 72889, 73418, 73395, 72867, 72890, 73419, 73396, 82359, 83991, 83992, 83921, 82362, 83994, 83995, 
83924, 82290, 82360, 83993, 83923
28541, 72867, 72890, 73419, 73396, 72868, 72891, 73420, 73397, 82362, 83994, 83995, 83924, 82365, 83997, 83998, 
83927, 82293, 82363, 83996, 83926
28542, 72868, 72891, 73420, 73397, 72869, 72892, 73421, 73398, 82365, 83997, 83998, 83927, 82368, 84000, 84001, 
83930, 82296, 82366, 83999, 83929
28543, 72869, 72892, 73421, 73398, 72870, 72893, 73422, 73399, 82368, 84000, 84001, 83930, 82371, 84003, 84004, 
83933, 82299, 82369, 84002, 83932
28544, 72870, 72893, 73422, 73399, 72871, 72894, 73423, 73400, 82371, 84003, 84004, 83933, 82374, 84006, 84007, 
83936, 82302, 82372, 84005, 83935
28545, 72871, 72894, 73423, 73400, 72872, 72895, 73424, 73401, 82374, 84006, 84007, 83936, 82377, 84009, 84010, 
83939, 82305, 82375, 84008, 83938
28546, 72872, 72895, 73424, 73401, 72873, 72896, 73425, 73402, 82377, 84009, 84010, 83939, 82380, 84012, 84013, 
83942, 82308, 82378, 84011, 83941
28547, 72873, 72896, 73425, 73402, 72874, 72897, 73426, 73403, 82380, 84012, 84013, 83942, 82383, 84015, 84016, 
83945, 82311, 82381, 84014, 83944
28548, 72874, 72897, 73426, 73403, 72875, 72898, 73427, 73404, 82383, 84015, 84016, 83945, 82386, 84018, 84019, 
83948, 82314, 82384, 84017, 83947
28549, 72875, 72898, 73427, 73404, 72876, 72899, 73428, 73405, 82386, 84018, 84019, 83948, 82389, 84021, 84022, 
83951, 82317, 82387, 84020, 83950
28550, 72876, 72899, 73428, 73405, 72877, 72900, 73429, 73406, 82389, 84021, 84022, 83951, 82392, 84024, 84025, 
83954, 82320, 82390, 84023, 83953
28551, 72877, 72900, 73429, 73406, 72878, 72901, 73430, 73407, 82392, 84024, 84025, 83954, 82395, 84027, 84028, 
83957, 82323, 82393, 84026, 83956
28552, 72878, 72901, 73430, 73407, 72879, 72902, 73431, 73408, 82395, 84027, 84028, 83957, 82398, 84030, 84031, 
83960, 82326, 82396, 84029, 83959
28553, 72879, 72902, 73431, 73408, 72880, 72903, 73432, 73409, 82398, 84030, 84031, 83960, 82401, 84033, 84034, 
83963, 82329, 82399, 84032, 83962
28554, 72880, 72903, 73432, 73409, 72881, 72904, 73433, 73410, 82401, 84033, 84034, 83963, 82404, 84036, 84037, 
83966, 82332, 82402, 84035, 83965
28555, 72881, 72904, 73433, 73410, 72882, 72905, 73434, 73411, 82404, 84036, 84037, 83966, 82407, 84039, 84040, 
83969, 82335, 82405, 84038, 83968
28556, 72882, 72905, 73434, 73411, 72883, 72906, 73435, 73412, 82407, 84039, 84040, 83969, 82410, 84042, 84043, 
83972, 82338, 82408, 84041, 83971
28557, 72883, 72906, 73435, 73412, 72884, 72907, 73436, 73413, 82410, 84042, 84043, 83972, 82413, 84045, 84046, 
83975, 82341, 82411, 84044, 83974
28558, 72884, 72907, 73436, 73413, 22913, 22914, 22937, 22936, 82413, 84045, 84046, 83975, 23247, 23293, 23294, 
23291, 82344, 82414, 84047, 83977
28559, 17269, 17270, 17293, 17292, 72885, 72908, 73437, 73414, 17604, 17650, 17651, 17648, 82417, 84049, 84050, 
83979, 82345, 82415, 84048, 83978
28560, 72885, 72908, 73437, 73414, 72886, 72909, 73438, 73415, 82417, 84049, 84050, 83979, 82420, 84052, 84053, 
83982, 82348, 82418, 84051, 83981
28561, 72886, 72909, 73438, 73415, 72887, 72910, 73439, 73416, 82420, 84052, 84053, 83982, 82423, 84055, 84056, 
83985, 82351, 82421, 84054, 83984
28562, 72887, 72910, 73439, 73416, 72888, 72911, 73440, 73417, 82423, 84055, 84056, 83985, 82426, 84058, 84059, 
83988, 82354, 82424, 84057, 83987
28563, 72888, 72911, 73440, 73417, 72889, 72912, 73441, 73418, 82426, 84058, 84059, 83988, 82429, 84061, 84062, 
83991, 82357, 82427, 84060, 83990
28564, 72889, 72912, 73441, 73418, 72890, 72913, 73442, 73419, 82429, 84061, 84062, 83991, 82432, 84064, 84065, 
83994, 82360, 82430, 84063, 83993
28565, 72890, 72913, 73442, 73419, 72891, 72914, 73443, 73420, 82432, 84064, 84065, 83994, 82435, 84067, 84068, 
83997, 82363, 82433, 84066, 83996
28566, 72891, 72914, 73443, 73420, 72892, 72915, 73444, 73421, 82435, 84067, 84068, 83997, 82438, 84070, 84071, 
84000, 82366, 82436, 84069, 83999
28567, 72892, 72915, 73444, 73421, 72893, 72916, 73445, 73422, 82438, 84070, 84071, 84000, 82441, 84073, 84074, 
84003, 82369, 82439, 84072, 84002
28568, 72893, 72916, 73445, 73422, 72894, 72917, 73446, 73423, 82441, 84073, 84074, 84003, 82444, 84076, 84077, 
84006, 82372, 82442, 84075, 84005
28569, 72894, 72917, 73446, 73423, 72895, 72918, 73447, 73424, 82444, 84076, 84077, 84006, 82447, 84079, 84080, 
84009, 82375, 82445, 84078, 84008
28570, 72895, 72918, 73447, 73424, 72896, 72919, 73448, 73425, 82447, 84079, 84080, 84009, 82450, 84082, 84083, 
84012, 82378, 82448, 84081, 84011
28571, 72896, 72919, 73448, 73425, 72897, 72920, 73449, 73426, 82450, 84082, 84083, 84012, 82453, 84085, 84086, 
84015, 82381, 82451, 84084, 84014
28572, 72897, 72920, 73449, 73426, 72898, 72921, 73450, 73427, 82453, 84085, 84086, 84015, 82456, 84088, 84089, 
84018, 82384, 82454, 84087, 84017
28573, 72898, 72921, 73450, 73427, 72899, 72922, 73451, 73428, 82456, 84088, 84089, 84018, 82459, 84091, 84092, 
84021, 82387, 82457, 84090, 84020
28574, 72899, 72922, 73451, 73428, 72900, 72923, 73452, 73429, 82459, 84091, 84092, 84021, 82462, 84094, 84095, 
84024, 82390, 82460, 84093, 84023
28575, 72900, 72923, 73452, 73429, 72901, 72924, 73453, 73430, 82462, 84094, 84095, 84024, 82465, 84097, 84098, 
84027, 82393, 82463, 84096, 84026
28576, 72901, 72924, 73453, 73430, 72902, 72925, 73454, 73431, 82465, 84097, 84098, 84027, 82468, 84100, 84101, 
84030, 82396, 82466, 84099, 84029
28577, 72902, 72925, 73454, 73431, 72903, 72926, 73455, 73432, 82468, 84100, 84101, 84030, 82471, 84103, 84104, 
84033, 82399, 82469, 84102, 84032
28578, 72903, 72926, 73455, 73432, 72904, 72927, 73456, 73433, 82471, 84103, 84104, 84033, 82474, 84106, 84107, 
84036, 82402, 82472, 84105, 84035
28579, 72904, 72927, 73456, 73433, 72905, 72928, 73457, 73434, 82474, 84106, 84107, 84036, 82477, 84109, 84110, 
84039, 82405, 82475, 84108, 84038
28580, 72905, 72928, 73457, 73434, 72906, 72929, 73458, 73435, 82477, 84109, 84110, 84039, 82480, 84112, 84113, 
84042, 82408, 82478, 84111, 84041
28581, 72906, 72929, 73458, 73435, 72907, 72930, 73459, 73436, 82480, 84112, 84113, 84042, 82483, 84115, 84116, 
84045, 82411, 82481, 84114, 84044
28582, 72907, 72930, 73459, 73436, 22914, 22915, 22938, 22937, 82483, 84115, 84116, 84045, 23249, 23295, 23296, 
23293, 82414, 82484, 84117, 84047
28583, 17270, 17271, 17294, 17293, 72908, 72931, 73460, 73437, 17606, 17652, 17653, 17650, 82487, 84119, 84120, 
84049, 82415, 82485, 84118, 84048
28584, 72908, 72931, 73460, 73437, 72909, 72932, 73461, 73438, 82487, 84119, 84120, 84049, 82490, 84122, 84123, 
84052, 82418, 82488, 84121, 84051
28585, 72909, 72932, 73461, 73438, 72910, 72933, 73462, 73439, 82490, 84122, 84123, 84052, 82493, 84125, 84126, 
84055, 82421, 82491, 84124, 84054
28586, 72910, 72933, 73462, 73439, 72911, 72934, 73463, 73440, 82493, 84125, 84126, 84055, 82496, 84128, 84129, 
84058, 82424, 82494, 84127, 84057
28587, 72911, 72934, 73463, 73440, 72912, 72935, 73464, 73441, 82496, 84128, 84129, 84058, 82499, 84131, 84132, 
84061, 82427, 82497, 84130, 84060
28588, 72912, 72935, 73464, 73441, 72913, 72936, 73465, 73442, 82499, 84131, 84132, 84061, 82502, 84134, 84135, 
84064, 82430, 82500, 84133, 84063
28589, 72913, 72936, 73465, 73442, 72914, 72937, 73466, 73443, 82502, 84134, 84135, 84064, 82505, 84137, 84138, 
84067, 82433, 82503, 84136, 84066
28590, 72914, 72937, 73466, 73443, 72915, 72938, 73467, 73444, 82505, 84137, 84138, 84067, 82508, 84140, 84141, 
84070, 82436, 82506, 84139, 84069
28591, 72915, 72938, 73467, 73444, 72916, 72939, 73468, 73445, 82508, 84140, 84141, 84070, 82511, 84143, 84144, 
84073, 82439, 82509, 84142, 84072
28592, 72916, 72939, 73468, 73445, 72917, 72940, 73469, 73446, 82511, 84143, 84144, 84073, 82514, 84146, 84147, 
84076, 82442, 82512, 84145, 84075
28593, 72917, 72940, 73469, 73446, 72918, 72941, 73470, 73447, 82514, 84146, 84147, 84076, 82517, 84149, 84150, 
84079, 82445, 82515, 84148, 84078
28594, 72918, 72941, 73470, 73447, 72919, 72942, 73471, 73448, 82517, 84149, 84150, 84079, 82520, 84152, 84153, 
84082, 82448, 82518, 84151, 84081
28595, 72919, 72942, 73471, 73448, 72920, 72943, 73472, 73449, 82520, 84152, 84153, 84082, 82523, 84155, 84156, 
84085, 82451, 82521, 84154, 84084
28596, 72920, 72943, 73472, 73449, 72921, 72944, 73473, 73450, 82523, 84155, 84156, 84085, 82526, 84158, 84159, 
84088, 82454, 82524, 84157, 84087
28597, 72921, 72944, 73473, 73450, 72922, 72945, 73474, 73451, 82526, 84158, 84159, 84088, 82529, 84161, 84162, 
84091, 82457, 82527, 84160, 84090
28598, 72922, 72945, 73474, 73451, 72923, 72946, 73475, 73452, 82529, 84161, 84162, 84091, 82532, 84164, 84165, 
84094, 82460, 82530, 84163, 84093
28599, 72923, 72946, 73475, 73452, 72924, 72947, 73476, 73453, 82532, 84164, 84165, 84094, 82535, 84167, 84168, 
84097, 82463, 82533, 84166, 84096
28600, 72924, 72947, 73476, 73453, 72925, 72948, 73477, 73454, 82535, 84167, 84168, 84097, 82538, 84170, 84171, 
84100, 82466, 82536, 84169, 84099
28601, 72925, 72948, 73477, 73454, 72926, 72949, 73478, 73455, 82538, 84170, 84171, 84100, 82541, 84173, 84174, 
84103, 82469, 82539, 84172, 84102
28602, 72926, 72949, 73478, 73455, 72927, 72950, 73479, 73456, 82541, 84173, 84174, 84103, 82544, 84176, 84177, 
84106, 82472, 82542, 84175, 84105
28603, 72927, 72950, 73479, 73456, 72928, 72951, 73480, 73457, 82544, 84176, 84177, 84106, 82547, 84179, 84180, 
84109, 82475, 82545, 84178, 84108
28604, 72928, 72951, 73480, 73457, 72929, 72952, 73481, 73458, 82547, 84179, 84180, 84109, 82550, 84182, 84183, 
84112, 82478, 82548, 84181, 84111
28605, 72929, 72952, 73481, 73458, 72930, 72953, 73482, 73459, 82550, 84182, 84183, 84112, 82553, 84185, 84186, 
84115, 82481, 82551, 84184, 84114
28606, 72930, 72953, 73482, 73459, 22915, 22916, 22939, 22938, 82553, 84185, 84186, 84115, 23251, 23297, 23298, 
23295, 82484, 82554, 84187, 84117
28607, 17271, 17272, 17295, 17294, 72931, 72954, 73483, 73460, 17608, 17654, 17655, 17652, 82557, 84189, 84190, 
84119, 82485, 82555, 84188, 84118
28608, 72931, 72954, 73483, 73460, 72932, 72955, 73484, 73461, 82557, 84189, 84190, 84119, 82560, 84192, 84193, 
84122, 82488, 82558, 84191, 84121
28609, 72932, 72955, 73484, 73461, 72933, 72956, 73485, 73462, 82560, 84192, 84193, 84122, 82563, 84195, 84196, 
84125, 82491, 82561, 84194, 84124
28610, 72933, 72956, 73485, 73462, 72934, 72957, 73486, 73463, 82563, 84195, 84196, 84125, 82566, 84198, 84199, 
84128, 82494, 82564, 84197, 84127
28611, 72934, 72957, 73486, 73463, 72935, 72958, 73487, 73464, 82566, 84198, 84199, 84128, 82569, 84201, 84202, 
84131, 82497, 82567, 84200, 84130
28612, 72935, 72958, 73487, 73464, 72936, 72959, 73488, 73465, 82569, 84201, 84202, 84131, 82572, 84204, 84205, 
84134, 82500, 82570, 84203, 84133
28613, 72936, 72959, 73488, 73465, 72937, 72960, 73489, 73466, 82572, 84204, 84205, 84134, 82575, 84207, 84208, 
84137, 82503, 82573, 84206, 84136
28614, 72937, 72960, 73489, 73466, 72938, 72961, 73490, 73467, 82575, 84207, 84208, 84137, 82578, 84210, 84211, 
84140, 82506, 82576, 84209, 84139
28615, 72938, 72961, 73490, 73467, 72939, 72962, 73491, 73468, 82578, 84210, 84211, 84140, 82581, 84213, 84214, 
84143, 82509, 82579, 84212, 84142
28616, 72939, 72962, 73491, 73468, 72940, 72963, 73492, 73469, 82581, 84213, 84214, 84143, 82584, 84216, 84217, 
84146, 82512, 82582, 84215, 84145
28617, 72940, 72963, 73492, 73469, 72941, 72964, 73493, 73470, 82584, 84216, 84217, 84146, 82587, 84219, 84220, 
84149, 82515, 82585, 84218, 84148
28618, 72941, 72964, 73493, 73470, 72942, 72965, 73494, 73471, 82587, 84219, 84220, 84149, 82590, 84222, 84223, 
84152, 82518, 82588, 84221, 84151
28619, 72942, 72965, 73494, 73471, 72943, 72966, 73495, 73472, 82590, 84222, 84223, 84152, 82593, 84225, 84226, 
84155, 82521, 82591, 84224, 84154
28620, 72943, 72966, 73495, 73472, 72944, 72967, 73496, 73473, 82593, 84225, 84226, 84155, 82596, 84228, 84229, 
84158, 82524, 82594, 84227, 84157
28621, 72944, 72967, 73496, 73473, 72945, 72968, 73497, 73474, 82596, 84228, 84229, 84158, 82599, 84231, 84232, 
84161, 82527, 82597, 84230, 84160
28622, 72945, 72968, 73497, 73474, 72946, 72969, 73498, 73475, 82599, 84231, 84232, 84161, 82602, 84234, 84235, 
84164, 82530, 82600, 84233, 84163
28623, 72946, 72969, 73498, 73475, 72947, 72970, 73499, 73476, 82602, 84234, 84235, 84164, 82605, 84237, 84238, 
84167, 82533, 82603, 84236, 84166
28624, 72947, 72970, 73499, 73476, 72948, 72971, 73500, 73477, 82605, 84237, 84238, 84167, 82608, 84240, 84241, 
84170, 82536, 82606, 84239, 84169
28625, 72948, 72971, 73500, 73477, 72949, 72972, 73501, 73478, 82608, 84240, 84241, 84170, 82611, 84243, 84244, 
84173, 82539, 82609, 84242, 84172
28626, 72949, 72972, 73501, 73478, 72950, 72973, 73502, 73479, 82611, 84243, 84244, 84173, 82614, 84246, 84247, 
84176, 82542, 82612, 84245, 84175
28627, 72950, 72973, 73502, 73479, 72951, 72974, 73503, 73480, 82614, 84246, 84247, 84176, 82617, 84249, 84250, 
84179, 82545, 82615, 84248, 84178
28628, 72951, 72974, 73503, 73480, 72952, 72975, 73504, 73481, 82617, 84249, 84250, 84179, 82620, 84252, 84253, 
84182, 82548, 82618, 84251, 84181
28629, 72952, 72975, 73504, 73481, 72953, 72976, 73505, 73482, 82620, 84252, 84253, 84182, 82623, 84255, 84256, 
84185, 82551, 82621, 84254, 84184
28630, 72953, 72976, 73505, 73482, 22916, 22917, 22940, 22939, 82623, 84255, 84256, 84185, 23253, 23299, 23300, 
23297, 82554, 82624, 84257, 84187
28631, 17272, 17273, 17296, 17295, 72954, 72977, 73506, 73483, 17610, 17656, 17657, 17654, 82627, 84259, 84260, 
84189, 82555, 82625, 84258, 84188
28632, 72954, 72977, 73506, 73483, 72955, 72978, 73507, 73484, 82627, 84259, 84260, 84189, 82630, 84262, 84263, 
84192, 82558, 82628, 84261, 84191
28633, 72955, 72978, 73507, 73484, 72956, 72979, 73508, 73485, 82630, 84262, 84263, 84192, 82633, 84265, 84266, 
84195, 82561, 82631, 84264, 84194
28634, 72956, 72979, 73508, 73485, 72957, 72980, 73509, 73486, 82633, 84265, 84266, 84195, 82636, 84268, 84269, 
84198, 82564, 82634, 84267, 84197
28635, 72957, 72980, 73509, 73486, 72958, 72981, 73510, 73487, 82636, 84268, 84269, 84198, 82639, 84271, 84272, 
84201, 82567, 82637, 84270, 84200
28636, 72958, 72981, 73510, 73487, 72959, 72982, 73511, 73488, 82639, 84271, 84272, 84201, 82642, 84274, 84275, 
84204, 82570, 82640, 84273, 84203
28637, 72959, 72982, 73511, 73488, 72960, 72983, 73512, 73489, 82642, 84274, 84275, 84204, 82645, 84277, 84278, 
84207, 82573, 82643, 84276, 84206
28638, 72960, 72983, 73512, 73489, 72961, 72984, 73513, 73490, 82645, 84277, 84278, 84207, 82648, 84280, 84281, 
84210, 82576, 82646, 84279, 84209
28639, 72961, 72984, 73513, 73490, 72962, 72985, 73514, 73491, 82648, 84280, 84281, 84210, 82651, 84283, 84284, 
84213, 82579, 82649, 84282, 84212
28640, 72962, 72985, 73514, 73491, 72963, 72986, 73515, 73492, 82651, 84283, 84284, 84213, 82654, 84286, 84287, 
84216, 82582, 82652, 84285, 84215
28641, 72963, 72986, 73515, 73492, 72964, 72987, 73516, 73493, 82654, 84286, 84287, 84216, 82657, 84289, 84290, 
84219, 82585, 82655, 84288, 84218
28642, 72964, 72987, 73516, 73493, 72965, 72988, 73517, 73494, 82657, 84289, 84290, 84219, 82660, 84292, 84293, 
84222, 82588, 82658, 84291, 84221
28643, 72965, 72988, 73517, 73494, 72966, 72989, 73518, 73495, 82660, 84292, 84293, 84222, 82663, 84295, 84296, 
84225, 82591, 82661, 84294, 84224
28644, 72966, 72989, 73518, 73495, 72967, 72990, 73519, 73496, 82663, 84295, 84296, 84225, 82666, 84298, 84299, 
84228, 82594, 82664, 84297, 84227
28645, 72967, 72990, 73519, 73496, 72968, 72991, 73520, 73497, 82666, 84298, 84299, 84228, 82669, 84301, 84302, 
84231, 82597, 82667, 84300, 84230
28646, 72968, 72991, 73520, 73497, 72969, 72992, 73521, 73498, 82669, 84301, 84302, 84231, 82672, 84304, 84305, 
84234, 82600, 82670, 84303, 84233
28647, 72969, 72992, 73521, 73498, 72970, 72993, 73522, 73499, 82672, 84304, 84305, 84234, 82675, 84307, 84308, 
84237, 82603, 82673, 84306, 84236
28648, 72970, 72993, 73522, 73499, 72971, 72994, 73523, 73500, 82675, 84307, 84308, 84237, 82678, 84310, 84311, 
84240, 82606, 82676, 84309, 84239
28649, 72971, 72994, 73523, 73500, 72972, 72995, 73524, 73501, 82678, 84310, 84311, 84240, 82681, 84313, 84314, 
84243, 82609, 82679, 84312, 84242
28650, 72972, 72995, 73524, 73501, 72973, 72996, 73525, 73502, 82681, 84313, 84314, 84243, 82684, 84316, 84317, 
84246, 82612, 82682, 84315, 84245
28651, 72973, 72996, 73525, 73502, 72974, 72997, 73526, 73503, 82684, 84316, 84317, 84246, 82687, 84319, 84320, 
84249, 82615, 82685, 84318, 84248
28652, 72974, 72997, 73526, 73503, 72975, 72998, 73527, 73504, 82687, 84319, 84320, 84249, 82690, 84322, 84323, 
84252, 82618, 82688, 84321, 84251
28653, 72975, 72998, 73527, 73504, 72976, 72999, 73528, 73505, 82690, 84322, 84323, 84252, 82693, 84325, 84326, 
84255, 82621, 82691, 84324, 84254
28654, 72976, 72999, 73528, 73505, 22917, 22918, 22941, 22940, 82693, 84325, 84326, 84255, 23255, 23301, 23302, 
23299, 82624, 82694, 84327, 84257
28655, 17273, 17274, 17297, 17296, 72977, 73000, 73529, 73506, 17612, 17658, 17659, 17656, 82697, 84329, 84330, 
84259, 82625, 82695, 84328, 84258
28656, 72977, 73000, 73529, 73506, 72978, 73001, 73530, 73507, 82697, 84329, 84330, 84259, 82700, 84332, 84333, 
84262, 82628, 82698, 84331, 84261
28657, 72978, 73001, 73530, 73507, 72979, 73002, 73531, 73508, 82700, 84332, 84333, 84262, 82703, 84335, 84336, 
84265, 82631, 82701, 84334, 84264
28658, 72979, 73002, 73531, 73508, 72980, 73003, 73532, 73509, 82703, 84335, 84336, 84265, 82706, 84338, 84339, 
84268, 82634, 82704, 84337, 84267
28659, 72980, 73003, 73532, 73509, 72981, 73004, 73533, 73510, 82706, 84338, 84339, 84268, 82709, 84341, 84342, 
84271, 82637, 82707, 84340, 84270
28660, 72981, 73004, 73533, 73510, 72982, 73005, 73534, 73511, 82709, 84341, 84342, 84271, 82712, 84344, 84345, 
84274, 82640, 82710, 84343, 84273
28661, 72982, 73005, 73534, 73511, 72983, 73006, 73535, 73512, 82712, 84344, 84345, 84274, 82715, 84347, 84348, 
84277, 82643, 82713, 84346, 84276
28662, 72983, 73006, 73535, 73512, 72984, 73007, 73536, 73513, 82715, 84347, 84348, 84277, 82718, 84350, 84351, 
84280, 82646, 82716, 84349, 84279
28663, 72984, 73007, 73536, 73513, 72985, 73008, 73537, 73514, 82718, 84350, 84351, 84280, 82721, 84353, 84354, 
84283, 82649, 82719, 84352, 84282
28664, 72985, 73008, 73537, 73514, 72986, 73009, 73538, 73515, 82721, 84353, 84354, 84283, 82724, 84356, 84357, 
84286, 82652, 82722, 84355, 84285
28665, 72986, 73009, 73538, 73515, 72987, 73010, 73539, 73516, 82724, 84356, 84357, 84286, 82727, 84359, 84360, 
84289, 82655, 82725, 84358, 84288
28666, 72987, 73010, 73539, 73516, 72988, 73011, 73540, 73517, 82727, 84359, 84360, 84289, 82730, 84362, 84363, 
84292, 82658, 82728, 84361, 84291
28667, 72988, 73011, 73540, 73517, 72989, 73012, 73541, 73518, 82730, 84362, 84363, 84292, 82733, 84365, 84366, 
84295, 82661, 82731, 84364, 84294
28668, 72989, 73012, 73541, 73518, 72990, 73013, 73542, 73519, 82733, 84365, 84366, 84295, 82736, 84368, 84369, 
84298, 82664, 82734, 84367, 84297
28669, 72990, 73013, 73542, 73519, 72991, 73014, 73543, 73520, 82736, 84368, 84369, 84298, 82739, 84371, 84372, 
84301, 82667, 82737, 84370, 84300
28670, 72991, 73014, 73543, 73520, 72992, 73015, 73544, 73521, 82739, 84371, 84372, 84301, 82742, 84374, 84375, 
84304, 82670, 82740, 84373, 84303
28671, 72992, 73015, 73544, 73521, 72993, 73016, 73545, 73522, 82742, 84374, 84375, 84304, 82745, 84377, 84378, 
84307, 82673, 82743, 84376, 84306
28672, 72993, 73016, 73545, 73522, 72994, 73017, 73546, 73523, 82745, 84377, 84378, 84307, 82748, 84380, 84381, 
84310, 82676, 82746, 84379, 84309
28673, 72994, 73017, 73546, 73523, 72995, 73018, 73547, 73524, 82748, 84380, 84381, 84310, 82751, 84383, 84384, 
84313, 82679, 82749, 84382, 84312
28674, 72995, 73018, 73547, 73524, 72996, 73019, 73548, 73525, 82751, 84383, 84384, 84313, 82754, 84386, 84387, 
84316, 82682, 82752, 84385, 84315
28675, 72996, 73019, 73548, 73525, 72997, 73020, 73549, 73526, 82754, 84386, 84387, 84316, 82757, 84389, 84390, 
84319, 82685, 82755, 84388, 84318
28676, 72997, 73020, 73549, 73526, 72998, 73021, 73550, 73527, 82757, 84389, 84390, 84319, 82760, 84392, 84393, 
84322, 82688, 82758, 84391, 84321
28677, 72998, 73021, 73550, 73527, 72999, 73022, 73551, 73528, 82760, 84392, 84393, 84322, 82763, 84395, 84396, 
84325, 82691, 82761, 84394, 84324
28678, 72999, 73022, 73551, 73528, 22918, 22919, 22942, 22941, 82763, 84395, 84396, 84325, 23257, 23303, 23304, 
23301, 82694, 82764, 84397, 84327
28679, 17274, 17275, 17298, 17297, 73000, 73023, 73552, 73529, 17614, 17660, 17661, 17658, 82767, 84399, 84400, 
84329, 82695, 82765, 84398, 84328
28680, 73000, 73023, 73552, 73529, 73001, 73024, 73553, 73530, 82767, 84399, 84400, 84329, 82770, 84402, 84403, 
84332, 82698, 82768, 84401, 84331
28681, 73001, 73024, 73553, 73530, 73002, 73025, 73554, 73531, 82770, 84402, 84403, 84332, 82773, 84405, 84406, 
84335, 82701, 82771, 84404, 84334
28682, 73002, 73025, 73554, 73531, 73003, 73026, 73555, 73532, 82773, 84405, 84406, 84335, 82776, 84408, 84409, 
84338, 82704, 82774, 84407, 84337
28683, 73003, 73026, 73555, 73532, 73004, 73027, 73556, 73533, 82776, 84408, 84409, 84338, 82779, 84411, 84412, 
84341, 82707, 82777, 84410, 84340
28684, 73004, 73027, 73556, 73533, 73005, 73028, 73557, 73534, 82779, 84411, 84412, 84341, 82782, 84414, 84415, 
84344, 82710, 82780, 84413, 84343
28685, 73005, 73028, 73557, 73534, 73006, 73029, 73558, 73535, 82782, 84414, 84415, 84344, 82785, 84417, 84418, 
84347, 82713, 82783, 84416, 84346
28686, 73006, 73029, 73558, 73535, 73007, 73030, 73559, 73536, 82785, 84417, 84418, 84347, 82788, 84420, 84421, 
84350, 82716, 82786, 84419, 84349
28687, 73007, 73030, 73559, 73536, 73008, 73031, 73560, 73537, 82788, 84420, 84421, 84350, 82791, 84423, 84424, 
84353, 82719, 82789, 84422, 84352
28688, 73008, 73031, 73560, 73537, 73009, 73032, 73561, 73538, 82791, 84423, 84424, 84353, 82794, 84426, 84427, 
84356, 82722, 82792, 84425, 84355
28689, 73009, 73032, 73561, 73538, 73010, 73033, 73562, 73539, 82794, 84426, 84427, 84356, 82797, 84429, 84430, 
84359, 82725, 82795, 84428, 84358
28690, 73010, 73033, 73562, 73539, 73011, 73034, 73563, 73540, 82797, 84429, 84430, 84359, 82800, 84432, 84433, 
84362, 82728, 82798, 84431, 84361
28691, 73011, 73034, 73563, 73540, 73012, 73035, 73564, 73541, 82800, 84432, 84433, 84362, 82803, 84435, 84436, 
84365, 82731, 82801, 84434, 84364
28692, 73012, 73035, 73564, 73541, 73013, 73036, 73565, 73542, 82803, 84435, 84436, 84365, 82806, 84438, 84439, 
84368, 82734, 82804, 84437, 84367
28693, 73013, 73036, 73565, 73542, 73014, 73037, 73566, 73543, 82806, 84438, 84439, 84368, 82809, 84441, 84442, 
84371, 82737, 82807, 84440, 84370
28694, 73014, 73037, 73566, 73543, 73015, 73038, 73567, 73544, 82809, 84441, 84442, 84371, 82812, 84444, 84445, 
84374, 82740, 82810, 84443, 84373
28695, 73015, 73038, 73567, 73544, 73016, 73039, 73568, 73545, 82812, 84444, 84445, 84374, 82815, 84447, 84448, 
84377, 82743, 82813, 84446, 84376
28696, 73016, 73039, 73568, 73545, 73017, 73040, 73569, 73546, 82815, 84447, 84448, 84377, 82818, 84450, 84451, 
84380, 82746, 82816, 84449, 84379
28697, 73017, 73040, 73569, 73546, 73018, 73041, 73570, 73547, 82818, 84450, 84451, 84380, 82821, 84453, 84454, 
84383, 82749, 82819, 84452, 84382
28698, 73018, 73041, 73570, 73547, 73019, 73042, 73571, 73548, 82821, 84453, 84454, 84383, 82824, 84456, 84457, 
84386, 82752, 82822, 84455, 84385
28699, 73019, 73042, 73571, 73548, 73020, 73043, 73572, 73549, 82824, 84456, 84457, 84386, 82827, 84459, 84460, 
84389, 82755, 82825, 84458, 84388
28700, 73020, 73043, 73572, 73549, 73021, 73044, 73573, 73550, 82827, 84459, 84460, 84389, 82830, 84462, 84463, 
84392, 82758, 82828, 84461, 84391
28701, 73021, 73044, 73573, 73550, 73022, 73045, 73574, 73551, 82830, 84462, 84463, 84392, 82833, 84465, 84466, 
84395, 82761, 82831, 84464, 84394
28702, 73022, 73045, 73574, 73551, 22919, 22920, 22943, 22942, 82833, 84465, 84466, 84395, 23259, 23305, 23306, 
23303, 82764, 82834, 84467, 84397
28703, 17275, 17276, 17299, 17298, 73023, 73046, 73575, 73552, 17616, 17662, 17663, 17660, 82837, 84469, 84470, 
84399, 82765, 82835, 84468, 84398
28704, 73023, 73046, 73575, 73552, 73024, 73047, 73576, 73553, 82837, 84469, 84470, 84399, 82840, 84472, 84473, 
84402, 82768, 82838, 84471, 84401
28705, 73024, 73047, 73576, 73553, 73025, 73048, 73577, 73554, 82840, 84472, 84473, 84402, 82843, 84475, 84476, 
84405, 82771, 82841, 84474, 84404
28706, 73025, 73048, 73577, 73554, 73026, 73049, 73578, 73555, 82843, 84475, 84476, 84405, 82846, 84478, 84479, 
84408, 82774, 82844, 84477, 84407
28707, 73026, 73049, 73578, 73555, 73027, 73050, 73579, 73556, 82846, 84478, 84479, 84408, 82849, 84481, 84482, 
84411, 82777, 82847, 84480, 84410
28708, 73027, 73050, 73579, 73556, 73028, 73051, 73580, 73557, 82849, 84481, 84482, 84411, 82852, 84484, 84485, 
84414, 82780, 82850, 84483, 84413
28709, 73028, 73051, 73580, 73557, 73029, 73052, 73581, 73558, 82852, 84484, 84485, 84414, 82855, 84487, 84488, 
84417, 82783, 82853, 84486, 84416
28710, 73029, 73052, 73581, 73558, 73030, 73053, 73582, 73559, 82855, 84487, 84488, 84417, 82858, 84490, 84491, 
84420, 82786, 82856, 84489, 84419
28711, 73030, 73053, 73582, 73559, 73031, 73054, 73583, 73560, 82858, 84490, 84491, 84420, 82861, 84493, 84494, 
84423, 82789, 82859, 84492, 84422
28712, 73031, 73054, 73583, 73560, 73032, 73055, 73584, 73561, 82861, 84493, 84494, 84423, 82864, 84496, 84497, 
84426, 82792, 82862, 84495, 84425
28713, 73032, 73055, 73584, 73561, 73033, 73056, 73585, 73562, 82864, 84496, 84497, 84426, 82867, 84499, 84500, 
84429, 82795, 82865, 84498, 84428
28714, 73033, 73056, 73585, 73562, 73034, 73057, 73586, 73563, 82867, 84499, 84500, 84429, 82870, 84502, 84503, 
84432, 82798, 82868, 84501, 84431
28715, 73034, 73057, 73586, 73563, 73035, 73058, 73587, 73564, 82870, 84502, 84503, 84432, 82873, 84505, 84506, 
84435, 82801, 82871, 84504, 84434
28716, 73035, 73058, 73587, 73564, 73036, 73059, 73588, 73565, 82873, 84505, 84506, 84435, 82876, 84508, 84509, 
84438, 82804, 82874, 84507, 84437
28717, 73036, 73059, 73588, 73565, 73037, 73060, 73589, 73566, 82876, 84508, 84509, 84438, 82879, 84511, 84512, 
84441, 82807, 82877, 84510, 84440
28718, 73037, 73060, 73589, 73566, 73038, 73061, 73590, 73567, 82879, 84511, 84512, 84441, 82882, 84514, 84515, 
84444, 82810, 82880, 84513, 84443
28719, 73038, 73061, 73590, 73567, 73039, 73062, 73591, 73568, 82882, 84514, 84515, 84444, 82885, 84517, 84518, 
84447, 82813, 82883, 84516, 84446
28720, 73039, 73062, 73591, 73568, 73040, 73063, 73592, 73569, 82885, 84517, 84518, 84447, 82888, 84520, 84521, 
84450, 82816, 82886, 84519, 84449
28721, 73040, 73063, 73592, 73569, 73041, 73064, 73593, 73570, 82888, 84520, 84521, 84450, 82891, 84523, 84524, 
84453, 82819, 82889, 84522, 84452
28722, 73041, 73064, 73593, 73570, 73042, 73065, 73594, 73571, 82891, 84523, 84524, 84453, 82894, 84526, 84527, 
84456, 82822, 82892, 84525, 84455
28723, 73042, 73065, 73594, 73571, 73043, 73066, 73595, 73572, 82894, 84526, 84527, 84456, 82897, 84529, 84530, 
84459, 82825, 82895, 84528, 84458
28724, 73043, 73066, 73595, 73572, 73044, 73067, 73596, 73573, 82897, 84529, 84530, 84459, 82900, 84532, 84533, 
84462, 82828, 82898, 84531, 84461
28725, 73044, 73067, 73596, 73573, 73045, 73068, 73597, 73574, 82900, 84532, 84533, 84462, 82903, 84535, 84536, 
84465, 82831, 82901, 84534, 84464
28726, 73045, 73068, 73597, 73574, 22920, 22921, 22944, 22943, 82903, 84535, 84536, 84465, 23261, 23307, 23308, 
23305, 82834, 82904, 84537, 84467
28727, 17276, 17277, 17300, 17299, 73046, 73069, 73598, 73575, 17618, 17664, 17665, 17662, 82907, 84539, 84540, 
84469, 82835, 82905, 84538, 84468
28728, 73046, 73069, 73598, 73575, 73047, 73070, 73599, 73576, 82907, 84539, 84540, 84469, 82910, 84542, 84543, 
84472, 82838, 82908, 84541, 84471
28729, 73047, 73070, 73599, 73576, 73048, 73071, 73600, 73577, 82910, 84542, 84543, 84472, 82913, 84545, 84546, 
84475, 82841, 82911, 84544, 84474
28730, 73048, 73071, 73600, 73577, 73049, 73072, 73601, 73578, 82913, 84545, 84546, 84475, 82916, 84548, 84549, 
84478, 82844, 82914, 84547, 84477
28731, 73049, 73072, 73601, 73578, 73050, 73073, 73602, 73579, 82916, 84548, 84549, 84478, 82919, 84551, 84552, 
84481, 82847, 82917, 84550, 84480
28732, 73050, 73073, 73602, 73579, 73051, 73074, 73603, 73580, 82919, 84551, 84552, 84481, 82922, 84554, 84555, 
84484, 82850, 82920, 84553, 84483
28733, 73051, 73074, 73603, 73580, 73052, 73075, 73604, 73581, 82922, 84554, 84555, 84484, 82925, 84557, 84558, 
84487, 82853, 82923, 84556, 84486
28734, 73052, 73075, 73604, 73581, 73053, 73076, 73605, 73582, 82925, 84557, 84558, 84487, 82928, 84560, 84561, 
84490, 82856, 82926, 84559, 84489
28735, 73053, 73076, 73605, 73582, 73054, 73077, 73606, 73583, 82928, 84560, 84561, 84490, 82931, 84563, 84564, 
84493, 82859, 82929, 84562, 84492
28736, 73054, 73077, 73606, 73583, 73055, 73078, 73607, 73584, 82931, 84563, 84564, 84493, 82934, 84566, 84567, 
84496, 82862, 82932, 84565, 84495
28737, 73055, 73078, 73607, 73584, 73056, 73079, 73608, 73585, 82934, 84566, 84567, 84496, 82937, 84569, 84570, 
84499, 82865, 82935, 84568, 84498
28738, 73056, 73079, 73608, 73585, 73057, 73080, 73609, 73586, 82937, 84569, 84570, 84499, 82940, 84572, 84573, 
84502, 82868, 82938, 84571, 84501
28739, 73057, 73080, 73609, 73586, 73058, 73081, 73610, 73587, 82940, 84572, 84573, 84502, 82943, 84575, 84576, 
84505, 82871, 82941, 84574, 84504
28740, 73058, 73081, 73610, 73587, 73059, 73082, 73611, 73588, 82943, 84575, 84576, 84505, 82946, 84578, 84579, 
84508, 82874, 82944, 84577, 84507
28741, 73059, 73082, 73611, 73588, 73060, 73083, 73612, 73589, 82946, 84578, 84579, 84508, 82949, 84581, 84582, 
84511, 82877, 82947, 84580, 84510
28742, 73060, 73083, 73612, 73589, 73061, 73084, 73613, 73590, 82949, 84581, 84582, 84511, 82952, 84584, 84585, 
84514, 82880, 82950, 84583, 84513
28743, 73061, 73084, 73613, 73590, 73062, 73085, 73614, 73591, 82952, 84584, 84585, 84514, 82955, 84587, 84588, 
84517, 82883, 82953, 84586, 84516
28744, 73062, 73085, 73614, 73591, 73063, 73086, 73615, 73592, 82955, 84587, 84588, 84517, 82958, 84590, 84591, 
84520, 82886, 82956, 84589, 84519
28745, 73063, 73086, 73615, 73592, 73064, 73087, 73616, 73593, 82958, 84590, 84591, 84520, 82961, 84593, 84594, 
84523, 82889, 82959, 84592, 84522
28746, 73064, 73087, 73616, 73593, 73065, 73088, 73617, 73594, 82961, 84593, 84594, 84523, 82964, 84596, 84597, 
84526, 82892, 82962, 84595, 84525
28747, 73065, 73088, 73617, 73594, 73066, 73089, 73618, 73595, 82964, 84596, 84597, 84526, 82967, 84599, 84600, 
84529, 82895, 82965, 84598, 84528
28748, 73066, 73089, 73618, 73595, 73067, 73090, 73619, 73596, 82967, 84599, 84600, 84529, 82970, 84602, 84603, 
84532, 82898, 82968, 84601, 84531
28749, 73067, 73090, 73619, 73596, 73068, 73091, 73620, 73597, 82970, 84602, 84603, 84532, 82973, 84605, 84606, 
84535, 82901, 82971, 84604, 84534
28750, 73068, 73091, 73620, 73597, 22921, 22922, 22945, 22944, 82973, 84605, 84606, 84535, 23263, 23309, 23310, 
23307, 82904, 82974, 84607, 84537
28751, 17277, 17278, 17301, 17300, 73069, 73092, 73621, 73598, 17620, 17666, 17667, 17664, 82977, 84609, 84610, 
84539, 82905, 82975, 84608, 84538
28752, 73069, 73092, 73621, 73598, 73070, 73093, 73622, 73599, 82977, 84609, 84610, 84539, 82980, 84612, 84613, 
84542, 82908, 82978, 84611, 84541
28753, 73070, 73093, 73622, 73599, 73071, 73094, 73623, 73600, 82980, 84612, 84613, 84542, 82983, 84615, 84616, 
84545, 82911, 82981, 84614, 84544
28754, 73071, 73094, 73623, 73600, 73072, 73095, 73624, 73601, 82983, 84615, 84616, 84545, 82986, 84618, 84619, 
84548, 82914, 82984, 84617, 84547
28755, 73072, 73095, 73624, 73601, 73073, 73096, 73625, 73602, 82986, 84618, 84619, 84548, 82989, 84621, 84622, 
84551, 82917, 82987, 84620, 84550
28756, 73073, 73096, 73625, 73602, 73074, 73097, 73626, 73603, 82989, 84621, 84622, 84551, 82992, 84624, 84625, 
84554, 82920, 82990, 84623, 84553
28757, 73074, 73097, 73626, 73603, 73075, 73098, 73627, 73604, 82992, 84624, 84625, 84554, 82995, 84627, 84628, 
84557, 82923, 82993, 84626, 84556
28758, 73075, 73098, 73627, 73604, 73076, 73099, 73628, 73605, 82995, 84627, 84628, 84557, 82998, 84630, 84631, 
84560, 82926, 82996, 84629, 84559
28759, 73076, 73099, 73628, 73605, 73077, 73100, 73629, 73606, 82998, 84630, 84631, 84560, 83001, 84633, 84634, 
84563, 82929, 82999, 84632, 84562
28760, 73077, 73100, 73629, 73606, 73078, 73101, 73630, 73607, 83001, 84633, 84634, 84563, 83004, 84636, 84637, 
84566, 82932, 83002, 84635, 84565
28761, 73078, 73101, 73630, 73607, 73079, 73102, 73631, 73608, 83004, 84636, 84637, 84566, 83007, 84639, 84640, 
84569, 82935, 83005, 84638, 84568
28762, 73079, 73102, 73631, 73608, 73080, 73103, 73632, 73609, 83007, 84639, 84640, 84569, 83010, 84642, 84643, 
84572, 82938, 83008, 84641, 84571
28763, 73080, 73103, 73632, 73609, 73081, 73104, 73633, 73610, 83010, 84642, 84643, 84572, 83013, 84645, 84646, 
84575, 82941, 83011, 84644, 84574
28764, 73081, 73104, 73633, 73610, 73082, 73105, 73634, 73611, 83013, 84645, 84646, 84575, 83016, 84648, 84649, 
84578, 82944, 83014, 84647, 84577
28765, 73082, 73105, 73634, 73611, 73083, 73106, 73635, 73612, 83016, 84648, 84649, 84578, 83019, 84651, 84652, 
84581, 82947, 83017, 84650, 84580
28766, 73083, 73106, 73635, 73612, 73084, 73107, 73636, 73613, 83019, 84651, 84652, 84581, 83022, 84654, 84655, 
84584, 82950, 83020, 84653, 84583
28767, 73084, 73107, 73636, 73613, 73085, 73108, 73637, 73614, 83022, 84654, 84655, 84584, 83025, 84657, 84658, 
84587, 82953, 83023, 84656, 84586
28768, 73085, 73108, 73637, 73614, 73086, 73109, 73638, 73615, 83025, 84657, 84658, 84587, 83028, 84660, 84661, 
84590, 82956, 83026, 84659, 84589
28769, 73086, 73109, 73638, 73615, 73087, 73110, 73639, 73616, 83028, 84660, 84661, 84590, 83031, 84663, 84664, 
84593, 82959, 83029, 84662, 84592
28770, 73087, 73110, 73639, 73616, 73088, 73111, 73640, 73617, 83031, 84663, 84664, 84593, 83034, 84666, 84667, 
84596, 82962, 83032, 84665, 84595
28771, 73088, 73111, 73640, 73617, 73089, 73112, 73641, 73618, 83034, 84666, 84667, 84596, 83037, 84669, 84670, 
84599, 82965, 83035, 84668, 84598
28772, 73089, 73112, 73641, 73618, 73090, 73113, 73642, 73619, 83037, 84669, 84670, 84599, 83040, 84672, 84673, 
84602, 82968, 83038, 84671, 84601
28773, 73090, 73113, 73642, 73619, 73091, 73114, 73643, 73620, 83040, 84672, 84673, 84602, 83043, 84675, 84676, 
84605, 82971, 83041, 84674, 84604
28774, 73091, 73114, 73643, 73620, 22922, 22923, 22946, 22945, 83043, 84675, 84676, 84605, 23265, 23311, 23312, 
23309, 82974, 83044, 84677, 84607
28775, 17278, 17279, 17302, 17301, 73092, 73115, 73644, 73621, 17622, 17668, 17669, 17666, 83047, 84679, 84680, 
84609, 82975, 83045, 84678, 84608
28776, 73092, 73115, 73644, 73621, 73093, 73116, 73645, 73622, 83047, 84679, 84680, 84609, 83050, 84682, 84683, 
84612, 82978, 83048, 84681, 84611
28777, 73093, 73116, 73645, 73622, 73094, 73117, 73646, 73623, 83050, 84682, 84683, 84612, 83053, 84685, 84686, 
84615, 82981, 83051, 84684, 84614
28778, 73094, 73117, 73646, 73623, 73095, 73118, 73647, 73624, 83053, 84685, 84686, 84615, 83056, 84688, 84689, 
84618, 82984, 83054, 84687, 84617
28779, 73095, 73118, 73647, 73624, 73096, 73119, 73648, 73625, 83056, 84688, 84689, 84618, 83059, 84691, 84692, 
84621, 82987, 83057, 84690, 84620
28780, 73096, 73119, 73648, 73625, 73097, 73120, 73649, 73626, 83059, 84691, 84692, 84621, 83062, 84694, 84695, 
84624, 82990, 83060, 84693, 84623
28781, 73097, 73120, 73649, 73626, 73098, 73121, 73650, 73627, 83062, 84694, 84695, 84624, 83065, 84697, 84698, 
84627, 82993, 83063, 84696, 84626
28782, 73098, 73121, 73650, 73627, 73099, 73122, 73651, 73628, 83065, 84697, 84698, 84627, 83068, 84700, 84701, 
84630, 82996, 83066, 84699, 84629
28783, 73099, 73122, 73651, 73628, 73100, 73123, 73652, 73629, 83068, 84700, 84701, 84630, 83071, 84703, 84704, 
84633, 82999, 83069, 84702, 84632
28784, 73100, 73123, 73652, 73629, 73101, 73124, 73653, 73630, 83071, 84703, 84704, 84633, 83074, 84706, 84707, 
84636, 83002, 83072, 84705, 84635
28785, 73101, 73124, 73653, 73630, 73102, 73125, 73654, 73631, 83074, 84706, 84707, 84636, 83077, 84709, 84710, 
84639, 83005, 83075, 84708, 84638
28786, 73102, 73125, 73654, 73631, 73103, 73126, 73655, 73632, 83077, 84709, 84710, 84639, 83080, 84712, 84713, 
84642, 83008, 83078, 84711, 84641
28787, 73103, 73126, 73655, 73632, 73104, 73127, 73656, 73633, 83080, 84712, 84713, 84642, 83083, 84715, 84716, 
84645, 83011, 83081, 84714, 84644
28788, 73104, 73127, 73656, 73633, 73105, 73128, 73657, 73634, 83083, 84715, 84716, 84645, 83086, 84718, 84719, 
84648, 83014, 83084, 84717, 84647
28789, 73105, 73128, 73657, 73634, 73106, 73129, 73658, 73635, 83086, 84718, 84719, 84648, 83089, 84721, 84722, 
84651, 83017, 83087, 84720, 84650
28790, 73106, 73129, 73658, 73635, 73107, 73130, 73659, 73636, 83089, 84721, 84722, 84651, 83092, 84724, 84725, 
84654, 83020, 83090, 84723, 84653
28791, 73107, 73130, 73659, 73636, 73108, 73131, 73660, 73637, 83092, 84724, 84725, 84654, 83095, 84727, 84728, 
84657, 83023, 83093, 84726, 84656
28792, 73108, 73131, 73660, 73637, 73109, 73132, 73661, 73638, 83095, 84727, 84728, 84657, 83098, 84730, 84731, 
84660, 83026, 83096, 84729, 84659
28793, 73109, 73132, 73661, 73638, 73110, 73133, 73662, 73639, 83098, 84730, 84731, 84660, 83101, 84733, 84734, 
84663, 83029, 83099, 84732, 84662
28794, 73110, 73133, 73662, 73639, 73111, 73134, 73663, 73640, 83101, 84733, 84734, 84663, 83104, 84736, 84737, 
84666, 83032, 83102, 84735, 84665
28795, 73111, 73134, 73663, 73640, 73112, 73135, 73664, 73641, 83104, 84736, 84737, 84666, 83107, 84739, 84740, 
84669, 83035, 83105, 84738, 84668
28796, 73112, 73135, 73664, 73641, 73113, 73136, 73665, 73642, 83107, 84739, 84740, 84669, 83110, 84742, 84743, 
84672, 83038, 83108, 84741, 84671
28797, 73113, 73136, 73665, 73642, 73114, 73137, 73666, 73643, 83110, 84742, 84743, 84672, 83113, 84745, 84746, 
84675, 83041, 83111, 84744, 84674
28798, 73114, 73137, 73666, 73643, 22923, 22924, 22947, 22946, 83113, 84745, 84746, 84675, 23267, 23313, 23314, 
23311, 83044, 83114, 84747, 84677
28799, 17279, 17280, 17303, 17302, 73115, 73138, 73667, 73644, 17624, 17670, 17671, 17668, 83117, 84749, 84750, 
84679, 83045, 83115, 84748, 84678
28800, 73115, 73138, 73667, 73644, 73116, 73139, 73668, 73645, 83117, 84749, 84750, 84679, 83120, 84752, 84753, 
84682, 83048, 83118, 84751, 84681
28801, 73116, 73139, 73668, 73645, 73117, 73140, 73669, 73646, 83120, 84752, 84753, 84682, 83123, 84755, 84756, 
84685, 83051, 83121, 84754, 84684
28802, 73117, 73140, 73669, 73646, 73118, 73141, 73670, 73647, 83123, 84755, 84756, 84685, 83126, 84758, 84759, 
84688, 83054, 83124, 84757, 84687
28803, 73118, 73141, 73670, 73647, 73119, 73142, 73671, 73648, 83126, 84758, 84759, 84688, 83129, 84761, 84762, 
84691, 83057, 83127, 84760, 84690
28804, 73119, 73142, 73671, 73648, 73120, 73143, 73672, 73649, 83129, 84761, 84762, 84691, 83132, 84764, 84765, 
84694, 83060, 83130, 84763, 84693
28805, 73120, 73143, 73672, 73649, 73121, 73144, 73673, 73650, 83132, 84764, 84765, 84694, 83135, 84767, 84768, 
84697, 83063, 83133, 84766, 84696
28806, 73121, 73144, 73673, 73650, 73122, 73145, 73674, 73651, 83135, 84767, 84768, 84697, 83138, 84770, 84771, 
84700, 83066, 83136, 84769, 84699
28807, 73122, 73145, 73674, 73651, 73123, 73146, 73675, 73652, 83138, 84770, 84771, 84700, 83141, 84773, 84774, 
84703, 83069, 83139, 84772, 84702
28808, 73123, 73146, 73675, 73652, 73124, 73147, 73676, 73653, 83141, 84773, 84774, 84703, 83144, 84776, 84777, 
84706, 83072, 83142, 84775, 84705
28809, 73124, 73147, 73676, 73653, 73125, 73148, 73677, 73654, 83144, 84776, 84777, 84706, 83147, 84779, 84780, 
84709, 83075, 83145, 84778, 84708
28810, 73125, 73148, 73677, 73654, 73126, 73149, 73678, 73655, 83147, 84779, 84780, 84709, 83150, 84782, 84783, 
84712, 83078, 83148, 84781, 84711
28811, 73126, 73149, 73678, 73655, 73127, 73150, 73679, 73656, 83150, 84782, 84783, 84712, 83153, 84785, 84786, 
84715, 83081, 83151, 84784, 84714
28812, 73127, 73150, 73679, 73656, 73128, 73151, 73680, 73657, 83153, 84785, 84786, 84715, 83156, 84788, 84789, 
84718, 83084, 83154, 84787, 84717
28813, 73128, 73151, 73680, 73657, 73129, 73152, 73681, 73658, 83156, 84788, 84789, 84718, 83159, 84791, 84792, 
84721, 83087, 83157, 84790, 84720
28814, 73129, 73152, 73681, 73658, 73130, 73153, 73682, 73659, 83159, 84791, 84792, 84721, 83162, 84794, 84795, 
84724, 83090, 83160, 84793, 84723
28815, 73130, 73153, 73682, 73659, 73131, 73154, 73683, 73660, 83162, 84794, 84795, 84724, 83165, 84797, 84798, 
84727, 83093, 83163, 84796, 84726
28816, 73131, 73154, 73683, 73660, 73132, 73155, 73684, 73661, 83165, 84797, 84798, 84727, 83168, 84800, 84801, 
84730, 83096, 83166, 84799, 84729
28817, 73132, 73155, 73684, 73661, 73133, 73156, 73685, 73662, 83168, 84800, 84801, 84730, 83171, 84803, 84804, 
84733, 83099, 83169, 84802, 84732
28818, 73133, 73156, 73685, 73662, 73134, 73157, 73686, 73663, 83171, 84803, 84804, 84733, 83174, 84806, 84807, 
84736, 83102, 83172, 84805, 84735
28819, 73134, 73157, 73686, 73663, 73135, 73158, 73687, 73664, 83174, 84806, 84807, 84736, 83177, 84809, 84810, 
84739, 83105, 83175, 84808, 84738
28820, 73135, 73158, 73687, 73664, 73136, 73159, 73688, 73665, 83177, 84809, 84810, 84739, 83180, 84812, 84813, 
84742, 83108, 83178, 84811, 84741
28821, 73136, 73159, 73688, 73665, 73137, 73160, 73689, 73666, 83180, 84812, 84813, 84742, 83183, 84815, 84816, 
84745, 83111, 83181, 84814, 84744
28822, 73137, 73160, 73689, 73666, 22924, 22925, 22948, 22947, 83183, 84815, 84816, 84745, 23269, 23315, 23316, 
23313, 83114, 83184, 84817, 84747
28823, 17280, 17281, 17304, 17303, 73138, 73161, 73690, 73667, 17626, 17672, 17673, 17670, 83187, 84819, 84820, 
84749, 83115, 83185, 84818, 84748
28824, 73138, 73161, 73690, 73667, 73139, 73162, 73691, 73668, 83187, 84819, 84820, 84749, 83190, 84822, 84823, 
84752, 83118, 83188, 84821, 84751
28825, 73139, 73162, 73691, 73668, 73140, 73163, 73692, 73669, 83190, 84822, 84823, 84752, 83193, 84825, 84826, 
84755, 83121, 83191, 84824, 84754
28826, 73140, 73163, 73692, 73669, 73141, 73164, 73693, 73670, 83193, 84825, 84826, 84755, 83196, 84828, 84829, 
84758, 83124, 83194, 84827, 84757
28827, 73141, 73164, 73693, 73670, 73142, 73165, 73694, 73671, 83196, 84828, 84829, 84758, 83199, 84831, 84832, 
84761, 83127, 83197, 84830, 84760
28828, 73142, 73165, 73694, 73671, 73143, 73166, 73695, 73672, 83199, 84831, 84832, 84761, 83202, 84834, 84835, 
84764, 83130, 83200, 84833, 84763
28829, 73143, 73166, 73695, 73672, 73144, 73167, 73696, 73673, 83202, 84834, 84835, 84764, 83205, 84837, 84838, 
84767, 83133, 83203, 84836, 84766
28830, 73144, 73167, 73696, 73673, 73145, 73168, 73697, 73674, 83205, 84837, 84838, 84767, 83208, 84840, 84841, 
84770, 83136, 83206, 84839, 84769
28831, 73145, 73168, 73697, 73674, 73146, 73169, 73698, 73675, 83208, 84840, 84841, 84770, 83211, 84843, 84844, 
84773, 83139, 83209, 84842, 84772
28832, 73146, 73169, 73698, 73675, 73147, 73170, 73699, 73676, 83211, 84843, 84844, 84773, 83214, 84846, 84847, 
84776, 83142, 83212, 84845, 84775
28833, 73147, 73170, 73699, 73676, 73148, 73171, 73700, 73677, 83214, 84846, 84847, 84776, 83217, 84849, 84850, 
84779, 83145, 83215, 84848, 84778
28834, 73148, 73171, 73700, 73677, 73149, 73172, 73701, 73678, 83217, 84849, 84850, 84779, 83220, 84852, 84853, 
84782, 83148, 83218, 84851, 84781
28835, 73149, 73172, 73701, 73678, 73150, 73173, 73702, 73679, 83220, 84852, 84853, 84782, 83223, 84855, 84856, 
84785, 83151, 83221, 84854, 84784
28836, 73150, 73173, 73702, 73679, 73151, 73174, 73703, 73680, 83223, 84855, 84856, 84785, 83226, 84858, 84859, 
84788, 83154, 83224, 84857, 84787
28837, 73151, 73174, 73703, 73680, 73152, 73175, 73704, 73681, 83226, 84858, 84859, 84788, 83229, 84861, 84862, 
84791, 83157, 83227, 84860, 84790
28838, 73152, 73175, 73704, 73681, 73153, 73176, 73705, 73682, 83229, 84861, 84862, 84791, 83232, 84864, 84865, 
84794, 83160, 83230, 84863, 84793
28839, 73153, 73176, 73705, 73682, 73154, 73177, 73706, 73683, 83232, 84864, 84865, 84794, 83235, 84867, 84868, 
84797, 83163, 83233, 84866, 84796
28840, 73154, 73177, 73706, 73683, 73155, 73178, 73707, 73684, 83235, 84867, 84868, 84797, 83238, 84870, 84871, 
84800, 83166, 83236, 84869, 84799
28841, 73155, 73178, 73707, 73684, 73156, 73179, 73708, 73685, 83238, 84870, 84871, 84800, 83241, 84873, 84874, 
84803, 83169, 83239, 84872, 84802
28842, 73156, 73179, 73708, 73685, 73157, 73180, 73709, 73686, 83241, 84873, 84874, 84803, 83244, 84876, 84877, 
84806, 83172, 83242, 84875, 84805
28843, 73157, 73180, 73709, 73686, 73158, 73181, 73710, 73687, 83244, 84876, 84877, 84806, 83247, 84879, 84880, 
84809, 83175, 83245, 84878, 84808
28844, 73158, 73181, 73710, 73687, 73159, 73182, 73711, 73688, 83247, 84879, 84880, 84809, 83250, 84882, 84883, 
84812, 83178, 83248, 84881, 84811
28845, 73159, 73182, 73711, 73688, 73160, 73183, 73712, 73689, 83250, 84882, 84883, 84812, 83253, 84885, 84886, 
84815, 83181, 83251, 84884, 84814
28846, 73160, 73183, 73712, 73689, 22925, 22926, 22949, 22948, 83253, 84885, 84886, 84815, 23271, 23317, 23318, 
23315, 83184, 83254, 84887, 84817
28847, 17281, 17282, 17305, 17304, 73161, 73184, 73713, 73690, 17628, 17674, 17675, 17672, 83257, 84889, 84890, 
84819, 83185, 83255, 84888, 84818
28848, 73161, 73184, 73713, 73690, 73162, 73185, 73714, 73691, 83257, 84889, 84890, 84819, 83260, 84892, 84893, 
84822, 83188, 83258, 84891, 84821
28849, 73162, 73185, 73714, 73691, 73163, 73186, 73715, 73692, 83260, 84892, 84893, 84822, 83263, 84895, 84896, 
84825, 83191, 83261, 84894, 84824
28850, 73163, 73186, 73715, 73692, 73164, 73187, 73716, 73693, 83263, 84895, 84896, 84825, 83266, 84898, 84899, 
84828, 83194, 83264, 84897, 84827
28851, 73164, 73187, 73716, 73693, 73165, 73188, 73717, 73694, 83266, 84898, 84899, 84828, 83269, 84901, 84902, 
84831, 83197, 83267, 84900, 84830
28852, 73165, 73188, 73717, 73694, 73166, 73189, 73718, 73695, 83269, 84901, 84902, 84831, 83272, 84904, 84905, 
84834, 83200, 83270, 84903, 84833
28853, 73166, 73189, 73718, 73695, 73167, 73190, 73719, 73696, 83272, 84904, 84905, 84834, 83275, 84907, 84908, 
84837, 83203, 83273, 84906, 84836
28854, 73167, 73190, 73719, 73696, 73168, 73191, 73720, 73697, 83275, 84907, 84908, 84837, 83278, 84910, 84911, 
84840, 83206, 83276, 84909, 84839
28855, 73168, 73191, 73720, 73697, 73169, 73192, 73721, 73698, 83278, 84910, 84911, 84840, 83281, 84913, 84914, 
84843, 83209, 83279, 84912, 84842
28856, 73169, 73192, 73721, 73698, 73170, 73193, 73722, 73699, 83281, 84913, 84914, 84843, 83284, 84916, 84917, 
84846, 83212, 83282, 84915, 84845
28857, 73170, 73193, 73722, 73699, 73171, 73194, 73723, 73700, 83284, 84916, 84917, 84846, 83287, 84919, 84920, 
84849, 83215, 83285, 84918, 84848
28858, 73171, 73194, 73723, 73700, 73172, 73195, 73724, 73701, 83287, 84919, 84920, 84849, 83290, 84922, 84923, 
84852, 83218, 83288, 84921, 84851
28859, 73172, 73195, 73724, 73701, 73173, 73196, 73725, 73702, 83290, 84922, 84923, 84852, 83293, 84925, 84926, 
84855, 83221, 83291, 84924, 84854
28860, 73173, 73196, 73725, 73702, 73174, 73197, 73726, 73703, 83293, 84925, 84926, 84855, 83296, 84928, 84929, 
84858, 83224, 83294, 84927, 84857
28861, 73174, 73197, 73726, 73703, 73175, 73198, 73727, 73704, 83296, 84928, 84929, 84858, 83299, 84931, 84932, 
84861, 83227, 83297, 84930, 84860
28862, 73175, 73198, 73727, 73704, 73176, 73199, 73728, 73705, 83299, 84931, 84932, 84861, 83302, 84934, 84935, 
84864, 83230, 83300, 84933, 84863
28863, 73176, 73199, 73728, 73705, 73177, 73200, 73729, 73706, 83302, 84934, 84935, 84864, 83305, 84937, 84938, 
84867, 83233, 83303, 84936, 84866
28864, 73177, 73200, 73729, 73706, 73178, 73201, 73730, 73707, 83305, 84937, 84938, 84867, 83308, 84940, 84941, 
84870, 83236, 83306, 84939, 84869
28865, 73178, 73201, 73730, 73707, 73179, 73202, 73731, 73708, 83308, 84940, 84941, 84870, 83311, 84943, 84944, 
84873, 83239, 83309, 84942, 84872
28866, 73179, 73202, 73731, 73708, 73180, 73203, 73732, 73709, 83311, 84943, 84944, 84873, 83314, 84946, 84947, 
84876, 83242, 83312, 84945, 84875
28867, 73180, 73203, 73732, 73709, 73181, 73204, 73733, 73710, 83314, 84946, 84947, 84876, 83317, 84949, 84950, 
84879, 83245, 83315, 84948, 84878
28868, 73181, 73204, 73733, 73710, 73182, 73205, 73734, 73711, 83317, 84949, 84950, 84879, 83320, 84952, 84953, 
84882, 83248, 83318, 84951, 84881
28869, 73182, 73205, 73734, 73711, 73183, 73206, 73735, 73712, 83320, 84952, 84953, 84882, 83323, 84955, 84956, 
84885, 83251, 83321, 84954, 84884
28870, 73183, 73206, 73735, 73712, 22926, 22927, 22950, 22949, 83323, 84955, 84956, 84885, 23273, 23319, 23320, 
23317, 83254, 83324, 84957, 84887
28871, 17282, 17283, 17306, 17305, 73184, 73207, 73736, 73713, 17630, 17676, 17677, 17674, 83327, 84959, 84960, 
84889, 83255, 83325, 84958, 84888
28872, 73184, 73207, 73736, 73713, 73185, 73208, 73737, 73714, 83327, 84959, 84960, 84889, 83330, 84962, 84963, 
84892, 83258, 83328, 84961, 84891
28873, 73185, 73208, 73737, 73714, 73186, 73209, 73738, 73715, 83330, 84962, 84963, 84892, 83333, 84965, 84966, 
84895, 83261, 83331, 84964, 84894
28874, 73186, 73209, 73738, 73715, 73187, 73210, 73739, 73716, 83333, 84965, 84966, 84895, 83336, 84968, 84969, 
84898, 83264, 83334, 84967, 84897
28875, 73187, 73210, 73739, 73716, 73188, 73211, 73740, 73717, 83336, 84968, 84969, 84898, 83339, 84971, 84972, 
84901, 83267, 83337, 84970, 84900
28876, 73188, 73211, 73740, 73717, 73189, 73212, 73741, 73718, 83339, 84971, 84972, 84901, 83342, 84974, 84975, 
84904, 83270, 83340, 84973, 84903
28877, 73189, 73212, 73741, 73718, 73190, 73213, 73742, 73719, 83342, 84974, 84975, 84904, 83345, 84977, 84978, 
84907, 83273, 83343, 84976, 84906
28878, 73190, 73213, 73742, 73719, 73191, 73214, 73743, 73720, 83345, 84977, 84978, 84907, 83348, 84980, 84981, 
84910, 83276, 83346, 84979, 84909
28879, 73191, 73214, 73743, 73720, 73192, 73215, 73744, 73721, 83348, 84980, 84981, 84910, 83351, 84983, 84984, 
84913, 83279, 83349, 84982, 84912
28880, 73192, 73215, 73744, 73721, 73193, 73216, 73745, 73722, 83351, 84983, 84984, 84913, 83354, 84986, 84987, 
84916, 83282, 83352, 84985, 84915
28881, 73193, 73216, 73745, 73722, 73194, 73217, 73746, 73723, 83354, 84986, 84987, 84916, 83357, 84989, 84990, 
84919, 83285, 83355, 84988, 84918
28882, 73194, 73217, 73746, 73723, 73195, 73218, 73747, 73724, 83357, 84989, 84990, 84919, 83360, 84992, 84993, 
84922, 83288, 83358, 84991, 84921
28883, 73195, 73218, 73747, 73724, 73196, 73219, 73748, 73725, 83360, 84992, 84993, 84922, 83363, 84995, 84996, 
84925, 83291, 83361, 84994, 84924
28884, 73196, 73219, 73748, 73725, 73197, 73220, 73749, 73726, 83363, 84995, 84996, 84925, 83366, 84998, 84999, 
84928, 83294, 83364, 84997, 84927
28885, 73197, 73220, 73749, 73726, 73198, 73221, 73750, 73727, 83366, 84998, 84999, 84928, 83369, 85001, 85002, 
84931, 83297, 83367, 85000, 84930
28886, 73198, 73221, 73750, 73727, 73199, 73222, 73751, 73728, 83369, 85001, 85002, 84931, 83372, 85004, 85005, 
84934, 83300, 83370, 85003, 84933
28887, 73199, 73222, 73751, 73728, 73200, 73223, 73752, 73729, 83372, 85004, 85005, 84934, 83375, 85007, 85008, 
84937, 83303, 83373, 85006, 84936
28888, 73200, 73223, 73752, 73729, 73201, 73224, 73753, 73730, 83375, 85007, 85008, 84937, 83378, 85010, 85011, 
84940, 83306, 83376, 85009, 84939
28889, 73201, 73224, 73753, 73730, 73202, 73225, 73754, 73731, 83378, 85010, 85011, 84940, 83381, 85013, 85014, 
84943, 83309, 83379, 85012, 84942
28890, 73202, 73225, 73754, 73731, 73203, 73226, 73755, 73732, 83381, 85013, 85014, 84943, 83384, 85016, 85017, 
84946, 83312, 83382, 85015, 84945
28891, 73203, 73226, 73755, 73732, 73204, 73227, 73756, 73733, 83384, 85016, 85017, 84946, 83387, 85019, 85020, 
84949, 83315, 83385, 85018, 84948
28892, 73204, 73227, 73756, 73733, 73205, 73228, 73757, 73734, 83387, 85019, 85020, 84949, 83390, 85022, 85023, 
84952, 83318, 83388, 85021, 84951
28893, 73205, 73228, 73757, 73734, 73206, 73229, 73758, 73735, 83390, 85022, 85023, 84952, 83393, 85025, 85026, 
84955, 83321, 83391, 85024, 84954
28894, 73206, 73229, 73758, 73735, 22927, 22928, 22951, 22950, 83393, 85025, 85026, 84955, 23275, 23321, 23322, 
23319, 83324, 83394, 85027, 84957
28895, 17283, 17284, 17307, 17306, 73207, 73230, 73759, 73736, 17632, 17678, 17679, 17676, 83397, 85029, 85030, 
84959, 83325, 83395, 85028, 84958
28896, 73207, 73230, 73759, 73736, 73208, 73231, 73760, 73737, 83397, 85029, 85030, 84959, 83400, 85032, 85033, 
84962, 83328, 83398, 85031, 84961
28897, 73208, 73231, 73760, 73737, 73209, 73232, 73761, 73738, 83400, 85032, 85033, 84962, 83403, 85035, 85036, 
84965, 83331, 83401, 85034, 84964
28898, 73209, 73232, 73761, 73738, 73210, 73233, 73762, 73739, 83403, 85035, 85036, 84965, 83406, 85038, 85039, 
84968, 83334, 83404, 85037, 84967
28899, 73210, 73233, 73762, 73739, 73211, 73234, 73763, 73740, 83406, 85038, 85039, 84968, 83409, 85041, 85042, 
84971, 83337, 83407, 85040, 84970
28900, 73211, 73234, 73763, 73740, 73212, 73235, 73764, 73741, 83409, 85041, 85042, 84971, 83412, 85044, 85045, 
84974, 83340, 83410, 85043, 84973
28901, 73212, 73235, 73764, 73741, 73213, 73236, 73765, 73742, 83412, 85044, 85045, 84974, 83415, 85047, 85048, 
84977, 83343, 83413, 85046, 84976
28902, 73213, 73236, 73765, 73742, 73214, 73237, 73766, 73743, 83415, 85047, 85048, 84977, 83418, 85050, 85051, 
84980, 83346, 83416, 85049, 84979
28903, 73214, 73237, 73766, 73743, 73215, 73238, 73767, 73744, 83418, 85050, 85051, 84980, 83421, 85053, 85054, 
84983, 83349, 83419, 85052, 84982
28904, 73215, 73238, 73767, 73744, 73216, 73239, 73768, 73745, 83421, 85053, 85054, 84983, 83424, 85056, 85057, 
84986, 83352, 83422, 85055, 84985
28905, 73216, 73239, 73768, 73745, 73217, 73240, 73769, 73746, 83424, 85056, 85057, 84986, 83427, 85059, 85060, 
84989, 83355, 83425, 85058, 84988
28906, 73217, 73240, 73769, 73746, 73218, 73241, 73770, 73747, 83427, 85059, 85060, 84989, 83430, 85062, 85063, 
84992, 83358, 83428, 85061, 84991
28907, 73218, 73241, 73770, 73747, 73219, 73242, 73771, 73748, 83430, 85062, 85063, 84992, 83433, 85065, 85066, 
84995, 83361, 83431, 85064, 84994
28908, 73219, 73242, 73771, 73748, 73220, 73243, 73772, 73749, 83433, 85065, 85066, 84995, 83436, 85068, 85069, 
84998, 83364, 83434, 85067, 84997
28909, 73220, 73243, 73772, 73749, 73221, 73244, 73773, 73750, 83436, 85068, 85069, 84998, 83439, 85071, 85072, 
85001, 83367, 83437, 85070, 85000
28910, 73221, 73244, 73773, 73750, 73222, 73245, 73774, 73751, 83439, 85071, 85072, 85001, 83442, 85074, 85075, 
85004, 83370, 83440, 85073, 85003
28911, 73222, 73245, 73774, 73751, 73223, 73246, 73775, 73752, 83442, 85074, 85075, 85004, 83445, 85077, 85078, 
85007, 83373, 83443, 85076, 85006
28912, 73223, 73246, 73775, 73752, 73224, 73247, 73776, 73753, 83445, 85077, 85078, 85007, 83448, 85080, 85081, 
85010, 83376, 83446, 85079, 85009
28913, 73224, 73247, 73776, 73753, 73225, 73248, 73777, 73754, 83448, 85080, 85081, 85010, 83451, 85083, 85084, 
85013, 83379, 83449, 85082, 85012
28914, 73225, 73248, 73777, 73754, 73226, 73249, 73778, 73755, 83451, 85083, 85084, 85013, 83454, 85086, 85087, 
85016, 83382, 83452, 85085, 85015
28915, 73226, 73249, 73778, 73755, 73227, 73250, 73779, 73756, 83454, 85086, 85087, 85016, 83457, 85089, 85090, 
85019, 83385, 83455, 85088, 85018
28916, 73227, 73250, 73779, 73756, 73228, 73251, 73780, 73757, 83457, 85089, 85090, 85019, 83460, 85092, 85093, 
85022, 83388, 83458, 85091, 85021
28917, 73228, 73251, 73780, 73757, 73229, 73252, 73781, 73758, 83460, 85092, 85093, 85022, 83463, 85095, 85096, 
85025, 83391, 83461, 85094, 85024
28918, 73229, 73252, 73781, 73758, 22928, 22929, 22952, 22951, 83463, 85095, 85096, 85025, 23277, 23323, 23324, 
23321, 83394, 83464, 85097, 85027
28919, 17284, 1633, 1634, 17307, 73230, 22114, 22137, 73759, 17633, 1645, 17680, 17678, 83465, 22487, 85098, 
85029, 83395, 22439, 22486, 85028
28920, 73230, 22114, 22137, 73759, 73231, 22115, 22138, 73760, 83465, 22487, 85098, 85029, 83466, 22489, 85099, 
85032, 83398, 22441, 22488, 85031
28921, 73231, 22115, 22138, 73760, 73232, 22116, 22139, 73761, 83466, 22489, 85099, 85032, 83467, 22491, 85100, 
85035, 83401, 22443, 22490, 85034
28922, 73232, 22116, 22139, 73761, 73233, 22117, 22140, 73762, 83467, 22491, 85100, 85035, 83468, 22493, 85101, 
85038, 83404, 22445, 22492, 85037
28923, 73233, 22117, 22140, 73762, 73234, 22118, 22141, 73763, 83468, 22493, 85101, 85038, 83469, 22495, 85102, 
85041, 83407, 22447, 22494, 85040
28924, 73234, 22118, 22141, 73763, 73235, 22119, 22142, 73764, 83469, 22495, 85102, 85041, 83470, 22497, 85103, 
85044, 83410, 22449, 22496, 85043
28925, 73235, 22119, 22142, 73764, 73236, 22120, 22143, 73765, 83470, 22497, 85103, 85044, 83471, 22499, 85104, 
85047, 83413, 22451, 22498, 85046
28926, 73236, 22120, 22143, 73765, 73237, 22121, 22144, 73766, 83471, 22499, 85104, 85047, 83472, 22501, 85105, 
85050, 83416, 22453, 22500, 85049
28927, 73237, 22121, 22144, 73766, 73238, 22122, 22145, 73767, 83472, 22501, 85105, 85050, 83473, 22503, 85106, 
85053, 83419, 22455, 22502, 85052
28928, 73238, 22122, 22145, 73767, 73239, 22123, 22146, 73768, 83473, 22503, 85106, 85053, 83474, 22505, 85107, 
85056, 83422, 22457, 22504, 85055
28929, 73239, 22123, 22146, 73768, 73240, 22124, 22147, 73769, 83474, 22505, 85107, 85056, 83475, 22507, 85108, 
85059, 83425, 22459, 22506, 85058
28930, 73240, 22124, 22147, 73769, 73241, 22125, 22148, 73770, 83475, 22507, 85108, 85059, 83476, 22509, 85109, 
85062, 83428, 22461, 22508, 85061
28931, 73241, 22125, 22148, 73770, 73242, 22126, 22149, 73771, 83476, 22509, 85109, 85062, 83477, 22511, 85110, 
85065, 83431, 22463, 22510, 85064
28932, 73242, 22126, 22149, 73771, 73243, 22127, 22150, 73772, 83477, 22511, 85110, 85065, 83478, 22513, 85111, 
85068, 83434, 22465, 22512, 85067
28933, 73243, 22127, 22150, 73772, 73244, 22128, 22151, 73773, 83478, 22513, 85111, 85068, 83479, 22515, 85112, 
85071, 83437, 22467, 22514, 85070
28934, 73244, 22128, 22151, 73773, 73245, 22129, 22152, 73774, 83479, 22515, 85112, 85071, 83480, 22517, 85113, 
85074, 83440, 22469, 22516, 85073
28935, 73245, 22129, 22152, 73774, 73246, 22130, 22153, 73775, 83480, 22517, 85113, 85074, 83481, 22519, 85114, 
85077, 83443, 22471, 22518, 85076
28936, 73246, 22130, 22153, 73775, 73247, 22131, 22154, 73776, 83481, 22519, 85114, 85077, 83482, 22521, 85115, 
85080, 83446, 22473, 22520, 85079
28937, 73247, 22131, 22154, 73776, 73248, 22132, 22155, 73777, 83482, 22521, 85115, 85080, 83483, 22523, 85116, 
85083, 83449, 22475, 22522, 85082
28938, 73248, 22132, 22155, 73777, 73249, 22133, 22156, 73778, 83483, 22523, 85116, 85083, 83484, 22525, 85117, 
85086, 83452, 22477, 22524, 85085
28939, 73249, 22133, 22156, 73778, 73250, 22134, 22157, 73779, 83484, 22525, 85117, 85086, 83485, 22527, 85118, 
85089, 83455, 22479, 22526, 85088
28940, 73250, 22134, 22157, 73779, 73251, 22135, 22158, 73780, 83485, 22527, 85118, 85089, 83486, 22529, 85119, 
85092, 83458, 22481, 22528, 85091
28941, 73251, 22135, 22158, 73780, 73252, 22136, 22159, 73781, 83486, 22529, 85119, 85092, 83487, 22531, 85120, 
85095, 83461, 22483, 22530, 85094
28942, 73252, 22136, 22159, 73781, 22929, 1961, 1962, 22952, 83487, 22531, 85120, 85095, 23278, 1973, 23325, 
23323, 83464, 22485, 22532, 85097
28943, 1611, 17285, 17308, 1612, 21344, 73253, 73782, 21367, 17635, 17681, 17682, 1623, 83490, 85122, 85123, 
21740, 21694, 83488, 85121, 21741
28944, 21344, 73253, 73782, 21367, 21345, 73254, 73783, 21368, 83490, 85122, 85123, 21740, 83493, 85125, 85126, 
21742, 21696, 83491, 85124, 21743
28945, 21345, 73254, 73783, 21368, 21346, 73255, 73784, 21369, 83493, 85125, 85126, 21742, 83496, 85128, 85129, 
21744, 21698, 83494, 85127, 21745
28946, 21346, 73255, 73784, 21369, 21347, 73256, 73785, 21370, 83496, 85128, 85129, 21744, 83499, 85131, 85132, 
21746, 21700, 83497, 85130, 21747
28947, 21347, 73256, 73785, 21370, 21348, 73257, 73786, 21371, 83499, 85131, 85132, 21746, 83502, 85134, 85135, 
21748, 21702, 83500, 85133, 21749
28948, 21348, 73257, 73786, 21371, 21349, 73258, 73787, 21372, 83502, 85134, 85135, 21748, 83505, 85137, 85138, 
21750, 21704, 83503, 85136, 21751
28949, 21349, 73258, 73787, 21372, 21350, 73259, 73788, 21373, 83505, 85137, 85138, 21750, 83508, 85140, 85141, 
21752, 21706, 83506, 85139, 21753
28950, 21350, 73259, 73788, 21373, 21351, 73260, 73789, 21374, 83508, 85140, 85141, 21752, 83511, 85143, 85144, 
21754, 21708, 83509, 85142, 21755
28951, 21351, 73260, 73789, 21374, 21352, 73261, 73790, 21375, 83511, 85143, 85144, 21754, 83514, 85146, 85147, 
21756, 21710, 83512, 85145, 21757
28952, 21352, 73261, 73790, 21375, 21353, 73262, 73791, 21376, 83514, 85146, 85147, 21756, 83517, 85149, 85150, 
21758, 21712, 83515, 85148, 21759
28953, 21353, 73262, 73791, 21376, 21354, 73263, 73792, 21377, 83517, 85149, 85150, 21758, 83520, 85152, 85153, 
21760, 21714, 83518, 85151, 21761
28954, 21354, 73263, 73792, 21377, 21355, 73264, 73793, 21378, 83520, 85152, 85153, 21760, 83523, 85155, 85156, 
21762, 21716, 83521, 85154, 21763
28955, 21355, 73264, 73793, 21378, 21356, 73265, 73794, 21379, 83523, 85155, 85156, 21762, 83526, 85158, 85159, 
21764, 21718, 83524, 85157, 21765
28956, 21356, 73265, 73794, 21379, 21357, 73266, 73795, 21380, 83526, 85158, 85159, 21764, 83529, 85161, 85162, 
21766, 21720, 83527, 85160, 21767
28957, 21357, 73266, 73795, 21380, 21358, 73267, 73796, 21381, 83529, 85161, 85162, 21766, 83532, 85164, 85165, 
21768, 21722, 83530, 85163, 21769
28958, 21358, 73267, 73796, 21381, 21359, 73268, 73797, 21382, 83532, 85164, 85165, 21768, 83535, 85167, 85168, 
21770, 21724, 83533, 85166, 21771
28959, 21359, 73268, 73797, 21382, 21360, 73269, 73798, 21383, 83535, 85167, 85168, 21770, 83538, 85170, 85171, 
21772, 21726, 83536, 85169, 21773
28960, 21360, 73269, 73798, 21383, 21361, 73270, 73799, 21384, 83538, 85170, 85171, 21772, 83541, 85173, 85174, 
21774, 21728, 83539, 85172, 21775
28961, 21361, 73270, 73799, 21384, 21362, 73271, 73800, 21385, 83541, 85173, 85174, 21774, 83544, 85176, 85177, 
21776, 21730, 83542, 85175, 21777
28962, 21362, 73271, 73800, 21385, 21363, 73272, 73801, 21386, 83544, 85176, 85177, 21776, 83547, 85179, 85180, 
21778, 21732, 83545, 85178, 21779
28963, 21363, 73272, 73801, 21386, 21364, 73273, 73802, 21387, 83547, 85179, 85180, 21778, 83550, 85182, 85183, 
21780, 21734, 83548, 85181, 21781
28964, 21364, 73273, 73802, 21387, 21365, 73274, 73803, 21388, 83550, 85182, 85183, 21780, 83553, 85185, 85186, 
21782, 21736, 83551, 85184, 21783
28965, 21365, 73274, 73803, 21388, 21366, 73275, 73804, 21389, 83553, 85185, 85186, 21782, 83556, 85188, 85189, 
21784, 21738, 83554, 85187, 21785
28966, 21366, 73275, 73804, 21389, 1939, 22930, 22953, 1940, 83556, 85188, 85189, 21784, 23280, 23326, 23327, 
1951, 21739, 83557, 85190, 21786
28967, 17285, 17286, 17309, 17308, 73253, 73276, 73805, 73782, 17637, 17683, 17684, 17681, 83560, 85192, 85193, 
85122, 83488, 83558, 85191, 85121
28968, 73253, 73276, 73805, 73782, 73254, 73277, 73806, 73783, 83560, 85192, 85193, 85122, 83563, 85195, 85196, 
85125, 83491, 83561, 85194, 85124
28969, 73254, 73277, 73806, 73783, 73255, 73278, 73807, 73784, 83563, 85195, 85196, 85125, 83566, 85198, 85199, 
85128, 83494, 83564, 85197, 85127
28970, 73255, 73278, 73807, 73784, 73256, 73279, 73808, 73785, 83566, 85198, 85199, 85128, 83569, 85201, 85202, 
85131, 83497, 83567, 85200, 85130
28971, 73256, 73279, 73808, 73785, 73257, 73280, 73809, 73786, 83569, 85201, 85202, 85131, 83572, 85204, 85205, 
85134, 83500, 83570, 85203, 85133
28972, 73257, 73280, 73809, 73786, 73258, 73281, 73810, 73787, 83572, 85204, 85205, 85134, 83575, 85207, 85208, 
85137, 83503, 83573, 85206, 85136
28973, 73258, 73281, 73810, 73787, 73259, 73282, 73811, 73788, 83575, 85207, 85208, 85137, 83578, 85210, 85211, 
85140, 83506, 83576, 85209, 85139
28974, 73259, 73282, 73811, 73788, 73260, 73283, 73812, 73789, 83578, 85210, 85211, 85140, 83581, 85213, 85214, 
85143, 83509, 83579, 85212, 85142
28975, 73260, 73283, 73812, 73789, 73261, 73284, 73813, 73790, 83581, 85213, 85214, 85143, 83584, 85216, 85217, 
85146, 83512, 83582, 85215, 85145
28976, 73261, 73284, 73813, 73790, 73262, 73285, 73814, 73791, 83584, 85216, 85217, 85146, 83587, 85219, 85220, 
85149, 83515, 83585, 85218, 85148
28977, 73262, 73285, 73814, 73791, 73263, 73286, 73815, 73792, 83587, 85219, 85220, 85149, 83590, 85222, 85223, 
85152, 83518, 83588, 85221, 85151
28978, 73263, 73286, 73815, 73792, 73264, 73287, 73816, 73793, 83590, 85222, 85223, 85152, 83593, 85225, 85226, 
85155, 83521, 83591, 85224, 85154
28979, 73264, 73287, 73816, 73793, 73265, 73288, 73817, 73794, 83593, 85225, 85226, 85155, 83596, 85228, 85229, 
85158, 83524, 83594, 85227, 85157
28980, 73265, 73288, 73817, 73794, 73266, 73289, 73818, 73795, 83596, 85228, 85229, 85158, 83599, 85231, 85232, 
85161, 83527, 83597, 85230, 85160
28981, 73266, 73289, 73818, 73795, 73267, 73290, 73819, 73796, 83599, 85231, 85232, 85161, 83602, 85234, 85235, 
85164, 83530, 83600, 85233, 85163
28982, 73267, 73290, 73819, 73796, 73268, 73291, 73820, 73797, 83602, 85234, 85235, 85164, 83605, 85237, 85238, 
85167, 83533, 83603, 85236, 85166
28983, 73268, 73291, 73820, 73797, 73269, 73292, 73821, 73798, 83605, 85237, 85238, 85167, 83608, 85240, 85241, 
85170, 83536, 83606, 85239, 85169
28984, 73269, 73292, 73821, 73798, 73270, 73293, 73822, 73799, 83608, 85240, 85241, 85170, 83611, 85243, 85244, 
85173, 83539, 83609, 85242, 85172
28985, 73270, 73293, 73822, 73799, 73271, 73294, 73823, 73800, 83611, 85243, 85244, 85173, 83614, 85246, 85247, 
85176, 83542, 83612, 85245, 85175
28986, 73271, 73294, 73823, 73800, 73272, 73295, 73824, 73801, 83614, 85246, 85247, 85176, 83617, 85249, 85250, 
85179, 83545, 83615, 85248, 85178
28987, 73272, 73295, 73824, 73801, 73273, 73296, 73825, 73802, 83617, 85249, 85250, 85179, 83620, 85252, 85253, 
85182, 83548, 83618, 85251, 85181
28988, 73273, 73296, 73825, 73802, 73274, 73297, 73826, 73803, 83620, 85252, 85253, 85182, 83623, 85255, 85256, 
85185, 83551, 83621, 85254, 85184
28989, 73274, 73297, 73826, 73803, 73275, 73298, 73827, 73804, 83623, 85255, 85256, 85185, 83626, 85258, 85259, 
85188, 83554, 83624, 85257, 85187
28990, 73275, 73298, 73827, 73804, 22930, 22931, 22954, 22953, 83626, 85258, 85259, 85188, 23282, 23328, 23329, 
23326, 83557, 83627, 85260, 85190
28991, 17286, 17287, 17310, 17309, 73276, 73299, 73828, 73805, 17639, 17685, 17686, 17683, 83630, 85262, 85263, 
85192, 83558, 83628, 85261, 85191
28992, 73276, 73299, 73828, 73805, 73277, 73300, 73829, 73806, 83630, 85262, 85263, 85192, 83633, 85265, 85266, 
85195, 83561, 83631, 85264, 85194
28993, 73277, 73300, 73829, 73806, 73278, 73301, 73830, 73807, 83633, 85265, 85266, 85195, 83636, 85268, 85269, 
85198, 83564, 83634, 85267, 85197
28994, 73278, 73301, 73830, 73807, 73279, 73302, 73831, 73808, 83636, 85268, 85269, 85198, 83639, 85271, 85272, 
85201, 83567, 83637, 85270, 85200
28995, 73279, 73302, 73831, 73808, 73280, 73303, 73832, 73809, 83639, 85271, 85272, 85201, 83642, 85274, 85275, 
85204, 83570, 83640, 85273, 85203
28996, 73280, 73303, 73832, 73809, 73281, 73304, 73833, 73810, 83642, 85274, 85275, 85204, 83645, 85277, 85278, 
85207, 83573, 83643, 85276, 85206
28997, 73281, 73304, 73833, 73810, 73282, 73305, 73834, 73811, 83645, 85277, 85278, 85207, 83648, 85280, 85281, 
85210, 83576, 83646, 85279, 85209
28998, 73282, 73305, 73834, 73811, 73283, 73306, 73835, 73812, 83648, 85280, 85281, 85210, 83651, 85283, 85284, 
85213, 83579, 83649, 85282, 85212
28999, 73283, 73306, 73835, 73812, 73284, 73307, 73836, 73813, 83651, 85283, 85284, 85213, 83654, 85286, 85287, 
85216, 83582, 83652, 85285, 85215
29000, 73284, 73307, 73836, 73813, 73285, 73308, 73837, 73814, 83654, 85286, 85287, 85216, 83657, 85289, 85290, 
85219, 83585, 83655, 85288, 85218
29001, 73285, 73308, 73837, 73814, 73286, 73309, 73838, 73815, 83657, 85289, 85290, 85219, 83660, 85292, 85293, 
85222, 83588, 83658, 85291, 85221
29002, 73286, 73309, 73838, 73815, 73287, 73310, 73839, 73816, 83660, 85292, 85293, 85222, 83663, 85295, 85296, 
85225, 83591, 83661, 85294, 85224
29003, 73287, 73310, 73839, 73816, 73288, 73311, 73840, 73817, 83663, 85295, 85296, 85225, 83666, 85298, 85299, 
85228, 83594, 83664, 85297, 85227
29004, 73288, 73311, 73840, 73817, 73289, 73312, 73841, 73818, 83666, 85298, 85299, 85228, 83669, 85301, 85302, 
85231, 83597, 83667, 85300, 85230
29005, 73289, 73312, 73841, 73818, 73290, 73313, 73842, 73819, 83669, 85301, 85302, 85231, 83672, 85304, 85305, 
85234, 83600, 83670, 85303, 85233
29006, 73290, 73313, 73842, 73819, 73291, 73314, 73843, 73820, 83672, 85304, 85305, 85234, 83675, 85307, 85308, 
85237, 83603, 83673, 85306, 85236
29007, 73291, 73314, 73843, 73820, 73292, 73315, 73844, 73821, 83675, 85307, 85308, 85237, 83678, 85310, 85311, 
85240, 83606, 83676, 85309, 85239
29008, 73292, 73315, 73844, 73821, 73293, 73316, 73845, 73822, 83678, 85310, 85311, 85240, 83681, 85313, 85314, 
85243, 83609, 83679, 85312, 85242
29009, 73293, 73316, 73845, 73822, 73294, 73317, 73846, 73823, 83681, 85313, 85314, 85243, 83684, 85316, 85317, 
85246, 83612, 83682, 85315, 85245
29010, 73294, 73317, 73846, 73823, 73295, 73318, 73847, 73824, 83684, 85316, 85317, 85246, 83687, 85319, 85320, 
85249, 83615, 83685, 85318, 85248
29011, 73295, 73318, 73847, 73824, 73296, 73319, 73848, 73825, 83687, 85319, 85320, 85249, 83690, 85322, 85323, 
85252, 83618, 83688, 85321, 85251
29012, 73296, 73319, 73848, 73825, 73297, 73320, 73849, 73826, 83690, 85322, 85323, 85252, 83693, 85325, 85326, 
85255, 83621, 83691, 85324, 85254
29013, 73297, 73320, 73849, 73826, 73298, 73321, 73850, 73827, 83693, 85325, 85326, 85255, 83696, 85328, 85329, 
85258, 83624, 83694, 85327, 85257
29014, 73298, 73321, 73850, 73827, 22931, 22932, 22955, 22954, 83696, 85328, 85329, 85258, 23284, 23330, 23331, 
23328, 83627, 83697, 85330, 85260
29015, 17287, 17288, 17311, 17310, 73299, 73322, 73851, 73828, 17641, 17687, 17688, 17685, 83700, 85332, 85333, 
85262, 83628, 83698, 85331, 85261
29016, 73299, 73322, 73851, 73828, 73300, 73323, 73852, 73829, 83700, 85332, 85333, 85262, 83703, 85335, 85336, 
85265, 83631, 83701, 85334, 85264
29017, 73300, 73323, 73852, 73829, 73301, 73324, 73853, 73830, 83703, 85335, 85336, 85265, 83706, 85338, 85339, 
85268, 83634, 83704, 85337, 85267
29018, 73301, 73324, 73853, 73830, 73302, 73325, 73854, 73831, 83706, 85338, 85339, 85268, 83709, 85341, 85342, 
85271, 83637, 83707, 85340, 85270
29019, 73302, 73325, 73854, 73831, 73303, 73326, 73855, 73832, 83709, 85341, 85342, 85271, 83712, 85344, 85345, 
85274, 83640, 83710, 85343, 85273
29020, 73303, 73326, 73855, 73832, 73304, 73327, 73856, 73833, 83712, 85344, 85345, 85274, 83715, 85347, 85348, 
85277, 83643, 83713, 85346, 85276
29021, 73304, 73327, 73856, 73833, 73305, 73328, 73857, 73834, 83715, 85347, 85348, 85277, 83718, 85350, 85351, 
85280, 83646, 83716, 85349, 85279
29022, 73305, 73328, 73857, 73834, 73306, 73329, 73858, 73835, 83718, 85350, 85351, 85280, 83721, 85353, 85354, 
85283, 83649, 83719, 85352, 85282
29023, 73306, 73329, 73858, 73835, 73307, 73330, 73859, 73836, 83721, 85353, 85354, 85283, 83724, 85356, 85357, 
85286, 83652, 83722, 85355, 85285
29024, 73307, 73330, 73859, 73836, 73308, 73331, 73860, 73837, 83724, 85356, 85357, 85286, 83727, 85359, 85360, 
85289, 83655, 83725, 85358, 85288
29025, 73308, 73331, 73860, 73837, 73309, 73332, 73861, 73838, 83727, 85359, 85360, 85289, 83730, 85362, 85363, 
85292, 83658, 83728, 85361, 85291
