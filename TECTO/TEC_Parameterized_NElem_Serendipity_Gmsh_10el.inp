13228, 32332, 32333, 32344, 32343, 32794, 32816, 32817, 32814
13229, 32333, 32334, 32345, 32344, 32796, 32818, 32819, 32816
13230, 32334, 32335, 32346, 32345, 32798, 32820, 32821, 32818
13231, 32335, 32336, 32347, 32346, 32800, 32822, 32823, 32820
13232, 32336, 32337, 32348, 32347, 32802, 32824, 32825, 32822
13233, 32337, 32338, 32349, 32348, 32804, 32826, 32827, 32824
13234, 32338, 32339, 32350, 32349, 32806, 32828, 32829, 32826
13235, 32339, 32340, 32351, 32350, 32808, 32830, 32831, 32828
13236, 32340, 3302, 3303, 32351, 32809, 3326, 32832, 32830
13237, 3215, 32341, 32352, 3216, 32811, 32833, 32834, 3239
13238, 32341, 32342, 32353, 32352, 32813, 32835, 32836, 32833
13239, 32342, 32343, 32354, 32353, 32815, 32837, 32838, 32835
13240, 32343, 32344, 32355, 32354, 32817, 32839, 32840, 32837
13241, 32344, 32345, 32356, 32355, 32819, 32841, 32842, 32839
13242, 32345, 32346, 32357, 32356, 32821, 32843, 32844, 32841
13243, 32346, 32347, 32358, 32357, 32823, 32845, 32846, 32843
13244, 32347, 32348, 32359, 32358, 32825, 32847, 32848, 32845
13245, 32348, 32349, 32360, 32359, 32827, 32849, 32850, 32847
13246, 32349, 32350, 32361, 32360, 32829, 32851, 32852, 32849
13247, 32350, 32351, 32362, 32361, 32831, 32853, 32854, 32851
13248, 32351, 3303, 3304, 32362, 32832, 3327, 32855, 32853
13249, 3216, 32352, 32363, 3217, 32834, 32856, 32857, 3240
13250, 32352, 32353, 32364, 32363, 32836, 32858, 32859, 32856
13251, 32353, 32354, 32365, 32364, 32838, 32860, 32861, 32858
13252, 32354, 32355, 32366, 32365, 32840, 32862, 32863, 32860
13253, 32355, 32356, 32367, 32366, 32842, 32864, 32865, 32862
13254, 32356, 32357, 32368, 32367, 32844, 32866, 32867, 32864
13255, 32357, 32358, 32369, 32368, 32846, 32868, 32869, 32866
13256, 32358, 32359, 32370, 32369, 32848, 32870, 32871, 32868
13257, 32359, 32360, 32371, 32370, 32850, 32872, 32873, 32870
13258, 32360, 32361, 32372, 32371, 32852, 32874, 32875, 32872
13259, 32361, 32362, 32373, 32372, 32854, 32876, 32877, 32874
13260, 32362, 3304, 3305, 32373, 32855, 3328, 32878, 32876
13261, 3217, 32363, 32374, 3218, 32857, 32879, 32880, 3241
13262, 32363, 32364, 32375, 32374, 32859, 32881, 32882, 32879
13263, 32364, 32365, 32376, 32375, 32861, 32883, 32884, 32881
13264, 32365, 32366, 32377, 32376, 32863, 32885, 32886, 32883
13265, 32366, 32367, 32378, 32377, 32865, 32887, 32888, 32885
13266, 32367, 32368, 32379, 32378, 32867, 32889, 32890, 32887
13267, 32368, 32369, 32380, 32379, 32869, 32891, 32892, 32889
13268, 32369, 32370, 32381, 32380, 32871, 32893, 32894, 32891
13269, 32370, 32371, 32382, 32381, 32873, 32895, 32896, 32893
13270, 32371, 32372, 32383, 32382, 32875, 32897, 32898, 32895
13271, 32372, 32373, 32384, 32383, 32877, 32899, 32900, 32897
13272, 32373, 3305, 3306, 32384, 32878, 3329, 32901, 32899
13273, 3218, 32374, 32385, 3219, 32880, 32902, 32903, 3242
13274, 32374, 32375, 32386, 32385, 32882, 32904, 32905, 32902
13275, 32375, 32376, 32387, 32386, 32884, 32906, 32907, 32904
13276, 32376, 32377, 32388, 32387, 32886, 32908, 32909, 32906
13277, 32377, 32378, 32389, 32388, 32888, 32910, 32911, 32908
13278, 32378, 32379, 32390, 32389, 32890, 32912, 32913, 32910
13279, 32379, 32380, 32391, 32390, 32892, 32914, 32915, 32912
13280, 32380, 32381, 32392, 32391, 32894, 32916, 32917, 32914
13281, 32381, 32382, 32393, 32392, 32896, 32918, 32919, 32916
13282, 32382, 32383, 32394, 32393, 32898, 32920, 32921, 32918
13283, 32383, 32384, 32395, 32394, 32900, 32922, 32923, 32920
13284, 32384, 3306, 3307, 32395, 32901, 3330, 32924, 32922
13285, 3219, 32385, 3253, 77, 32903, 32925, 3264, 3243
13286, 32385, 32386, 3254, 3253, 32905, 32926, 3265, 32925
13287, 32386, 32387, 3255, 3254, 32907, 32927, 3266, 32926
13288, 32387, 32388, 3256, 3255, 32909, 32928, 3267, 32927
13289, 32388, 32389, 3257, 3256, 32911, 32929, 3268, 32928
13290, 32389, 32390, 3258, 3257, 32913, 32930, 3269, 32929
13291, 32390, 32391, 3259, 3258, 32915, 32931, 3270, 32930
13292, 32391, 32392, 3260, 3259, 32917, 32932, 3271, 32931
13293, 32392, 32393, 3261, 3260, 32919, 32933, 3272, 32932
13294, 32393, 32394, 3262, 3261, 32921, 32934, 3273, 32933
13295, 32394, 32395, 3263, 3262, 32923, 32935, 3274, 32934
13296, 32395, 3307, 79, 3263, 32924, 3331, 3275, 32935
*ELEMENT, type=CPS8, ELSET=Surface110
13297, 23, 1182, 32936, 3244, 1186, 32952, 32953, 3248
13298, 3244, 32936, 32937, 3245, 32953, 32954, 32955, 3249
13299, 3245, 32937, 32938, 3246, 32955, 32956, 32957, 3250
13300, 3246, 32938, 32939, 3247, 32957, 32958, 32959, 3251
13301, 3247, 32939, 3364, 79, 32959, 32960, 3368, 3252
13302, 1182, 1183, 32940, 32936, 1187, 32961, 32962, 32952
13303, 32936, 32940, 32941, 32937, 32962, 32963, 32964, 32954
13304, 32937, 32941, 32942, 32938, 32964, 32965, 32966, 32956
13305, 32938, 32942, 32943, 32939, 32966, 32967, 32968, 32958
13306, 32939, 32943, 3365, 3364, 32968, 32969, 3369, 32960
13307, 1183, 1184, 32944, 32940, 1188, 32970, 32971, 32961
13308, 32940, 32944, 32945, 32941, 32971, 32972, 32973, 32963
13309, 32941, 32945, 32946, 32942, 32973, 32974, 32975, 32965
13310, 32942, 32946, 32947, 32943, 32975, 32976, 32977, 32967
13311, 32943, 32947, 3366, 3365, 32977, 32978, 3370, 32969
13312, 1184, 1185, 32948, 32944, 1189, 32979, 32980, 32970
13313, 32944, 32948, 32949, 32945, 32980, 32981, 32982, 32972
13314, 32945, 32949, 32950, 32946, 32982, 32983, 32984, 32974
13315, 32946, 32950, 32951, 32947, 32984, 32985, 32986, 32976
13316, 32947, 32951, 3367, 3366, 32986, 32987, 3371, 32978
13317, 1185, 26, 3355, 32948, 1190, 3359, 32988, 32979
13318, 32948, 3355, 3356, 32949, 32988, 3360, 32989, 32981
13319, 32949, 3356, 3357, 32950, 32989, 3361, 32990, 32983
13320, 32950, 3357, 3358, 32951, 32990, 3362, 32991, 32985
13321, 32951, 3358, 81, 3367, 32991, 3363, 3372, 32987
*ELEMENT, type=CPS8, ELSET=Surface111
13322, 21, 3179, 32992, 1205, 3183, 33008, 33009, 1209
13323, 3179, 3180, 32993, 32992, 3184, 33010, 33011, 33008
13324, 3180, 3181, 32994, 32993, 3185, 33012, 33013, 33010
13325, 3181, 3182, 32995, 32994, 3186, 33014, 33015, 33012
13326, 3182, 77, 3382, 32995, 3187, 3386, 33016, 33014
13327, 1205, 32992, 32996, 1206, 33009, 33017, 33018, 1210
13328, 32992, 32993, 32997, 32996, 33011, 33019, 33020, 33017
13329, 32993, 32994, 32998, 32997, 33013, 33021, 33022, 33019
13330, 32994, 32995, 32999, 32998, 33015, 33023, 33024, 33021
13331, 32995, 3382, 3383, 32999, 33016, 3387, 33025, 33023
13332, 1206, 32996, 33000, 1207, 33018, 33026, 33027, 1211
13333, 32996, 32997, 33001, 33000, 33020, 33028, 33029, 33026
13334, 32997, 32998, 33002, 33001, 33022, 33030, 33031, 33028
13335, 32998, 32999, 33003, 33002, 33024, 33032, 33033, 33030
13336, 32999, 3383, 3384, 33003, 33025, 3388, 33034, 33032
13337, 1207, 33000, 33004, 1208, 33027, 33035, 33036, 1212
13338, 33000, 33001, 33005, 33004, 33029, 33037, 33038, 33035
13339, 33001, 33002, 33006, 33005, 33031, 33039, 33040, 33037
13340, 33002, 33003, 33007, 33006, 33033, 33041, 33042, 33039
13341, 33003, 3384, 3385, 33007, 33034, 3389, 33043, 33041
13342, 1208, 33004, 3373, 28, 33036, 33044, 3377, 1213
13343, 33004, 33005, 3374, 3373, 33038, 33045, 3378, 33044
13344, 33005, 33006, 3375, 3374, 33040, 33046, 3379, 33045
13345, 33006, 33007, 3376, 3375, 33042, 33047, 3380, 33046
13346, 33007, 3385, 82, 3376, 33043, 3390, 3381, 33047
*ELEMENT, type=CPS8, ELSET=Surface112
13347, 28, 3373, 33048, 1242, 3377, 33092, 33093, 1253
13348, 3373, 3374, 33049, 33048, 3378, 33094, 33095, 33092
13349, 3374, 3375, 33050, 33049, 3379, 33096, 33097, 33094
13350, 3375, 3376, 33051, 33050, 3380, 33098, 33099, 33096
13351, 3376, 82, 3391, 33051, 3381, 3402, 33100, 33098
13352, 1242, 33048, 33052, 1243, 33093, 33101, 33102, 1254
13353, 33048, 33049, 33053, 33052, 33095, 33103, 33104, 33101
13354, 33049, 33050, 33054, 33053, 33097, 33105, 33106, 33103
13355, 33050, 33051, 33055, 33054, 33099, 33107, 33108, 33105
13356, 33051, 3391, 3392, 33055, 33100, 3403, 33109, 33107
13357, 1243, 33052, 33056, 1244, 33102, 33110, 33111, 1255
13358, 33052, 33053, 33057, 33056, 33104, 33112, 33113, 33110
13359, 33053, 33054, 33058, 33057, 33106, 33114, 33115, 33112
13360, 33054, 33055, 33059, 33058, 33108, 33116, 33117, 33114
13361, 33055, 3392, 3393, 33059, 33109, 3404, 33118, 33116
13362, 1244, 33056, 33060, 1245, 33111, 33119, 33120, 1256
13363, 33056, 33057, 33061, 33060, 33113, 33121, 33122, 33119
13364, 33057, 33058, 33062, 33061, 33115, 33123, 33124, 33121
13365, 33058, 33059, 33063, 33062, 33117, 33125, 33126, 33123
13366, 33059, 3393, 3394, 33063, 33118, 3405, 33127, 33125
13367, 1245, 33060, 33064, 1246, 33120, 33128, 33129, 1257
13368, 33060, 33061, 33065, 33064, 33122, 33130, 33131, 33128
13369, 33061, 33062, 33066, 33065, 33124, 33132, 33133, 33130
13370, 33062, 33063, 33067, 33066, 33126, 33134, 33135, 33132
13371, 33063, 3394, 3395, 33067, 33127, 3406, 33136, 33134
13372, 1246, 33064, 33068, 1247, 33129, 33137, 33138, 1258
13373, 33064, 33065, 33069, 33068, 33131, 33139, 33140, 33137
13374, 33065, 33066, 33070, 33069, 33133, 33141, 33142, 33139
13375, 33066, 33067, 33071, 33070, 33135, 33143, 33144, 33141
13376, 33067, 3395, 3396, 33071, 33136, 3407, 33145, 33143
13377, 1247, 33068, 33072, 1248, 33138, 33146, 33147, 1259
13378, 33068, 33069, 33073, 33072, 33140, 33148, 33149, 33146
13379, 33069, 33070, 33074, 33073, 33142, 33150, 33151, 33148
13380, 33070, 33071, 33075, 33074, 33144, 33152, 33153, 33150
13381, 33071, 3396, 3397, 33075, 33145, 3408, 33154, 33152
13382, 1248, 33072, 33076, 1249, 33147, 33155, 33156, 1260
13383, 33072, 33073, 33077, 33076, 33149, 33157, 33158, 33155
13384, 33073, 33074, 33078, 33077, 33151, 33159, 33160, 33157
13385, 33074, 33075, 33079, 33078, 33153, 33161, 33162, 33159
13386, 33075, 3397, 3398, 33079, 33154, 3409, 33163, 33161
13387, 1249, 33076, 33080, 1250, 33156, 33164, 33165, 1261
13388, 33076, 33077, 33081, 33080, 33158, 33166, 33167, 33164
13389, 33077, 33078, 33082, 33081, 33160, 33168, 33169, 33166
13390, 33078, 33079, 33083, 33082, 33162, 33170, 33171, 33168
13391, 33079, 3398, 3399, 33083, 33163, 3410, 33172, 33170
13392, 1250, 33080, 33084, 1251, 33165, 33173, 33174, 1262
13393, 33080, 33081, 33085, 33084, 33167, 33175, 33176, 33173
13394, 33081, 33082, 33086, 33085, 33169, 33177, 33178, 33175
13395, 33082, 33083, 33087, 33086, 33171, 33179, 33180, 33177
13396, 33083, 3399, 3400, 33087, 33172, 3411, 33181, 33179
13397, 1251, 33084, 33088, 1252, 33174, 33182, 33183, 1263
13398, 33084, 33085, 33089, 33088, 33176, 33184, 33185, 33182
13399, 33085, 33086, 33090, 33089, 33178, 33186, 33187, 33184
13400, 33086, 33087, 33091, 33090, 33180, 33188, 33189, 33186
13401, 33087, 3400, 3401, 33091, 33181, 3412, 33190, 33188
13402, 1252, 33088, 3355, 26, 33183, 33191, 3359, 1264
13403, 33088, 33089, 3356, 3355, 33185, 33192, 3360, 33191
13404, 33089, 33090, 3357, 3356, 33187, 33193, 3361, 33192
13405, 33090, 33091, 3358, 3357, 33189, 33194, 3362, 33193
13406, 33091, 3401, 81, 3358, 33190, 3413, 3363, 33194
*ELEMENT, type=CPS8, ELSET=Surface113
13407, 77, 3253, 33195, 3382, 3264, 33239, 33240, 3386
13408, 3382, 33195, 33196, 3383, 33240, 33241, 33242, 3387
13409, 3383, 33196, 33197, 3384, 33242, 33243, 33244, 3388
13410, 3384, 33197, 33198, 3385, 33244, 33245, 33246, 3389
13411, 3385, 33198, 3391, 82, 33246, 33247, 3402, 3390
13412, 3253, 3254, 33199, 33195, 3265, 33248, 33249, 33239
13413, 33195, 33199, 33200, 33196, 33249, 33250, 33251, 33241
13414, 33196, 33200, 33201, 33197, 33251, 33252, 33253, 33243
13415, 33197, 33201, 33202, 33198, 33253, 33254, 33255, 33245
13416, 33198, 33202, 3392, 3391, 33255, 33256, 3403, 33247
13417, 3254, 3255, 33203, 33199, 3266, 33257, 33258, 33248
13418, 33199, 33203, 33204, 33200, 33258, 33259, 33260, 33250
13419, 33200, 33204, 33205, 33201, 33260, 33261, 33262, 33252
13420, 33201, 33205, 33206, 33202, 33262, 33263, 33264, 33254
13421, 33202, 33206, 3393, 3392, 33264, 33265, 3404, 33256
13422, 3255, 3256, 33207, 33203, 3267, 33266, 33267, 33257
13423, 33203, 33207, 33208, 33204, 33267, 33268, 33269, 33259
13424, 33204, 33208, 33209, 33205, 33269, 33270, 33271, 33261
13425, 33205, 33209, 33210, 33206, 33271, 33272, 33273, 33263
13426, 33206, 33210, 3394, 3393, 33273, 33274, 3405, 33265
13427, 3256, 3257, 33211, 33207, 3268, 33275, 33276, 33266
13428, 33207, 33211, 33212, 33208, 33276, 33277, 33278, 33268
13429, 33208, 33212, 33213, 33209, 33278, 33279, 33280, 33270
13430, 33209, 33213, 33214, 33210, 33280, 33281, 33282, 33272
13431, 33210, 33214, 3395, 3394, 33282, 33283, 3406, 33274
13432, 3257, 3258, 33215, 33211, 3269, 33284, 33285, 33275
13433, 33211, 33215, 33216, 33212, 33285, 33286, 33287, 33277
13434, 33212, 33216, 33217, 33213, 33287, 33288, 33289, 33279
13435, 33213, 33217, 33218, 33214, 33289, 33290, 33291, 33281
13436, 33214, 33218, 3396, 3395, 33291, 33292, 3407, 33283
13437, 3258, 3259, 33219, 33215, 3270, 33293, 33294, 33284
13438, 33215, 33219, 33220, 33216, 33294, 33295, 33296, 33286
13439, 33216, 33220, 33221, 33217, 33296, 33297, 33298, 33288
13440, 33217, 33221, 33222, 33218, 33298, 33299, 33300, 33290
13441, 33218, 33222, 3397, 3396, 33300, 33301, 3408, 33292
13442, 3259, 3260, 33223, 33219, 3271, 33302, 33303, 33293
13443, 33219, 33223, 33224, 33220, 33303, 33304, 33305, 33295
13444, 33220, 33224, 33225, 33221, 33305, 33306, 33307, 33297
13445, 33221, 33225, 33226, 33222, 33307, 33308, 33309, 33299
13446, 33222, 33226, 3398, 3397, 33309, 33310, 3409, 33301
13447, 3260, 3261, 33227, 33223, 3272, 33311, 33312, 33302
13448, 33223, 33227, 33228, 33224, 33312, 33313, 33314, 33304
13449, 33224, 33228, 33229, 33225, 33314, 33315, 33316, 33306
13450, 33225, 33229, 33230, 33226, 33316, 33317, 33318, 33308
13451, 33226, 33230, 3399, 3398, 33318, 33319, 3410, 33310
13452, 3261, 3262, 33231, 33227, 3273, 33320, 33321, 33311
13453, 33227, 33231, 33232, 33228, 33321, 33322, 33323, 33313
13454, 33228, 33232, 33233, 33229, 33323, 33324, 33325, 33315
13455, 33229, 33233, 33234, 33230, 33325, 33326, 33327, 33317
13456, 33230, 33234, 3400, 3399, 33327, 33328, 3411, 33319
13457, 3262, 3263, 33235, 33231, 3274, 33329, 33330, 33320
13458, 33231, 33235, 33236, 33232, 33330, 33331, 33332, 33322
13459, 33232, 33236, 33237, 33233, 33332, 33333, 33334, 33324
13460, 33233, 33237, 33238, 33234, 33334, 33335, 33336, 33326
13461, 33234, 33238, 3401, 3400, 33336, 33337, 3412, 33328
13462, 3263, 79, 3364, 33235, 3275, 3368, 33338, 33329
13463, 33235, 3364, 3365, 33236, 33338, 3369, 33339, 33331
13464, 33236, 3365, 3366, 33237, 33339, 3370, 33340, 33333
13465, 33237, 3366, 3367, 33238, 33340, 3371, 33341, 33335
13466, 33238, 3367, 81, 3401, 33341, 3372, 3413, 33337
*ELEMENT, type=CPS8, ELSET=Surface114
13467, 26, 1312, 33342, 3355, 1335, 33434, 33435, 3359
13468, 3355, 33342, 33343, 3356, 33435, 33436, 33437, 3360
13469, 3356, 33343, 33344, 3357, 33437, 33438, 33439, 3361
13470, 3357, 33344, 33345, 3358, 33439, 33440, 33441, 3362
13471, 3358, 33345, 3423, 81, 33441, 33442, 3446, 3363
13472, 1312, 1313, 33346, 33342, 1336, 33443, 33444, 33434
13473, 33342, 33346, 33347, 33343, 33444, 33445, 33446, 33436
13474, 33343, 33347, 33348, 33344, 33446, 33447, 33448, 33438
13475, 33344, 33348, 33349, 33345, 33448, 33449, 33450, 33440
13476, 33345, 33349, 3424, 3423, 33450, 33451, 3447, 33442
13477, 1313, 1314, 33350, 33346, 1337, 33452, 33453, 33443
13478, 33346, 33350, 33351, 33347, 33453, 33454, 33455, 33445
13479, 33347, 33351, 33352, 33348, 33455, 33456, 33457, 33447
13480, 33348, 33352, 33353, 33349, 33457, 33458, 33459, 33449
13481, 33349, 33353, 3425, 3424, 33459, 33460, 3448, 33451
13482, 1314, 1315, 33354, 33350, 1338, 33461, 33462, 33452
13483, 33350, 33354, 33355, 33351, 33462, 33463, 33464, 33454
13484, 33351, 33355, 33356, 33352, 33464, 33465, 33466, 33456
13485, 33352, 33356, 33357, 33353, 33466, 33467, 33468, 33458
13486, 33353, 33357, 3426, 3425, 33468, 33469, 3449, 33460
13487, 1315, 1316, 33358, 33354, 1339, 33470, 33471, 33461
13488, 33354, 33358, 33359, 33355, 33471, 33472, 33473, 33463
13489, 33355, 33359, 33360, 33356, 33473, 33474, 33475, 33465
13490, 33356, 33360, 33361, 33357, 33475, 33476, 33477, 33467
13491, 33357, 33361, 3427, 3426, 33477, 33478, 3450, 33469
13492, 1316, 1317, 33362, 33358, 1340, 33479, 33480, 33470
13493, 33358, 33362, 33363, 33359, 33480, 33481, 33482, 33472
13494, 33359, 33363, 33364, 33360, 33482, 33483, 33484, 33474
13495, 33360, 33364, 33365, 33361, 33484, 33485, 33486, 33476
13496, 33361, 33365, 3428, 3427, 33486, 33487, 3451, 33478
13497, 1317, 1318, 33366, 33362, 1341, 33488, 33489, 33479
13498, 33362, 33366, 33367, 33363, 33489, 33490, 33491, 33481
13499, 33363, 33367, 33368, 33364, 33491, 33492, 33493, 33483
13500, 33364, 33368, 33369, 33365, 33493, 33494, 33495, 33485
13501, 33365, 33369, 3429, 3428, 33495, 33496, 3452, 33487
13502, 1318, 1319, 33370, 33366, 1342, 33497, 33498, 33488
13503, 33366, 33370, 33371, 33367, 33498, 33499, 33500, 33490
13504, 33367, 33371, 33372, 33368, 33500, 33501, 33502, 33492
13505, 33368, 33372, 33373, 33369, 33502, 33503, 33504, 33494
13506, 33369, 33373, 3430, 3429, 33504, 33505, 3453, 33496
13507, 1319, 1320, 33374, 33370, 1343, 33506, 33507, 33497
13508, 33370, 33374, 33375, 33371, 33507, 33508, 33509, 33499
13509, 33371, 33375, 33376, 33372, 33509, 33510, 33511, 33501
13510, 33372, 33376, 33377, 33373, 33511, 33512, 33513, 33503
13511, 33373, 33377, 3431, 3430, 33513, 33514, 3454, 33505
13512, 1320, 1321, 33378, 33374, 1344, 33515, 33516, 33506
13513, 33374, 33378, 33379, 33375, 33516, 33517, 33518, 33508
13514, 33375, 33379, 33380, 33376, 33518, 33519, 33520, 33510
13515, 33376, 33380, 33381, 33377, 33520, 33521, 33522, 33512
13516, 33377, 33381, 3432, 3431, 33522, 33523, 3455, 33514
13517, 1321, 1322, 33382, 33378, 1345, 33524, 33525, 33515
13518, 33378, 33382, 33383, 33379, 33525, 33526, 33527, 33517
13519, 33379, 33383, 33384, 33380, 33527, 33528, 33529, 33519
13520, 33380, 33384, 33385, 33381, 33529, 33530, 33531, 33521
13521, 33381, 33385, 3433, 3432, 33531, 33532, 3456, 33523
13522, 1322, 1323, 33386, 33382, 1346, 33533, 33534, 33524
13523, 33382, 33386, 33387, 33383, 33534, 33535, 33536, 33526
13524, 33383, 33387, 33388, 33384, 33536, 33537, 33538, 33528
13525, 33384, 33388, 33389, 33385, 33538, 33539, 33540, 33530
13526, 33385, 33389, 3434, 3433, 33540, 33541, 3457, 33532
13527, 1323, 1324, 33390, 33386, 1347, 33542, 33543, 33533
13528, 33386, 33390, 33391, 33387, 33543, 33544, 33545, 33535
13529, 33387, 33391, 33392, 33388, 33545, 33546, 33547, 33537
13530, 33388, 33392, 33393, 33389, 33547, 33548, 33549, 33539
13531, 33389, 33393, 3435, 3434, 33549, 33550, 3458, 33541
13532, 1324, 1325, 33394, 33390, 1348, 33551, 33552, 33542
13533, 33390, 33394, 33395, 33391, 33552, 33553, 33554, 33544
13534, 33391, 33395, 33396, 33392, 33554, 33555, 33556, 33546
13535, 33392, 33396, 33397, 33393, 33556, 33557, 33558, 33548
13536, 33393, 33397, 3436, 3435, 33558, 33559, 3459, 33550
13537, 1325, 1326, 33398, 33394, 1349, 33560, 33561, 33551
13538, 33394, 33398, 33399, 33395, 33561, 33562, 33563, 33553
13539, 33395, 33399, 33400, 33396, 33563, 33564, 33565, 33555
13540, 33396, 33400, 33401, 33397, 33565, 33566, 33567, 33557
13541, 33397, 33401, 3437, 3436, 33567, 33568, 3460, 33559
13542, 1326, 1327, 33402, 33398, 1350, 33569, 33570, 33560
13543, 33398, 33402, 33403, 33399, 33570, 33571, 33572, 33562
13544, 33399, 33403, 33404, 33400, 33572, 33573, 33574, 33564
13545, 33400, 33404, 33405, 33401, 33574, 33575, 33576, 33566
13546, 33401, 33405, 3438, 3437, 33576, 33577, 3461, 33568
13547, 1327, 1328, 33406, 33402, 1351, 33578, 33579, 33569
13548, 33402, 33406, 33407, 33403, 33579, 33580, 33581, 33571
13549, 33403, 33407, 33408, 33404, 33581, 33582, 33583, 33573
13550, 33404, 33408, 33409, 33405, 33583, 33584, 33585, 33575
13551, 33405, 33409, 3439, 3438, 33585, 33586, 3462, 33577
13552, 1328, 1329, 33410, 33406, 1352, 33587, 33588, 33578
13553, 33406, 33410, 33411, 33407, 33588, 33589, 33590, 33580
13554, 33407, 33411, 33412, 33408, 33590, 33591, 33592, 33582
13555, 33408, 33412, 33413, 33409, 33592, 33593, 33594, 33584
13556, 33409, 33413, 3440, 3439, 33594, 33595, 3463, 33586
13557, 1329, 1330, 33414, 33410, 1353, 33596, 33597, 33587
13558, 33410, 33414, 33415, 33411, 33597, 33598, 33599, 33589
13559, 33411, 33415, 33416, 33412, 33599, 33600, 33601, 33591
13560, 33412, 33416, 33417, 33413, 33601, 33602, 33603, 33593
13561, 33413, 33417, 3441, 3440, 33603, 33604, 3464, 33595
13562, 1330, 1331, 33418, 33414, 1354, 33605, 33606, 33596
13563, 33414, 33418, 33419, 33415, 33606, 33607, 33608, 33598
13564, 33415, 33419, 33420, 33416, 33608, 33609, 33610, 33600
13565, 33416, 33420, 33421, 33417, 33610, 33611, 33612, 33602
13566, 33417, 33421, 3442, 3441, 33612, 33613, 3465, 33604
13567, 1331, 1332, 33422, 33418, 1355, 33614, 33615, 33605
13568, 33418, 33422, 33423, 33419, 33615, 33616, 33617, 33607
13569, 33419, 33423, 33424, 33420, 33617, 33618, 33619, 33609
13570, 33420, 33424, 33425, 33421, 33619, 33620, 33621, 33611
13571, 33421, 33425, 3443, 3442, 33621, 33622, 3466, 33613
13572, 1332, 1333, 33426, 33422, 1356, 33623, 33624, 33614
13573, 33422, 33426, 33427, 33423, 33624, 33625, 33626, 33616
13574, 33423, 33427, 33428, 33424, 33626, 33627, 33628, 33618
13575, 33424, 33428, 33429, 33425, 33628, 33629, 33630, 33620
13576, 33425, 33429, 3444, 3443, 33630, 33631, 3467, 33622
13577, 1333, 1334, 33430, 33426, 1357, 33632, 33633, 33623
13578, 33426, 33430, 33431, 33427, 33633, 33634, 33635, 33625
13579, 33427, 33431, 33432, 33428, 33635, 33636, 33637, 33627
13580, 33428, 33432, 33433, 33429, 33637, 33638, 33639, 33629
13581, 33429, 33433, 3445, 3444, 33639, 33640, 3468, 33631
13582, 1334, 30, 3414, 33430, 1358, 3418, 33641, 33632
13583, 33430, 3414, 3415, 33431, 33641, 3419, 33642, 33634
13584, 33431, 3415, 3416, 33432, 33642, 3420, 33643, 33636
13585, 33432, 3416, 3417, 33433, 33643, 3421, 33644, 33638
13586, 33433, 3417, 83, 3445, 33644, 3422, 3469, 33640
*ELEMENT, type=CPS8, ELSET=Surface115
13587, 28, 3373, 33645, 1411, 3377, 33737, 33738, 1434
13588, 3373, 3374, 33646, 33645, 3378, 33739, 33740, 33737
13589, 3374, 3375, 33647, 33646, 3379, 33741, 33742, 33739
13590, 3375, 3376, 33648, 33647, 3380, 33743, 33744, 33741
13591, 3376, 82, 3479, 33648, 3381, 3502, 33745, 33743
13592, 1411, 33645, 33649, 1412, 33738, 33746, 33747, 1435
13593, 33645, 33646, 33650, 33649, 33740, 33748, 33749, 33746
13594, 33646, 33647, 33651, 33650, 33742, 33750, 33751, 33748
13595, 33647, 33648, 33652, 33651, 33744, 33752, 33753, 33750
13596, 33648, 3479, 3480, 33652, 33745, 3503, 33754, 33752
13597, 1412, 33649, 33653, 1413, 33747, 33755, 33756, 1436
13598, 33649, 33650, 33654, 33653, 33749, 33757, 33758, 33755
13599, 33650, 33651, 33655, 33654, 33751, 33759, 33760, 33757
13600, 33651, 33652, 33656, 33655, 33753, 33761, 33762, 33759
13601, 33652, 3480, 3481, 33656, 33754, 3504, 33763, 33761
13602, 1413, 33653, 33657, 1414, 33756, 33764, 33765, 1437
13603, 33653, 33654, 33658, 33657, 33758, 33766, 33767, 33764
13604, 33654, 33655, 33659, 33658, 33760, 33768, 33769, 33766
13605, 33655, 33656, 33660, 33659, 33762, 33770, 33771, 33768
13606, 33656, 3481, 3482, 33660, 33763, 3505, 33772, 33770
13607, 1414, 33657, 33661, 1415, 33765, 33773, 33774, 1438
13608, 33657, 33658, 33662, 33661, 33767, 33775, 33776, 33773
13609, 33658, 33659, 33663, 33662, 33769, 33777, 33778, 33775
13610, 33659, 33660, 33664, 33663, 33771, 33779, 33780, 33777
13611, 33660, 3482, 3483, 33664, 33772, 3506, 33781, 33779
13612, 1415, 33661, 33665, 1416, 33774, 33782, 33783, 1439
13613, 33661, 33662, 33666, 33665, 33776, 33784, 33785, 33782
13614, 33662, 33663, 33667, 33666, 33778, 33786, 33787, 33784
13615, 33663, 33664, 33668, 33667, 33780, 33788, 33789, 33786
13616, 33664, 3483, 3484, 33668, 33781, 3507, 33790, 33788
13617, 1416, 33665, 33669, 1417, 33783, 33791, 33792, 1440
13618, 33665, 33666, 33670, 33669, 33785, 33793, 33794, 33791
13619, 33666, 33667, 33671, 33670, 33787, 33795, 33796, 33793
13620, 33667, 33668, 33672, 33671, 33789, 33797, 33798, 33795
13621, 33668, 3484, 3485, 33672, 33790, 3508, 33799, 33797
13622, 1417, 33669, 33673, 1418, 33792, 33800, 33801, 1441
13623, 33669, 33670, 33674, 33673, 33794, 33802, 33803, 33800
13624, 33670, 33671, 33675, 33674, 33796, 33804, 33805, 33802
13625, 33671, 33672, 33676, 33675, 33798, 33806, 33807, 33804
13626, 33672, 3485, 3486, 33676, 33799, 3509, 33808, 33806
13627, 1418, 33673, 33677, 1419, 33801, 33809, 33810, 1442
13628, 33673, 33674, 33678, 33677, 33803, 33811, 33812, 33809
13629, 33674, 33675, 33679, 33678, 33805, 33813, 33814, 33811
13630, 33675, 33676, 33680, 33679, 33807, 33815, 33816, 33813
13631, 33676, 3486, 3487, 33680, 33808, 3510, 33817, 33815
13632, 1419, 33677, 33681, 1420, 33810, 33818, 33819, 1443
13633, 33677, 33678, 33682, 33681, 33812, 33820, 33821, 33818
13634, 33678, 33679, 33683, 33682, 33814, 33822, 33823, 33820
13635, 33679, 33680, 33684, 33683, 33816, 33824, 33825, 33822
13636, 33680, 3487, 3488, 33684, 33817, 3511, 33826, 33824
13637, 1420, 33681, 33685, 1421, 33819, 33827, 33828, 1444
13638, 33681, 33682, 33686, 33685, 33821, 33829, 33830, 33827
13639, 33682, 33683, 33687, 33686, 33823, 33831, 33832, 33829
13640, 33683, 33684, 33688, 33687, 33825, 33833, 33834, 33831
13641, 33684, 3488, 3489, 33688, 33826, 3512, 33835, 33833
13642, 1421, 33685, 33689, 1422, 33828, 33836, 33837, 1445
13643, 33685, 33686, 33690, 33689, 33830, 33838, 33839, 33836
13644, 33686, 33687, 33691, 33690, 33832, 33840, 33841, 33838
13645, 33687, 33688, 33692, 33691, 33834, 33842, 33843, 33840
13646, 33688, 3489, 3490, 33692, 33835, 3513, 33844, 33842
13647, 1422, 33689, 33693, 1423, 33837, 33845, 33846, 1446
13648, 33689, 33690, 33694, 33693, 33839, 33847, 33848, 33845
13649, 33690, 33691, 33695, 33694, 33841, 33849, 33850, 33847
13650, 33691, 33692, 33696, 33695, 33843, 33851, 33852, 33849
13651, 33692, 3490, 3491, 33696, 33844, 3514, 33853, 33851
13652, 1423, 33693, 33697, 1424, 33846, 33854, 33855, 1447
13653, 33693, 33694, 33698, 33697, 33848, 33856, 33857, 33854
13654, 33694, 33695, 33699, 33698, 33850, 33858, 33859, 33856
13655, 33695, 33696, 33700, 33699, 33852, 33860, 33861, 33858
13656, 33696, 3491, 3492, 33700, 33853, 3515, 33862, 33860
13657, 1424, 33697, 33701, 1425, 33855, 33863, 33864, 1448
13658, 33697, 33698, 33702, 33701, 33857, 33865, 33866, 33863
13659, 33698, 33699, 33703, 33702, 33859, 33867, 33868, 33865
13660, 33699, 33700, 33704, 33703, 33861, 33869, 33870, 33867
13661, 33700, 3492, 3493, 33704, 33862, 3516, 33871, 33869
13662, 1425, 33701, 33705, 1426, 33864, 33872, 33873, 1449
13663, 33701, 33702, 33706, 33705, 33866, 33874, 33875, 33872
13664, 33702, 33703, 33707, 33706, 33868, 33876, 33877, 33874
13665, 33703, 33704, 33708, 33707, 33870, 33878, 33879, 33876
13666, 33704, 3493, 3494, 33708, 33871, 3517, 33880, 33878
13667, 1426, 33705, 33709, 1427, 33873, 33881, 33882, 1450
13668, 33705, 33706, 33710, 33709, 33875, 33883, 33884, 33881
13669, 33706, 33707, 33711, 33710, 33877, 33885, 33886, 33883
13670, 33707, 33708, 33712, 33711, 33879, 33887, 33888, 33885
13671, 33708, 3494, 3495, 33712, 33880, 3518, 33889, 33887
13672, 1427, 33709, 33713, 1428, 33882, 33890, 33891, 1451
13673, 33709, 33710, 33714, 33713, 33884, 33892, 33893, 33890
13674, 33710, 33711, 33715, 33714, 33886, 33894, 33895, 33892
13675, 33711, 33712, 33716, 33715, 33888, 33896, 33897, 33894
13676, 33712, 3495, 3496, 33716, 33889, 3519, 33898, 33896
13677, 1428, 33713, 33717, 1429, 33891, 33899, 33900, 1452
13678, 33713, 33714, 33718, 33717, 33893, 33901, 33902, 33899
13679, 33714, 33715, 33719, 33718, 33895, 33903, 33904, 33901
13680, 33715, 33716, 33720, 33719, 33897, 33905, 33906, 33903
13681, 33716, 3496, 3497, 33720, 33898, 3520, 33907, 33905
13682, 1429, 33717, 33721, 1430, 33900, 33908, 33909, 1453
13683, 33717, 33718, 33722, 33721, 33902, 33910, 33911, 33908
13684, 33718, 33719, 33723, 33722, 33904, 33912, 33913, 33910
13685, 33719, 33720, 33724, 33723, 33906, 33914, 33915, 33912
13686, 33720, 3497, 3498, 33724, 33907, 3521, 33916, 33914
13687, 1430, 33721, 33725, 1431, 33909, 33917, 33918, 1454
13688, 33721, 33722, 33726, 33725, 33911, 33919, 33920, 33917
13689, 33722, 33723, 33727, 33726, 33913, 33921, 33922, 33919
13690, 33723, 33724, 33728, 33727, 33915, 33923, 33924, 33921
13691, 33724, 3498, 3499, 33728, 33916, 3522, 33925, 33923
13692, 1431, 33725, 33729, 1432, 33918, 33926, 33927, 1455
13693, 33725, 33726, 33730, 33729, 33920, 33928, 33929, 33926
13694, 33726, 33727, 33731, 33730, 33922, 33930, 33931, 33928
13695, 33727, 33728, 33732, 33731, 33924, 33932, 33933, 33930
13696, 33728, 3499, 3500, 33732, 33925, 3523, 33934, 33932
13697, 1432, 33729, 33733, 1433, 33927, 33935, 33936, 1456
13698, 33729, 33730, 33734, 33733, 33929, 33937, 33938, 33935
13699, 33730, 33731, 33735, 33734, 33931, 33939, 33940, 33937
13700, 33731, 33732, 33736, 33735, 33933, 33941, 33942, 33939
13701, 33732, 3500, 3501, 33736, 33934, 3524, 33943, 33941
13702, 1433, 33733, 3470, 32, 33936, 33944, 3474, 1457
13703, 33733, 33734, 3471, 3470, 33938, 33945, 3475, 33944
13704, 33734, 33735, 3472, 3471, 33940, 33946, 3476, 33945
13705, 33735, 33736, 3473, 3472, 33942, 33947, 3477, 33946
13706, 33736, 3501, 84, 3473, 33943, 3525, 3478, 33947
*ELEMENT, type=CPS8, ELSET=Surface116
13707, 32, 3470, 33948, 1486, 3474, 33992, 33993, 1497
13708, 3470, 3471, 33949, 33948, 3475, 33994, 33995, 33992
13709, 3471, 3472, 33950, 33949, 3476, 33996, 33997, 33994
13710, 3472, 3473, 33951, 33950, 3477, 33998, 33999, 33996
13711, 3473, 84, 3526, 33951, 3478, 3537, 34000, 33998
13712, 1486, 33948, 33952, 1487, 33993, 34001, 34002, 1498
13713, 33948, 33949, 33953, 33952, 33995, 34003, 34004, 34001
13714, 33949, 33950, 33954, 33953, 33997, 34005, 34006, 34003
13715, 33950, 33951, 33955, 33954, 33999, 34007, 34008, 34005
13716, 33951, 3526, 3527, 33955, 34000, 3538, 34009, 34007
13717, 1487, 33952, 33956, 1488, 34002, 34010, 34011, 1499
13718, 33952, 33953, 33957, 33956, 34004, 34012, 34013, 34010
13719, 33953, 33954, 33958, 33957, 34006, 34014, 34015, 34012
13720, 33954, 33955, 33959, 33958, 34008, 34016, 34017, 34014
13721, 33955, 3527, 3528, 33959, 34009, 3539, 34018, 34016
13722, 1488, 33956, 33960, 1489, 34011, 34019, 34020, 1500
13723, 33956, 33957, 33961, 33960, 34013, 34021, 34022, 34019
13724, 33957, 33958, 33962, 33961, 34015, 34023, 34024, 34021
13725, 33958, 33959, 33963, 33962, 34017, 34025, 34026, 34023
13726, 33959, 3528, 3529, 33963, 34018, 3540, 34027, 34025
13727, 1489, 33960, 33964, 1490, 34020, 34028, 34029, 1501
13728, 33960, 33961, 33965, 33964, 34022, 34030, 34031, 34028
13729, 33961, 33962, 33966, 33965, 34024, 34032, 34033, 34030
13730, 33962, 33963, 33967, 33966, 34026, 34034, 34035, 34032
13731, 33963, 3529, 3530, 33967, 34027, 3541, 34036, 34034
13732, 1490, 33964, 33968, 1491, 34029, 34037, 34038, 1502
13733, 33964, 33965, 33969, 33968, 34031, 34039, 34040, 34037
13734, 33965, 33966, 33970, 33969, 34033, 34041, 34042, 34039
13735, 33966, 33967, 33971, 33970, 34035, 34043, 34044, 34041
13736, 33967, 3530, 3531, 33971, 34036, 3542, 34045, 34043
13737, 1491, 33968, 33972, 1492, 34038, 34046, 34047, 1503
13738, 33968, 33969, 33973, 33972, 34040, 34048, 34049, 34046
13739, 33969, 33970, 33974, 33973, 34042, 34050, 34051, 34048
13740, 33970, 33971, 33975, 33974, 34044, 34052, 34053, 34050
13741, 33971, 3531, 3532, 33975, 34045, 3543, 34054, 34052
13742, 1492, 33972, 33976, 1493, 34047, 34055, 34056, 1504
13743, 33972, 33973, 33977, 33976, 34049, 34057, 34058, 34055
13744, 33973, 33974, 33978, 33977, 34051, 34059, 34060, 34057
13745, 33974, 33975, 33979, 33978, 34053, 34061, 34062, 34059
13746, 33975, 3532, 3533, 33979, 34054, 3544, 34063, 34061
13747, 1493, 33976, 33980, 1494, 34056, 34064, 34065, 1505
13748, 33976, 33977, 33981, 33980, 34058, 34066, 34067, 34064
13749, 33977, 33978, 33982, 33981, 34060, 34068, 34069, 34066
13750, 33978, 33979, 33983, 33982, 34062, 34070, 34071, 34068
13751, 33979, 3533, 3534, 33983, 34063, 3545, 34072, 34070
13752, 1494, 33980, 33984, 1495, 34065, 34073, 34074, 1506
13753, 33980, 33981, 33985, 33984, 34067, 34075, 34076, 34073
13754, 33981, 33982, 33986, 33985, 34069, 34077, 34078, 34075
13755, 33982, 33983, 33987, 33986, 34071, 34079, 34080, 34077
13756, 33983, 3534, 3535, 33987, 34072, 3546, 34081, 34079
13757, 1495, 33984, 33988, 1496, 34074, 34082, 34083, 1507
13758, 33984, 33985, 33989, 33988, 34076, 34084, 34085, 34082
13759, 33985, 33986, 33990, 33989, 34078, 34086, 34087, 34084
13760, 33986, 33987, 33991, 33990, 34080, 34088, 34089, 34086
13761, 33987, 3535, 3536, 33991, 34081, 3547, 34090, 34088
13762, 1496, 33988, 3414, 30, 34083, 34091, 3418, 1508
13763, 33988, 33989, 3415, 3414, 34085, 34092, 3419, 34091
13764, 33989, 33990, 3416, 3415, 34087, 34093, 3420, 34092
13765, 33990, 33991, 3417, 3416, 34089, 34094, 3421, 34093
13766, 33991, 3536, 83, 3417, 34090, 3548, 3422, 34094
*ELEMENT, type=CPS8, ELSET=Surface117
13767, 82, 3391, 34095, 3479, 3402, 34348, 34349, 3502
13768, 3479, 34095, 34096, 3480, 34349, 34350, 34351, 3503
13769, 3480, 34096, 34097, 3481, 34351, 34352, 34353, 3504
13770, 3481, 34097, 34098, 3482, 34353, 34354, 34355, 3505
13771, 3482, 34098, 34099, 3483, 34355, 34356, 34357, 3506
13772, 3483, 34099, 34100, 3484, 34357, 34358, 34359, 3507
13773, 3484, 34100, 34101, 3485, 34359, 34360, 34361, 3508
13774, 3485, 34101, 34102, 3486, 34361, 34362, 34363, 3509
13775, 3486, 34102, 34103, 3487, 34363, 34364, 34365, 3510
13776, 3487, 34103, 34104, 3488, 34365, 34366, 34367, 3511
13777, 3488, 34104, 34105, 3489, 34367, 34368, 34369, 3512
13778, 3489, 34105, 34106, 3490, 34369, 34370, 34371, 3513
13779, 3490, 34106, 34107, 3491, 34371, 34372, 34373, 3514
13780, 3491, 34107, 34108, 3492, 34373, 34374, 34375, 3515
13781, 3492, 34108, 34109, 3493, 34375, 34376, 34377, 3516
13782, 3493, 34109, 34110, 3494, 34377, 34378, 34379, 3517
13783, 3494, 34110, 34111, 3495, 34379, 34380, 34381, 3518
13784, 3495, 34111, 34112, 3496, 34381, 34382, 34383, 3519
13785, 3496, 34112, 34113, 3497, 34383, 34384, 34385, 3520
13786, 3497, 34113, 34114, 3498, 34385, 34386, 34387, 3521
13787, 3498, 34114, 34115, 3499, 34387, 34388, 34389, 3522
13788, 3499, 34115, 34116, 3500, 34389, 34390, 34391, 3523
13789, 3500, 34116, 34117, 3501, 34391, 34392, 34393, 3524
13790, 3501, 34117, 3526, 84, 34393, 34394, 3537, 3525
13791, 3391, 3392, 34118, 34095, 3403, 34395, 34396, 34348
13792, 34095, 34118, 34119, 34096, 34396, 34397, 34398, 34350
13793, 34096, 34119, 34120, 34097, 34398, 34399, 34400, 34352
13794, 34097, 34120, 34121, 34098, 34400, 34401, 34402, 34354
13795, 34098, 34121, 34122, 34099, 34402, 34403, 34404, 34356
13796, 34099, 34122, 34123, 34100, 34404, 34405, 34406, 34358
13797, 34100, 34123, 34124, 34101, 34406, 34407, 34408, 34360
13798, 34101, 34124, 34125, 34102, 34408, 34409, 34410, 34362
13799, 34102, 34125, 34126, 34103, 34410, 34411, 34412, 34364
13800, 34103, 34126, 34127, 34104, 34412, 34413, 34414, 34366
13801, 34104, 34127, 34128, 34105, 34414, 34415, 34416, 34368
13802, 34105, 34128, 34129, 34106, 34416, 34417, 34418, 34370
13803, 34106, 34129, 34130, 34107, 34418, 34419, 34420, 34372
13804, 34107, 34130, 34131, 34108, 34420, 34421, 34422, 34374
13805, 34108, 34131, 34132, 34109, 34422, 34423, 34424, 34376
13806, 34109, 34132, 34133, 34110, 34424, 34425, 34426, 34378
13807, 34110, 34133, 34134, 34111, 34426, 34427, 34428, 34380
13808, 34111, 34134, 34135, 34112, 34428, 34429, 34430, 34382
13809, 34112, 34135, 34136, 34113, 34430, 34431, 34432, 34384
13810, 34113, 34136, 34137, 34114, 34432, 34433, 34434, 34386
13811, 34114, 34137, 34138, 34115, 34434, 34435, 34436, 34388
13812, 34115, 34138, 34139, 34116, 34436, 34437, 34438, 34390
13813, 34116, 34139, 34140, 34117, 34438, 34439, 34440, 34392
13814, 34117, 34140, 3527, 3526, 34440, 34441, 3538, 34394
13815, 3392, 3393, 34141, 34118, 3404, 34442, 34443, 34395
13816, 34118, 34141, 34142, 34119, 34443, 34444, 34445, 34397
13817, 34119, 34142, 34143, 34120, 34445, 34446, 34447, 34399
13818, 34120, 34143, 34144, 34121, 34447, 34448, 34449, 34401
13819, 34121, 34144, 34145, 34122, 34449, 34450, 34451, 34403
13820, 34122, 34145, 34146, 34123, 34451, 34452, 34453, 34405
13821, 34123, 34146, 34147, 34124, 34453, 34454, 34455, 34407
13822, 34124, 34147, 34148, 34125, 34455, 34456, 34457, 34409
13823, 34125, 34148, 34149, 34126, 34457, 34458, 34459, 34411
13824, 34126, 34149, 34150, 34127, 34459, 34460, 34461, 34413
13825, 34127, 34150, 34151, 34128, 34461, 34462, 34463, 34415
13826, 34128, 34151, 34152, 34129, 34463, 34464, 34465, 34417
13827, 34129, 34152, 34153, 34130, 34465, 34466, 34467, 34419
13828, 34130, 34153, 34154, 34131, 34467, 34468, 34469, 34421
13829, 34131, 34154, 34155, 34132, 34469, 34470, 34471, 34423
13830, 34132, 34155, 34156, 34133, 34471, 34472, 34473, 34425
13831, 34133, 34156, 34157, 34134, 34473, 34474, 34475, 34427
13832, 34134, 34157, 34158, 34135, 34475, 34476, 34477, 34429
13833, 34135, 34158, 34159, 34136, 34477, 34478, 34479, 34431
13834, 34136, 34159, 34160, 34137, 34479, 34480, 34481, 34433
13835, 34137, 34160, 34161, 34138, 34481, 34482, 34483, 34435
13836, 34138, 34161, 34162, 34139, 34483, 34484, 34485, 34437
13837, 34139, 34162, 34163, 34140, 34485, 34486, 34487, 34439
13838, 34140, 34163, 3528, 3527, 34487, 34488, 3539, 34441
13839, 3393, 3394, 34164, 34141, 3405, 34489, 34490, 34442
13840, 34141, 34164, 34165, 34142, 34490, 34491, 34492, 34444
13841, 34142, 34165, 34166, 34143, 34492, 34493, 34494, 34446
13842, 34143, 34166, 34167, 34144, 34494, 34495, 34496, 34448
13843, 34144, 34167, 34168, 34145, 34496, 34497, 34498, 34450
13844, 34145, 34168, 34169, 34146, 34498, 34499, 34500, 34452
13845, 34146, 34169, 34170, 34147, 34500, 34501, 34502, 34454
13846, 34147, 34170, 34171, 34148, 34502, 34503, 34504, 34456
13847, 34148, 34171, 34172, 34149, 34504, 34505, 34506, 34458
13848, 34149, 34172, 34173, 34150, 34506, 34507, 34508, 34460
13849, 34150, 34173, 34174, 34151, 34508, 34509, 34510, 34462
13850, 34151, 34174, 34175, 34152, 34510, 34511, 34512, 34464
13851, 34152, 34175, 34176, 34153, 34512, 34513, 34514, 34466
13852, 34153, 34176, 34177, 34154, 34514, 34515, 34516, 34468
13853, 34154, 34177, 34178, 34155, 34516, 34517, 34518, 34470
13854, 34155, 34178, 34179, 34156, 34518, 34519, 34520, 34472
13855, 34156, 34179, 34180, 34157, 34520, 34521, 34522, 34474
13856, 34157, 34180, 34181, 34158, 34522, 34523, 34524, 34476
13857, 34158, 34181, 34182, 34159, 34524, 34525, 34526, 34478
13858, 34159, 34182, 34183, 34160, 34526, 34527, 34528, 34480
13859, 34160, 34183, 34184, 34161, 34528, 34529, 34530, 34482
13860, 34161, 34184, 34185, 34162, 34530, 34531, 34532, 34484
13861, 34162, 34185, 34186, 34163, 34532, 34533, 34534, 34486
13862, 34163, 34186, 3529, 3528, 34534, 34535, 3540, 34488
13863, 3394, 3395, 34187, 34164, 3406, 34536, 34537, 34489
13864, 34164, 34187, 34188, 34165, 34537, 34538, 34539, 34491
13865, 34165, 34188, 34189, 34166, 34539, 34540, 34541, 34493
13866, 34166, 34189, 34190, 34167, 34541, 34542, 34543, 34495
13867, 34167, 34190, 34191, 34168, 34543, 34544, 34545, 34497
13868, 34168, 34191, 34192, 34169, 34545, 34546, 34547, 34499
13869, 34169, 34192, 34193, 34170, 34547, 34548, 34549, 34501
13870, 34170, 34193, 34194, 34171, 34549, 34550, 34551, 34503
13871, 34171, 34194, 34195, 34172, 34551, 34552, 34553, 34505
13872, 34172, 34195, 34196, 34173, 34553, 34554, 34555, 34507
13873, 34173, 34196, 34197, 34174, 34555, 34556, 34557, 34509
13874, 34174, 34197, 34198, 34175, 34557, 34558, 34559, 34511
13875, 34175, 34198, 34199, 34176, 34559, 34560, 34561, 34513
13876, 34176, 34199, 34200, 34177, 34561, 34562, 34563, 34515
13877, 34177, 34200, 34201, 34178, 34563, 34564, 34565, 34517
13878, 34178, 34201, 34202, 34179, 34565, 34566, 34567, 34519
13879, 34179, 34202, 34203, 34180, 34567, 34568, 34569, 34521
13880, 34180, 34203, 34204, 34181, 34569, 34570, 34571, 34523
13881, 34181, 34204, 34205, 34182, 34571, 34572, 34573, 34525
13882, 34182, 34205, 34206, 34183, 34573, 34574, 34575, 34527
13883, 34183, 34206, 34207, 34184, 34575, 34576, 34577, 34529
13884, 34184, 34207, 34208, 34185, 34577, 34578, 34579, 34531
13885, 34185, 34208, 34209, 34186, 34579, 34580, 34581, 34533
13886, 34186, 34209, 3530, 3529, 34581, 34582, 3541, 34535
13887, 3395, 3396, 34210, 34187, 3407, 34583, 34584, 34536
13888, 34187, 34210, 34211, 34188, 34584, 34585, 34586, 34538
13889, 34188, 34211, 34212, 34189, 34586, 34587, 34588, 34540
13890, 34189, 34212, 34213, 34190, 34588, 34589, 34590, 34542
13891, 34190, 34213, 34214, 34191, 34590, 34591, 34592, 34544
13892, 34191, 34214, 34215, 34192, 34592, 34593, 34594, 34546
13893, 34192, 34215, 34216, 34193, 34594, 34595, 34596, 34548
13894, 34193, 34216, 34217, 34194, 34596, 34597, 34598, 34550
13895, 34194, 34217, 34218, 34195, 34598, 34599, 34600, 34552
13896, 34195, 34218, 34219, 34196, 34600, 34601, 34602, 34554
13897, 34196, 34219, 34220, 34197, 34602, 34603, 34604, 34556
13898, 34197, 34220, 34221, 34198, 34604, 34605, 34606, 34558
13899, 34198, 34221, 34222, 34199, 34606, 34607, 34608, 34560
13900, 34199, 34222, 34223, 34200, 34608, 34609, 34610, 34562
13901, 34200, 34223, 34224, 34201, 34610, 34611, 34612, 34564
13902, 34201, 34224, 34225, 34202, 34612, 34613, 34614, 34566
13903, 34202, 34225, 34226, 34203, 34614, 34615, 34616, 34568
13904, 34203, 34226, 34227, 34204, 34616, 34617, 34618, 34570
13905, 34204, 34227, 34228, 34205, 34618, 34619, 34620, 34572
13906, 34205, 34228, 34229, 34206, 34620, 34621, 34622, 34574
13907, 34206, 34229, 34230, 34207, 34622, 34623, 34624, 34576
13908, 34207, 34230, 34231, 34208, 34624, 34625, 34626, 34578
13909, 34208, 34231, 34232, 34209, 34626, 34627, 34628, 34580
13910, 34209, 34232, 3531, 3530, 34628, 34629, 3542, 34582
13911, 3396, 3397, 34233, 34210, 3408, 34630, 34631, 34583
13912, 34210, 34233, 34234, 34211, 34631, 34632, 34633, 34585
13913, 34211, 34234, 34235, 34212, 34633, 34634, 34635, 34587
13914, 34212, 34235, 34236, 34213, 34635, 34636, 34637, 34589
13915, 34213, 34236, 34237, 34214, 34637, 34638, 34639, 34591
13916, 34214, 34237, 34238, 34215, 34639, 34640, 34641, 34593
13917, 34215, 34238, 34239, 34216, 34641, 34642, 34643, 34595
13918, 34216, 34239, 34240, 34217, 34643, 34644, 34645, 34597
13919, 34217, 34240, 34241, 34218, 34645, 34646, 34647, 34599
13920, 34218, 34241, 34242, 34219, 34647, 34648, 34649, 34601
13921, 34219, 34242, 34243, 34220, 34649, 34650, 34651, 34603
13922, 34220, 34243, 34244, 34221, 34651, 34652, 34653, 34605
13923, 34221, 34244, 34245, 34222, 34653, 34654, 34655, 34607
13924, 34222, 34245, 34246, 34223, 34655, 34656, 34657, 34609
13925, 34223, 34246, 34247, 34224, 34657, 34658, 34659, 34611
13926, 34224, 34247, 34248, 34225, 34659, 34660, 34661, 34613
13927, 34225, 34248, 34249, 34226, 34661, 34662, 34663, 34615
13928, 34226, 34249, 34250, 34227, 34663, 34664, 34665, 34617
13929, 34227, 34250, 34251, 34228, 34665, 34666, 34667, 34619
13930, 34228, 34251, 34252, 34229, 34667, 34668, 34669, 34621
13931, 34229, 34252, 34253, 34230, 34669, 34670, 34671, 34623
13932, 34230, 34253, 34254, 34231, 34671, 34672, 34673, 34625
13933, 34231, 34254, 34255, 34232, 34673, 34674, 34675, 34627
13934, 34232, 34255, 3532, 3531, 34675, 34676, 3543, 34629
13935, 3397, 3398, 34256, 34233, 3409, 34677, 34678, 34630
13936, 34233, 34256, 34257, 34234, 34678, 34679, 34680, 34632
13937, 34234, 34257, 34258, 34235, 34680, 34681, 34682, 34634
13938, 34235, 34258, 34259, 34236, 34682, 34683, 34684, 34636
13939, 34236, 34259, 34260, 34237, 34684, 34685, 34686, 34638
13940, 34237, 34260, 34261, 34238, 34686, 34687, 34688, 34640
13941, 34238, 34261, 34262, 34239, 34688, 34689, 34690, 34642
13942, 34239, 34262, 34263, 34240, 34690, 34691, 34692, 34644
13943, 34240, 34263, 34264, 34241, 34692, 34693, 34694, 34646
13944, 34241, 34264, 34265, 34242, 34694, 34695, 34696, 34648
13945, 34242, 34265, 34266, 34243, 34696, 34697, 34698, 34650
13946, 34243, 34266, 34267, 34244, 34698, 34699, 34700, 34652
13947, 34244, 34267, 34268, 34245, 34700, 34701, 34702, 34654
13948, 34245, 34268, 34269, 34246, 34702, 34703, 34704, 34656
13949, 34246, 34269, 34270, 34247, 34704, 34705, 34706, 34658
13950, 34247, 34270, 34271, 34248, 34706, 34707, 34708, 34660
13951, 34248, 34271, 34272, 34249, 34708, 34709, 34710, 34662
13952, 34249, 34272, 34273, 34250, 34710, 34711, 34712, 34664
13953, 34250, 34273, 34274, 34251, 34712, 34713, 34714, 34666
13954, 34251, 34274, 34275, 34252, 34714, 34715, 34716, 34668
13955, 34252, 34275, 34276, 34253, 34716, 34717, 34718, 34670
13956, 34253, 34276, 34277, 34254, 34718, 34719, 34720, 34672
13957, 34254, 34277, 34278, 34255, 34720, 34721, 34722, 34674
13958, 34255, 34278, 3533, 3532, 34722, 34723, 3544, 34676
13959, 3398, 3399, 34279, 34256, 3410, 34724, 34725, 34677
13960, 34256, 34279, 34280, 34257, 34725, 34726, 34727, 34679
13961, 34257, 34280, 34281, 34258, 34727, 34728, 34729, 34681
13962, 34258, 34281, 34282, 34259, 34729, 34730, 34731, 34683
13963, 34259, 34282, 34283, 34260, 34731, 34732, 34733, 34685
13964, 34260, 34283, 34284, 34261, 34733, 34734, 34735, 34687
13965, 34261, 34284, 34285, 34262, 34735, 34736, 34737, 34689
13966, 34262, 34285, 34286, 34263, 34737, 34738, 34739, 34691
13967, 34263, 34286, 34287, 34264, 34739, 34740, 34741, 34693
13968, 34264, 34287, 34288, 34265, 34741, 34742, 34743, 34695
13969, 34265, 34288, 34289, 34266, 34743, 34744, 34745, 34697
13970, 34266, 34289, 34290, 34267, 34745, 34746, 34747, 34699
13971, 34267, 34290, 34291, 34268, 34747, 34748, 34749, 34701
13972, 34268, 34291, 34292, 34269, 34749, 34750, 34751, 34703
13973, 34269, 34292, 34293, 34270, 34751, 34752, 34753, 34705
13974, 34270, 34293, 34294, 34271, 34753, 34754, 34755, 34707
13975, 34271, 34294, 34295, 34272, 34755, 34756, 34757, 34709
13976, 34272, 34295, 34296, 34273, 34757, 34758, 34759, 34711
13977, 34273, 34296, 34297, 34274, 34759, 34760, 34761, 34713
13978, 34274, 34297, 34298, 34275, 34761, 34762, 34763, 34715
13979, 34275, 34298, 34299, 34276, 34763, 34764, 34765, 34717
13980, 34276, 34299, 34300, 34277, 34765, 34766, 34767, 34719
13981, 34277, 34300, 34301, 34278, 34767, 34768, 34769, 34721
13982, 34278, 34301, 3534, 3533, 34769, 34770, 3545, 34723
13983, 3399, 3400, 34302, 34279, 3411, 34771, 34772, 34724
13984, 34279, 34302, 34303, 34280, 34772, 34773, 34774, 34726
13985, 34280, 34303, 34304, 34281, 34774, 34775, 34776, 34728
13986, 34281, 34304, 34305, 34282, 34776, 34777, 34778, 34730
13987, 34282, 34305, 34306, 34283, 34778, 34779, 34780, 34732
13988, 34283, 34306, 34307, 34284, 34780, 34781, 34782, 34734
13989, 34284, 34307, 34308, 34285, 34782, 34783, 34784, 34736
13990, 34285, 34308, 34309, 34286, 34784, 34785, 34786, 34738
13991, 34286, 34309, 34310, 34287, 34786, 34787, 34788, 34740
13992, 34287, 34310, 34311, 34288, 34788, 34789, 34790, 34742
13993, 34288, 34311, 34312, 34289, 34790, 34791, 34792, 34744
13994, 34289, 34312, 34313, 34290, 34792, 34793, 34794, 34746
13995, 34290, 34313, 34314, 34291, 34794, 34795, 34796, 34748
13996, 34291, 34314, 34315, 34292, 34796, 34797, 34798, 34750
13997, 34292, 34315, 34316, 34293, 34798, 34799, 34800, 34752
13998, 34293, 34316, 34317, 34294, 34800, 34801, 34802, 34754
13999, 34294, 34317, 34318, 34295, 34802, 34803, 34804, 34756
14000, 34295, 34318, 34319, 34296, 34804, 34805, 34806, 34758
14001, 34296, 34319, 34320, 34297, 34806, 34807, 34808, 34760
14002, 34297, 34320, 34321, 34298, 34808, 34809, 34810, 34762
14003, 34298, 34321, 34322, 34299, 34810, 34811, 34812, 34764
14004, 34299, 34322, 34323, 34300, 34812, 34813, 34814, 34766
14005, 34300, 34323, 34324, 34301, 34814, 34815, 34816, 34768
14006, 34301, 34324, 3535, 3534, 34816, 34817, 3546, 34770
14007, 3400, 3401, 34325, 34302, 3412, 34818, 34819, 34771
14008, 34302, 34325, 34326, 34303, 34819, 34820, 34821, 34773
14009, 34303, 34326, 34327, 34304, 34821, 34822, 34823, 34775
14010, 34304, 34327, 34328, 34305, 34823, 34824, 34825, 34777
14011, 34305, 34328, 34329, 34306, 34825, 34826, 34827, 34779
14012, 34306, 34329, 34330, 34307, 34827, 34828, 34829, 34781
14013, 34307, 34330, 34331, 34308, 34829, 34830, 34831, 34783
14014, 34308, 34331, 34332, 34309, 34831, 34832, 34833, 34785
14015, 34309, 34332, 34333, 34310, 34833, 34834, 34835, 34787
14016, 34310, 34333, 34334, 34311, 34835, 34836, 34837, 34789
14017, 34311, 34334, 34335, 34312, 34837, 34838, 34839, 34791
14018, 34312, 34335, 34336, 34313, 34839, 34840, 34841, 34793
14019, 34313, 34336, 34337, 34314, 34841, 34842, 34843, 34795
14020, 34314, 34337, 34338, 34315, 34843, 34844, 34845, 34797
14021, 34315, 34338, 34339, 34316, 34845, 34846, 34847, 34799
14022, 34316, 34339, 34340, 34317, 34847, 34848, 34849, 34801
14023, 34317, 34340, 34341, 34318, 34849, 34850, 34851, 34803
14024, 34318, 34341, 34342, 34319, 34851, 34852, 34853, 34805
14025, 34319, 34342, 34343, 34320, 34853, 34854, 34855, 34807
14026, 34320, 34343, 34344, 34321, 34855, 34856, 34857, 34809
14027, 34321, 34344, 34345, 34322, 34857, 34858, 34859, 34811
14028, 34322, 34345, 34346, 34323, 34859, 34860, 34861, 34813
14029, 34323, 34346, 34347, 34324, 34861, 34862, 34863, 34815
14030, 34324, 34347, 3536, 3535, 34863, 34864, 3547, 34817
14031, 3401, 81, 3423, 34325, 3413, 3446, 34865, 34818
14032, 34325, 3423, 3424, 34326, 34865, 3447, 34866, 34820
14033, 34326, 3424, 3425, 34327, 34866, 3448, 34867, 34822
14034, 34327, 3425, 3426, 34328, 34867, 3449, 34868, 34824
14035, 34328, 3426, 3427, 34329, 34868, 3450, 34869, 34826
14036, 34329, 3427, 3428, 34330, 34869, 3451, 34870, 34828
14037, 34330, 3428, 3429, 34331, 34870, 3452, 34871, 34830
14038, 34331, 3429, 3430, 34332, 34871, 3453, 34872, 34832
14039, 34332, 3430, 3431, 34333, 34872, 3454, 34873, 34834
14040, 34333, 3431, 3432, 34334, 34873, 3455, 34874, 34836
14041, 34334, 3432, 3433, 34335, 34874, 3456, 34875, 34838
14042, 34335, 3433, 3434, 34336, 34875, 3457, 34876, 34840
14043, 34336, 3434, 3435, 34337, 34876, 3458, 34877, 34842
14044, 34337, 3435, 3436, 34338, 34877, 3459, 34878, 34844
14045, 34338, 3436, 3437, 34339, 34878, 3460, 34879, 34846
14046, 34339, 3437, 3438, 34340, 34879, 3461, 34880, 34848
14047, 34340, 3438, 3439, 34341, 34880, 3462, 34881, 34850
14048, 34341, 3439, 3440, 34342, 34881, 3463, 34882, 34852
14049, 34342, 3440, 3441, 34343, 34882, 3464, 34883, 34854
14050, 34343, 3441, 3442, 34344, 34883, 3465, 34884, 34856
14051, 34344, 3442, 3443, 34345, 34884, 3466, 34885, 34858
14052, 34345, 3443, 3444, 34346, 34885, 3467, 34886, 34860
14053, 34346, 3444, 3445, 34347, 34886, 3468, 34887, 34862
14054, 34347, 3445, 83, 3536, 34887, 3469, 3548, 34864
*ELEMENT, type=CPS8, ELSET=Surface118
14055, 2, 209, 34888, 3558, 232, 34980, 34981, 3562
14056, 3558, 34888, 34889, 3559, 34981, 34982, 34983, 3563
14057, 3559, 34889, 34890, 3560, 34983, 34984, 34985, 3564
14058, 3560, 34890, 34891, 3561, 34985, 34986, 34987, 3565
14059, 3561, 34891, 3567, 86, 34987, 34988, 3590, 3566
14060, 209, 210, 34892, 34888, 233, 34989, 34990, 34980
14061, 34888, 34892, 34893, 34889, 34990, 34991, 34992, 34982
14062, 34889, 34893, 34894, 34890, 34992, 34993, 34994, 34984
14063, 34890, 34894, 34895, 34891, 34994, 34995, 34996, 34986
14064, 34891, 34895, 3568, 3567, 34996, 34997, 3591, 34988
14065, 210, 211, 34896, 34892, 234, 34998, 34999, 34989
14066, 34892, 34896, 34897, 34893, 34999, 35000, 35001, 34991
14067, 34893, 34897, 34898, 34894, 35001, 35002, 35003, 34993
14068, 34894, 34898, 34899, 34895, 35003, 35004, 35005, 34995
14069, 34895, 34899, 3569, 3568, 35005, 35006, 3592, 34997
14070, 211, 212, 34900, 34896, 235, 35007, 35008, 34998
14071, 34896, 34900, 34901, 34897, 35008, 35009, 35010, 35000
14072, 34897, 34901, 34902, 34898, 35010, 35011, 35012, 35002
14073, 34898, 34902, 34903, 34899, 35012, 35013, 35014, 35004
14074, 34899, 34903, 3570, 3569, 35014, 35015, 3593, 35006
14075, 212, 213, 34904, 34900, 236, 35016, 35017, 35007
14076, 34900, 34904, 34905, 34901, 35017, 35018, 35019, 35009
14077, 34901, 34905, 34906, 34902, 35019, 35020, 35021, 35011
14078, 34902, 34906, 34907, 34903, 35021, 35022, 35023, 35013
14079, 34903, 34907, 3571, 3570, 35023, 35024, 3594, 35015
14080, 213, 214, 34908, 34904, 237, 35025, 35026, 35016
14081, 34904, 34908, 34909, 34905, 35026, 35027, 35028, 35018
14082, 34905, 34909, 34910, 34906, 35028, 35029, 35030, 35020
14083, 34906, 34910, 34911, 34907, 35030, 35031, 35032, 35022
14084, 34907, 34911, 3572, 3571, 35032, 35033, 3595, 35024
14085, 214, 215, 34912, 34908, 238, 35034, 35035, 35025
14086, 34908, 34912, 34913, 34909, 35035, 35036, 35037, 35027
14087, 34909, 34913, 34914, 34910, 35037, 35038, 35039, 35029
14088, 34910, 34914, 34915, 34911, 35039, 35040, 35041, 35031
14089, 34911, 34915, 3573, 3572, 35041, 35042, 3596, 35033
14090, 215, 216, 34916, 34912, 239, 35043, 35044, 35034
14091, 34912, 34916, 34917, 34913, 35044, 35045, 35046, 35036
14092, 34913, 34917, 34918, 34914, 35046, 35047, 35048, 35038
14093, 34914, 34918, 34919, 34915, 35048, 35049, 35050, 35040
14094, 34915, 34919, 3574, 3573, 35050, 35051, 3597, 35042
14095, 216, 217, 34920, 34916, 240, 35052, 35053, 35043
14096, 34916, 34920, 34921, 34917, 35053, 35054, 35055, 35045
14097, 34917, 34921, 34922, 34918, 35055, 35056, 35057, 35047
14098, 34918, 34922, 34923, 34919, 35057, 35058, 35059, 35049
14099, 34919, 34923, 3575, 3574, 35059, 35060, 3598, 35051
14100, 217, 218, 34924, 34920, 241, 35061, 35062, 35052
14101, 34920, 34924, 34925, 34921, 35062, 35063, 35064, 35054
14102, 34921, 34925, 34926, 34922, 35064, 35065, 35066, 35056
14103, 34922, 34926, 34927, 34923, 35066, 35067, 35068, 35058
14104, 34923, 34927, 3576, 3575, 35068, 35069, 3599, 35060
14105, 218, 219, 34928, 34924, 242, 35070, 35071, 35061
14106, 34924, 34928, 34929, 34925, 35071, 35072, 35073, 35063
14107, 34925, 34929, 34930, 34926, 35073, 35074, 35075, 35065
14108, 34926, 34930, 34931, 34927, 35075, 35076, 35077, 35067
14109, 34927, 34931, 3577, 3576, 35077, 35078, 3600, 35069
14110, 219, 220, 34932, 34928, 243, 35079, 35080, 35070
14111, 34928, 34932, 34933, 34929, 35080, 35081, 35082, 35072
14112, 34929, 34933, 34934, 34930, 35082, 35083, 35084, 35074
14113, 34930, 34934, 34935, 34931, 35084, 35085, 35086, 35076
14114, 34931, 34935, 3578, 3577, 35086, 35087, 3601, 35078
14115, 220, 221, 34936, 34932, 244, 35088, 35089, 35079
14116, 34932, 34936, 34937, 34933, 35089, 35090, 35091, 35081
14117, 34933, 34937, 34938, 34934, 35091, 35092, 35093, 35083
14118, 34934, 34938, 34939, 34935, 35093, 35094, 35095, 35085
14119, 34935, 34939, 3579, 3578, 35095, 35096, 3602, 35087
14120, 221, 222, 34940, 34936, 245, 35097, 35098, 35088
14121, 34936, 34940, 34941, 34937, 35098, 35099, 35100, 35090
14122, 34937, 34941, 34942, 34938, 35100, 35101, 35102, 35092
14123, 34938, 34942, 34943, 34939, 35102, 35103, 35104, 35094
14124, 34939, 34943, 3580, 3579, 35104, 35105, 3603, 35096
14125, 222, 223, 34944, 34940, 246, 35106, 35107, 35097
14126, 34940, 34944, 34945, 34941, 35107, 35108, 35109, 35099
14127, 34941, 34945, 34946, 34942, 35109, 35110, 35111, 35101
14128, 34942, 34946, 34947, 34943, 35111, 35112, 35113, 35103
14129, 34943, 34947, 3581, 3580, 35113, 35114, 3604, 35105
14130, 223, 224, 34948, 34944, 247, 35115, 35116, 35106
14131, 34944, 34948, 34949, 34945, 35116, 35117, 35118, 35108
14132, 34945, 34949, 34950, 34946, 35118, 35119, 35120, 35110
14133, 34946, 34950, 34951, 34947, 35120, 35121, 35122, 35112
14134, 34947, 34951, 3582, 3581, 35122, 35123, 3605, 35114
14135, 224, 225, 34952, 34948, 248, 35124, 35125, 35115
14136, 34948, 34952, 34953, 34949, 35125, 35126, 35127, 35117
14137, 34949, 34953, 34954, 34950, 35127, 35128, 35129, 35119
14138, 34950, 34954, 34955, 34951, 35129, 35130, 35131, 35121
14139, 34951, 34955, 3583, 3582, 35131, 35132, 3606, 35123
14140, 225, 226, 34956, 34952, 249, 35133, 35134, 35124
14141, 34952, 34956, 34957, 34953, 35134, 35135, 35136, 35126
14142, 34953, 34957, 34958, 34954, 35136, 35137, 35138, 35128
14143, 34954, 34958, 34959, 34955, 35138, 35139, 35140, 35130
14144, 34955, 34959, 3584, 3583, 35140, 35141, 3607, 35132
14145, 226, 227, 34960, 34956, 250, 35142, 35143, 35133
14146, 34956, 34960, 34961, 34957, 35143, 35144, 35145, 35135
14147, 34957, 34961, 34962, 34958, 35145, 35146, 35147, 35137
14148, 34958, 34962, 34963, 34959, 35147, 35148, 35149, 35139
14149, 34959, 34963, 3585, 3584, 35149, 35150, 3608, 35141
14150, 227, 228, 34964, 34960, 251, 35151, 35152, 35142
14151, 34960, 34964, 34965, 34961, 35152, 35153, 35154, 35144
14152, 34961, 34965, 34966, 34962, 35154, 35155, 35156, 35146
14153, 34962, 34966, 34967, 34963, 35156, 35157, 35158, 35148
14154, 34963, 34967, 3586, 3585, 35158, 35159, 3609, 35150
14155, 228, 229, 34968, 34964, 252, 35160, 35161, 35151
14156, 34964, 34968, 34969, 34965, 35161, 35162, 35163, 35153
14157, 34965, 34969, 34970, 34966, 35163, 35164, 35165, 35155
14158, 34966, 34970, 34971, 34967, 35165, 35166, 35167, 35157
14159, 34967, 34971, 3587, 3586, 35167, 35168, 3610, 35159
14160, 229, 230, 34972, 34968, 253, 35169, 35170, 35160
14161, 34968, 34972, 34973, 34969, 35170, 35171, 35172, 35162
14162, 34969, 34973, 34974, 34970, 35172, 35173, 35174, 35164
14163, 34970, 34974, 34975, 34971, 35174, 35175, 35176, 35166
14164, 34971, 34975, 3588, 3587, 35176, 35177, 3611, 35168
14165, 230, 231, 34976, 34972, 254, 35178, 35179, 35169
14166, 34972, 34976, 34977, 34973, 35179, 35180, 35181, 35171
14167, 34973, 34977, 34978, 34974, 35181, 35182, 35183, 35173
14168, 34974, 34978, 34979, 34975, 35183, 35184, 35185, 35175
14169, 34975, 34979, 3589, 3588, 35185, 35186, 3612, 35177
14170, 231, 6, 3549, 34976, 255, 3553, 35187, 35178
14171, 34976, 3549, 3550, 34977, 35187, 3554, 35188, 35180
14172, 34977, 3550, 3551, 34978, 35188, 3555, 35189, 35182
14173, 34978, 3551, 3552, 34979, 35189, 3556, 35190, 35184
14174, 34979, 3552, 85, 3589, 35190, 3557, 3613, 35186
*ELEMENT, type=CPS8, ELSET=Surface119
14175, 6, 153, 35191, 3549, 164, 35235, 35236, 3553
14176, 3549, 35191, 35192, 3550, 35236, 35237, 35238, 3554
14177, 3550, 35192, 35193, 3551, 35238, 35239, 35240, 3555
14178, 3551, 35193, 35194, 3552, 35240, 35241, 35242, 3556
14179, 3552, 35194, 3623, 85, 35242, 35243, 3634, 3557
14180, 153, 154, 35195, 35191, 165, 35244, 35245, 35235
14181, 35191, 35195, 35196, 35192, 35245, 35246, 35247, 35237
14182, 35192, 35196, 35197, 35193, 35247, 35248, 35249, 35239
14183, 35193, 35197, 35198, 35194, 35249, 35250, 35251, 35241
14184, 35194, 35198, 3624, 3623, 35251, 35252, 3635, 35243
14185, 154, 155, 35199, 35195, 166, 35253, 35254, 35244
14186, 35195, 35199, 35200, 35196, 35254, 35255, 35256, 35246
14187, 35196, 35200, 35201, 35197, 35256, 35257, 35258, 35248
14188, 35197, 35201, 35202, 35198, 35258, 35259, 35260, 35250
14189, 35198, 35202, 3625, 3624, 35260, 35261, 3636, 35252
14190, 155, 156, 35203, 35199, 167, 35262, 35263, 35253
14191, 35199, 35203, 35204, 35200, 35263, 35264, 35265, 35255
14192, 35200, 35204, 35205, 35201, 35265, 35266, 35267, 35257
14193, 35201, 35205, 35206, 35202, 35267, 35268, 35269, 35259
14194, 35202, 35206, 3626, 3625, 35269, 35270, 3637, 35261
14195, 156, 157, 35207, 35203, 168, 35271, 35272, 35262
14196, 35203, 35207, 35208, 35204, 35272, 35273, 35274, 35264
14197, 35204, 35208, 35209, 35205, 35274, 35275, 35276, 35266
14198, 35205, 35209, 35210, 35206, 35276, 35277, 35278, 35268
14199, 35206, 35210, 3627, 3626, 35278, 35279, 3638, 35270
14200, 157, 158, 35211, 35207, 169, 35280, 35281, 35271
14201, 35207, 35211, 35212, 35208, 35281, 35282, 35283, 35273
14202, 35208, 35212, 35213, 35209, 35283, 35284, 35285, 35275
14203, 35209, 35213, 35214, 35210, 35285, 35286, 35287, 35277
14204, 35210, 35214, 3628, 3627, 35287, 35288, 3639, 35279
14205, 158, 159, 35215, 35211, 170, 35289, 35290, 35280
14206, 35211, 35215, 35216, 35212, 35290, 35291, 35292, 35282
14207, 35212, 35216, 35217, 35213, 35292, 35293, 35294, 35284
14208, 35213, 35217, 35218, 35214, 35294, 35295, 35296, 35286
14209, 35214, 35218, 3629, 3628, 35296, 35297, 3640, 35288
14210, 159, 160, 35219, 35215, 171, 35298, 35299, 35289
14211, 35215, 35219, 35220, 35216, 35299, 35300, 35301, 35291
14212, 35216, 35220, 35221, 35217, 35301, 35302, 35303, 35293
14213, 35217, 35221, 35222, 35218, 35303, 35304, 35305, 35295
14214, 35218, 35222, 3630, 3629, 35305, 35306, 3641, 35297
14215, 160, 161, 35223, 35219, 172, 35307, 35308, 35298
14216, 35219, 35223, 35224, 35220, 35308, 35309, 35310, 35300
14217, 35220, 35224, 35225, 35221, 35310, 35311, 35312, 35302
14218, 35221, 35225, 35226, 35222, 35312, 35313, 35314, 35304
14219, 35222, 35226, 3631, 3630, 35314, 35315, 3642, 35306
14220, 161, 162, 35227, 35223, 173, 35316, 35317, 35307
14221, 35223, 35227, 35228, 35224, 35317, 35318, 35319, 35309
14222, 35224, 35228, 35229, 35225, 35319, 35320, 35321, 35311
14223, 35225, 35229, 35230, 35226, 35321, 35322, 35323, 35313
14224, 35226, 35230, 3632, 3631, 35323, 35324, 3643, 35315
14225, 162, 163, 35231, 35227, 174, 35325, 35326, 35316
14226, 35227, 35231, 35232, 35228, 35326, 35327, 35328, 35318
14227, 35228, 35232, 35233, 35229, 35328, 35329, 35330, 35320
14228, 35229, 35233, 35234, 35230, 35330, 35331, 35332, 35322
14229, 35230, 35234, 3633, 3632, 35332, 35333, 3644, 35324
14230, 163, 5, 3614, 35231, 175, 3618, 35334, 35325
14231, 35231, 3614, 3615, 35232, 35334, 3619, 35335, 35327
14232, 35232, 3615, 3616, 35233, 35335, 3620, 35336, 35329
14233, 35233, 3616, 3617, 35234, 35336, 3621, 35337, 35331
14234, 35234, 3617, 87, 3633, 35337, 3622, 3645, 35333
*ELEMENT, type=CPS8, ELSET=Surface120
14235, 1, 3646, 35338, 256, 3650, 35430, 35431, 279
14236, 3646, 3647, 35339, 35338, 3651, 35432, 35433, 35430
14237, 3647, 3648, 35340, 35339, 3652, 35434, 35435, 35432
14238, 3648, 3649, 35341, 35340, 3653, 35436, 35437, 35434
14239, 3649, 88, 3655, 35341, 3654, 3678, 35438, 35436
14240, 256, 35338, 35342, 257, 35431, 35439, 35440, 280
14241, 35338, 35339, 35343, 35342, 35433, 35441, 35442, 35439
14242, 35339, 35340, 35344, 35343, 35435, 35443, 35444, 35441
14243, 35340, 35341, 35345, 35344, 35437, 35445, 35446, 35443
14244, 35341, 3655, 3656, 35345, 35438, 3679, 35447, 35445
14245, 257, 35342, 35346, 258, 35440, 35448, 35449, 281
14246, 35342, 35343, 35347, 35346, 35442, 35450, 35451, 35448
14247, 35343, 35344, 35348, 35347, 35444, 35452, 35453, 35450
14248, 35344, 35345, 35349, 35348, 35446, 35454, 35455, 35452
14249, 35345, 3656, 3657, 35349, 35447, 3680, 35456, 35454
14250, 258, 35346, 35350, 259, 35449, 35457, 35458, 282
14251, 35346, 35347, 35351, 35350, 35451, 35459, 35460, 35457
14252, 35347, 35348, 35352, 35351, 35453, 35461, 35462, 35459
14253, 35348, 35349, 35353, 35352, 35455, 35463, 35464, 35461
14254, 35349, 3657, 3658, 35353, 35456, 3681, 35465, 35463
14255, 259, 35350, 35354, 260, 35458, 35466, 35467, 283
14256, 35350, 35351, 35355, 35354, 35460, 35468, 35469, 35466
14257, 35351, 35352, 35356, 35355, 35462, 35470, 35471, 35468
14258, 35352, 35353, 35357, 35356, 35464, 35472, 35473, 35470
14259, 35353, 3658, 3659, 35357, 35465, 3682, 35474, 35472
14260, 260, 35354, 35358, 261, 35467, 35475, 35476, 284
14261, 35354, 35355, 35359, 35358, 35469, 35477, 35478, 35475
14262, 35355, 35356, 35360, 35359, 35471, 35479, 35480, 35477
14263, 35356, 35357, 35361, 35360, 35473, 35481, 35482, 35479
14264, 35357, 3659, 3660, 35361, 35474, 3683, 35483, 35481
14265, 261, 35358, 35362, 262, 35476, 35484, 35485, 285
14266, 35358, 35359, 35363, 35362, 35478, 35486, 35487, 35484
14267, 35359, 35360, 35364, 35363, 35480, 35488, 35489, 35486
14268, 35360, 35361, 35365, 35364, 35482, 35490, 35491, 35488
14269, 35361, 3660, 3661, 35365, 35483, 3684, 35492, 35490
14270, 262, 35362, 35366, 263, 35485, 35493, 35494, 286
14271, 35362, 35363, 35367, 35366, 35487, 35495, 35496, 35493
14272, 35363, 35364, 35368, 35367, 35489, 35497, 35498, 35495
14273, 35364, 35365, 35369, 35368, 35491, 35499, 35500, 35497
14274, 35365, 3661, 3662, 35369, 35492, 3685, 35501, 35499
14275, 263, 35366, 35370, 264, 35494, 35502, 35503, 287
14276, 35366, 35367, 35371, 35370, 35496, 35504, 35505, 35502
14277, 35367, 35368, 35372, 35371, 35498, 35506, 35507, 35504
14278, 35368, 35369, 35373, 35372, 35500, 35508, 35509, 35506
14279, 35369, 3662, 3663, 35373, 35501, 3686, 35510, 35508
14280, 264, 35370, 35374, 265, 35503, 35511, 35512, 288
14281, 35370, 35371, 35375, 35374, 35505, 35513, 35514, 35511
14282, 35371, 35372, 35376, 35375, 35507, 35515, 35516, 35513
14283, 35372, 35373, 35377, 35376, 35509, 35517, 35518, 35515
14284, 35373, 3663, 3664, 35377, 35510, 3687, 35519, 35517
14285, 265, 35374, 35378, 266, 35512, 35520, 35521, 289
14286, 35374, 35375, 35379, 35378, 35514, 35522, 35523, 35520
14287, 35375, 35376, 35380, 35379, 35516, 35524, 35525, 35522
14288, 35376, 35377, 35381, 35380, 35518, 35526, 35527, 35524
14289, 35377, 3664, 3665, 35381, 35519, 3688, 35528, 35526
14290, 266, 35378, 35382, 267, 35521, 35529, 35530, 290
14291, 35378, 35379, 35383, 35382, 35523, 35531, 35532, 35529
14292, 35379, 35380, 35384, 35383, 35525, 35533, 35534, 35531
14293, 35380, 35381, 35385, 35384, 35527, 35535, 35536, 35533
14294, 35381, 3665, 3666, 35385, 35528, 3689, 35537, 35535
14295, 267, 35382, 35386, 268, 35530, 35538, 35539, 291
14296, 35382, 35383, 35387, 35386, 35532, 35540, 35541, 35538
14297, 35383, 35384, 35388, 35387, 35534, 35542, 35543, 35540
14298, 35384, 35385, 35389, 35388, 35536, 35544, 35545, 35542
14299, 35385, 3666, 3667, 35389, 35537, 3690, 35546, 35544
14300, 268, 35386, 35390, 269, 35539, 35547, 35548, 292
14301, 35386, 35387, 35391, 35390, 35541, 35549, 35550, 35547
14302, 35387, 35388, 35392, 35391, 35543, 35551, 35552, 35549
14303, 35388, 35389, 35393, 35392, 35545, 35553, 35554, 35551
14304, 35389, 3667, 3668, 35393, 35546, 3691, 35555, 35553
14305, 269, 35390, 35394, 270, 35548, 35556, 35557, 293
14306, 35390, 35391, 35395, 35394, 35550, 35558, 35559, 35556
14307, 35391, 35392, 35396, 35395, 35552, 35560, 35561, 35558
14308, 35392, 35393, 35397, 35396, 35554, 35562, 35563, 35560
14309, 35393, 3668, 3669, 35397, 35555, 3692, 35564, 35562
14310, 270, 35394, 35398, 271, 35557, 35565, 35566, 294
14311, 35394, 35395, 35399, 35398, 35559, 35567, 35568, 35565
14312, 35395, 35396, 35400, 35399, 35561, 35569, 35570, 35567
14313, 35396, 35397, 35401, 35400, 35563, 35571, 35572, 35569
14314, 35397, 3669, 3670, 35401, 35564, 3693, 35573, 35571
14315, 271, 35398, 35402, 272, 35566, 35574, 35575, 295
14316, 35398, 35399, 35403, 35402, 35568, 35576, 35577, 35574
14317, 35399, 35400, 35404, 35403, 35570, 35578, 35579, 35576
14318, 35400, 35401, 35405, 35404, 35572, 35580, 35581, 35578
14319, 35401, 3670, 3671, 35405, 35573, 3694, 35582, 35580
14320, 272, 35402, 35406, 273, 35575, 35583, 35584, 296
14321, 35402, 35403, 35407, 35406, 35577, 35585, 35586, 35583
14322, 35403, 35404, 35408, 35407, 35579, 35587, 35588, 35585
14323, 35404, 35405, 35409, 35408, 35581, 35589, 35590, 35587
14324, 35405, 3671, 3672, 35409, 35582, 3695, 35591, 35589
14325, 273, 35406, 35410, 274, 35584, 35592, 35593, 297
14326, 35406, 35407, 35411, 35410, 35586, 35594, 35595, 35592
14327, 35407, 35408, 35412, 35411, 35588, 35596, 35597, 35594
14328, 35408, 35409, 35413, 35412, 35590, 35598, 35599, 35596
14329, 35409, 3672, 3673, 35413, 35591, 3696, 35600, 35598
14330, 274, 35410, 35414, 275, 35593, 35601, 35602, 298
14331, 35410, 35411, 35415, 35414, 35595, 35603, 35604, 35601
14332, 35411, 35412, 35416, 35415, 35597, 35605, 35606, 35603
14333, 35412, 35413, 35417, 35416, 35599, 35607, 35608, 35605
14334, 35413, 3673, 3674, 35417, 35600, 3697, 35609, 35607
14335, 275, 35414, 35418, 276, 35602, 35610, 35611, 299
14336, 35414, 35415, 35419, 35418, 35604, 35612, 35613, 35610
14337, 35415, 35416, 35420, 35419, 35606, 35614, 35615, 35612
14338, 35416, 35417, 35421, 35420, 35608, 35616, 35617, 35614
14339, 35417, 3674, 3675, 35421, 35609, 3698, 35618, 35616
14340, 276, 35418, 35422, 277, 35611, 35619, 35620, 300
14341, 35418, 35419, 35423, 35422, 35613, 35621, 35622, 35619
14342, 35419, 35420, 35424, 35423, 35615, 35623, 35624, 35621
14343, 35420, 35421, 35425, 35424, 35617, 35625, 35626, 35623
14344, 35421, 3675, 3676, 35425, 35618, 3699, 35627, 35625
14345, 277, 35422, 35426, 278, 35620, 35628, 35629, 301
14346, 35422, 35423, 35427, 35426, 35622, 35630, 35631, 35628
14347, 35423, 35424, 35428, 35427, 35624, 35632, 35633, 35630
14348, 35424, 35425, 35429, 35428, 35626, 35634, 35635, 35632
14349, 35425, 3676, 3677, 35429, 35627, 3700, 35636, 35634
14350, 278, 35426, 3614, 5, 35629, 35637, 3618, 302
14351, 35426, 35427, 3615, 3614, 35631, 35638, 3619, 35637
14352, 35427, 35428, 3616, 3615, 35633, 35639, 3620, 35638
14353, 35428, 35429, 3617, 3616, 35635, 35640, 3621, 35639
14354, 35429, 3677, 87, 3617, 35636, 3701, 3622, 35640
*ELEMENT, type=CPS8, ELSET=Surface121
14355, 2, 3558, 35641, 97, 3562, 35685, 35686, 108
14356, 3558, 3559, 35642, 35641, 3563, 35687, 35688, 35685
14357, 3559, 3560, 35643, 35642, 3564, 35689, 35690, 35687
14358, 3560, 3561, 35644, 35643, 3565, 35691, 35692, 35689
14359, 3561, 86, 3702, 35644, 3566, 3713, 35693, 35691
14360, 97, 35641, 35645, 98, 35686, 35694, 35695, 109
14361, 35641, 35642, 35646, 35645, 35688, 35696, 35697, 35694
14362, 35642, 35643, 35647, 35646, 35690, 35698, 35699, 35696
14363, 35643, 35644, 35648, 35647, 35692, 35700, 35701, 35698
14364, 35644, 3702, 3703, 35648, 35693, 3714, 35702, 35700
14365, 98, 35645, 35649, 99, 35695, 35703, 35704, 110
14366, 35645, 35646, 35650, 35649, 35697, 35705, 35706, 35703
14367, 35646, 35647, 35651, 35650, 35699, 35707, 35708, 35705
14368, 35647, 35648, 35652, 35651, 35701, 35709, 35710, 35707
14369, 35648, 3703, 3704, 35652, 35702, 3715, 35711, 35709
14370, 99, 35649, 35653, 100, 35704, 35712, 35713, 111
14371, 35649, 35650, 35654, 35653, 35706, 35714, 35715, 35712
14372, 35650, 35651, 35655, 35654, 35708, 35716, 35717, 35714
14373, 35651, 35652, 35656, 35655, 35710, 35718, 35719, 35716
14374, 35652, 3704, 3705, 35656, 35711, 3716, 35720, 35718
14375, 100, 35653, 35657, 101, 35713, 35721, 35722, 112
14376, 35653, 35654, 35658, 35657, 35715, 35723, 35724, 35721
14377, 35654, 35655, 35659, 35658, 35717, 35725, 35726, 35723
14378, 35655, 35656, 35660, 35659, 35719, 35727, 35728, 35725
14379, 35656, 3705, 3706, 35660, 35720, 3717, 35729, 35727
14380, 101, 35657, 35661, 102, 35722, 35730, 35731, 113
14381, 35657, 35658, 35662, 35661, 35724, 35732, 35733, 35730
14382, 35658, 35659, 35663, 35662, 35726, 35734, 35735, 35732
14383, 35659, 35660, 35664, 35663, 35728, 35736, 35737, 35734
14384, 35660, 3706, 3707, 35664, 35729, 3718, 35738, 35736
14385, 102, 35661, 35665, 103, 35731, 35739, 35740, 114
14386, 35661, 35662, 35666, 35665, 35733, 35741, 35742, 35739
14387, 35662, 35663, 35667, 35666, 35735, 35743, 35744, 35741
14388, 35663, 35664, 35668, 35667, 35737, 35745, 35746, 35743
14389, 35664, 3707, 3708, 35668, 35738, 3719, 35747, 35745
14390, 103, 35665, 35669, 104, 35740, 35748, 35749, 115
14391, 35665, 35666, 35670, 35669, 35742, 35750, 35751, 35748
14392, 35666, 35667, 35671, 35670, 35744, 35752, 35753, 35750
14393, 35667, 35668, 35672, 35671, 35746, 35754, 35755, 35752
14394, 35668, 3708, 3709, 35672, 35747, 3720, 35756, 35754
14395, 104, 35669, 35673, 105, 35749, 35757, 35758, 116
14396, 35669, 35670, 35674, 35673, 35751, 35759, 35760, 35757
14397, 35670, 35671, 35675, 35674, 35753, 35761, 35762, 35759
14398, 35671, 35672, 35676, 35675, 35755, 35763, 35764, 35761
14399, 35672, 3709, 3710, 35676, 35756, 3721, 35765, 35763
14400, 105, 35673, 35677, 106, 35758, 35766, 35767, 117
14401, 35673, 35674, 35678, 35677, 35760, 35768, 35769, 35766
14402, 35674, 35675, 35679, 35678, 35762, 35770, 35771, 35768
14403, 35675, 35676, 35680, 35679, 35764, 35772, 35773, 35770
14404, 35676, 3710, 3711, 35680, 35765, 3722, 35774, 35772
14405, 106, 35677, 35681, 107, 35767, 35775, 35776, 118
14406, 35677, 35678, 35682, 35681, 35769, 35777, 35778, 35775
14407, 35678, 35679, 35683, 35682, 35771, 35779, 35780, 35777
14408, 35679, 35680, 35684, 35683, 35773, 35781, 35782, 35779
14409, 35680, 3711, 3712, 35684, 35774, 3723, 35783, 35781
14410, 107, 35681, 3646, 1, 35776, 35784, 3650, 119
14411, 35681, 35682, 3647, 3646, 35778, 35785, 3651, 35784
14412, 35682, 35683, 3648, 3647, 35780, 35786, 3652, 35785
14413, 35683, 35684, 3649, 3648, 35782, 35787, 3653, 35786
14414, 35684, 3712, 88, 3649, 35783, 3724, 3654, 35787
*ELEMENT, type=CPS8, ELSET=Surface122
14415, 86, 3567, 35788, 3702, 3590, 36041, 36042, 3713
14416, 3702, 35788, 35789, 3703, 36042, 36043, 36044, 3714
14417, 3703, 35789, 35790, 3704, 36044, 36045, 36046, 3715
14418, 3704, 35790, 35791, 3705, 36046, 36047, 36048, 3716
14419, 3705, 35791, 35792, 3706, 36048, 36049, 36050, 3717
14420, 3706, 35792, 35793, 3707, 36050, 36051, 36052, 3718
14421, 3707, 35793, 35794, 3708, 36052, 36053, 36054, 3719
14422, 3708, 35794, 35795, 3709, 36054, 36055, 36056, 3720
14423, 3709, 35795, 35796, 3710, 36056, 36057, 36058, 3721
14424, 3710, 35796, 35797, 3711, 36058, 36059, 36060, 3722
14425, 3711, 35797, 35798, 3712, 36060, 36061, 36062, 3723
14426, 3712, 35798, 3655, 88, 36062, 36063, 3678, 3724
14427, 3567, 3568, 35799, 35788, 3591, 36064, 36065, 36041
14428, 35788, 35799, 35800, 35789, 36065, 36066, 36067, 36043
14429, 35789, 35800, 35801, 35790, 36067, 36068, 36069, 36045
14430, 35790, 35801, 35802, 35791, 36069, 36070, 36071, 36047
14431, 35791, 35802, 35803, 35792, 36071, 36072, 36073, 36049
14432, 35792, 35803, 35804, 35793, 36073, 36074, 36075, 36051
14433, 35793, 35804, 35805, 35794, 36075, 36076, 36077, 36053
14434, 35794, 35805, 35806, 35795, 36077, 36078, 36079, 36055
14435, 35795, 35806, 35807, 35796, 36079, 36080, 36081, 36057
14436, 35796, 35807, 35808, 35797, 36081, 36082, 36083, 36059
14437, 35797, 35808, 35809, 35798, 36083, 36084, 36085, 36061
14438, 35798, 35809, 3656, 3655, 36085, 36086, 3679, 36063
14439, 3568, 3569, 35810, 35799, 3592, 36087, 36088, 36064
14440, 35799, 35810, 35811, 35800, 36088, 36089, 36090, 36066
14441, 35800, 35811, 35812, 35801, 36090, 36091, 36092, 36068
14442, 35801, 35812, 35813, 35802, 36092, 36093, 36094, 36070
14443, 35802, 35813, 35814, 35803, 36094, 36095, 36096, 36072
14444, 35803, 35814, 35815, 35804, 36096, 36097, 36098, 36074
14445, 35804, 35815, 35816, 35805, 36098, 36099, 36100, 36076
14446, 35805, 35816, 35817, 35806, 36100, 36101, 36102, 36078
14447, 35806, 35817, 35818, 35807, 36102, 36103, 36104, 36080
14448, 35807, 35818, 35819, 35808, 36104, 36105, 36106, 36082
14449, 35808, 35819, 35820, 35809, 36106, 36107, 36108, 36084
14450, 35809, 35820, 3657, 3656, 36108, 36109, 3680, 36086
14451, 3569, 3570, 35821, 35810, 3593, 36110, 36111, 36087
14452, 35810, 35821, 35822, 35811, 36111, 36112, 36113, 36089
14453, 35811, 35822, 35823, 35812, 36113, 36114, 36115, 36091
14454, 35812, 35823, 35824, 35813, 36115, 36116, 36117, 36093
14455, 35813, 35824, 35825, 35814, 36117, 36118, 36119, 36095
14456, 35814, 35825, 35826, 35815, 36119, 36120, 36121, 36097
14457, 35815, 35826, 35827, 35816, 36121, 36122, 36123, 36099
14458, 35816, 35827, 35828, 35817, 36123, 36124, 36125, 36101
14459, 35817, 35828, 35829, 35818, 36125, 36126, 36127, 36103
14460, 35818, 35829, 35830, 35819, 36127, 36128, 36129, 36105
14461, 35819, 35830, 35831, 35820, 36129, 36130, 36131, 36107
14462, 35820, 35831, 3658, 3657, 36131, 36132, 3681, 36109
14463, 3570, 3571, 35832, 35821, 3594, 36133, 36134, 36110
14464, 35821, 35832, 35833, 35822, 36134, 36135, 36136, 36112
14465, 35822, 35833, 35834, 35823, 36136, 36137, 36138, 36114
14466, 35823, 35834, 35835, 35824, 36138, 36139, 36140, 36116
14467, 35824, 35835, 35836, 35825, 36140, 36141, 36142, 36118
14468, 35825, 35836, 35837, 35826, 36142, 36143, 36144, 36120
14469, 35826, 35837, 35838, 35827, 36144, 36145, 36146, 36122
14470, 35827, 35838, 35839, 35828, 36146, 36147, 36148, 36124
14471, 35828, 35839, 35840, 35829, 36148, 36149, 36150, 36126
14472, 35829, 35840, 35841, 35830, 36150, 36151, 36152, 36128
14473, 35830, 35841, 35842, 35831, 36152, 36153, 36154, 36130
14474, 35831, 35842, 3659, 3658, 36154, 36155, 3682, 36132
14475, 3571, 3572, 35843, 35832, 3595, 36156, 36157, 36133
14476, 35832, 35843, 35844, 35833, 36157, 36158, 36159, 36135
14477, 35833, 35844, 35845, 35834, 36159, 36160, 36161, 36137
14478, 35834, 35845, 35846, 35835, 36161, 36162, 36163, 36139
14479, 35835, 35846, 35847, 35836, 36163, 36164, 36165, 36141
14480, 35836, 35847, 35848, 35837, 36165, 36166, 36167, 36143
14481, 35837, 35848, 35849, 35838, 36167, 36168, 36169, 36145
14482, 35838, 35849, 35850, 35839, 36169, 36170, 36171, 36147
14483, 35839, 35850, 35851, 35840, 36171, 36172, 36173, 36149
14484, 35840, 35851, 35852, 35841, 36173, 36174, 36175, 36151
14485, 35841, 35852, 35853, 35842, 36175, 36176, 36177, 36153
14486, 35842, 35853, 3660, 3659, 36177, 36178, 3683, 36155
14487, 3572, 3573, 35854, 35843, 3596, 36179, 36180, 36156
14488, 35843, 35854, 35855, 35844, 36180, 36181, 36182, 36158
14489, 35844, 35855, 35856, 35845, 36182, 36183, 36184, 36160
14490, 35845, 35856, 35857, 35846, 36184, 36185, 36186, 36162
14491, 35846, 35857, 35858, 35847, 36186, 36187, 36188, 36164
14492, 35847, 35858, 35859, 35848, 36188, 36189, 36190, 36166
14493, 35848, 35859, 35860, 35849, 36190, 36191, 36192, 36168
14494, 35849, 35860, 35861, 35850, 36192, 36193, 36194, 36170
14495, 35850, 35861, 35862, 35851, 36194, 36195, 36196, 36172
14496, 35851, 35862, 35863, 35852, 36196, 36197, 36198, 36174
14497, 35852, 35863, 35864, 35853, 36198, 36199, 36200, 36176
14498, 35853, 35864, 3661, 3660, 36200, 36201, 3684, 36178
14499, 3573, 3574, 35865, 35854, 3597, 36202, 36203, 36179
14500, 35854, 35865, 35866, 35855, 36203, 36204, 36205, 36181
14501, 35855, 35866, 35867, 35856, 36205, 36206, 36207, 36183
14502, 35856, 35867, 35868, 35857, 36207, 36208, 36209, 36185
14503, 35857, 35868, 35869, 35858, 36209, 36210, 36211, 36187
14504, 35858, 35869, 35870, 35859, 36211, 36212, 36213, 36189
14505, 35859, 35870, 35871, 35860, 36213, 36214, 36215, 36191
14506, 35860, 35871, 35872, 35861, 36215, 36216, 36217, 36193
14507, 35861, 35872, 35873, 35862, 36217, 36218, 36219, 36195
14508, 35862, 35873, 35874, 35863, 36219, 36220, 36221, 36197
14509, 35863, 35874, 35875, 35864, 36221, 36222, 36223, 36199
14510, 35864, 35875, 3662, 3661, 36223, 36224, 3685, 36201
14511, 3574, 3575, 35876, 35865, 3598, 36225, 36226, 36202
14512, 35865, 35876, 35877, 35866, 36226, 36227, 36228, 36204
14513, 35866, 35877, 35878, 35867, 36228, 36229, 36230, 36206
14514, 35867, 35878, 35879, 35868, 36230, 36231, 36232, 36208
14515, 35868, 35879, 35880, 35869, 36232, 36233, 36234, 36210
14516, 35869, 35880, 35881, 35870, 36234, 36235, 36236, 36212
14517, 35870, 35881, 35882, 35871, 36236, 36237, 36238, 36214
14518, 35871, 35882, 35883, 35872, 36238, 36239, 36240, 36216
14519, 35872, 35883, 35884, 35873, 36240, 36241, 36242, 36218
14520, 35873, 35884, 35885, 35874, 36242, 36243, 36244, 36220
14521, 35874, 35885, 35886, 35875, 36244, 36245, 36246, 36222
14522, 35875, 35886, 3663, 3662, 36246, 36247, 3686, 36224
14523, 3575, 3576, 35887, 35876, 3599, 36248, 36249, 36225
14524, 35876, 35887, 35888, 35877, 36249, 36250, 36251, 36227
14525, 35877, 35888, 35889, 35878, 36251, 36252, 36253, 36229
14526, 35878, 35889, 35890, 35879, 36253, 36254, 36255, 36231
14527, 35879, 35890, 35891, 35880, 36255, 36256, 36257, 36233
14528, 35880, 35891, 35892, 35881, 36257, 36258, 36259, 36235
14529, 35881, 35892, 35893, 35882, 36259, 36260, 36261, 36237
14530, 35882, 35893, 35894, 35883, 36261, 36262, 36263, 36239
14531, 35883, 35894, 35895, 35884, 36263, 36264, 36265, 36241
14532, 35884, 35895, 35896, 35885, 36265, 36266, 36267, 36243
14533, 35885, 35896, 35897, 35886, 36267, 36268, 36269, 36245
14534, 35886, 35897, 3664, 3663, 36269, 36270, 3687, 36247
14535, 3576, 3577, 35898, 35887, 3600, 36271, 36272, 36248
14536, 35887, 35898, 35899, 35888, 36272, 36273, 36274, 36250
14537, 35888, 35899, 35900, 35889, 36274, 36275, 36276, 36252
14538, 35889, 35900, 35901, 35890, 36276, 36277, 36278, 36254
14539, 35890, 35901, 35902, 35891, 36278, 36279, 36280, 36256
14540, 35891, 35902, 35903, 35892, 36280, 36281, 36282, 36258
14541, 35892, 35903, 35904, 35893, 36282, 36283, 36284, 36260
14542, 35893, 35904, 35905, 35894, 36284, 36285, 36286, 36262
14543, 35894, 35905, 35906, 35895, 36286, 36287, 36288, 36264
14544, 35895, 35906, 35907, 35896, 36288, 36289, 36290, 36266
14545, 35896, 35907, 35908, 35897, 36290, 36291, 36292, 36268
14546, 35897, 35908, 3665, 3664, 36292, 36293, 3688, 36270
14547, 3577, 3578, 35909, 35898, 3601, 36294, 36295, 36271
14548, 35898, 35909, 35910, 35899, 36295, 36296, 36297, 36273
14549, 35899, 35910, 35911, 35900, 36297, 36298, 36299, 36275
14550, 35900, 35911, 35912, 35901, 36299, 36300, 36301, 36277
14551, 35901, 35912, 35913, 35902, 36301, 36302, 36303, 36279
14552, 35902, 35913, 35914, 35903, 36303, 36304, 36305, 36281
14553, 35903, 35914, 35915, 35904, 36305, 36306, 36307, 36283
14554, 35904, 35915, 35916, 35905, 36307, 36308, 36309, 36285
14555, 35905, 35916, 35917, 35906, 36309, 36310, 36311, 36287
14556, 35906, 35917, 35918, 35907, 36311, 36312, 36313, 36289
14557, 35907, 35918, 35919, 35908, 36313, 36314, 36315, 36291
14558, 35908, 35919, 3666, 3665, 36315, 36316, 3689, 36293
14559, 3578, 3579, 35920, 35909, 3602, 36317, 36318, 36294
14560, 35909, 35920, 35921, 35910, 36318, 36319, 36320, 36296
14561, 35910, 35921, 35922, 35911, 36320, 36321, 36322, 36298
14562, 35911, 35922, 35923, 35912, 36322, 36323, 36324, 36300
14563, 35912, 35923, 35924, 35913, 36324, 36325, 36326, 36302
14564, 35913, 35924, 35925, 35914, 36326, 36327, 36328, 36304
14565, 35914, 35925, 35926, 35915, 36328, 36329, 36330, 36306
14566, 35915, 35926, 35927, 35916, 36330, 36331, 36332, 36308
14567, 35916, 35927, 35928, 35917, 36332, 36333, 36334, 36310
14568, 35917, 35928, 35929, 35918, 36334, 36335, 36336, 36312
14569, 35918, 35929, 35930, 35919, 36336, 36337, 36338, 36314
14570, 35919, 35930, 3667, 3666, 36338, 36339, 3690, 36316
14571, 3579, 3580, 35931, 35920, 3603, 36340, 36341, 36317
14572, 35920, 35931, 35932, 35921, 36341, 36342, 36343, 36319
14573, 35921, 35932, 35933, 35922, 36343, 36344, 36345, 36321
14574, 35922, 35933, 35934, 35923, 36345, 36346, 36347, 36323
14575, 35923, 35934, 35935, 35924, 36347, 36348, 36349, 36325
14576, 35924, 35935, 35936, 35925, 36349, 36350, 36351, 36327
14577, 35925, 35936, 35937, 35926, 36351, 36352, 36353, 36329
14578, 35926, 35937, 35938, 35927, 36353, 36354, 36355, 36331
14579, 35927, 35938, 35939, 35928, 36355, 36356, 36357, 36333
14580, 35928, 35939, 35940, 35929, 36357, 36358, 36359, 36335
14581, 35929, 35940, 35941, 35930, 36359, 36360, 36361, 36337
14582, 35930, 35941, 3668, 3667, 36361, 36362, 3691, 36339
14583, 3580, 3581, 35942, 35931, 3604, 36363, 36364, 36340
14584, 35931, 35942, 35943, 35932, 36364, 36365, 36366, 36342
14585, 35932, 35943, 35944, 35933, 36366, 36367, 36368, 36344
14586, 35933, 35944, 35945, 35934, 36368, 36369, 36370, 36346
14587, 35934, 35945, 35946, 35935, 36370, 36371, 36372, 36348
14588, 35935, 35946, 35947, 35936, 36372, 36373, 36374, 36350
14589, 35936, 35947, 35948, 35937, 36374, 36375, 36376, 36352
14590, 35937, 35948, 35949, 35938, 36376, 36377, 36378, 36354
14591, 35938, 35949, 35950, 35939, 36378, 36379, 36380, 36356
14592, 35939, 35950, 35951, 35940, 36380, 36381, 36382, 36358
14593, 35940, 35951, 35952, 35941, 36382, 36383, 36384, 36360
14594, 35941, 35952, 3669, 3668, 36384, 36385, 3692, 36362
14595, 3581, 3582, 35953, 35942, 3605, 36386, 36387, 36363
14596, 35942, 35953, 35954, 35943, 36387, 36388, 36389, 36365
14597, 35943, 35954, 35955, 35944, 36389, 36390, 36391, 36367
14598, 35944, 35955, 35956, 35945, 36391, 36392, 36393, 36369
14599, 35945, 35956, 35957, 35946, 36393, 36394, 36395, 36371
14600, 35946, 35957, 35958, 35947, 36395, 36396, 36397, 36373
14601, 35947, 35958, 35959, 35948, 36397, 36398, 36399, 36375
14602, 35948, 35959, 35960, 35949, 36399, 36400, 36401, 36377
14603, 35949, 35960, 35961, 35950, 36401, 36402, 36403, 36379
14604, 35950, 35961, 35962, 35951, 36403, 36404, 36405, 36381
14605, 35951, 35962, 35963, 35952, 36405, 36406, 36407, 36383
14606, 35952, 35963, 3670, 3669, 36407, 36408, 3693, 36385
14607, 3582, 3583, 35964, 35953, 3606, 36409, 36410, 36386
14608, 35953, 35964, 35965, 35954, 36410, 36411, 36412, 36388
14609, 35954, 35965, 35966, 35955, 36412, 36413, 36414, 36390
14610, 35955, 35966, 35967, 35956, 36414, 36415, 36416, 36392
14611, 35956, 35967, 35968, 35957, 36416, 36417, 36418, 36394
14612, 35957, 35968, 35969, 35958, 36418, 36419, 36420, 36396
14613, 35958, 35969, 35970, 35959, 36420, 36421, 36422, 36398
14614, 35959, 35970, 35971, 35960, 36422, 36423, 36424, 36400
14615, 35960, 35971, 35972, 35961, 36424, 36425, 36426, 36402
14616, 35961, 35972, 35973, 35962, 36426, 36427, 36428, 36404
14617, 35962, 35973, 35974, 35963, 36428, 36429, 36430, 36406
14618, 35963, 35974, 3671, 3670, 36430, 36431, 3694, 36408
14619, 3583, 3584, 35975, 35964, 3607, 36432, 36433, 36409
14620, 35964, 35975, 35976, 35965, 36433, 36434, 36435, 36411
14621, 35965, 35976, 35977, 35966, 36435, 36436, 36437, 36413
14622, 35966, 35977, 35978, 35967, 36437, 36438, 36439, 36415
14623, 35967, 35978, 35979, 35968, 36439, 36440, 36441, 36417
14624, 35968, 35979, 35980, 35969, 36441, 36442, 36443, 36419
14625, 35969, 35980, 35981, 35970, 36443, 36444, 36445, 36421
14626, 35970, 35981, 35982, 35971, 36445, 36446, 36447, 36423
14627, 35971, 35982, 35983, 35972, 36447, 36448, 36449, 36425
14628, 35972, 35983, 35984, 35973, 36449, 36450, 36451, 36427
14629, 35973, 35984, 35985, 35974, 36451, 36452, 36453, 36429
14630, 35974, 35985, 3672, 3671, 36453, 36454, 3695, 36431
14631, 3584, 3585, 35986, 35975, 3608, 36455, 36456, 36432
14632, 35975, 35986, 35987, 35976, 36456, 36457, 36458, 36434
14633, 35976, 35987, 35988, 35977, 36458, 36459, 36460, 36436
14634, 35977, 35988, 35989, 35978, 36460, 36461, 36462, 36438
14635, 35978, 35989, 35990, 35979, 36462, 36463, 36464, 36440
14636, 35979, 35990, 35991, 35980, 36464, 36465, 36466, 36442
14637, 35980, 35991, 35992, 35981, 36466, 36467, 36468, 36444
14638, 35981, 35992, 35993, 35982, 36468, 36469, 36470, 36446
14639, 35982, 35993, 35994, 35983, 36470, 36471, 36472, 36448
14640, 35983, 35994, 35995, 35984, 36472, 36473, 36474, 36450
14641, 35984, 35995, 35996, 35985, 36474, 36475, 36476, 36452
14642, 35985, 35996, 3673, 3672, 36476, 36477, 3696, 36454
14643, 3585, 3586, 35997, 35986, 3609, 36478, 36479, 36455
14644, 35986, 35997, 35998, 35987, 36479, 36480, 36481, 36457
14645, 35987, 35998, 35999, 35988, 36481, 36482, 36483, 36459
14646, 35988, 35999, 36000, 35989, 36483, 36484, 36485, 36461
14647, 35989, 36000, 36001, 35990, 36485, 36486, 36487, 36463
14648, 35990, 36001, 36002, 35991, 36487, 36488, 36489, 36465
14649, 35991, 36002, 36003, 35992, 36489, 36490, 36491, 36467
14650, 35992, 36003, 36004, 35993, 36491, 36492, 36493, 36469
14651, 35993, 36004, 36005, 35994, 36493, 36494, 36495, 36471
14652, 35994, 36005, 36006, 35995, 36495, 36496, 36497, 36473
14653, 35995, 36006, 36007, 35996, 36497, 36498, 36499, 36475
14654, 35996, 36007, 3674, 3673, 36499, 36500, 3697, 36477
14655, 3586, 3587, 36008, 35997, 3610, 36501, 36502, 36478
14656, 35997, 36008, 36009, 35998, 36502, 36503, 36504, 36480
14657, 35998, 36009, 36010, 35999, 36504, 36505, 36506, 36482
14658, 35999, 36010, 36011, 36000, 36506, 36507, 36508, 36484
14659, 36000, 36011, 36012, 36001, 36508, 36509, 36510, 36486
14660, 36001, 36012, 36013, 36002, 36510, 36511, 36512, 36488
14661, 36002, 36013, 36014, 36003, 36512, 36513, 36514, 36490
14662, 36003, 36014, 36015, 36004, 36514, 36515, 36516, 36492
14663, 36004, 36015, 36016, 36005, 36516, 36517, 36518, 36494
14664, 36005, 36016, 36017, 36006, 36518, 36519, 36520, 36496
14665, 36006, 36017, 36018, 36007, 36520, 36521, 36522, 36498
14666, 36007, 36018, 3675, 3674, 36522, 36523, 3698, 36500
14667, 3587, 3588, 36019, 36008, 3611, 36524, 36525, 36501
14668, 36008, 36019, 36020, 36009, 36525, 36526, 36527, 36503
14669, 36009, 36020, 36021, 36010, 36527, 36528, 36529, 36505
14670, 36010, 36021, 36022, 36011, 36529, 36530, 36531, 36507
14671, 36011, 36022, 36023, 36012, 36531, 36532, 36533, 36509
14672, 36012, 36023, 36024, 36013, 36533, 36534, 36535, 36511
14673, 36013, 36024, 36025, 36014, 36535, 36536, 36537, 36513
14674, 36014, 36025, 36026, 36015, 36537, 36538, 36539, 36515
14675, 36015, 36026, 36027, 36016, 36539, 36540, 36541, 36517
14676, 36016, 36027, 36028, 36017, 36541, 36542, 36543, 36519
14677, 36017, 36028, 36029, 36018, 36543, 36544, 36545, 36521
14678, 36018, 36029, 3676, 3675, 36545, 36546, 3699, 36523
14679, 3588, 3589, 36030, 36019, 3612, 36547, 36548, 36524
14680, 36019, 36030, 36031, 36020, 36548, 36549, 36550, 36526
14681, 36020, 36031, 36032, 36021, 36550, 36551, 36552, 36528
14682, 36021, 36032, 36033, 36022, 36552, 36553, 36554, 36530
14683, 36022, 36033, 36034, 36023, 36554, 36555, 36556, 36532
14684, 36023, 36034, 36035, 36024, 36556, 36557, 36558, 36534
14685, 36024, 36035, 36036, 36025, 36558, 36559, 36560, 36536
14686, 36025, 36036, 36037, 36026, 36560, 36561, 36562, 36538
14687, 36026, 36037, 36038, 36027, 36562, 36563, 36564, 36540
14688, 36027, 36038, 36039, 36028, 36564, 36565, 36566, 36542
14689, 36028, 36039, 36040, 36029, 36566, 36567, 36568, 36544
14690, 36029, 36040, 3677, 3676, 36568, 36569, 3700, 36546
14691, 3589, 85, 3623, 36030, 3613, 3634, 36570, 36547
14692, 36030, 3623, 3624, 36031, 36570, 3635, 36571, 36549
14693, 36031, 3624, 3625, 36032, 36571, 3636, 36572, 36551
14694, 36032, 3625, 3626, 36033, 36572, 3637, 36573, 36553
14695, 36033, 3626, 3627, 36034, 36573, 3638, 36574, 36555
14696, 36034, 3627, 3628, 36035, 36574, 3639, 36575, 36557
14697, 36035, 3628, 3629, 36036, 36575, 3640, 36576, 36559
14698, 36036, 3629, 3630, 36037, 36576, 3641, 36577, 36561
14699, 36037, 3630, 3631, 36038, 36577, 3642, 36578, 36563
14700, 36038, 3631, 3632, 36039, 36578, 3643, 36579, 36565
14701, 36039, 3632, 3633, 36040, 36579, 3644, 36580, 36567
14702, 36040, 3633, 87, 3677, 36580, 3645, 3701, 36569
*ELEMENT, type=CPS8, ELSET=Surface123
14703, 1, 53, 3725, 3646, 2345, 3729, 36581, 3650
14704, 3646, 3725, 3726, 3647, 36581, 3730, 36582, 3651
14705, 3647, 3726, 3727, 3648, 36582, 3731, 36583, 3652
14706, 3648, 3727, 3728, 3649, 36583, 3732, 36584, 3653
14707, 3649, 3728, 89, 88, 36584, 3733, 3734, 3654
*ELEMENT, type=CPS8, ELSET=Surface124
14708, 2, 3558, 3735, 54, 3562, 36585, 3739, 2346
14709, 3558, 3559, 3736, 3735, 3563, 36586, 3740, 36585
14710, 3559, 3560, 3737, 3736, 3564, 36587, 3741, 36586
14711, 3560, 3561, 3738, 3737, 3565, 36588, 3742, 36587
14712, 3561, 86, 90, 3738, 3566, 3744, 3743, 36588
*ELEMENT, type=CPS8, ELSET=Surface125
14713, 54, 3735, 36589, 2347, 3739, 36633, 36634, 2358
14714, 3735, 3736, 36590, 36589, 3740, 36635, 36636, 36633
14715, 3736, 3737, 36591, 36590, 3741, 36637, 36638, 36635
14716, 3737, 3738, 36592, 36591, 3742, 36639, 36640, 36637
14717, 3738, 90, 3745, 36592, 3743, 3756, 36641, 36639
14718, 2347, 36589, 36593, 2348, 36634, 36642, 36643, 2359
14719, 36589, 36590, 36594, 36593, 36636, 36644, 36645, 36642
14720, 36590, 36591, 36595, 36594, 36638, 36646, 36647, 36644
14721, 36591, 36592, 36596, 36595, 36640, 36648, 36649, 36646
14722, 36592, 3745, 3746, 36596, 36641, 3757, 36650, 36648
14723, 2348, 36593, 36597, 2349, 36643, 36651, 36652, 2360
14724, 36593, 36594, 36598, 36597, 36645, 36653, 36654, 36651
14725, 36594, 36595, 36599, 36598, 36647, 36655, 36656, 36653
14726, 36595, 36596, 36600, 36599, 36649, 36657, 36658, 36655
14727, 36596, 3746, 3747, 36600, 36650, 3758, 36659, 36657
14728, 2349, 36597, 36601, 2350, 36652, 36660, 36661, 2361
14729, 36597, 36598, 36602, 36601, 36654, 36662, 36663, 36660
14730, 36598, 36599, 36603, 36602, 36656, 36664, 36665, 36662
14731, 36599, 36600, 36604, 36603, 36658, 36666, 36667, 36664
14732, 36600, 3747, 3748, 36604, 36659, 3759, 36668, 36666
14733, 2350, 36601, 36605, 2351, 36661, 36669, 36670, 2362
14734, 36601, 36602, 36606, 36605, 36663, 36671, 36672, 36669
14735, 36602, 36603, 36607, 36606, 36665, 36673, 36674, 36671
14736, 36603, 36604, 36608, 36607, 36667, 36675, 36676, 36673
14737, 36604, 3748, 3749, 36608, 36668, 3760, 36677, 36675
14738, 2351, 36605, 36609, 2352, 36670, 36678, 36679, 2363
14739, 36605, 36606, 36610, 36609, 36672, 36680, 36681, 36678
14740, 36606, 36607, 36611, 36610, 36674, 36682, 36683, 36680
14741, 36607, 36608, 36612, 36611, 36676, 36684, 36685, 36682
14742, 36608, 3749, 3750, 36612, 36677, 3761, 36686, 36684
14743, 2352, 36609, 36613, 2353, 36679, 36687, 36688, 2364
14744, 36609, 36610, 36614, 36613, 36681, 36689, 36690, 36687
14745, 36610, 36611, 36615, 36614, 36683, 36691, 36692, 36689
14746, 36611, 36612, 36616, 36615, 36685, 36693, 36694, 36691
14747, 36612, 3750, 3751, 36616, 36686, 3762, 36695, 36693
14748, 2353, 36613, 36617, 2354, 36688, 36696, 36697, 2365
14749, 36613, 36614, 36618, 36617, 36690, 36698, 36699, 36696
14750, 36614, 36615, 36619, 36618, 36692, 36700, 36701, 36698
14751, 36615, 36616, 36620, 36619, 36694, 36702, 36703, 36700
14752, 36616, 3751, 3752, 36620, 36695, 3763, 36704, 36702
14753, 2354, 36617, 36621, 2355, 36697, 36705, 36706, 2366
14754, 36617, 36618, 36622, 36621, 36699, 36707, 36708, 36705
14755, 36618, 36619, 36623, 36622, 36701, 36709, 36710, 36707
14756, 36619, 36620, 36624, 36623, 36703, 36711, 36712, 36709
14757, 36620, 3752, 3753, 36624, 36704, 3764, 36713, 36711
14758, 2355, 36621, 36625, 2356, 36706, 36714, 36715, 2367
14759, 36621, 36622, 36626, 36625, 36708, 36716, 36717, 36714
14760, 36622, 36623, 36627, 36626, 36710, 36718, 36719, 36716
14761, 36623, 36624, 36628, 36627, 36712, 36720, 36721, 36718
14762, 36624, 3753, 3754, 36628, 36713, 3765, 36722, 36720
14763, 2356, 36625, 36629, 2357, 36715, 36723, 36724, 2368
14764, 36625, 36626, 36630, 36629, 36717, 36725, 36726, 36723
14765, 36626, 36627, 36631, 36630, 36719, 36727, 36728, 36725
14766, 36627, 36628, 36632, 36631, 36721, 36729, 36730, 36727
14767, 36628, 3754, 3755, 36632, 36722, 3766, 36731, 36729
14768, 2357, 36629, 3725, 53, 36724, 36732, 3729, 2369
14769, 36629, 36630, 3726, 3725, 36726, 36733, 3730, 36732
14770, 36630, 36631, 3727, 3726, 36728, 36734, 3731, 36733
14771, 36631, 36632, 3728, 3727, 36730, 36735, 3732, 36734
14772, 36632, 3755, 89, 3728, 36731, 3767, 3733, 36735
*ELEMENT, type=CPS8, ELSET=Surface126
14773, 86, 3702, 3745, 90, 3713, 36736, 3756, 3744
14774, 3702, 3703, 3746, 3745, 3714, 36737, 3757, 36736
14775, 3703, 3704, 3747, 3746, 3715, 36738, 3758, 36737
14776, 3704, 3705, 3748, 3747, 3716, 36739, 3759, 36738
14777, 3705, 3706, 3749, 3748, 3717, 36740, 3760, 36739
14778, 3706, 3707, 3750, 3749, 3718, 36741, 3761, 36740
14779, 3707, 3708, 3751, 3750, 3719, 36742, 3762, 36741
14780, 3708, 3709, 3752, 3751, 3720, 36743, 3763, 36742
14781, 3709, 3710, 3753, 3752, 3721, 36744, 3764, 36743
14782, 3710, 3711, 3754, 3753, 3722, 36745, 3765, 36744
14783, 3711, 3712, 3755, 3754, 3723, 36746, 3766, 36745
14784, 3712, 88, 89, 3755, 3724, 3734, 3767, 36746
*ELEMENT, type=CPS8, ELSET=Surface127
14785, 45, 3768, 36747, 2135, 3772, 36839, 36840, 2158
14786, 3768, 3769, 36748, 36747, 3773, 36841, 36842, 36839
14787, 3769, 3770, 36749, 36748, 3774, 36843, 36844, 36841
14788, 3770, 3771, 36750, 36749, 3775, 36845, 36846, 36843
14789, 3771, 91, 3786, 36750, 3776, 3809, 36847, 36845
14790, 2135, 36747, 36751, 2136, 36840, 36848, 36849, 2159
14791, 36747, 36748, 36752, 36751, 36842, 36850, 36851, 36848
14792, 36748, 36749, 36753, 36752, 36844, 36852, 36853, 36850
14793, 36749, 36750, 36754, 36753, 36846, 36854, 36855, 36852
14794, 36750, 3786, 3787, 36754, 36847, 3810, 36856, 36854
14795, 2136, 36751, 36755, 2137, 36849, 36857, 36858, 2160
14796, 36751, 36752, 36756, 36755, 36851, 36859, 36860, 36857
14797, 36752, 36753, 36757, 36756, 36853, 36861, 36862, 36859
14798, 36753, 36754, 36758, 36757, 36855, 36863, 36864, 36861
14799, 36754, 3787, 3788, 36758, 36856, 3811, 36865, 36863
14800, 2137, 36755, 36759, 2138, 36858, 36866, 36867, 2161
14801, 36755, 36756, 36760, 36759, 36860, 36868, 36869, 36866
14802, 36756, 36757, 36761, 36760, 36862, 36870, 36871, 36868
14803, 36757, 36758, 36762, 36761, 36864, 36872, 36873, 36870
14804, 36758, 3788, 3789, 36762, 36865, 3812, 36874, 36872
14805, 2138, 36759, 36763, 2139, 36867, 36875, 36876, 2162
14806, 36759, 36760, 36764, 36763, 36869, 36877, 36878, 36875
14807, 36760, 36761, 36765, 36764, 36871, 36879, 36880, 36877
14808, 36761, 36762, 36766, 36765, 36873, 36881, 36882, 36879
14809, 36762, 3789, 3790, 36766, 36874, 3813, 36883, 36881
14810, 2139, 36763, 36767, 2140, 36876, 36884, 36885, 2163
14811, 36763, 36764, 36768, 36767, 36878, 36886, 36887, 36884
14812, 36764, 36765, 36769, 36768, 36880, 36888, 36889, 36886
14813, 36765, 36766, 36770, 36769, 36882, 36890, 36891, 36888
14814, 36766, 3790, 3791, 36770, 36883, 3814, 36892, 36890
14815, 2140, 36767, 36771, 2141, 36885, 36893, 36894, 2164
14816, 36767, 36768, 36772, 36771, 36887, 36895, 36896, 36893
14817, 36768, 36769, 36773, 36772, 36889, 36897, 36898, 36895
14818, 36769, 36770, 36774, 36773, 36891, 36899, 36900, 36897
14819, 36770, 3791, 3792, 36774, 36892, 3815, 36901, 36899
14820, 2141, 36771, 36775, 2142, 36894, 36902, 36903, 2165
14821, 36771, 36772, 36776, 36775, 36896, 36904, 36905, 36902
14822, 36772, 36773, 36777, 36776, 36898, 36906, 36907, 36904
14823, 36773, 36774, 36778, 36777, 36900, 36908, 36909, 36906
14824, 36774, 3792, 3793, 36778, 36901, 3816, 36910, 36908
14825, 2142, 36775, 36779, 2143, 36903, 36911, 36912, 2166
14826, 36775, 36776, 36780, 36779, 36905, 36913, 36914, 36911
14827, 36776, 36777, 36781, 36780, 36907, 36915, 36916, 36913
14828, 36777, 36778, 36782, 36781, 36909, 36917, 36918, 36915
14829, 36778, 3793, 3794, 36782, 36910, 3817, 36919, 36917
14830, 2143, 36779, 36783, 2144, 36912, 36920, 36921, 2167
14831, 36779, 36780, 36784, 36783, 36914, 36922, 36923, 36920
14832, 36780, 36781, 36785, 36784, 36916, 36924, 36925, 36922
14833, 36781, 36782, 36786, 36785, 36918, 36926, 36927, 36924
14834, 36782, 3794, 3795, 36786, 36919, 3818, 36928, 36926
14835, 2144, 36783, 36787, 2145, 36921, 36929, 36930, 2168
14836, 36783, 36784, 36788, 36787, 36923, 36931, 36932, 36929
14837, 36784, 36785, 36789, 36788, 36925, 36933, 36934, 36931
14838, 36785, 36786, 36790, 36789, 36927, 36935, 36936, 36933
14839, 36786, 3795, 3796, 36790, 36928, 3819, 36937, 36935
14840, 2145, 36787, 36791, 2146, 36930, 36938, 36939, 2169
14841, 36787, 36788, 36792, 36791, 36932, 36940, 36941, 36938
14842, 36788, 36789, 36793, 36792, 36934, 36942, 36943, 36940
14843, 36789, 36790, 36794, 36793, 36936, 36944, 36945, 36942
14844, 36790, 3796, 3797, 36794, 36937, 3820, 36946, 36944
14845, 2146, 36791, 36795, 2147, 36939, 36947, 36948, 2170
14846, 36791, 36792, 36796, 36795, 36941, 36949, 36950, 36947
14847, 36792, 36793, 36797, 36796, 36943, 36951, 36952, 36949
14848, 36793, 36794, 36798, 36797, 36945, 36953, 36954, 36951
14849, 36794, 3797, 3798, 36798, 36946, 3821, 36955, 36953
14850, 2147, 36795, 36799, 2148, 36948, 36956, 36957, 2171
14851, 36795, 36796, 36800, 36799, 36950, 36958, 36959, 36956
14852, 36796, 36797, 36801, 36800, 36952, 36960, 36961, 36958
14853, 36797, 36798, 36802, 36801, 36954, 36962, 36963, 36960
14854, 36798, 3798, 3799, 36802, 36955, 3822, 36964, 36962
14855, 2148, 36799, 36803, 2149, 36957, 36965, 36966, 2172
14856, 36799, 36800, 36804, 36803, 36959, 36967, 36968, 36965
14857, 36800, 36801, 36805, 36804, 36961, 36969, 36970, 36967
14858, 36801, 36802, 36806, 36805, 36963, 36971, 36972, 36969
14859, 36802, 3799, 3800, 36806, 36964, 3823, 36973, 36971
14860, 2149, 36803, 36807, 2150, 36966, 36974, 36975, 2173
14861, 36803, 36804, 36808, 36807, 36968, 36976, 36977, 36974
14862, 36804, 36805, 36809, 36808, 36970, 36978, 36979, 36976
14863, 36805, 36806, 36810, 36809, 36972, 36980, 36981, 36978
14864, 36806, 3800, 3801, 36810, 36973, 3824, 36982, 36980
14865, 2150, 36807, 36811, 2151, 36975, 36983, 36984, 2174
14866, 36807, 36808, 36812, 36811, 36977, 36985, 36986, 36983
14867, 36808, 36809, 36813, 36812, 36979, 36987, 36988, 36985
14868, 36809, 36810, 36814, 36813, 36981, 36989, 36990, 36987
14869, 36810, 3801, 3802, 36814, 36982, 3825, 36991, 36989
