84877, 2.0125, 0.35, 0.20833333333333
84878, 2.0333333333333, 0.325, 0.20833333333333
84879, 2.0333333333333, 0.3, 0.1875
84880, 2.0125, 0.3, 0.20833333333333
84881, 2.0333333333333, 0.275, 0.20833333333333
84882, 2.0333333333333, 0.25, 0.1875
84883, 2.0125, 0.25, 0.20833333333333
84884, 2.0333333333333, 0.225, 0.20833333333333
84885, 2.0333333333333, 0.2, 0.1875
84886, 2.0125, 0.2, 0.20833333333333
84887, 2.0333333333333, 0.175, 0.20833333333333
84888, 2.075, 1.325, 0.20833333333333
84889, 2.075, 1.3, 0.1875
84890, 2.0541666666667, 1.3, 0.20833333333333
84891, 2.075, 1.275, 0.20833333333333
84892, 2.075, 1.25, 0.1875
84893, 2.0541666666667, 1.25, 0.20833333333333
84894, 2.075, 1.225, 0.20833333333333
84895, 2.075, 1.2, 0.1875
84896, 2.0541666666667, 1.2, 0.20833333333333
84897, 2.075, 1.175, 0.20833333333333
84898, 2.075, 1.15, 0.1875
84899, 2.0541666666667, 1.15, 0.20833333333333
84900, 2.075, 1.125, 0.20833333333333
84901, 2.075, 1.1, 0.1875
84902, 2.0541666666667, 1.1, 0.20833333333333
84903, 2.075, 1.075, 0.20833333333333
84904, 2.075, 1.05, 0.1875
84905, 2.0541666666667, 1.05, 0.20833333333333
84906, 2.075, 1.025, 0.20833333333333
84907, 2.075, 1, 0.1875
84908, 2.0541666666667, 1, 0.20833333333333
84909, 2.075, 0.975, 0.20833333333333
84910, 2.075, 0.95, 0.1875
84911, 2.0541666666667, 0.95, 0.20833333333333
84912, 2.075, 0.925, 0.20833333333333
84913, 2.075, 0.9, 0.1875
84914, 2.0541666666667, 0.9, 0.20833333333333
84915, 2.075, 0.875, 0.20833333333333
84916, 2.075, 0.85, 0.1875
84917, 2.0541666666667, 0.85, 0.20833333333333
84918, 2.075, 0.825, 0.20833333333333
84919, 2.075, 0.8, 0.1875
84920, 2.0541666666667, 0.8, 0.20833333333333
84921, 2.075, 0.775, 0.20833333333333
84922, 2.075, 0.75, 0.1875
84923, 2.0541666666667, 0.75, 0.20833333333333
84924, 2.075, 0.725, 0.20833333333333
84925, 2.075, 0.7, 0.1875
84926, 2.0541666666667, 0.7, 0.20833333333333
84927, 2.075, 0.675, 0.20833333333333
84928, 2.075, 0.65, 0.1875
84929, 2.0541666666667, 0.65, 0.20833333333333
84930, 2.075, 0.625, 0.20833333333333
84931, 2.075, 0.6, 0.1875
84932, 2.0541666666667, 0.6, 0.20833333333333
84933, 2.075, 0.575, 0.20833333333333
84934, 2.075, 0.55, 0.1875
84935, 2.0541666666667, 0.55, 0.20833333333333
84936, 2.075, 0.525, 0.20833333333333
84937, 2.075, 0.5, 0.1875
84938, 2.0541666666667, 0.5, 0.20833333333333
84939, 2.075, 0.475, 0.20833333333333
84940, 2.075, 0.45, 0.1875
84941, 2.0541666666667, 0.45, 0.20833333333333
84942, 2.075, 0.425, 0.20833333333333
84943, 2.075, 0.4, 0.1875
84944, 2.0541666666667, 0.4, 0.20833333333333
84945, 2.075, 0.375, 0.20833333333333
84946, 2.075, 0.35, 0.1875
84947, 2.0541666666667, 0.35, 0.20833333333333
84948, 2.075, 0.325, 0.20833333333333
84949, 2.075, 0.3, 0.1875
84950, 2.0541666666667, 0.3, 0.20833333333333
84951, 2.075, 0.275, 0.20833333333333
84952, 2.075, 0.25, 0.1875
84953, 2.0541666666667, 0.25, 0.20833333333333
84954, 2.075, 0.225, 0.20833333333333
84955, 2.075, 0.2, 0.1875
84956, 2.0541666666667, 0.2, 0.20833333333333
84957, 2.075, 0.175, 0.20833333333333
84958, 2.1166666666667, 1.325, 0.20833333333333
84959, 2.1166666666667, 1.3, 0.1875
84960, 2.0958333333333, 1.3, 0.20833333333333
84961, 2.1166666666667, 1.275, 0.20833333333333
84962, 2.1166666666667, 1.25, 0.1875
84963, 2.0958333333333, 1.25, 0.20833333333333
84964, 2.1166666666667, 1.225, 0.20833333333333
84965, 2.1166666666667, 1.2, 0.1875
84966, 2.0958333333333, 1.2, 0.20833333333333
84967, 2.1166666666667, 1.175, 0.20833333333333
84968, 2.1166666666667, 1.15, 0.1875
84969, 2.0958333333333, 1.15, 0.20833333333333
84970, 2.1166666666667, 1.125, 0.20833333333333
84971, 2.1166666666667, 1.1, 0.1875
84972, 2.0958333333333, 1.1, 0.20833333333333
84973, 2.1166666666667, 1.075, 0.20833333333333
84974, 2.1166666666667, 1.05, 0.1875
84975, 2.0958333333333, 1.05, 0.20833333333333
84976, 2.1166666666667, 1.025, 0.20833333333333
84977, 2.1166666666667, 1, 0.1875
84978, 2.0958333333333, 1, 0.20833333333333
84979, 2.1166666666667, 0.975, 0.20833333333333
84980, 2.1166666666667, 0.95, 0.1875
84981, 2.0958333333333, 0.95, 0.20833333333333
84982, 2.1166666666667, 0.925, 0.20833333333333
84983, 2.1166666666667, 0.9, 0.1875
84984, 2.0958333333333, 0.9, 0.20833333333333
84985, 2.1166666666667, 0.875, 0.20833333333333
84986, 2.1166666666667, 0.85, 0.1875
84987, 2.0958333333333, 0.85, 0.20833333333333
84988, 2.1166666666667, 0.825, 0.20833333333333
84989, 2.1166666666667, 0.8, 0.1875
84990, 2.0958333333333, 0.8, 0.20833333333333
84991, 2.1166666666667, 0.775, 0.20833333333333
84992, 2.1166666666667, 0.75, 0.1875
84993, 2.0958333333333, 0.75, 0.20833333333333
84994, 2.1166666666667, 0.725, 0.20833333333333
84995, 2.1166666666667, 0.7, 0.1875
84996, 2.0958333333333, 0.7, 0.20833333333333
84997, 2.1166666666667, 0.675, 0.20833333333333
84998, 2.1166666666667, 0.65, 0.1875
84999, 2.0958333333333, 0.65, 0.20833333333333
85000, 2.1166666666667, 0.625, 0.20833333333333
85001, 2.1166666666667, 0.6, 0.1875
85002, 2.0958333333333, 0.6, 0.20833333333333
85003, 2.1166666666667, 0.575, 0.20833333333333
85004, 2.1166666666667, 0.55, 0.1875
85005, 2.0958333333333, 0.55, 0.20833333333333
85006, 2.1166666666667, 0.525, 0.20833333333333
85007, 2.1166666666667, 0.5, 0.1875
85008, 2.0958333333333, 0.5, 0.20833333333333
85009, 2.1166666666667, 0.475, 0.20833333333333
85010, 2.1166666666667, 0.45, 0.1875
85011, 2.0958333333333, 0.45, 0.20833333333333
85012, 2.1166666666667, 0.425, 0.20833333333333
85013, 2.1166666666667, 0.4, 0.1875
85014, 2.0958333333333, 0.4, 0.20833333333333
85015, 2.1166666666667, 0.375, 0.20833333333333
85016, 2.1166666666667, 0.35, 0.1875
85017, 2.0958333333333, 0.35, 0.20833333333333
85018, 2.1166666666667, 0.325, 0.20833333333333
85019, 2.1166666666667, 0.3, 0.1875
85020, 2.0958333333333, 0.3, 0.20833333333333
85021, 2.1166666666667, 0.275, 0.20833333333333
85022, 2.1166666666667, 0.25, 0.1875
85023, 2.0958333333333, 0.25, 0.20833333333333
85024, 2.1166666666667, 0.225, 0.20833333333333
85025, 2.1166666666667, 0.2, 0.1875
85026, 2.0958333333333, 0.2, 0.20833333333333
85027, 2.1166666666667, 0.175, 0.20833333333333
85028, 2.1583333333333, 1.325, 0.20833333333333
85029, 2.1583333333333, 1.3, 0.1875
85030, 2.1375, 1.3, 0.20833333333333
85031, 2.1583333333333, 1.275, 0.20833333333333
85032, 2.1583333333333, 1.25, 0.1875
85033, 2.1375, 1.25, 0.20833333333333
85034, 2.1583333333333, 1.225, 0.20833333333333
85035, 2.1583333333333, 1.2, 0.1875
85036, 2.1375, 1.2, 0.20833333333333
85037, 2.1583333333333, 1.175, 0.20833333333333
85038, 2.1583333333333, 1.15, 0.1875
85039, 2.1375, 1.15, 0.20833333333333
85040, 2.1583333333333, 1.125, 0.20833333333333
85041, 2.1583333333333, 1.1, 0.1875
85042, 2.1375, 1.1, 0.20833333333333
85043, 2.1583333333333, 1.075, 0.20833333333333
85044, 2.1583333333333, 1.05, 0.1875
85045, 2.1375, 1.05, 0.20833333333333
85046, 2.1583333333333, 1.025, 0.20833333333333
85047, 2.1583333333333, 1, 0.1875
85048, 2.1375, 1, 0.20833333333333
85049, 2.1583333333333, 0.975, 0.20833333333333
85050, 2.1583333333333, 0.95, 0.1875
85051, 2.1375, 0.95, 0.20833333333333
85052, 2.1583333333333, 0.925, 0.20833333333333
85053, 2.1583333333333, 0.9, 0.1875
85054, 2.1375, 0.9, 0.20833333333333
85055, 2.1583333333333, 0.875, 0.20833333333333
85056, 2.1583333333333, 0.85, 0.1875
85057, 2.1375, 0.85, 0.20833333333333
85058, 2.1583333333333, 0.825, 0.20833333333333
85059, 2.1583333333333, 0.8, 0.1875
85060, 2.1375, 0.8, 0.20833333333333
85061, 2.1583333333333, 0.775, 0.20833333333333
85062, 2.1583333333333, 0.75, 0.1875
85063, 2.1375, 0.75, 0.20833333333333
85064, 2.1583333333333, 0.725, 0.20833333333333
85065, 2.1583333333333, 0.7, 0.1875
85066, 2.1375, 0.7, 0.20833333333333
85067, 2.1583333333333, 0.675, 0.20833333333333
85068, 2.1583333333333, 0.65, 0.1875
85069, 2.1375, 0.65, 0.20833333333333
85070, 2.1583333333333, 0.625, 0.20833333333333
85071, 2.1583333333333, 0.6, 0.1875
85072, 2.1375, 0.6, 0.20833333333333
85073, 2.1583333333333, 0.575, 0.20833333333333
85074, 2.1583333333333, 0.55, 0.1875
85075, 2.1375, 0.55, 0.20833333333333
85076, 2.1583333333333, 0.525, 0.20833333333333
85077, 2.1583333333333, 0.5, 0.1875
85078, 2.1375, 0.5, 0.20833333333333
85079, 2.1583333333333, 0.475, 0.20833333333333
85080, 2.1583333333333, 0.45, 0.1875
85081, 2.1375, 0.45, 0.20833333333333
85082, 2.1583333333333, 0.425, 0.20833333333333
85083, 2.1583333333333, 0.4, 0.1875
85084, 2.1375, 0.4, 0.20833333333333
85085, 2.1583333333333, 0.375, 0.20833333333333
85086, 2.1583333333333, 0.35, 0.1875
85087, 2.1375, 0.35, 0.20833333333333
85088, 2.1583333333333, 0.325, 0.20833333333333
85089, 2.1583333333333, 0.3, 0.1875
85090, 2.1375, 0.3, 0.20833333333333
85091, 2.1583333333333, 0.275, 0.20833333333333
85092, 2.1583333333333, 0.25, 0.1875
85093, 2.1375, 0.25, 0.20833333333333
85094, 2.1583333333333, 0.225, 0.20833333333333
85095, 2.1583333333333, 0.2, 0.1875
85096, 2.1375, 0.2, 0.20833333333333
85097, 2.1583333333333, 0.175, 0.20833333333333
85098, 2.1791666666667, 1.3, 0.20833333333333
85099, 2.1791666666667, 1.25, 0.20833333333333
85100, 2.1791666666667, 1.2, 0.20833333333333
85101, 2.1791666666667, 1.15, 0.20833333333333
85102, 2.1791666666667, 1.1, 0.20833333333333
85103, 2.1791666666667, 1.05, 0.20833333333333
85104, 2.1791666666667, 1, 0.20833333333333
85105, 2.1791666666667, 0.95, 0.20833333333333
85106, 2.1791666666667, 0.9, 0.20833333333333
85107, 2.1791666666667, 0.85, 0.20833333333333
85108, 2.1791666666667, 0.8, 0.20833333333333
85109, 2.1791666666667, 0.75, 0.20833333333333
85110, 2.1791666666667, 0.7, 0.20833333333333
85111, 2.1791666666667, 0.65, 0.20833333333333
85112, 2.1791666666667, 0.6, 0.20833333333333
85113, 2.1791666666667, 0.55, 0.20833333333333
85114, 2.1791666666667, 0.5, 0.20833333333333
85115, 2.1791666666667, 0.45, 0.20833333333333
85116, 2.1791666666667, 0.4, 0.20833333333333
85117, 2.1791666666667, 0.35, 0.20833333333333
85118, 2.1791666666667, 0.3, 0.20833333333333
85119, 2.1791666666667, 0.25, 0.20833333333333
85120, 2.1791666666667, 0.2, 0.20833333333333
85121, 1.2416666666667, 1.325, 0.25
85122, 1.2416666666667, 1.3, 0.22916666666667
85123, 1.2208333333333, 1.3, 0.25
85124, 1.2416666666667, 1.275, 0.25
85125, 1.2416666666667, 1.25, 0.22916666666667
85126, 1.2208333333333, 1.25, 0.25
85127, 1.2416666666667, 1.225, 0.25
85128, 1.2416666666667, 1.2, 0.22916666666667
85129, 1.2208333333333, 1.2, 0.25
85130, 1.2416666666667, 1.175, 0.25
85131, 1.2416666666667, 1.15, 0.22916666666667
85132, 1.2208333333333, 1.15, 0.25
85133, 1.2416666666667, 1.125, 0.25
85134, 1.2416666666667, 1.1, 0.22916666666667
85135, 1.2208333333333, 1.1, 0.25
85136, 1.2416666666667, 1.075, 0.25
85137, 1.2416666666667, 1.05, 0.22916666666667
85138, 1.2208333333333, 1.05, 0.25
85139, 1.2416666666667, 1.025, 0.25
85140, 1.2416666666667, 1, 0.22916666666667
85141, 1.2208333333333, 1, 0.25
85142, 1.2416666666667, 0.975, 0.25
85143, 1.2416666666667, 0.95, 0.22916666666667
85144, 1.2208333333333, 0.95, 0.25
85145, 1.2416666666667, 0.925, 0.25
85146, 1.2416666666667, 0.9, 0.22916666666667
85147, 1.2208333333333, 0.9, 0.25
85148, 1.2416666666667, 0.875, 0.25
85149, 1.2416666666667, 0.85, 0.22916666666667
85150, 1.2208333333333, 0.85, 0.25
85151, 1.2416666666667, 0.825, 0.25
85152, 1.2416666666667, 0.8, 0.22916666666667
85153, 1.2208333333333, 0.8, 0.25
85154, 1.2416666666667, 0.775, 0.25
85155, 1.2416666666667, 0.75, 0.22916666666667
85156, 1.2208333333333, 0.75, 0.25
85157, 1.2416666666667, 0.725, 0.25
85158, 1.2416666666667, 0.7, 0.22916666666667
85159, 1.2208333333333, 0.7, 0.25
85160, 1.2416666666667, 0.675, 0.25
85161, 1.2416666666667, 0.65, 0.22916666666667
85162, 1.2208333333333, 0.65, 0.25
85163, 1.2416666666667, 0.625, 0.25
85164, 1.2416666666667, 0.6, 0.22916666666667
85165, 1.2208333333333, 0.6, 0.25
85166, 1.2416666666667, 0.575, 0.25
85167, 1.2416666666667, 0.55, 0.22916666666667
85168, 1.2208333333333, 0.55, 0.25
85169, 1.2416666666667, 0.525, 0.25
85170, 1.2416666666667, 0.5, 0.22916666666667
85171, 1.2208333333333, 0.5, 0.25
85172, 1.2416666666667, 0.475, 0.25
85173, 1.2416666666667, 0.45, 0.22916666666667
85174, 1.2208333333333, 0.45, 0.25
85175, 1.2416666666667, 0.425, 0.25
85176, 1.2416666666667, 0.4, 0.22916666666667
85177, 1.2208333333333, 0.4, 0.25
85178, 1.2416666666667, 0.375, 0.25
85179, 1.2416666666667, 0.35, 0.22916666666667
85180, 1.2208333333333, 0.35, 0.25
85181, 1.2416666666667, 0.325, 0.25
85182, 1.2416666666667, 0.3, 0.22916666666667
85183, 1.2208333333333, 0.3, 0.25
85184, 1.2416666666667, 0.275, 0.25
85185, 1.2416666666667, 0.25, 0.22916666666667
85186, 1.2208333333333, 0.25, 0.25
85187, 1.2416666666667, 0.225, 0.25
85188, 1.2416666666667, 0.2, 0.22916666666667
85189, 1.2208333333333, 0.2, 0.25
85190, 1.2416666666667, 0.175, 0.25
85191, 1.2833333333333, 1.325, 0.25
85192, 1.2833333333333, 1.3, 0.22916666666667
85193, 1.2625, 1.3, 0.25
85194, 1.2833333333333, 1.275, 0.25
85195, 1.2833333333333, 1.25, 0.22916666666667
85196, 1.2625, 1.25, 0.25
85197, 1.2833333333333, 1.225, 0.25
85198, 1.2833333333333, 1.2, 0.22916666666667
85199, 1.2625, 1.2, 0.25
85200, 1.2833333333333, 1.175, 0.25
85201, 1.2833333333333, 1.15, 0.22916666666667
85202, 1.2625, 1.15, 0.25
85203, 1.2833333333333, 1.125, 0.25
85204, 1.2833333333333, 1.1, 0.22916666666667
85205, 1.2625, 1.1, 0.25
85206, 1.2833333333333, 1.075, 0.25
85207, 1.2833333333333, 1.05, 0.22916666666667
85208, 1.2625, 1.05, 0.25
85209, 1.2833333333333, 1.025, 0.25
85210, 1.2833333333333, 1, 0.22916666666667
85211, 1.2625, 1, 0.25
85212, 1.2833333333333, 0.975, 0.25
85213, 1.2833333333333, 0.95, 0.22916666666667
85214, 1.2625, 0.95, 0.25
85215, 1.2833333333333, 0.925, 0.25
85216, 1.2833333333333, 0.9, 0.22916666666667
85217, 1.2625, 0.9, 0.25
85218, 1.2833333333333, 0.875, 0.25
85219, 1.2833333333333, 0.85, 0.22916666666667
85220, 1.2625, 0.85, 0.25
85221, 1.2833333333333, 0.825, 0.25
85222, 1.2833333333333, 0.8, 0.22916666666667
85223, 1.2625, 0.8, 0.25
85224, 1.2833333333333, 0.775, 0.25
85225, 1.2833333333333, 0.75, 0.22916666666667
85226, 1.2625, 0.75, 0.25
85227, 1.2833333333333, 0.725, 0.25
85228, 1.2833333333333, 0.7, 0.22916666666667
85229, 1.2625, 0.7, 0.25
85230, 1.2833333333333, 0.675, 0.25
85231, 1.2833333333333, 0.65, 0.22916666666667
85232, 1.2625, 0.65, 0.25
85233, 1.2833333333333, 0.625, 0.25
85234, 1.2833333333333, 0.6, 0.22916666666667
85235, 1.2625, 0.6, 0.25
85236, 1.2833333333333, 0.575, 0.25
85237, 1.2833333333333, 0.55, 0.22916666666667
85238, 1.2625, 0.55, 0.25
85239, 1.2833333333333, 0.525, 0.25
85240, 1.2833333333333, 0.5, 0.22916666666667
85241, 1.2625, 0.5, 0.25
85242, 1.2833333333333, 0.475, 0.25
85243, 1.2833333333333, 0.45, 0.22916666666667
85244, 1.2625, 0.45, 0.25
85245, 1.2833333333333, 0.425, 0.25
85246, 1.2833333333333, 0.4, 0.22916666666667
85247, 1.2625, 0.4, 0.25
85248, 1.2833333333333, 0.375, 0.25
85249, 1.2833333333333, 0.35, 0.22916666666667
85250, 1.2625, 0.35, 0.25
85251, 1.2833333333333, 0.325, 0.25
85252, 1.2833333333333, 0.3, 0.22916666666667
85253, 1.2625, 0.3, 0.25
85254, 1.2833333333333, 0.275, 0.25
85255, 1.2833333333333, 0.25, 0.22916666666667
85256, 1.2625, 0.25, 0.25
85257, 1.2833333333333, 0.225, 0.25
85258, 1.2833333333333, 0.2, 0.22916666666667
85259, 1.2625, 0.2, 0.25
85260, 1.2833333333333, 0.175, 0.25
85261, 1.325, 1.325, 0.25
85262, 1.325, 1.3, 0.22916666666667
85263, 1.3041666666667, 1.3, 0.25
85264, 1.325, 1.275, 0.25
85265, 1.325, 1.25, 0.22916666666667
85266, 1.3041666666667, 1.25, 0.25
85267, 1.325, 1.225, 0.25
85268, 1.325, 1.2, 0.22916666666667
85269, 1.3041666666667, 1.2, 0.25
85270, 1.325, 1.175, 0.25
85271, 1.325, 1.15, 0.22916666666667
85272, 1.3041666666667, 1.15, 0.25
85273, 1.325, 1.125, 0.25
85274, 1.325, 1.1, 0.22916666666667
85275, 1.3041666666667, 1.1, 0.25
85276, 1.325, 1.075, 0.25
85277, 1.325, 1.05, 0.22916666666667
85278, 1.3041666666667, 1.05, 0.25
85279, 1.325, 1.025, 0.25
85280, 1.325, 1, 0.22916666666667
85281, 1.3041666666667, 1, 0.25
85282, 1.325, 0.975, 0.25
85283, 1.325, 0.95, 0.22916666666667
85284, 1.3041666666667, 0.95, 0.25
85285, 1.325, 0.925, 0.25
85286, 1.325, 0.9, 0.22916666666667
85287, 1.3041666666667, 0.9, 0.25
85288, 1.325, 0.875, 0.25
85289, 1.325, 0.85, 0.22916666666667
85290, 1.3041666666667, 0.85, 0.25
85291, 1.325, 0.825, 0.25
85292, 1.325, 0.8, 0.22916666666667
85293, 1.3041666666667, 0.8, 0.25
85294, 1.325, 0.775, 0.25
85295, 1.325, 0.75, 0.22916666666667
85296, 1.3041666666667, 0.75, 0.25
85297, 1.325, 0.725, 0.25
85298, 1.325, 0.7, 0.22916666666667
85299, 1.3041666666667, 0.7, 0.25
85300, 1.325, 0.675, 0.25
85301, 1.325, 0.65, 0.22916666666667
85302, 1.3041666666667, 0.65, 0.25
85303, 1.325, 0.625, 0.25
85304, 1.325, 0.6, 0.22916666666667
85305, 1.3041666666667, 0.6, 0.25
85306, 1.325, 0.575, 0.25
85307, 1.325, 0.55, 0.22916666666667
85308, 1.3041666666667, 0.55, 0.25
85309, 1.325, 0.525, 0.25
85310, 1.325, 0.5, 0.22916666666667
85311, 1.3041666666667, 0.5, 0.25
85312, 1.325, 0.475, 0.25
85313, 1.325, 0.45, 0.22916666666667
85314, 1.3041666666667, 0.45, 0.25
85315, 1.325, 0.425, 0.25
85316, 1.325, 0.4, 0.22916666666667
85317, 1.3041666666667, 0.4, 0.25
85318, 1.325, 0.375, 0.25
85319, 1.325, 0.35, 0.22916666666667
85320, 1.3041666666667, 0.35, 0.25
85321, 1.325, 0.325, 0.25
85322, 1.325, 0.3, 0.22916666666667
85323, 1.3041666666667, 0.3, 0.25
85324, 1.325, 0.275, 0.25
85325, 1.325, 0.25, 0.22916666666667
85326, 1.3041666666667, 0.25, 0.25
85327, 1.325, 0.225, 0.25
85328, 1.325, 0.2, 0.22916666666667
85329, 1.3041666666667, 0.2, 0.25
85330, 1.325, 0.175, 0.25
85331, 1.3666666666667, 1.325, 0.25
85332, 1.3666666666667, 1.3, 0.22916666666667
85333, 1.3458333333333, 1.3, 0.25
85334, 1.3666666666667, 1.275, 0.25
85335, 1.3666666666667, 1.25, 0.22916666666667
85336, 1.3458333333333, 1.25, 0.25
85337, 1.3666666666667, 1.225, 0.25
85338, 1.3666666666667, 1.2, 0.22916666666667
85339, 1.3458333333333, 1.2, 0.25
85340, 1.3666666666667, 1.175, 0.25
85341, 1.3666666666667, 1.15, 0.22916666666667
85342, 1.3458333333333, 1.15, 0.25
85343, 1.3666666666667, 1.125, 0.25
85344, 1.3666666666667, 1.1, 0.22916666666667
85345, 1.3458333333333, 1.1, 0.25
85346, 1.3666666666667, 1.075, 0.25
85347, 1.3666666666667, 1.05, 0.22916666666667
85348, 1.3458333333333, 1.05, 0.25
85349, 1.3666666666667, 1.025, 0.25
85350, 1.3666666666667, 1, 0.22916666666667
85351, 1.3458333333333, 1, 0.25
85352, 1.3666666666667, 0.975, 0.25
85353, 1.3666666666667, 0.95, 0.22916666666667
85354, 1.3458333333333, 0.95, 0.25
85355, 1.3666666666667, 0.925, 0.25
85356, 1.3666666666667, 0.9, 0.22916666666667
85357, 1.3458333333333, 0.9, 0.25
85358, 1.3666666666667, 0.875, 0.25
85359, 1.3666666666667, 0.85, 0.22916666666667
85360, 1.3458333333333, 0.85, 0.25
85361, 1.3666666666667, 0.825, 0.25
85362, 1.3666666666667, 0.8, 0.22916666666667
85363, 1.3458333333333, 0.8, 0.25
85364, 1.3666666666667, 0.775, 0.25
85365, 1.3666666666667, 0.75, 0.22916666666667
85366, 1.3458333333333, 0.75, 0.25
85367, 1.3666666666667, 0.725, 0.25
85368, 1.3666666666667, 0.7, 0.22916666666667
85369, 1.3458333333333, 0.7, 0.25
85370, 1.3666666666667, 0.675, 0.25
85371, 1.3666666666667, 0.65, 0.22916666666667
85372, 1.3458333333333, 0.65, 0.25
85373, 1.3666666666667, 0.625, 0.25
85374, 1.3666666666667, 0.6, 0.22916666666667
85375, 1.3458333333333, 0.6, 0.25
85376, 1.3666666666667, 0.575, 0.25
85377, 1.3666666666667, 0.55, 0.22916666666667
85378, 1.3458333333333, 0.55, 0.25
85379, 1.3666666666667, 0.525, 0.25
85380, 1.3666666666667, 0.5, 0.22916666666667
85381, 1.3458333333333, 0.5, 0.25
85382, 1.3666666666667, 0.475, 0.25
85383, 1.3666666666667, 0.45, 0.22916666666667
85384, 1.3458333333333, 0.45, 0.25
85385, 1.3666666666667, 0.425, 0.25
85386, 1.3666666666667, 0.4, 0.22916666666667
85387, 1.3458333333333, 0.4, 0.25
85388, 1.3666666666667, 0.375, 0.25
85389, 1.3666666666667, 0.35, 0.22916666666667
85390, 1.3458333333333, 0.35, 0.25
85391, 1.3666666666667, 0.325, 0.25
85392, 1.3666666666667, 0.3, 0.22916666666667
85393, 1.3458333333333, 0.3, 0.25
85394, 1.3666666666667, 0.275, 0.25
85395, 1.3666666666667, 0.25, 0.22916666666667
85396, 1.3458333333333, 0.25, 0.25
85397, 1.3666666666667, 0.225, 0.25
85398, 1.3666666666667, 0.2, 0.22916666666667
85399, 1.3458333333333, 0.2, 0.25
85400, 1.3666666666667, 0.175, 0.25
85401, 1.4083333333333, 1.325, 0.25
85402, 1.4083333333333, 1.3, 0.22916666666667
85403, 1.3875, 1.3, 0.25
85404, 1.4083333333333, 1.275, 0.25
85405, 1.4083333333333, 1.25, 0.22916666666667
85406, 1.3875, 1.25, 0.25
85407, 1.4083333333333, 1.225, 0.25
85408, 1.4083333333333, 1.2, 0.22916666666667
85409, 1.3875, 1.2, 0.25
85410, 1.4083333333333, 1.175, 0.25
85411, 1.4083333333333, 1.15, 0.22916666666667
85412, 1.3875, 1.15, 0.25
85413, 1.4083333333333, 1.125, 0.25
85414, 1.4083333333333, 1.1, 0.22916666666667
85415, 1.3875, 1.1, 0.25
85416, 1.4083333333333, 1.075, 0.25
85417, 1.4083333333333, 1.05, 0.22916666666667
85418, 1.3875, 1.05, 0.25
85419, 1.4083333333333, 1.025, 0.25
85420, 1.4083333333333, 1, 0.22916666666667
85421, 1.3875, 1, 0.25
85422, 1.4083333333333, 0.975, 0.25
85423, 1.4083333333333, 0.95, 0.22916666666667
85424, 1.3875, 0.95, 0.25
85425, 1.4083333333333, 0.925, 0.25
85426, 1.4083333333333, 0.9, 0.22916666666667
85427, 1.3875, 0.9, 0.25
85428, 1.4083333333333, 0.875, 0.25
85429, 1.4083333333333, 0.85, 0.22916666666667
85430, 1.3875, 0.85, 0.25
85431, 1.4083333333333, 0.825, 0.25
85432, 1.4083333333333, 0.8, 0.22916666666667
85433, 1.3875, 0.8, 0.25
85434, 1.4083333333333, 0.775, 0.25
85435, 1.4083333333333, 0.75, 0.22916666666667
85436, 1.3875, 0.75, 0.25
85437, 1.4083333333333, 0.725, 0.25
85438, 1.4083333333333, 0.7, 0.22916666666667
85439, 1.3875, 0.7, 0.25
85440, 1.4083333333333, 0.675, 0.25
85441, 1.4083333333333, 0.65, 0.22916666666667
85442, 1.3875, 0.65, 0.25
85443, 1.4083333333333, 0.625, 0.25
85444, 1.4083333333333, 0.6, 0.22916666666667
85445, 1.3875, 0.6, 0.25
85446, 1.4083333333333, 0.575, 0.25
85447, 1.4083333333333, 0.55, 0.22916666666667
85448, 1.3875, 0.55, 0.25
85449, 1.4083333333333, 0.525, 0.25
85450, 1.4083333333333, 0.5, 0.22916666666667
85451, 1.3875, 0.5, 0.25
85452, 1.4083333333333, 0.475, 0.25
85453, 1.4083333333333, 0.45, 0.22916666666667
85454, 1.3875, 0.45, 0.25
85455, 1.4083333333333, 0.425, 0.25
85456, 1.4083333333333, 0.4, 0.22916666666667
85457, 1.3875, 0.4, 0.25
85458, 1.4083333333333, 0.375, 0.25
85459, 1.4083333333333, 0.35, 0.22916666666667
85460, 1.3875, 0.35, 0.25
85461, 1.4083333333333, 0.325, 0.25
85462, 1.4083333333333, 0.3, 0.22916666666667
85463, 1.3875, 0.3, 0.25
85464, 1.4083333333333, 0.275, 0.25
85465, 1.4083333333333, 0.25, 0.22916666666667
85466, 1.3875, 0.25, 0.25
85467, 1.4083333333333, 0.225, 0.25
85468, 1.4083333333333, 0.2, 0.22916666666667
85469, 1.3875, 0.2, 0.25
85470, 1.4083333333333, 0.175, 0.25
85471, 1.45, 1.325, 0.25
85472, 1.45, 1.3, 0.22916666666667
85473, 1.4291666666667, 1.3, 0.25
85474, 1.45, 1.275, 0.25
85475, 1.45, 1.25, 0.22916666666667
85476, 1.4291666666667, 1.25, 0.25
85477, 1.45, 1.225, 0.25
85478, 1.45, 1.2, 0.22916666666667
85479, 1.4291666666667, 1.2, 0.25
85480, 1.45, 1.175, 0.25
85481, 1.45, 1.15, 0.22916666666667
85482, 1.4291666666667, 1.15, 0.25
85483, 1.45, 1.125, 0.25
85484, 1.45, 1.1, 0.22916666666667
85485, 1.4291666666667, 1.1, 0.25
85486, 1.45, 1.075, 0.25
85487, 1.45, 1.05, 0.22916666666667
85488, 1.4291666666667, 1.05, 0.25
85489, 1.45, 1.025, 0.25
85490, 1.45, 1, 0.22916666666667
85491, 1.4291666666667, 1, 0.25
85492, 1.45, 0.975, 0.25
85493, 1.45, 0.95, 0.22916666666667
85494, 1.4291666666667, 0.95, 0.25
85495, 1.45, 0.925, 0.25
85496, 1.45, 0.9, 0.22916666666667
85497, 1.4291666666667, 0.9, 0.25
85498, 1.45, 0.875, 0.25
85499, 1.45, 0.85, 0.22916666666667
85500, 1.4291666666667, 0.85, 0.25
85501, 1.45, 0.825, 0.25
85502, 1.45, 0.8, 0.22916666666667
85503, 1.4291666666667, 0.8, 0.25
85504, 1.45, 0.775, 0.25
85505, 1.45, 0.75, 0.22916666666667
85506, 1.4291666666667, 0.75, 0.25
85507, 1.45, 0.725, 0.25
85508, 1.45, 0.7, 0.22916666666667
85509, 1.4291666666667, 0.7, 0.25
85510, 1.45, 0.675, 0.25
85511, 1.45, 0.65, 0.22916666666667
85512, 1.4291666666667, 0.65, 0.25
85513, 1.45, 0.625, 0.25
85514, 1.45, 0.6, 0.22916666666667
85515, 1.4291666666667, 0.6, 0.25
85516, 1.45, 0.575, 0.25
85517, 1.45, 0.55, 0.22916666666667
85518, 1.4291666666667, 0.55, 0.25
85519, 1.45, 0.525, 0.25
85520, 1.45, 0.5, 0.22916666666667
85521, 1.4291666666667, 0.5, 0.25
85522, 1.45, 0.475, 0.25
85523, 1.45, 0.45, 0.22916666666667
85524, 1.4291666666667, 0.45, 0.25
85525, 1.45, 0.425, 0.25
85526, 1.45, 0.4, 0.22916666666667
85527, 1.4291666666667, 0.4, 0.25
85528, 1.45, 0.375, 0.25
85529, 1.45, 0.35, 0.22916666666667
85530, 1.4291666666667, 0.35, 0.25
85531, 1.45, 0.325, 0.25
85532, 1.45, 0.3, 0.22916666666667
85533, 1.4291666666667, 0.3, 0.25
85534, 1.45, 0.275, 0.25
85535, 1.45, 0.25, 0.22916666666667
85536, 1.4291666666667, 0.25, 0.25
85537, 1.45, 0.225, 0.25
85538, 1.45, 0.2, 0.22916666666667
85539, 1.4291666666667, 0.2, 0.25
85540, 1.45, 0.175, 0.25
85541, 1.4916666666667, 1.325, 0.25
85542, 1.4916666666667, 1.3, 0.22916666666667
85543, 1.4708333333333, 1.3, 0.25
85544, 1.4916666666667, 1.275, 0.25
85545, 1.4916666666667, 1.25, 0.22916666666667
85546, 1.4708333333333, 1.25, 0.25
85547, 1.4916666666667, 1.225, 0.25
85548, 1.4916666666667, 1.2, 0.22916666666667
85549, 1.4708333333333, 1.2, 0.25
85550, 1.4916666666667, 1.175, 0.25
85551, 1.4916666666667, 1.15, 0.22916666666667
85552, 1.4708333333333, 1.15, 0.25
85553, 1.4916666666667, 1.125, 0.25
85554, 1.4916666666667, 1.1, 0.22916666666667
85555, 1.4708333333333, 1.1, 0.25
85556, 1.4916666666667, 1.075, 0.25
85557, 1.4916666666667, 1.05, 0.22916666666667
85558, 1.4708333333333, 1.05, 0.25
85559, 1.4916666666667, 1.025, 0.25
85560, 1.4916666666667, 1, 0.22916666666667
85561, 1.4708333333333, 1, 0.25
85562, 1.4916666666667, 0.975, 0.25
85563, 1.4916666666667, 0.95, 0.22916666666667
85564, 1.4708333333333, 0.95, 0.25
85565, 1.4916666666667, 0.925, 0.25
85566, 1.4916666666667, 0.9, 0.22916666666667
85567, 1.4708333333333, 0.9, 0.25
85568, 1.4916666666667, 0.875, 0.25
85569, 1.4916666666667, 0.85, 0.22916666666667
85570, 1.4708333333333, 0.85, 0.25
85571, 1.4916666666667, 0.825, 0.25
85572, 1.4916666666667, 0.8, 0.22916666666667
85573, 1.4708333333333, 0.8, 0.25
85574, 1.4916666666667, 0.775, 0.25
85575, 1.4916666666667, 0.75, 0.22916666666667
85576, 1.4708333333333, 0.75, 0.25
85577, 1.4916666666667, 0.725, 0.25
85578, 1.4916666666667, 0.7, 0.22916666666667
85579, 1.4708333333333, 0.7, 0.25
85580, 1.4916666666667, 0.675, 0.25
85581, 1.4916666666667, 0.65, 0.22916666666667
85582, 1.4708333333333, 0.65, 0.25
85583, 1.4916666666667, 0.625, 0.25
85584, 1.4916666666667, 0.6, 0.22916666666667
85585, 1.4708333333333, 0.6, 0.25
85586, 1.4916666666667, 0.575, 0.25
85587, 1.4916666666667, 0.55, 0.22916666666667
85588, 1.4708333333333, 0.55, 0.25
85589, 1.4916666666667, 0.525, 0.25
85590, 1.4916666666667, 0.5, 0.22916666666667
85591, 1.4708333333333, 0.5, 0.25
85592, 1.4916666666667, 0.475, 0.25
85593, 1.4916666666667, 0.45, 0.22916666666667
85594, 1.4708333333333, 0.45, 0.25
85595, 1.4916666666667, 0.425, 0.25
85596, 1.4916666666667, 0.4, 0.22916666666667
85597, 1.4708333333333, 0.4, 0.25
85598, 1.4916666666667, 0.375, 0.25
85599, 1.4916666666667, 0.35, 0.22916666666667
85600, 1.4708333333333, 0.35, 0.25
85601, 1.4916666666667, 0.325, 0.25
85602, 1.4916666666667, 0.3, 0.22916666666667
85603, 1.4708333333333, 0.3, 0.25
85604, 1.4916666666667, 0.275, 0.25
85605, 1.4916666666667, 0.25, 0.22916666666667
85606, 1.4708333333333, 0.25, 0.25
85607, 1.4916666666667, 0.225, 0.25
85608, 1.4916666666667, 0.2, 0.22916666666667
85609, 1.4708333333333, 0.2, 0.25
85610, 1.4916666666667, 0.175, 0.25
85611, 1.5333333333333, 1.325, 0.25
85612, 1.5333333333333, 1.3, 0.22916666666667
85613, 1.5125, 1.3, 0.25
85614, 1.5333333333333, 1.275, 0.25
85615, 1.5333333333333, 1.25, 0.22916666666667
85616, 1.5125, 1.25, 0.25
85617, 1.5333333333333, 1.225, 0.25
85618, 1.5333333333333, 1.2, 0.22916666666667
85619, 1.5125, 1.2, 0.25
85620, 1.5333333333333, 1.175, 0.25
85621, 1.5333333333333, 1.15, 0.22916666666667
85622, 1.5125, 1.15, 0.25
85623, 1.5333333333333, 1.125, 0.25
85624, 1.5333333333333, 1.1, 0.22916666666667
85625, 1.5125, 1.1, 0.25
85626, 1.5333333333333, 1.075, 0.25
85627, 1.5333333333333, 1.05, 0.22916666666667
85628, 1.5125, 1.05, 0.25
85629, 1.5333333333333, 1.025, 0.25
85630, 1.5333333333333, 1, 0.22916666666667
85631, 1.5125, 1, 0.25
85632, 1.5333333333333, 0.975, 0.25
85633, 1.5333333333333, 0.95, 0.22916666666667
85634, 1.5125, 0.95, 0.25
85635, 1.5333333333333, 0.925, 0.25
85636, 1.5333333333333, 0.9, 0.22916666666667
85637, 1.5125, 0.9, 0.25
85638, 1.5333333333333, 0.875, 0.25
85639, 1.5333333333333, 0.85, 0.22916666666667
85640, 1.5125, 0.85, 0.25
85641, 1.5333333333333, 0.825, 0.25
85642, 1.5333333333333, 0.8, 0.22916666666667
85643, 1.5125, 0.8, 0.25
85644, 1.5333333333333, 0.775, 0.25
85645, 1.5333333333333, 0.75, 0.22916666666667
85646, 1.5125, 0.75, 0.25
85647, 1.5333333333333, 0.725, 0.25
85648, 1.5333333333333, 0.7, 0.22916666666667
85649, 1.5125, 0.7, 0.25
85650, 1.5333333333333, 0.675, 0.25
85651, 1.5333333333333, 0.65, 0.22916666666667
85652, 1.5125, 0.65, 0.25
85653, 1.5333333333333, 0.625, 0.25
85654, 1.5333333333333, 0.6, 0.22916666666667
85655, 1.5125, 0.6, 0.25
85656, 1.5333333333333, 0.575, 0.25
85657, 1.5333333333333, 0.55, 0.22916666666667
85658, 1.5125, 0.55, 0.25
85659, 1.5333333333333, 0.525, 0.25
85660, 1.5333333333333, 0.5, 0.22916666666667
85661, 1.5125, 0.5, 0.25
85662, 1.5333333333333, 0.475, 0.25
85663, 1.5333333333333, 0.45, 0.22916666666667
85664, 1.5125, 0.45, 0.25
85665, 1.5333333333333, 0.425, 0.25
85666, 1.5333333333333, 0.4, 0.22916666666667
85667, 1.5125, 0.4, 0.25
85668, 1.5333333333333, 0.375, 0.25
85669, 1.5333333333333, 0.35, 0.22916666666667
85670, 1.5125, 0.35, 0.25
85671, 1.5333333333333, 0.325, 0.25
85672, 1.5333333333333, 0.3, 0.22916666666667
85673, 1.5125, 0.3, 0.25
85674, 1.5333333333333, 0.275, 0.25
85675, 1.5333333333333, 0.25, 0.22916666666667
85676, 1.5125, 0.25, 0.25
85677, 1.5333333333333, 0.225, 0.25
85678, 1.5333333333333, 0.2, 0.22916666666667
85679, 1.5125, 0.2, 0.25
85680, 1.5333333333333, 0.175, 0.25
85681, 1.575, 1.325, 0.25
85682, 1.575, 1.3, 0.22916666666667
85683, 1.5541666666667, 1.3, 0.25
85684, 1.575, 1.275, 0.25
85685, 1.575, 1.25, 0.22916666666667
85686, 1.5541666666667, 1.25, 0.25
85687, 1.575, 1.225, 0.25
85688, 1.575, 1.2, 0.22916666666667
85689, 1.5541666666667, 1.2, 0.25
85690, 1.575, 1.175, 0.25
85691, 1.575, 1.15, 0.22916666666667
85692, 1.5541666666667, 1.15, 0.25
85693, 1.575, 1.125, 0.25
85694, 1.575, 1.1, 0.22916666666667
85695, 1.5541666666667, 1.1, 0.25
85696, 1.575, 1.075, 0.25
85697, 1.575, 1.05, 0.22916666666667
85698, 1.5541666666667, 1.05, 0.25
85699, 1.575, 1.025, 0.25
85700, 1.575, 1, 0.22916666666667
85701, 1.5541666666667, 1, 0.25
85702, 1.575, 0.975, 0.25
85703, 1.575, 0.95, 0.22916666666667
85704, 1.5541666666667, 0.95, 0.25
85705, 1.575, 0.925, 0.25
85706, 1.575, 0.9, 0.22916666666667
85707, 1.5541666666667, 0.9, 0.25
85708, 1.575, 0.875, 0.25
85709, 1.575, 0.85, 0.22916666666667
85710, 1.5541666666667, 0.85, 0.25
85711, 1.575, 0.825, 0.25
85712, 1.575, 0.8, 0.22916666666667
85713, 1.5541666666667, 0.8, 0.25
85714, 1.575, 0.775, 0.25
85715, 1.575, 0.75, 0.22916666666667
85716, 1.5541666666667, 0.75, 0.25
85717, 1.575, 0.725, 0.25
85718, 1.575, 0.7, 0.22916666666667
85719, 1.5541666666667, 0.7, 0.25
85720, 1.575, 0.675, 0.25
85721, 1.575, 0.65, 0.22916666666667
85722, 1.5541666666667, 0.65, 0.25
85723, 1.575, 0.625, 0.25
85724, 1.575, 0.6, 0.22916666666667
85725, 1.5541666666667, 0.6, 0.25
85726, 1.575, 0.575, 0.25
85727, 1.575, 0.55, 0.22916666666667
85728, 1.5541666666667, 0.55, 0.25
85729, 1.575, 0.525, 0.25
85730, 1.575, 0.5, 0.22916666666667
85731, 1.5541666666667, 0.5, 0.25
85732, 1.575, 0.475, 0.25
85733, 1.575, 0.45, 0.22916666666667
85734, 1.5541666666667, 0.45, 0.25
85735, 1.575, 0.425, 0.25
85736, 1.575, 0.4, 0.22916666666667
85737, 1.5541666666667, 0.4, 0.25
85738, 1.575, 0.375, 0.25
85739, 1.575, 0.35, 0.22916666666667
85740, 1.5541666666667, 0.35, 0.25
85741, 1.575, 0.325, 0.25
85742, 1.575, 0.3, 0.22916666666667
85743, 1.5541666666667, 0.3, 0.25
85744, 1.575, 0.275, 0.25
85745, 1.575, 0.25, 0.22916666666667
85746, 1.5541666666667, 0.25, 0.25
85747, 1.575, 0.225, 0.25
85748, 1.575, 0.2, 0.22916666666667
85749, 1.5541666666667, 0.2, 0.25
85750, 1.575, 0.175, 0.25
85751, 1.6166666666667, 1.325, 0.25
85752, 1.6166666666667, 1.3, 0.22916666666667
85753, 1.5958333333333, 1.3, 0.25
85754, 1.6166666666667, 1.275, 0.25
85755, 1.6166666666667, 1.25, 0.22916666666667
85756, 1.5958333333333, 1.25, 0.25
85757, 1.6166666666667, 1.225, 0.25
85758, 1.6166666666667, 1.2, 0.22916666666667
85759, 1.5958333333333, 1.2, 0.25
85760, 1.6166666666667, 1.175, 0.25
85761, 1.6166666666667, 1.15, 0.22916666666667
85762, 1.5958333333333, 1.15, 0.25
85763, 1.6166666666667, 1.125, 0.25
85764, 1.6166666666667, 1.1, 0.22916666666667
85765, 1.5958333333333, 1.1, 0.25
85766, 1.6166666666667, 1.075, 0.25
85767, 1.6166666666667, 1.05, 0.22916666666667
85768, 1.5958333333333, 1.05, 0.25
85769, 1.6166666666667, 1.025, 0.25
85770, 1.6166666666667, 1, 0.22916666666667
85771, 1.5958333333333, 1, 0.25
85772, 1.6166666666667, 0.975, 0.25
85773, 1.6166666666667, 0.95, 0.22916666666667
85774, 1.5958333333333, 0.95, 0.25
85775, 1.6166666666667, 0.925, 0.25
85776, 1.6166666666667, 0.9, 0.22916666666667
85777, 1.5958333333333, 0.9, 0.25
85778, 1.6166666666667, 0.875, 0.25
85779, 1.6166666666667, 0.85, 0.22916666666667
85780, 1.5958333333333, 0.85, 0.25
85781, 1.6166666666667, 0.825, 0.25
85782, 1.6166666666667, 0.8, 0.22916666666667
85783, 1.5958333333333, 0.8, 0.25
85784, 1.6166666666667, 0.775, 0.25
85785, 1.6166666666667, 0.75, 0.22916666666667
85786, 1.5958333333333, 0.75, 0.25
85787, 1.6166666666667, 0.725, 0.25
85788, 1.6166666666667, 0.7, 0.22916666666667
85789, 1.5958333333333, 0.7, 0.25
85790, 1.6166666666667, 0.675, 0.25
85791, 1.6166666666667, 0.65, 0.22916666666667
85792, 1.5958333333333, 0.65, 0.25
85793, 1.6166666666667, 0.625, 0.25
85794, 1.6166666666667, 0.6, 0.22916666666667
85795, 1.5958333333333, 0.6, 0.25
85796, 1.6166666666667, 0.575, 0.25
85797, 1.6166666666667, 0.55, 0.22916666666667
85798, 1.5958333333333, 0.55, 0.25
85799, 1.6166666666667, 0.525, 0.25
85800, 1.6166666666667, 0.5, 0.22916666666667
85801, 1.5958333333333, 0.5, 0.25
85802, 1.6166666666667, 0.475, 0.25
85803, 1.6166666666667, 0.45, 0.22916666666667
85804, 1.5958333333333, 0.45, 0.25
85805, 1.6166666666667, 0.425, 0.25
85806, 1.6166666666667, 0.4, 0.22916666666667
85807, 1.5958333333333, 0.4, 0.25
85808, 1.6166666666667, 0.375, 0.25
85809, 1.6166666666667, 0.35, 0.22916666666667
85810, 1.5958333333333, 0.35, 0.25
85811, 1.6166666666667, 0.325, 0.25
85812, 1.6166666666667, 0.3, 0.22916666666667
85813, 1.5958333333333, 0.3, 0.25
85814, 1.6166666666667, 0.275, 0.25
85815, 1.6166666666667, 0.25, 0.22916666666667
85816, 1.5958333333333, 0.25, 0.25
85817, 1.6166666666667, 0.225, 0.25
85818, 1.6166666666667, 0.2, 0.22916666666667
85819, 1.5958333333333, 0.2, 0.25
85820, 1.6166666666667, 0.175, 0.25
85821, 1.6583333333333, 1.325, 0.25
85822, 1.6583333333333, 1.3, 0.22916666666667
85823, 1.6375, 1.3, 0.25
85824, 1.6583333333333, 1.275, 0.25
85825, 1.6583333333333, 1.25, 0.22916666666667
85826, 1.6375, 1.25, 0.25
85827, 1.6583333333333, 1.225, 0.25
85828, 1.6583333333333, 1.2, 0.22916666666667
85829, 1.6375, 1.2, 0.25
85830, 1.6583333333333, 1.175, 0.25
85831, 1.6583333333333, 1.15, 0.22916666666667
85832, 1.6375, 1.15, 0.25
85833, 1.6583333333333, 1.125, 0.25
85834, 1.6583333333333, 1.1, 0.22916666666667
85835, 1.6375, 1.1, 0.25
85836, 1.6583333333333, 1.075, 0.25
85837, 1.6583333333333, 1.05, 0.22916666666667
85838, 1.6375, 1.05, 0.25
85839, 1.6583333333333, 1.025, 0.25
85840, 1.6583333333333, 1, 0.22916666666667
85841, 1.6375, 1, 0.25
85842, 1.6583333333333, 0.975, 0.25
85843, 1.6583333333333, 0.95, 0.22916666666667
85844, 1.6375, 0.95, 0.25
85845, 1.6583333333333, 0.925, 0.25
85846, 1.6583333333333, 0.9, 0.22916666666667
85847, 1.6375, 0.9, 0.25
85848, 1.6583333333333, 0.875, 0.25
85849, 1.6583333333333, 0.85, 0.22916666666667
85850, 1.6375, 0.85, 0.25
85851, 1.6583333333333, 0.825, 0.25
85852, 1.6583333333333, 0.8, 0.22916666666667
85853, 1.6375, 0.8, 0.25
85854, 1.6583333333333, 0.775, 0.25
85855, 1.6583333333333, 0.75, 0.22916666666667
85856, 1.6375, 0.75, 0.25
85857, 1.6583333333333, 0.725, 0.25
85858, 1.6583333333333, 0.7, 0.22916666666667
85859, 1.6375, 0.7, 0.25
85860, 1.6583333333333, 0.675, 0.25
85861, 1.6583333333333, 0.65, 0.22916666666667
85862, 1.6375, 0.65, 0.25
85863, 1.6583333333333, 0.625, 0.25
85864, 1.6583333333333, 0.6, 0.22916666666667
85865, 1.6375, 0.6, 0.25
85866, 1.6583333333333, 0.575, 0.25
85867, 1.6583333333333, 0.55, 0.22916666666667
85868, 1.6375, 0.55, 0.25
85869, 1.6583333333333, 0.525, 0.25
85870, 1.6583333333333, 0.5, 0.22916666666667
85871, 1.6375, 0.5, 0.25
85872, 1.6583333333333, 0.475, 0.25
85873, 1.6583333333333, 0.45, 0.22916666666667
85874, 1.6375, 0.45, 0.25
85875, 1.6583333333333, 0.425, 0.25
85876, 1.6583333333333, 0.4, 0.22916666666667
85877, 1.6375, 0.4, 0.25
85878, 1.6583333333333, 0.375, 0.25
85879, 1.6583333333333, 0.35, 0.22916666666667
85880, 1.6375, 0.35, 0.25
85881, 1.6583333333333, 0.325, 0.25
85882, 1.6583333333333, 0.3, 0.22916666666667
85883, 1.6375, 0.3, 0.25
85884, 1.6583333333333, 0.275, 0.25
85885, 1.6583333333333, 0.25, 0.22916666666667
85886, 1.6375, 0.25, 0.25
85887, 1.6583333333333, 0.225, 0.25
85888, 1.6583333333333, 0.2, 0.22916666666667
85889, 1.6375, 0.2, 0.25
85890, 1.6583333333333, 0.175, 0.25
85891, 1.7, 1.325, 0.25
85892, 1.7, 1.3, 0.22916666666667
85893, 1.6791666666667, 1.3, 0.25
85894, 1.7, 1.275, 0.25
85895, 1.7, 1.25, 0.22916666666667
85896, 1.6791666666667, 1.25, 0.25
85897, 1.7, 1.225, 0.25
85898, 1.7, 1.2, 0.22916666666667
85899, 1.6791666666667, 1.2, 0.25
85900, 1.7, 1.175, 0.25
85901, 1.7, 1.15, 0.22916666666667
85902, 1.6791666666667, 1.15, 0.25
85903, 1.7, 1.125, 0.25
85904, 1.7, 1.1, 0.22916666666667
85905, 1.6791666666667, 1.1, 0.25
85906, 1.7, 1.075, 0.25
85907, 1.7, 1.05, 0.22916666666667
85908, 1.6791666666667, 1.05, 0.25
85909, 1.7, 1.025, 0.25
85910, 1.7, 1, 0.22916666666667
85911, 1.6791666666667, 1, 0.25
85912, 1.7, 0.975, 0.25
85913, 1.7, 0.95, 0.22916666666667
85914, 1.6791666666667, 0.95, 0.25
85915, 1.7, 0.925, 0.25
85916, 1.7, 0.9, 0.22916666666667
85917, 1.6791666666667, 0.9, 0.25
85918, 1.7, 0.875, 0.25
85919, 1.7, 0.85, 0.22916666666667
85920, 1.6791666666667, 0.85, 0.25
85921, 1.7, 0.825, 0.25
85922, 1.7, 0.8, 0.22916666666667
85923, 1.6791666666667, 0.8, 0.25
85924, 1.7, 0.775, 0.25
85925, 1.7, 0.75, 0.22916666666667
85926, 1.6791666666667, 0.75, 0.25
85927, 1.7, 0.725, 0.25
85928, 1.7, 0.7, 0.22916666666667
85929, 1.6791666666667, 0.7, 0.25
85930, 1.7, 0.675, 0.25
85931, 1.7, 0.65, 0.22916666666667
85932, 1.6791666666667, 0.65, 0.25
85933, 1.7, 0.625, 0.25
85934, 1.7, 0.6, 0.22916666666667
85935, 1.6791666666667, 0.6, 0.25
85936, 1.7, 0.575, 0.25
85937, 1.7, 0.55, 0.22916666666667
85938, 1.6791666666667, 0.55, 0.25
85939, 1.7, 0.525, 0.25
85940, 1.7, 0.5, 0.22916666666667
85941, 1.6791666666667, 0.5, 0.25
85942, 1.7, 0.475, 0.25
85943, 1.7, 0.45, 0.22916666666667
85944, 1.6791666666667, 0.45, 0.25
85945, 1.7, 0.425, 0.25
85946, 1.7, 0.4, 0.22916666666667
85947, 1.6791666666667, 0.4, 0.25
85948, 1.7, 0.375, 0.25
85949, 1.7, 0.35, 0.22916666666667
85950, 1.6791666666667, 0.35, 0.25
85951, 1.7, 0.325, 0.25
85952, 1.7, 0.3, 0.22916666666667
85953, 1.6791666666667, 0.3, 0.25
85954, 1.7, 0.275, 0.25
85955, 1.7, 0.25, 0.22916666666667
85956, 1.6791666666667, 0.25, 0.25
85957, 1.7, 0.225, 0.25
85958, 1.7, 0.2, 0.22916666666667
85959, 1.6791666666667, 0.2, 0.25
85960, 1.7, 0.175, 0.25
85961, 1.7416666666667, 1.325, 0.25
85962, 1.7416666666667, 1.3, 0.22916666666667
85963, 1.7208333333333, 1.3, 0.25
85964, 1.7416666666667, 1.275, 0.25
85965, 1.7416666666667, 1.25, 0.22916666666667
85966, 1.7208333333333, 1.25, 0.25
85967, 1.7416666666667, 1.225, 0.25
85968, 1.7416666666667, 1.2, 0.22916666666667
85969, 1.7208333333333, 1.2, 0.25
85970, 1.7416666666667, 1.175, 0.25
85971, 1.7416666666667, 1.15, 0.22916666666667
85972, 1.7208333333333, 1.15, 0.25
85973, 1.7416666666667, 1.125, 0.25
85974, 1.7416666666667, 1.1, 0.22916666666667
85975, 1.7208333333333, 1.1, 0.25
85976, 1.7416666666667, 1.075, 0.25
85977, 1.7416666666667, 1.05, 0.22916666666667
85978, 1.7208333333333, 1.05, 0.25
85979, 1.7416666666667, 1.025, 0.25
85980, 1.7416666666667, 1, 0.22916666666667
85981, 1.7208333333333, 1, 0.25
85982, 1.7416666666667, 0.975, 0.25
85983, 1.7416666666667, 0.95, 0.22916666666667
85984, 1.7208333333333, 0.95, 0.25
85985, 1.7416666666667, 0.925, 0.25
85986, 1.7416666666667, 0.9, 0.22916666666667
85987, 1.7208333333333, 0.9, 0.25
85988, 1.7416666666667, 0.875, 0.25
85989, 1.7416666666667, 0.85, 0.22916666666667
85990, 1.7208333333333, 0.85, 0.25
85991, 1.7416666666667, 0.825, 0.25
85992, 1.7416666666667, 0.8, 0.22916666666667
85993, 1.7208333333333, 0.8, 0.25
85994, 1.7416666666667, 0.775, 0.25
85995, 1.7416666666667, 0.75, 0.22916666666667
85996, 1.7208333333333, 0.75, 0.25
85997, 1.7416666666667, 0.725, 0.25
85998, 1.7416666666667, 0.7, 0.22916666666667
85999, 1.7208333333333, 0.7, 0.25
86000, 1.7416666666667, 0.675, 0.25
86001, 1.7416666666667, 0.65, 0.22916666666667
86002, 1.7208333333333, 0.65, 0.25
86003, 1.7416666666667, 0.625, 0.25
86004, 1.7416666666667, 0.6, 0.22916666666667
86005, 1.7208333333333, 0.6, 0.25
86006, 1.7416666666667, 0.575, 0.25
86007, 1.7416666666667, 0.55, 0.22916666666667
86008, 1.7208333333333, 0.55, 0.25
86009, 1.7416666666667, 0.525, 0.25
86010, 1.7416666666667, 0.5, 0.22916666666667
86011, 1.7208333333333, 0.5, 0.25
86012, 1.7416666666667, 0.475, 0.25
86013, 1.7416666666667, 0.45, 0.22916666666667
86014, 1.7208333333333, 0.45, 0.25
86015, 1.7416666666667, 0.425, 0.25
86016, 1.7416666666667, 0.4, 0.22916666666667
86017, 1.7208333333333, 0.4, 0.25
86018, 1.7416666666667, 0.375, 0.25
86019, 1.7416666666667, 0.35, 0.22916666666667
86020, 1.7208333333333, 0.35, 0.25
86021, 1.7416666666667, 0.325, 0.25
86022, 1.7416666666667, 0.3, 0.22916666666667
86023, 1.7208333333333, 0.3, 0.25
86024, 1.7416666666667, 0.275, 0.25
86025, 1.7416666666667, 0.25, 0.22916666666667
86026, 1.7208333333333, 0.25, 0.25
86027, 1.7416666666667, 0.225, 0.25
86028, 1.7416666666667, 0.2, 0.22916666666667
86029, 1.7208333333333, 0.2, 0.25
86030, 1.7416666666667, 0.175, 0.25
86031, 1.7833333333333, 1.325, 0.25
86032, 1.7833333333333, 1.3, 0.22916666666667
86033, 1.7625, 1.3, 0.25
86034, 1.7833333333333, 1.275, 0.25
86035, 1.7833333333333, 1.25, 0.22916666666667
86036, 1.7625, 1.25, 0.25
86037, 1.7833333333333, 1.225, 0.25
86038, 1.7833333333333, 1.2, 0.22916666666667
86039, 1.7625, 1.2, 0.25
86040, 1.7833333333333, 1.175, 0.25
86041, 1.7833333333333, 1.15, 0.22916666666667
86042, 1.7625, 1.15, 0.25
86043, 1.7833333333333, 1.125, 0.25
86044, 1.7833333333333, 1.1, 0.22916666666667
86045, 1.7625, 1.1, 0.25
86046, 1.7833333333333, 1.075, 0.25
86047, 1.7833333333333, 1.05, 0.22916666666667
86048, 1.7625, 1.05, 0.25
86049, 1.7833333333333, 1.025, 0.25
86050, 1.7833333333333, 1, 0.22916666666667
86051, 1.7625, 1, 0.25
86052, 1.7833333333333, 0.975, 0.25
86053, 1.7833333333333, 0.95, 0.22916666666667
86054, 1.7625, 0.95, 0.25
86055, 1.7833333333333, 0.925, 0.25
86056, 1.7833333333333, 0.9, 0.22916666666667
86057, 1.7625, 0.9, 0.25
86058, 1.7833333333333, 0.875, 0.25
86059, 1.7833333333333, 0.85, 0.22916666666667
86060, 1.7625, 0.85, 0.25
86061, 1.7833333333333, 0.825, 0.25
86062, 1.7833333333333, 0.8, 0.22916666666667
86063, 1.7625, 0.8, 0.25
86064, 1.7833333333333, 0.775, 0.25
86065, 1.7833333333333, 0.75, 0.22916666666667
86066, 1.7625, 0.75, 0.25
86067, 1.7833333333333, 0.725, 0.25
86068, 1.7833333333333, 0.7, 0.22916666666667
86069, 1.7625, 0.7, 0.25
86070, 1.7833333333333, 0.675, 0.25
86071, 1.7833333333333, 0.65, 0.22916666666667
86072, 1.7625, 0.65, 0.25
86073, 1.7833333333333, 0.625, 0.25
86074, 1.7833333333333, 0.6, 0.22916666666667
86075, 1.7625, 0.6, 0.25
86076, 1.7833333333333, 0.575, 0.25
86077, 1.7833333333333, 0.55, 0.22916666666667
86078, 1.7625, 0.55, 0.25
86079, 1.7833333333333, 0.525, 0.25
86080, 1.7833333333333, 0.5, 0.22916666666667
86081, 1.7625, 0.5, 0.25
86082, 1.7833333333333, 0.475, 0.25
86083, 1.7833333333333, 0.45, 0.22916666666667
86084, 1.7625, 0.45, 0.25
86085, 1.7833333333333, 0.425, 0.25
86086, 1.7833333333333, 0.4, 0.22916666666667
86087, 1.7625, 0.4, 0.25
86088, 1.7833333333333, 0.375, 0.25
86089, 1.7833333333333, 0.35, 0.22916666666667
86090, 1.7625, 0.35, 0.25
86091, 1.7833333333333, 0.325, 0.25
86092, 1.7833333333333, 0.3, 0.22916666666667
86093, 1.7625, 0.3, 0.25
86094, 1.7833333333333, 0.275, 0.25
86095, 1.7833333333333, 0.25, 0.22916666666667
86096, 1.7625, 0.25, 0.25
86097, 1.7833333333333, 0.225, 0.25
86098, 1.7833333333333, 0.2, 0.22916666666667
86099, 1.7625, 0.2, 0.25
86100, 1.7833333333333, 0.175, 0.25
86101, 1.825, 1.325, 0.25
86102, 1.825, 1.3, 0.22916666666667
86103, 1.8041666666667, 1.3, 0.25
86104, 1.825, 1.275, 0.25
86105, 1.825, 1.25, 0.22916666666667
86106, 1.8041666666667, 1.25, 0.25
86107, 1.825, 1.225, 0.25
86108, 1.825, 1.2, 0.22916666666667
86109, 1.8041666666667, 1.2, 0.25
86110, 1.825, 1.175, 0.25
86111, 1.825, 1.15, 0.22916666666667
86112, 1.8041666666667, 1.15, 0.25
86113, 1.825, 1.125, 0.25
86114, 1.825, 1.1, 0.22916666666667
86115, 1.8041666666667, 1.1, 0.25
86116, 1.825, 1.075, 0.25
86117, 1.825, 1.05, 0.22916666666667
86118, 1.8041666666667, 1.05, 0.25
86119, 1.825, 1.025, 0.25
86120, 1.825, 1, 0.22916666666667
86121, 1.8041666666667, 1, 0.25
86122, 1.825, 0.975, 0.25
86123, 1.825, 0.95, 0.22916666666667
86124, 1.8041666666667, 0.95, 0.25
86125, 1.825, 0.925, 0.25
86126, 1.825, 0.9, 0.22916666666667
86127, 1.8041666666667, 0.9, 0.25
86128, 1.825, 0.875, 0.25
86129, 1.825, 0.85, 0.22916666666667
86130, 1.8041666666667, 0.85, 0.25
86131, 1.825, 0.825, 0.25
86132, 1.825, 0.8, 0.22916666666667
86133, 1.8041666666667, 0.8, 0.25
86134, 1.825, 0.775, 0.25
86135, 1.825, 0.75, 0.22916666666667
86136, 1.8041666666667, 0.75, 0.25
86137, 1.825, 0.725, 0.25
86138, 1.825, 0.7, 0.22916666666667
86139, 1.8041666666667, 0.7, 0.25
86140, 1.825, 0.675, 0.25
86141, 1.825, 0.65, 0.22916666666667
86142, 1.8041666666667, 0.65, 0.25
86143, 1.825, 0.625, 0.25
86144, 1.825, 0.6, 0.22916666666667
86145, 1.8041666666667, 0.6, 0.25
86146, 1.825, 0.575, 0.25
86147, 1.825, 0.55, 0.22916666666667
86148, 1.8041666666667, 0.55, 0.25
86149, 1.825, 0.525, 0.25
86150, 1.825, 0.5, 0.22916666666667
86151, 1.8041666666667, 0.5, 0.25
86152, 1.825, 0.475, 0.25
86153, 1.825, 0.45, 0.22916666666667
86154, 1.8041666666667, 0.45, 0.25
86155, 1.825, 0.425, 0.25
86156, 1.825, 0.4, 0.22916666666667
86157, 1.8041666666667, 0.4, 0.25
86158, 1.825, 0.375, 0.25
86159, 1.825, 0.35, 0.22916666666667
86160, 1.8041666666667, 0.35, 0.25
86161, 1.825, 0.325, 0.25
86162, 1.825, 0.3, 0.22916666666667
86163, 1.8041666666667, 0.3, 0.25
86164, 1.825, 0.275, 0.25
86165, 1.825, 0.25, 0.22916666666667
86166, 1.8041666666667, 0.25, 0.25
86167, 1.825, 0.225, 0.25
86168, 1.825, 0.2, 0.22916666666667
86169, 1.8041666666667, 0.2, 0.25
86170, 1.825, 0.175, 0.25
86171, 1.8666666666667, 1.325, 0.25
86172, 1.8666666666667, 1.3, 0.22916666666667
86173, 1.8458333333333, 1.3, 0.25
86174, 1.8666666666667, 1.275, 0.25
86175, 1.8666666666667, 1.25, 0.22916666666667
86176, 1.8458333333333, 1.25, 0.25
86177, 1.8666666666667, 1.225, 0.25
86178, 1.8666666666667, 1.2, 0.22916666666667
86179, 1.8458333333333, 1.2, 0.25
86180, 1.8666666666667, 1.175, 0.25
86181, 1.8666666666667, 1.15, 0.22916666666667
86182, 1.8458333333333, 1.15, 0.25
86183, 1.8666666666667, 1.125, 0.25
86184, 1.8666666666667, 1.1, 0.22916666666667
86185, 1.8458333333333, 1.1, 0.25
86186, 1.8666666666667, 1.075, 0.25
86187, 1.8666666666667, 1.05, 0.22916666666667
86188, 1.8458333333333, 1.05, 0.25
86189, 1.8666666666667, 1.025, 0.25
86190, 1.8666666666667, 1, 0.22916666666667
86191, 1.8458333333333, 1, 0.25
86192, 1.8666666666667, 0.975, 0.25
86193, 1.8666666666667, 0.95, 0.22916666666667
86194, 1.8458333333333, 0.95, 0.25
86195, 1.8666666666667, 0.925, 0.25
86196, 1.8666666666667, 0.9, 0.22916666666667
86197, 1.8458333333333, 0.9, 0.25
86198, 1.8666666666667, 0.875, 0.25
86199, 1.8666666666667, 0.85, 0.22916666666667
86200, 1.8458333333333, 0.85, 0.25
86201, 1.8666666666667, 0.825, 0.25
86202, 1.8666666666667, 0.8, 0.22916666666667
86203, 1.8458333333333, 0.8, 0.25
86204, 1.8666666666667, 0.775, 0.25
86205, 1.8666666666667, 0.75, 0.22916666666667
86206, 1.8458333333333, 0.75, 0.25
86207, 1.8666666666667, 0.725, 0.25
86208, 1.8666666666667, 0.7, 0.22916666666667
86209, 1.8458333333333, 0.7, 0.25
86210, 1.8666666666667, 0.675, 0.25
86211, 1.8666666666667, 0.65, 0.22916666666667
86212, 1.8458333333333, 0.65, 0.25
86213, 1.8666666666667, 0.625, 0.25
86214, 1.8666666666667, 0.6, 0.22916666666667
86215, 1.8458333333333, 0.6, 0.25
86216, 1.8666666666667, 0.575, 0.25
86217, 1.8666666666667, 0.55, 0.22916666666667
86218, 1.8458333333333, 0.55, 0.25
86219, 1.8666666666667, 0.525, 0.25
86220, 1.8666666666667, 0.5, 0.22916666666667
86221, 1.8458333333333, 0.5, 0.25
86222, 1.8666666666667, 0.475, 0.25
86223, 1.8666666666667, 0.45, 0.22916666666667
86224, 1.8458333333333, 0.45, 0.25
86225, 1.8666666666667, 0.425, 0.25
86226, 1.8666666666667, 0.4, 0.22916666666667
86227, 1.8458333333333, 0.4, 0.25
86228, 1.8666666666667, 0.375, 0.25
86229, 1.8666666666667, 0.35, 0.22916666666667
86230, 1.8458333333333, 0.35, 0.25
86231, 1.8666666666667, 0.325, 0.25
86232, 1.8666666666667, 0.3, 0.22916666666667
86233, 1.8458333333333, 0.3, 0.25
86234, 1.8666666666667, 0.275, 0.25
86235, 1.8666666666667, 0.25, 0.22916666666667
86236, 1.8458333333333, 0.25, 0.25
86237, 1.8666666666667, 0.225, 0.25
86238, 1.8666666666667, 0.2, 0.22916666666667
86239, 1.8458333333333, 0.2, 0.25
86240, 1.8666666666667, 0.175, 0.25
86241, 1.9083333333333, 1.325, 0.25
86242, 1.9083333333333, 1.3, 0.22916666666667
86243, 1.8875, 1.3, 0.25
86244, 1.9083333333333, 1.275, 0.25
86245, 1.9083333333333, 1.25, 0.22916666666667
86246, 1.8875, 1.25, 0.25
86247, 1.9083333333333, 1.225, 0.25
86248, 1.9083333333333, 1.2, 0.22916666666667
86249, 1.8875, 1.2, 0.25
86250, 1.9083333333333, 1.175, 0.25
86251, 1.9083333333333, 1.15, 0.22916666666667
86252, 1.8875, 1.15, 0.25
86253, 1.9083333333333, 1.125, 0.25
86254, 1.9083333333333, 1.1, 0.22916666666667
86255, 1.8875, 1.1, 0.25
86256, 1.9083333333333, 1.075, 0.25
86257, 1.9083333333333, 1.05, 0.22916666666667
86258, 1.8875, 1.05, 0.25
86259, 1.9083333333333, 1.025, 0.25
86260, 1.9083333333333, 1, 0.22916666666667
86261, 1.8875, 1, 0.25
86262, 1.9083333333333, 0.975, 0.25
86263, 1.9083333333333, 0.95, 0.22916666666667
86264, 1.8875, 0.95, 0.25
86265, 1.9083333333333, 0.925, 0.25
86266, 1.9083333333333, 0.9, 0.22916666666667
86267, 1.8875, 0.9, 0.25
86268, 1.9083333333333, 0.875, 0.25
86269, 1.9083333333333, 0.85, 0.22916666666667
86270, 1.8875, 0.85, 0.25
86271, 1.9083333333333, 0.825, 0.25
86272, 1.9083333333333, 0.8, 0.22916666666667
86273, 1.8875, 0.8, 0.25
86274, 1.9083333333333, 0.775, 0.25
86275, 1.9083333333333, 0.75, 0.22916666666667
86276, 1.8875, 0.75, 0.25
86277, 1.9083333333333, 0.725, 0.25
86278, 1.9083333333333, 0.7, 0.22916666666667
86279, 1.8875, 0.7, 0.25
86280, 1.9083333333333, 0.675, 0.25
86281, 1.9083333333333, 0.65, 0.22916666666667
86282, 1.8875, 0.65, 0.25
86283, 1.9083333333333, 0.625, 0.25
86284, 1.9083333333333, 0.6, 0.22916666666667
86285, 1.8875, 0.6, 0.25
86286, 1.9083333333333, 0.575, 0.25
86287, 1.9083333333333, 0.55, 0.22916666666667
86288, 1.8875, 0.55, 0.25
86289, 1.9083333333333, 0.525, 0.25
86290, 1.9083333333333, 0.5, 0.22916666666667
86291, 1.8875, 0.5, 0.25
86292, 1.9083333333333, 0.475, 0.25
86293, 1.9083333333333, 0.45, 0.22916666666667
86294, 1.8875, 0.45, 0.25
86295, 1.9083333333333, 0.425, 0.25
86296, 1.9083333333333, 0.4, 0.22916666666667
86297, 1.8875, 0.4, 0.25
86298, 1.9083333333333, 0.375, 0.25
86299, 1.9083333333333, 0.35, 0.22916666666667
86300, 1.8875, 0.35, 0.25
86301, 1.9083333333333, 0.325, 0.25
86302, 1.9083333333333, 0.3, 0.22916666666667
86303, 1.8875, 0.3, 0.25
86304, 1.9083333333333, 0.275, 0.25
86305, 1.9083333333333, 0.25, 0.22916666666667
86306, 1.8875, 0.25, 0.25
86307, 1.9083333333333, 0.225, 0.25
86308, 1.9083333333333, 0.2, 0.22916666666667
86309, 1.8875, 0.2, 0.25
86310, 1.9083333333333, 0.175, 0.25
86311, 1.95, 1.325, 0.25
86312, 1.95, 1.3, 0.22916666666667
86313, 1.9291666666667, 1.3, 0.25
86314, 1.95, 1.275, 0.25
86315, 1.95, 1.25, 0.22916666666667
86316, 1.9291666666667, 1.25, 0.25
86317, 1.95, 1.225, 0.25
86318, 1.95, 1.2, 0.22916666666667
86319, 1.9291666666667, 1.2, 0.25
86320, 1.95, 1.175, 0.25
86321, 1.95, 1.15, 0.22916666666667
86322, 1.9291666666667, 1.15, 0.25
86323, 1.95, 1.125, 0.25
86324, 1.95, 1.1, 0.22916666666667
86325, 1.9291666666667, 1.1, 0.25
86326, 1.95, 1.075, 0.25
86327, 1.95, 1.05, 0.22916666666667
86328, 1.9291666666667, 1.05, 0.25
86329, 1.95, 1.025, 0.25
86330, 1.95, 1, 0.22916666666667
86331, 1.9291666666667, 1, 0.25
86332, 1.95, 0.975, 0.25
86333, 1.95, 0.95, 0.22916666666667
86334, 1.9291666666667, 0.95, 0.25
86335, 1.95, 0.925, 0.25
86336, 1.95, 0.9, 0.22916666666667
86337, 1.9291666666667, 0.9, 0.25
86338, 1.95, 0.875, 0.25
86339, 1.95, 0.85, 0.22916666666667
86340, 1.9291666666667, 0.85, 0.25
86341, 1.95, 0.825, 0.25
86342, 1.95, 0.8, 0.22916666666667
86343, 1.9291666666667, 0.8, 0.25
86344, 1.95, 0.775, 0.25
86345, 1.95, 0.75, 0.22916666666667
86346, 1.9291666666667, 0.75, 0.25
86347, 1.95, 0.725, 0.25
86348, 1.95, 0.7, 0.22916666666667
86349, 1.9291666666667, 0.7, 0.25
86350, 1.95, 0.675, 0.25
86351, 1.95, 0.65, 0.22916666666667
86352, 1.9291666666667, 0.65, 0.25
86353, 1.95, 0.625, 0.25
86354, 1.95, 0.6, 0.22916666666667
86355, 1.9291666666667, 0.6, 0.25
86356, 1.95, 0.575, 0.25
86357, 1.95, 0.55, 0.22916666666667
86358, 1.9291666666667, 0.55, 0.25
86359, 1.95, 0.525, 0.25
86360, 1.95, 0.5, 0.22916666666667
86361, 1.9291666666667, 0.5, 0.25
86362, 1.95, 0.475, 0.25
86363, 1.95, 0.45, 0.22916666666667
86364, 1.9291666666667, 0.45, 0.25
86365, 1.95, 0.425, 0.25
86366, 1.95, 0.4, 0.22916666666667
86367, 1.9291666666667, 0.4, 0.25
86368, 1.95, 0.375, 0.25
86369, 1.95, 0.35, 0.22916666666667
86370, 1.9291666666667, 0.35, 0.25
86371, 1.95, 0.325, 0.25
86372, 1.95, 0.3, 0.22916666666667
86373, 1.9291666666667, 0.3, 0.25
86374, 1.95, 0.275, 0.25
86375, 1.95, 0.25, 0.22916666666667
86376, 1.9291666666667, 0.25, 0.25
86377, 1.95, 0.225, 0.25
86378, 1.95, 0.2, 0.22916666666667
86379, 1.9291666666667, 0.2, 0.25
86380, 1.95, 0.175, 0.25
86381, 1.9916666666667, 1.325, 0.25
86382, 1.9916666666667, 1.3, 0.22916666666667
86383, 1.9708333333333, 1.3, 0.25
86384, 1.9916666666667, 1.275, 0.25
86385, 1.9916666666667, 1.25, 0.22916666666667
86386, 1.9708333333333, 1.25, 0.25
86387, 1.9916666666667, 1.225, 0.25
86388, 1.9916666666667, 1.2, 0.22916666666667
86389, 1.9708333333333, 1.2, 0.25
86390, 1.9916666666667, 1.175, 0.25
86391, 1.9916666666667, 1.15, 0.22916666666667
86392, 1.9708333333333, 1.15, 0.25
86393, 1.9916666666667, 1.125, 0.25
86394, 1.9916666666667, 1.1, 0.22916666666667
86395, 1.9708333333333, 1.1, 0.25
86396, 1.9916666666667, 1.075, 0.25
86397, 1.9916666666667, 1.05, 0.22916666666667
86398, 1.9708333333333, 1.05, 0.25
86399, 1.9916666666667, 1.025, 0.25
86400, 1.9916666666667, 1, 0.22916666666667
86401, 1.9708333333333, 1, 0.25
86402, 1.9916666666667, 0.975, 0.25
86403, 1.9916666666667, 0.95, 0.22916666666667
86404, 1.9708333333333, 0.95, 0.25
86405, 1.9916666666667, 0.925, 0.25
86406, 1.9916666666667, 0.9, 0.22916666666667
86407, 1.9708333333333, 0.9, 0.25
86408, 1.9916666666667, 0.875, 0.25
86409, 1.9916666666667, 0.85, 0.22916666666667
86410, 1.9708333333333, 0.85, 0.25
86411, 1.9916666666667, 0.825, 0.25
86412, 1.9916666666667, 0.8, 0.22916666666667
86413, 1.9708333333333, 0.8, 0.25
86414, 1.9916666666667, 0.775, 0.25
86415, 1.9916666666667, 0.75, 0.22916666666667
86416, 1.9708333333333, 0.75, 0.25
86417, 1.9916666666667, 0.725, 0.25
86418, 1.9916666666667, 0.7, 0.22916666666667
86419, 1.9708333333333, 0.7, 0.25
86420, 1.9916666666667, 0.675, 0.25
86421, 1.9916666666667, 0.65, 0.22916666666667
86422, 1.9708333333333, 0.65, 0.25
86423, 1.9916666666667, 0.625, 0.25
86424, 1.9916666666667, 0.6, 0.22916666666667
86425, 1.9708333333333, 0.6, 0.25
86426, 1.9916666666667, 0.575, 0.25
86427, 1.9916666666667, 0.55, 0.22916666666667
86428, 1.9708333333333, 0.55, 0.25
86429, 1.9916666666667, 0.525, 0.25
86430, 1.9916666666667, 0.5, 0.22916666666667
86431, 1.9708333333333, 0.5, 0.25
86432, 1.9916666666667, 0.475, 0.25
86433, 1.9916666666667, 0.45, 0.22916666666667
86434, 1.9708333333333, 0.45, 0.25
86435, 1.9916666666667, 0.425, 0.25
86436, 1.9916666666667, 0.4, 0.22916666666667
86437, 1.9708333333333, 0.4, 0.25
86438, 1.9916666666667, 0.375, 0.25
86439, 1.9916666666667, 0.35, 0.22916666666667
86440, 1.9708333333333, 0.35, 0.25
86441, 1.9916666666667, 0.325, 0.25
86442, 1.9916666666667, 0.3, 0.22916666666667
86443, 1.9708333333333, 0.3, 0.25
86444, 1.9916666666667, 0.275, 0.25
86445, 1.9916666666667, 0.25, 0.22916666666667
86446, 1.9708333333333, 0.25, 0.25
86447, 1.9916666666667, 0.225, 0.25
86448, 1.9916666666667, 0.2, 0.22916666666667
86449, 1.9708333333333, 0.2, 0.25
86450, 1.9916666666667, 0.175, 0.25
86451, 2.0333333333333, 1.325, 0.25
86452, 2.0333333333333, 1.3, 0.22916666666667
86453, 2.0125, 1.3, 0.25
86454, 2.0333333333333, 1.275, 0.25
86455, 2.0333333333333, 1.25, 0.22916666666667
86456, 2.0125, 1.25, 0.25
86457, 2.0333333333333, 1.225, 0.25
86458, 2.0333333333333, 1.2, 0.22916666666667
86459, 2.0125, 1.2, 0.25
86460, 2.0333333333333, 1.175, 0.25
86461, 2.0333333333333, 1.15, 0.22916666666667
86462, 2.0125, 1.15, 0.25
86463, 2.0333333333333, 1.125, 0.25
86464, 2.0333333333333, 1.1, 0.22916666666667
86465, 2.0125, 1.1, 0.25
86466, 2.0333333333333, 1.075, 0.25
86467, 2.0333333333333, 1.05, 0.22916666666667
86468, 2.0125, 1.05, 0.25
86469, 2.0333333333333, 1.025, 0.25
86470, 2.0333333333333, 1, 0.22916666666667
86471, 2.0125, 1, 0.25
86472, 2.0333333333333, 0.975, 0.25
86473, 2.0333333333333, 0.95, 0.22916666666667
86474, 2.0125, 0.95, 0.25
86475, 2.0333333333333, 0.925, 0.25
86476, 2.0333333333333, 0.9, 0.22916666666667
86477, 2.0125, 0.9, 0.25
86478, 2.0333333333333, 0.875, 0.25
86479, 2.0333333333333, 0.85, 0.22916666666667
86480, 2.0125, 0.85, 0.25
86481, 2.0333333333333, 0.825, 0.25
86482, 2.0333333333333, 0.8, 0.22916666666667
86483, 2.0125, 0.8, 0.25
86484, 2.0333333333333, 0.775, 0.25
86485, 2.0333333333333, 0.75, 0.22916666666667
86486, 2.0125, 0.75, 0.25
86487, 2.0333333333333, 0.725, 0.25
86488, 2.0333333333333, 0.7, 0.22916666666667
86489, 2.0125, 0.7, 0.25
86490, 2.0333333333333, 0.675, 0.25
86491, 2.0333333333333, 0.65, 0.22916666666667
86492, 2.0125, 0.65, 0.25
86493, 2.0333333333333, 0.625, 0.25
86494, 2.0333333333333, 0.6, 0.22916666666667
86495, 2.0125, 0.6, 0.25
86496, 2.0333333333333, 0.575, 0.25
86497, 2.0333333333333, 0.55, 0.22916666666667
86498, 2.0125, 0.55, 0.25
86499, 2.0333333333333, 0.525, 0.25
86500, 2.0333333333333, 0.5, 0.22916666666667
86501, 2.0125, 0.5, 0.25
86502, 2.0333333333333, 0.475, 0.25
86503, 2.0333333333333, 0.45, 0.22916666666667
86504, 2.0125, 0.45, 0.25
86505, 2.0333333333333, 0.425, 0.25
86506, 2.0333333333333, 0.4, 0.22916666666667
86507, 2.0125, 0.4, 0.25
86508, 2.0333333333333, 0.375, 0.25
86509, 2.0333333333333, 0.35, 0.22916666666667
86510, 2.0125, 0.35, 0.25
86511, 2.0333333333333, 0.325, 0.25
86512, 2.0333333333333, 0.3, 0.22916666666667
86513, 2.0125, 0.3, 0.25
86514, 2.0333333333333, 0.275, 0.25
86515, 2.0333333333333, 0.25, 0.22916666666667
86516, 2.0125, 0.25, 0.25
86517, 2.0333333333333, 0.225, 0.25
86518, 2.0333333333333, 0.2, 0.22916666666667
86519, 2.0125, 0.2, 0.25
86520, 2.0333333333333, 0.175, 0.25
86521, 2.075, 1.325, 0.25
86522, 2.075, 1.3, 0.22916666666667
86523, 2.0541666666667, 1.3, 0.25
86524, 2.075, 1.275, 0.25
86525, 2.075, 1.25, 0.22916666666667
86526, 2.0541666666667, 1.25, 0.25
86527, 2.075, 1.225, 0.25
86528, 2.075, 1.2, 0.22916666666667
86529, 2.0541666666667, 1.2, 0.25
86530, 2.075, 1.175, 0.25
86531, 2.075, 1.15, 0.22916666666667
86532, 2.0541666666667, 1.15, 0.25
86533, 2.075, 1.125, 0.25
86534, 2.075, 1.1, 0.22916666666667
86535, 2.0541666666667, 1.1, 0.25
86536, 2.075, 1.075, 0.25
86537, 2.075, 1.05, 0.22916666666667
86538, 2.0541666666667, 1.05, 0.25
86539, 2.075, 1.025, 0.25
86540, 2.075, 1, 0.22916666666667
86541, 2.0541666666667, 1, 0.25
86542, 2.075, 0.975, 0.25
86543, 2.075, 0.95, 0.22916666666667
86544, 2.0541666666667, 0.95, 0.25
86545, 2.075, 0.925, 0.25
86546, 2.075, 0.9, 0.22916666666667
86547, 2.0541666666667, 0.9, 0.25
86548, 2.075, 0.875, 0.25
86549, 2.075, 0.85, 0.22916666666667
86550, 2.0541666666667, 0.85, 0.25
86551, 2.075, 0.825, 0.25
86552, 2.075, 0.8, 0.22916666666667
86553, 2.0541666666667, 0.8, 0.25
86554, 2.075, 0.775, 0.25
86555, 2.075, 0.75, 0.22916666666667
86556, 2.0541666666667, 0.75, 0.25
86557, 2.075, 0.725, 0.25
86558, 2.075, 0.7, 0.22916666666667
86559, 2.0541666666667, 0.7, 0.25
86560, 2.075, 0.675, 0.25
86561, 2.075, 0.65, 0.22916666666667
86562, 2.0541666666667, 0.65, 0.25
86563, 2.075, 0.625, 0.25
86564, 2.075, 0.6, 0.22916666666667
86565, 2.0541666666667, 0.6, 0.25
86566, 2.075, 0.575, 0.25
86567, 2.075, 0.55, 0.22916666666667
86568, 2.0541666666667, 0.55, 0.25
86569, 2.075, 0.525, 0.25
86570, 2.075, 0.5, 0.22916666666667
86571, 2.0541666666667, 0.5, 0.25
86572, 2.075, 0.475, 0.25
86573, 2.075, 0.45, 0.22916666666667
86574, 2.0541666666667, 0.45, 0.25
86575, 2.075, 0.425, 0.25
86576, 2.075, 0.4, 0.22916666666667
86577, 2.0541666666667, 0.4, 0.25
86578, 2.075, 0.375, 0.25
86579, 2.075, 0.35, 0.22916666666667
86580, 2.0541666666667, 0.35, 0.25
86581, 2.075, 0.325, 0.25
86582, 2.075, 0.3, 0.22916666666667
86583, 2.0541666666667, 0.3, 0.25
86584, 2.075, 0.275, 0.25
86585, 2.075, 0.25, 0.22916666666667
86586, 2.0541666666667, 0.25, 0.25
86587, 2.075, 0.225, 0.25
86588, 2.075, 0.2, 0.22916666666667
86589, 2.0541666666667, 0.2, 0.25
86590, 2.075, 0.175, 0.25
86591, 2.1166666666667, 1.325, 0.25
86592, 2.1166666666667, 1.3, 0.22916666666667
86593, 2.0958333333333, 1.3, 0.25
86594, 2.1166666666667, 1.275, 0.25
86595, 2.1166666666667, 1.25, 0.22916666666667
86596, 2.0958333333333, 1.25, 0.25
86597, 2.1166666666667, 1.225, 0.25
86598, 2.1166666666667, 1.2, 0.22916666666667
86599, 2.0958333333333, 1.2, 0.25
86600, 2.1166666666667, 1.175, 0.25
86601, 2.1166666666667, 1.15, 0.22916666666667
86602, 2.0958333333333, 1.15, 0.25
86603, 2.1166666666667, 1.125, 0.25
86604, 2.1166666666667, 1.1, 0.22916666666667
86605, 2.0958333333333, 1.1, 0.25
86606, 2.1166666666667, 1.075, 0.25
86607, 2.1166666666667, 1.05, 0.22916666666667
86608, 2.0958333333333, 1.05, 0.25
86609, 2.1166666666667, 1.025, 0.25
86610, 2.1166666666667, 1, 0.22916666666667
86611, 2.0958333333333, 1, 0.25
86612, 2.1166666666667, 0.975, 0.25
86613, 2.1166666666667, 0.95, 0.22916666666667
86614, 2.0958333333333, 0.95, 0.25
86615, 2.1166666666667, 0.925, 0.25
86616, 2.1166666666667, 0.9, 0.22916666666667
86617, 2.0958333333333, 0.9, 0.25
86618, 2.1166666666667, 0.875, 0.25
86619, 2.1166666666667, 0.85, 0.22916666666667
86620, 2.0958333333333, 0.85, 0.25
86621, 2.1166666666667, 0.825, 0.25
86622, 2.1166666666667, 0.8, 0.22916666666667
86623, 2.0958333333333, 0.8, 0.25
86624, 2.1166666666667, 0.775, 0.25
86625, 2.1166666666667, 0.75, 0.22916666666667
86626, 2.0958333333333, 0.75, 0.25
86627, 2.1166666666667, 0.725, 0.25
86628, 2.1166666666667, 0.7, 0.22916666666667
86629, 2.0958333333333, 0.7, 0.25
86630, 2.1166666666667, 0.675, 0.25
86631, 2.1166666666667, 0.65, 0.22916666666667
86632, 2.0958333333333, 0.65, 0.25
86633, 2.1166666666667, 0.625, 0.25
86634, 2.1166666666667, 0.6, 0.22916666666667
86635, 2.0958333333333, 0.6, 0.25
86636, 2.1166666666667, 0.575, 0.25
86637, 2.1166666666667, 0.55, 0.22916666666667
86638, 2.0958333333333, 0.55, 0.25
86639, 2.1166666666667, 0.525, 0.25
86640, 2.1166666666667, 0.5, 0.22916666666667
86641, 2.0958333333333, 0.5, 0.25
86642, 2.1166666666667, 0.475, 0.25
86643, 2.1166666666667, 0.45, 0.22916666666667
86644, 2.0958333333333, 0.45, 0.25
86645, 2.1166666666667, 0.425, 0.25
86646, 2.1166666666667, 0.4, 0.22916666666667
86647, 2.0958333333333, 0.4, 0.25
86648, 2.1166666666667, 0.375, 0.25
86649, 2.1166666666667, 0.35, 0.22916666666667
86650, 2.0958333333333, 0.35, 0.25
86651, 2.1166666666667, 0.325, 0.25
86652, 2.1166666666667, 0.3, 0.22916666666667
86653, 2.0958333333333, 0.3, 0.25
86654, 2.1166666666667, 0.275, 0.25
86655, 2.1166666666667, 0.25, 0.22916666666667
86656, 2.0958333333333, 0.25, 0.25
86657, 2.1166666666667, 0.225, 0.25
86658, 2.1166666666667, 0.2, 0.22916666666667
86659, 2.0958333333333, 0.2, 0.25
86660, 2.1166666666667, 0.175, 0.25
86661, 2.1583333333333, 1.325, 0.25
86662, 2.1583333333333, 1.3, 0.22916666666667
86663, 2.1375, 1.3, 0.25
86664, 2.1583333333333, 1.275, 0.25
86665, 2.1583333333333, 1.25, 0.22916666666667
86666, 2.1375, 1.25, 0.25
86667, 2.1583333333333, 1.225, 0.25
86668, 2.1583333333333, 1.2, 0.22916666666667
86669, 2.1375, 1.2, 0.25
86670, 2.1583333333333, 1.175, 0.25
86671, 2.1583333333333, 1.15, 0.22916666666667
86672, 2.1375, 1.15, 0.25
86673, 2.1583333333333, 1.125, 0.25
86674, 2.1583333333333, 1.1, 0.22916666666667
86675, 2.1375, 1.1, 0.25
86676, 2.1583333333333, 1.075, 0.25
86677, 2.1583333333333, 1.05, 0.22916666666667
86678, 2.1375, 1.05, 0.25
86679, 2.1583333333333, 1.025, 0.25
86680, 2.1583333333333, 1, 0.22916666666667
86681, 2.1375, 1, 0.25
86682, 2.1583333333333, 0.975, 0.25
86683, 2.1583333333333, 0.95, 0.22916666666667
86684, 2.1375, 0.95, 0.25
86685, 2.1583333333333, 0.925, 0.25
86686, 2.1583333333333, 0.9, 0.22916666666667
86687, 2.1375, 0.9, 0.25
86688, 2.1583333333333, 0.875, 0.25
86689, 2.1583333333333, 0.85, 0.22916666666667
86690, 2.1375, 0.85, 0.25
86691, 2.1583333333333, 0.825, 0.25
86692, 2.1583333333333, 0.8, 0.22916666666667
86693, 2.1375, 0.8, 0.25
86694, 2.1583333333333, 0.775, 0.25
86695, 2.1583333333333, 0.75, 0.22916666666667
86696, 2.1375, 0.75, 0.25
86697, 2.1583333333333, 0.725, 0.25
86698, 2.1583333333333, 0.7, 0.22916666666667
86699, 2.1375, 0.7, 0.25
86700, 2.1583333333333, 0.675, 0.25
86701, 2.1583333333333, 0.65, 0.22916666666667
86702, 2.1375, 0.65, 0.25
86703, 2.1583333333333, 0.625, 0.25
86704, 2.1583333333333, 0.6, 0.22916666666667
86705, 2.1375, 0.6, 0.25
86706, 2.1583333333333, 0.575, 0.25
86707, 2.1583333333333, 0.55, 0.22916666666667
86708, 2.1375, 0.55, 0.25
86709, 2.1583333333333, 0.525, 0.25
86710, 2.1583333333333, 0.5, 0.22916666666667
86711, 2.1375, 0.5, 0.25
86712, 2.1583333333333, 0.475, 0.25
86713, 2.1583333333333, 0.45, 0.22916666666667
86714, 2.1375, 0.45, 0.25
86715, 2.1583333333333, 0.425, 0.25
86716, 2.1583333333333, 0.4, 0.22916666666667
86717, 2.1375, 0.4, 0.25
86718, 2.1583333333333, 0.375, 0.25
86719, 2.1583333333333, 0.35, 0.22916666666667
86720, 2.1375, 0.35, 0.25
86721, 2.1583333333333, 0.325, 0.25
86722, 2.1583333333333, 0.3, 0.22916666666667
86723, 2.1375, 0.3, 0.25
86724, 2.1583333333333, 0.275, 0.25
86725, 2.1583333333333, 0.25, 0.22916666666667
86726, 2.1375, 0.25, 0.25
86727, 2.1583333333333, 0.225, 0.25
86728, 2.1583333333333, 0.2, 0.22916666666667
86729, 2.1375, 0.2, 0.25
86730, 2.1583333333333, 0.175, 0.25
86731, 2.1791666666667, 1.3, 0.25
86732, 2.1791666666667, 1.25, 0.25
86733, 2.1791666666667, 1.2, 0.25
86734, 2.1791666666667, 1.15, 0.25
86735, 2.1791666666667, 1.1, 0.25
86736, 2.1791666666667, 1.05, 0.25
86737, 2.1791666666667, 1, 0.25
86738, 2.1791666666667, 0.95, 0.25
86739, 2.1791666666667, 0.9, 0.25
86740, 2.1791666666667, 0.85, 0.25
86741, 2.1791666666667, 0.8, 0.25
86742, 2.1791666666667, 0.75, 0.25
86743, 2.1791666666667, 0.7, 0.25
86744, 2.1791666666667, 0.65, 0.25
86745, 2.1791666666667, 0.6, 0.25
86746, 2.1791666666667, 0.55, 0.25
86747, 2.1791666666667, 0.5, 0.25
86748, 2.1791666666667, 0.45, 0.25
86749, 2.1791666666667, 0.4, 0.25
86750, 2.1791666666667, 0.35, 0.25
86751, 2.1791666666667, 0.3, 0.25
86752, 2.1791666666667, 0.25, 0.25
86753, 2.1791666666667, 0.2, 0.25
86754, 1.2416666666667, 1.325, 0.29166666666667
86755, 1.2416666666667, 1.3, 0.27083333333333
86756, 1.2208333333333, 1.3, 0.29166666666667
86757, 1.2416666666667, 1.275, 0.29166666666667
86758, 1.2416666666667, 1.25, 0.27083333333333
86759, 1.2208333333333, 1.25, 0.29166666666667
86760, 1.2416666666667, 1.225, 0.29166666666667
86761, 1.2416666666667, 1.2, 0.27083333333333
86762, 1.2208333333333, 1.2, 0.29166666666667
86763, 1.2416666666667, 1.175, 0.29166666666667
86764, 1.2416666666667, 1.15, 0.27083333333333
86765, 1.2208333333333, 1.15, 0.29166666666667
86766, 1.2416666666667, 1.125, 0.29166666666667
86767, 1.2416666666667, 1.1, 0.27083333333333
86768, 1.2208333333333, 1.1, 0.29166666666667
86769, 1.2416666666667, 1.075, 0.29166666666667
86770, 1.2416666666667, 1.05, 0.27083333333333
86771, 1.2208333333333, 1.05, 0.29166666666667
86772, 1.2416666666667, 1.025, 0.29166666666667
86773, 1.2416666666667, 1, 0.27083333333333
86774, 1.2208333333333, 1, 0.29166666666667
86775, 1.2416666666667, 0.975, 0.29166666666667
86776, 1.2416666666667, 0.95, 0.27083333333333
86777, 1.2208333333333, 0.95, 0.29166666666667
86778, 1.2416666666667, 0.925, 0.29166666666667
86779, 1.2416666666667, 0.9, 0.27083333333333
86780, 1.2208333333333, 0.9, 0.29166666666667
86781, 1.2416666666667, 0.875, 0.29166666666667
86782, 1.2416666666667, 0.85, 0.27083333333333
86783, 1.2208333333333, 0.85, 0.29166666666667
86784, 1.2416666666667, 0.825, 0.29166666666667
86785, 1.2416666666667, 0.8, 0.27083333333333
86786, 1.2208333333333, 0.8, 0.29166666666667
86787, 1.2416666666667, 0.775, 0.29166666666667
86788, 1.2416666666667, 0.75, 0.27083333333333
86789, 1.2208333333333, 0.75, 0.29166666666667
86790, 1.2416666666667, 0.725, 0.29166666666667
86791, 1.2416666666667, 0.7, 0.27083333333333
86792, 1.2208333333333, 0.7, 0.29166666666667
86793, 1.2416666666667, 0.675, 0.29166666666667
86794, 1.2416666666667, 0.65, 0.27083333333333
86795, 1.2208333333333, 0.65, 0.29166666666667
86796, 1.2416666666667, 0.625, 0.29166666666667
86797, 1.2416666666667, 0.6, 0.27083333333333
86798, 1.2208333333333, 0.6, 0.29166666666667
86799, 1.2416666666667, 0.575, 0.29166666666667
86800, 1.2416666666667, 0.55, 0.27083333333333
86801, 1.2208333333333, 0.55, 0.29166666666667
86802, 1.2416666666667, 0.525, 0.29166666666667
86803, 1.2416666666667, 0.5, 0.27083333333333
86804, 1.2208333333333, 0.5, 0.29166666666667
86805, 1.2416666666667, 0.475, 0.29166666666667
86806, 1.2416666666667, 0.45, 0.27083333333333
86807, 1.2208333333333, 0.45, 0.29166666666667
86808, 1.2416666666667, 0.425, 0.29166666666667
86809, 1.2416666666667, 0.4, 0.27083333333333
86810, 1.2208333333333, 0.4, 0.29166666666667
86811, 1.2416666666667, 0.375, 0.29166666666667
86812, 1.2416666666667, 0.35, 0.27083333333333
86813, 1.2208333333333, 0.35, 0.29166666666667
86814, 1.2416666666667, 0.325, 0.29166666666667
86815, 1.2416666666667, 0.3, 0.27083333333333
86816, 1.2208333333333, 0.3, 0.29166666666667
86817, 1.2416666666667, 0.275, 0.29166666666667
86818, 1.2416666666667, 0.25, 0.27083333333333
86819, 1.2208333333333, 0.25, 0.29166666666667
86820, 1.2416666666667, 0.225, 0.29166666666667
86821, 1.2416666666667, 0.2, 0.27083333333333
86822, 1.2208333333333, 0.2, 0.29166666666667
86823, 1.2416666666667, 0.175, 0.29166666666667
86824, 1.2833333333333, 1.325, 0.29166666666667
86825, 1.2833333333333, 1.3, 0.27083333333333
86826, 1.2625, 1.3, 0.29166666666667
86827, 1.2833333333333, 1.275, 0.29166666666667
86828, 1.2833333333333, 1.25, 0.27083333333333
86829, 1.2625, 1.25, 0.29166666666667
86830, 1.2833333333333, 1.225, 0.29166666666667
86831, 1.2833333333333, 1.2, 0.27083333333333
86832, 1.2625, 1.2, 0.29166666666667
86833, 1.2833333333333, 1.175, 0.29166666666667
86834, 1.2833333333333, 1.15, 0.27083333333333
86835, 1.2625, 1.15, 0.29166666666667
86836, 1.2833333333333, 1.125, 0.29166666666667
86837, 1.2833333333333, 1.1, 0.27083333333333
86838, 1.2625, 1.1, 0.29166666666667
86839, 1.2833333333333, 1.075, 0.29166666666667
86840, 1.2833333333333, 1.05, 0.27083333333333
86841, 1.2625, 1.05, 0.29166666666667
86842, 1.2833333333333, 1.025, 0.29166666666667
86843, 1.2833333333333, 1, 0.27083333333333
86844, 1.2625, 1, 0.29166666666667
86845, 1.2833333333333, 0.975, 0.29166666666667
86846, 1.2833333333333, 0.95, 0.27083333333333
86847, 1.2625, 0.95, 0.29166666666667
86848, 1.2833333333333, 0.925, 0.29166666666667
86849, 1.2833333333333, 0.9, 0.27083333333333
86850, 1.2625, 0.9, 0.29166666666667
86851, 1.2833333333333, 0.875, 0.29166666666667
86852, 1.2833333333333, 0.85, 0.27083333333333
86853, 1.2625, 0.85, 0.29166666666667
86854, 1.2833333333333, 0.825, 0.29166666666667
86855, 1.2833333333333, 0.8, 0.27083333333333
86856, 1.2625, 0.8, 0.29166666666667
86857, 1.2833333333333, 0.775, 0.29166666666667
86858, 1.2833333333333, 0.75, 0.27083333333333
86859, 1.2625, 0.75, 0.29166666666667
86860, 1.2833333333333, 0.725, 0.29166666666667
86861, 1.2833333333333, 0.7, 0.27083333333333
86862, 1.2625, 0.7, 0.29166666666667
86863, 1.2833333333333, 0.675, 0.29166666666667
86864, 1.2833333333333, 0.65, 0.27083333333333
86865, 1.2625, 0.65, 0.29166666666667
86866, 1.2833333333333, 0.625, 0.29166666666667
86867, 1.2833333333333, 0.6, 0.27083333333333
86868, 1.2625, 0.6, 0.29166666666667
86869, 1.2833333333333, 0.575, 0.29166666666667
86870, 1.2833333333333, 0.55, 0.27083333333333
86871, 1.2625, 0.55, 0.29166666666667
86872, 1.2833333333333, 0.525, 0.29166666666667
86873, 1.2833333333333, 0.5, 0.27083333333333
86874, 1.2625, 0.5, 0.29166666666667
86875, 1.2833333333333, 0.475, 0.29166666666667
86876, 1.2833333333333, 0.45, 0.27083333333333
86877, 1.2625, 0.45, 0.29166666666667
86878, 1.2833333333333, 0.425, 0.29166666666667
86879, 1.2833333333333, 0.4, 0.27083333333333
86880, 1.2625, 0.4, 0.29166666666667
86881, 1.2833333333333, 0.375, 0.29166666666667
86882, 1.2833333333333, 0.35, 0.27083333333333
86883, 1.2625, 0.35, 0.29166666666667
86884, 1.2833333333333, 0.325, 0.29166666666667
86885, 1.2833333333333, 0.3, 0.27083333333333
86886, 1.2625, 0.3, 0.29166666666667
86887, 1.2833333333333, 0.275, 0.29166666666667
86888, 1.2833333333333, 0.25, 0.27083333333333
86889, 1.2625, 0.25, 0.29166666666667
86890, 1.2833333333333, 0.225, 0.29166666666667
86891, 1.2833333333333, 0.2, 0.27083333333333
86892, 1.2625, 0.2, 0.29166666666667
86893, 1.2833333333333, 0.175, 0.29166666666667
86894, 1.325, 1.325, 0.29166666666667
86895, 1.325, 1.3, 0.27083333333333
86896, 1.3041666666667, 1.3, 0.29166666666667
86897, 1.325, 1.275, 0.29166666666667
86898, 1.325, 1.25, 0.27083333333333
86899, 1.3041666666667, 1.25, 0.29166666666667
86900, 1.325, 1.225, 0.29166666666667
86901, 1.325, 1.2, 0.27083333333333
86902, 1.3041666666667, 1.2, 0.29166666666667
86903, 1.325, 1.175, 0.29166666666667
86904, 1.325, 1.15, 0.27083333333333
86905, 1.3041666666667, 1.15, 0.29166666666667
86906, 1.325, 1.125, 0.29166666666667
86907, 1.325, 1.1, 0.27083333333333
86908, 1.3041666666667, 1.1, 0.29166666666667
86909, 1.325, 1.075, 0.29166666666667
86910, 1.325, 1.05, 0.27083333333333
86911, 1.3041666666667, 1.05, 0.29166666666667
86912, 1.325, 1.025, 0.29166666666667
86913, 1.325, 1, 0.27083333333333
86914, 1.3041666666667, 1, 0.29166666666667
86915, 1.325, 0.975, 0.29166666666667
86916, 1.325, 0.95, 0.27083333333333
86917, 1.3041666666667, 0.95, 0.29166666666667
86918, 1.325, 0.925, 0.29166666666667
86919, 1.325, 0.9, 0.27083333333333
86920, 1.3041666666667, 0.9, 0.29166666666667
86921, 1.325, 0.875, 0.29166666666667
86922, 1.325, 0.85, 0.27083333333333
86923, 1.3041666666667, 0.85, 0.29166666666667
86924, 1.325, 0.825, 0.29166666666667
86925, 1.325, 0.8, 0.27083333333333
86926, 1.3041666666667, 0.8, 0.29166666666667
86927, 1.325, 0.775, 0.29166666666667
86928, 1.325, 0.75, 0.27083333333333
86929, 1.3041666666667, 0.75, 0.29166666666667
86930, 1.325, 0.725, 0.29166666666667
86931, 1.325, 0.7, 0.27083333333333
86932, 1.3041666666667, 0.7, 0.29166666666667
86933, 1.325, 0.675, 0.29166666666667
86934, 1.325, 0.65, 0.27083333333333
86935, 1.3041666666667, 0.65, 0.29166666666667
86936, 1.325, 0.625, 0.29166666666667
86937, 1.325, 0.6, 0.27083333333333
86938, 1.3041666666667, 0.6, 0.29166666666667
86939, 1.325, 0.575, 0.29166666666667
86940, 1.325, 0.55, 0.27083333333333
86941, 1.3041666666667, 0.55, 0.29166666666667
86942, 1.325, 0.525, 0.29166666666667
86943, 1.325, 0.5, 0.27083333333333
86944, 1.3041666666667, 0.5, 0.29166666666667
86945, 1.325, 0.475, 0.29166666666667
86946, 1.325, 0.45, 0.27083333333333
86947, 1.3041666666667, 0.45, 0.29166666666667
86948, 1.325, 0.425, 0.29166666666667
86949, 1.325, 0.4, 0.27083333333333
86950, 1.3041666666667, 0.4, 0.29166666666667
86951, 1.325, 0.375, 0.29166666666667
86952, 1.325, 0.35, 0.27083333333333
86953, 1.3041666666667, 0.35, 0.29166666666667
86954, 1.325, 0.325, 0.29166666666667
86955, 1.325, 0.3, 0.27083333333333
86956, 1.3041666666667, 0.3, 0.29166666666667
86957, 1.325, 0.275, 0.29166666666667
86958, 1.325, 0.25, 0.27083333333333
86959, 1.3041666666667, 0.25, 0.29166666666667
86960, 1.325, 0.225, 0.29166666666667
86961, 1.325, 0.2, 0.27083333333333
86962, 1.3041666666667, 0.2, 0.29166666666667
86963, 1.325, 0.175, 0.29166666666667
86964, 1.3666666666667, 1.325, 0.29166666666667
86965, 1.3666666666667, 1.3, 0.27083333333333
86966, 1.3458333333333, 1.3, 0.29166666666667
86967, 1.3666666666667, 1.275, 0.29166666666667
86968, 1.3666666666667, 1.25, 0.27083333333333
86969, 1.3458333333333, 1.25, 0.29166666666667
86970, 1.3666666666667, 1.225, 0.29166666666667
86971, 1.3666666666667, 1.2, 0.27083333333333
86972, 1.3458333333333, 1.2, 0.29166666666667
86973, 1.3666666666667, 1.175, 0.29166666666667
86974, 1.3666666666667, 1.15, 0.27083333333333
86975, 1.3458333333333, 1.15, 0.29166666666667
86976, 1.3666666666667, 1.125, 0.29166666666667
86977, 1.3666666666667, 1.1, 0.27083333333333
86978, 1.3458333333333, 1.1, 0.29166666666667
86979, 1.3666666666667, 1.075, 0.29166666666667
86980, 1.3666666666667, 1.05, 0.27083333333333
86981, 1.3458333333333, 1.05, 0.29166666666667
86982, 1.3666666666667, 1.025, 0.29166666666667
86983, 1.3666666666667, 1, 0.27083333333333
86984, 1.3458333333333, 1, 0.29166666666667
86985, 1.3666666666667, 0.975, 0.29166666666667
86986, 1.3666666666667, 0.95, 0.27083333333333
86987, 1.3458333333333, 0.95, 0.29166666666667
86988, 1.3666666666667, 0.925, 0.29166666666667
86989, 1.3666666666667, 0.9, 0.27083333333333
86990, 1.3458333333333, 0.9, 0.29166666666667
86991, 1.3666666666667, 0.875, 0.29166666666667
86992, 1.3666666666667, 0.85, 0.27083333333333
86993, 1.3458333333333, 0.85, 0.29166666666667
86994, 1.3666666666667, 0.825, 0.29166666666667
86995, 1.3666666666667, 0.8, 0.27083333333333
86996, 1.3458333333333, 0.8, 0.29166666666667
86997, 1.3666666666667, 0.775, 0.29166666666667
86998, 1.3666666666667, 0.75, 0.27083333333333
86999, 1.3458333333333, 0.75, 0.29166666666667
87000, 1.3666666666667, 0.725, 0.29166666666667
87001, 1.3666666666667, 0.7, 0.27083333333333
87002, 1.3458333333333, 0.7, 0.29166666666667
87003, 1.3666666666667, 0.675, 0.29166666666667
87004, 1.3666666666667, 0.65, 0.27083333333333
87005, 1.3458333333333, 0.65, 0.29166666666667
87006, 1.3666666666667, 0.625, 0.29166666666667
87007, 1.3666666666667, 0.6, 0.27083333333333
87008, 1.3458333333333, 0.6, 0.29166666666667
87009, 1.3666666666667, 0.575, 0.29166666666667
87010, 1.3666666666667, 0.55, 0.27083333333333
87011, 1.3458333333333, 0.55, 0.29166666666667
87012, 1.3666666666667, 0.525, 0.29166666666667
87013, 1.3666666666667, 0.5, 0.27083333333333
87014, 1.3458333333333, 0.5, 0.29166666666667
87015, 1.3666666666667, 0.475, 0.29166666666667
87016, 1.3666666666667, 0.45, 0.27083333333333
87017, 1.3458333333333, 0.45, 0.29166666666667
87018, 1.3666666666667, 0.425, 0.29166666666667
87019, 1.3666666666667, 0.4, 0.27083333333333
87020, 1.3458333333333, 0.4, 0.29166666666667
87021, 1.3666666666667, 0.375, 0.29166666666667
87022, 1.3666666666667, 0.35, 0.27083333333333
87023, 1.3458333333333, 0.35, 0.29166666666667
87024, 1.3666666666667, 0.325, 0.29166666666667
87025, 1.3666666666667, 0.3, 0.27083333333333
87026, 1.3458333333333, 0.3, 0.29166666666667
87027, 1.3666666666667, 0.275, 0.29166666666667
87028, 1.3666666666667, 0.25, 0.27083333333333
87029, 1.3458333333333, 0.25, 0.29166666666667
87030, 1.3666666666667, 0.225, 0.29166666666667
87031, 1.3666666666667, 0.2, 0.27083333333333
87032, 1.3458333333333, 0.2, 0.29166666666667
87033, 1.3666666666667, 0.175, 0.29166666666667
87034, 1.4083333333333, 1.325, 0.29166666666667
87035, 1.4083333333333, 1.3, 0.27083333333333
87036, 1.3875, 1.3, 0.29166666666667
87037, 1.4083333333333, 1.275, 0.29166666666667
87038, 1.4083333333333, 1.25, 0.27083333333333
87039, 1.3875, 1.25, 0.29166666666667
87040, 1.4083333333333, 1.225, 0.29166666666667
87041, 1.4083333333333, 1.2, 0.27083333333333
87042, 1.3875, 1.2, 0.29166666666667
87043, 1.4083333333333, 1.175, 0.29166666666667
87044, 1.4083333333333, 1.15, 0.27083333333333
87045, 1.3875, 1.15, 0.29166666666667
87046, 1.4083333333333, 1.125, 0.29166666666667
87047, 1.4083333333333, 1.1, 0.27083333333333
87048, 1.3875, 1.1, 0.29166666666667
87049, 1.4083333333333, 1.075, 0.29166666666667
87050, 1.4083333333333, 1.05, 0.27083333333333
87051, 1.3875, 1.05, 0.29166666666667
87052, 1.4083333333333, 1.025, 0.29166666666667
87053, 1.4083333333333, 1, 0.27083333333333
87054, 1.3875, 1, 0.29166666666667
87055, 1.4083333333333, 0.975, 0.29166666666667
87056, 1.4083333333333, 0.95, 0.27083333333333
87057, 1.3875, 0.95, 0.29166666666667
87058, 1.4083333333333, 0.925, 0.29166666666667
87059, 1.4083333333333, 0.9, 0.27083333333333
87060, 1.3875, 0.9, 0.29166666666667
87061, 1.4083333333333, 0.875, 0.29166666666667
87062, 1.4083333333333, 0.85, 0.27083333333333
87063, 1.3875, 0.85, 0.29166666666667
87064, 1.4083333333333, 0.825, 0.29166666666667
87065, 1.4083333333333, 0.8, 0.27083333333333
87066, 1.3875, 0.8, 0.29166666666667
87067, 1.4083333333333, 0.775, 0.29166666666667
87068, 1.4083333333333, 0.75, 0.27083333333333
87069, 1.3875, 0.75, 0.29166666666667
87070, 1.4083333333333, 0.725, 0.29166666666667
87071, 1.4083333333333, 0.7, 0.27083333333333
87072, 1.3875, 0.7, 0.29166666666667
87073, 1.4083333333333, 0.675, 0.29166666666667
87074, 1.4083333333333, 0.65, 0.27083333333333
87075, 1.3875, 0.65, 0.29166666666667
87076, 1.4083333333333, 0.625, 0.29166666666667
87077, 1.4083333333333, 0.6, 0.27083333333333
87078, 1.3875, 0.6, 0.29166666666667
87079, 1.4083333333333, 0.575, 0.29166666666667
87080, 1.4083333333333, 0.55, 0.27083333333333
87081, 1.3875, 0.55, 0.29166666666667
87082, 1.4083333333333, 0.525, 0.29166666666667
87083, 1.4083333333333, 0.5, 0.27083333333333
87084, 1.3875, 0.5, 0.29166666666667
87085, 1.4083333333333, 0.475, 0.29166666666667
87086, 1.4083333333333, 0.45, 0.27083333333333
87087, 1.3875, 0.45, 0.29166666666667
87088, 1.4083333333333, 0.425, 0.29166666666667
87089, 1.4083333333333, 0.4, 0.27083333333333
87090, 1.3875, 0.4, 0.29166666666667
87091, 1.4083333333333, 0.375, 0.29166666666667
87092, 1.4083333333333, 0.35, 0.27083333333333
87093, 1.3875, 0.35, 0.29166666666667
87094, 1.4083333333333, 0.325, 0.29166666666667
87095, 1.4083333333333, 0.3, 0.27083333333333
87096, 1.3875, 0.3, 0.29166666666667
87097, 1.4083333333333, 0.275, 0.29166666666667
87098, 1.4083333333333, 0.25, 0.27083333333333
87099, 1.3875, 0.25, 0.29166666666667
87100, 1.4083333333333, 0.225, 0.29166666666667
87101, 1.4083333333333, 0.2, 0.27083333333333
87102, 1.3875, 0.2, 0.29166666666667
87103, 1.4083333333333, 0.175, 0.29166666666667
87104, 1.45, 1.325, 0.29166666666667
87105, 1.45, 1.3, 0.27083333333333
87106, 1.4291666666667, 1.3, 0.29166666666667
87107, 1.45, 1.275, 0.29166666666667
87108, 1.45, 1.25, 0.27083333333333
87109, 1.4291666666667, 1.25, 0.29166666666667
87110, 1.45, 1.225, 0.29166666666667
87111, 1.45, 1.2, 0.27083333333333
87112, 1.4291666666667, 1.2, 0.29166666666667
87113, 1.45, 1.175, 0.29166666666667
87114, 1.45, 1.15, 0.27083333333333
87115, 1.4291666666667, 1.15, 0.29166666666667
87116, 1.45, 1.125, 0.29166666666667
87117, 1.45, 1.1, 0.27083333333333
87118, 1.4291666666667, 1.1, 0.29166666666667
87119, 1.45, 1.075, 0.29166666666667
87120, 1.45, 1.05, 0.27083333333333
87121, 1.4291666666667, 1.05, 0.29166666666667
87122, 1.45, 1.025, 0.29166666666667
87123, 1.45, 1, 0.27083333333333
87124, 1.4291666666667, 1, 0.29166666666667
87125, 1.45, 0.975, 0.29166666666667
87126, 1.45, 0.95, 0.27083333333333
87127, 1.4291666666667, 0.95, 0.29166666666667
87128, 1.45, 0.925, 0.29166666666667
87129, 1.45, 0.9, 0.27083333333333
87130, 1.4291666666667, 0.9, 0.29166666666667
87131, 1.45, 0.875, 0.29166666666667
87132, 1.45, 0.85, 0.27083333333333
87133, 1.4291666666667, 0.85, 0.29166666666667
87134, 1.45, 0.825, 0.29166666666667
87135, 1.45, 0.8, 0.27083333333333
87136, 1.4291666666667, 0.8, 0.29166666666667
87137, 1.45, 0.775, 0.29166666666667
87138, 1.45, 0.75, 0.27083333333333
87139, 1.4291666666667, 0.75, 0.29166666666667
87140, 1.45, 0.725, 0.29166666666667
87141, 1.45, 0.7, 0.27083333333333
87142, 1.4291666666667, 0.7, 0.29166666666667
87143, 1.45, 0.675, 0.29166666666667
87144, 1.45, 0.65, 0.27083333333333
87145, 1.4291666666667, 0.65, 0.29166666666667
87146, 1.45, 0.625, 0.29166666666667
87147, 1.45, 0.6, 0.27083333333333
87148, 1.4291666666667, 0.6, 0.29166666666667
87149, 1.45, 0.575, 0.29166666666667
87150, 1.45, 0.55, 0.27083333333333
87151, 1.4291666666667, 0.55, 0.29166666666667
87152, 1.45, 0.525, 0.29166666666667
87153, 1.45, 0.5, 0.27083333333333
87154, 1.4291666666667, 0.5, 0.29166666666667
87155, 1.45, 0.475, 0.29166666666667
87156, 1.45, 0.45, 0.27083333333333
87157, 1.4291666666667, 0.45, 0.29166666666667
87158, 1.45, 0.425, 0.29166666666667
87159, 1.45, 0.4, 0.27083333333333
87160, 1.4291666666667, 0.4, 0.29166666666667
87161, 1.45, 0.375, 0.29166666666667
87162, 1.45, 0.35, 0.27083333333333
87163, 1.4291666666667, 0.35, 0.29166666666667
87164, 1.45, 0.325, 0.29166666666667
87165, 1.45, 0.3, 0.27083333333333
87166, 1.4291666666667, 0.3, 0.29166666666667
87167, 1.45, 0.275, 0.29166666666667
87168, 1.45, 0.25, 0.27083333333333
87169, 1.4291666666667, 0.25, 0.29166666666667
87170, 1.45, 0.225, 0.29166666666667
87171, 1.45, 0.2, 0.27083333333333
87172, 1.4291666666667, 0.2, 0.29166666666667
87173, 1.45, 0.175, 0.29166666666667
87174, 1.4916666666667, 1.325, 0.29166666666667
87175, 1.4916666666667, 1.3, 0.27083333333333
87176, 1.4708333333333, 1.3, 0.29166666666667
87177, 1.4916666666667, 1.275, 0.29166666666667
87178, 1.4916666666667, 1.25, 0.27083333333333
87179, 1.4708333333333, 1.25, 0.29166666666667
87180, 1.4916666666667, 1.225, 0.29166666666667
87181, 1.4916666666667, 1.2, 0.27083333333333
87182, 1.4708333333333, 1.2, 0.29166666666667
87183, 1.4916666666667, 1.175, 0.29166666666667
87184, 1.4916666666667, 1.15, 0.27083333333333
87185, 1.4708333333333, 1.15, 0.29166666666667
87186, 1.4916666666667, 1.125, 0.29166666666667
87187, 1.4916666666667, 1.1, 0.27083333333333
87188, 1.4708333333333, 1.1, 0.29166666666667
87189, 1.4916666666667, 1.075, 0.29166666666667
87190, 1.4916666666667, 1.05, 0.27083333333333
87191, 1.4708333333333, 1.05, 0.29166666666667
87192, 1.4916666666667, 1.025, 0.29166666666667
87193, 1.4916666666667, 1, 0.27083333333333
87194, 1.4708333333333, 1, 0.29166666666667
87195, 1.4916666666667, 0.975, 0.29166666666667
87196, 1.4916666666667, 0.95, 0.27083333333333
87197, 1.4708333333333, 0.95, 0.29166666666667
87198, 1.4916666666667, 0.925, 0.29166666666667
87199, 1.4916666666667, 0.9, 0.27083333333333
87200, 1.4708333333333, 0.9, 0.29166666666667
87201, 1.4916666666667, 0.875, 0.29166666666667
87202, 1.4916666666667, 0.85, 0.27083333333333
87203, 1.4708333333333, 0.85, 0.29166666666667
87204, 1.4916666666667, 0.825, 0.29166666666667
87205, 1.4916666666667, 0.8, 0.27083333333333
87206, 1.4708333333333, 0.8, 0.29166666666667
87207, 1.4916666666667, 0.775, 0.29166666666667
87208, 1.4916666666667, 0.75, 0.27083333333333
87209, 1.4708333333333, 0.75, 0.29166666666667
87210, 1.4916666666667, 0.725, 0.29166666666667
87211, 1.4916666666667, 0.7, 0.27083333333333
87212, 1.4708333333333, 0.7, 0.29166666666667
87213, 1.4916666666667, 0.675, 0.29166666666667
87214, 1.4916666666667, 0.65, 0.27083333333333
87215, 1.4708333333333, 0.65, 0.29166666666667
87216, 1.4916666666667, 0.625, 0.29166666666667
87217, 1.4916666666667, 0.6, 0.27083333333333
87218, 1.4708333333333, 0.6, 0.29166666666667
87219, 1.4916666666667, 0.575, 0.29166666666667
87220, 1.4916666666667, 0.55, 0.27083333333333
87221, 1.4708333333333, 0.55, 0.29166666666667
87222, 1.4916666666667, 0.525, 0.29166666666667
87223, 1.4916666666667, 0.5, 0.27083333333333
87224, 1.4708333333333, 0.5, 0.29166666666667
87225, 1.4916666666667, 0.475, 0.29166666666667
87226, 1.4916666666667, 0.45, 0.27083333333333
87227, 1.4708333333333, 0.45, 0.29166666666667
87228, 1.4916666666667, 0.425, 0.29166666666667
87229, 1.4916666666667, 0.4, 0.27083333333333
87230, 1.4708333333333, 0.4, 0.29166666666667
87231, 1.4916666666667, 0.375, 0.29166666666667
87232, 1.4916666666667, 0.35, 0.27083333333333
87233, 1.4708333333333, 0.35, 0.29166666666667
87234, 1.4916666666667, 0.325, 0.29166666666667
87235, 1.4916666666667, 0.3, 0.27083333333333
87236, 1.4708333333333, 0.3, 0.29166666666667
87237, 1.4916666666667, 0.275, 0.29166666666667
87238, 1.4916666666667, 0.25, 0.27083333333333
87239, 1.4708333333333, 0.25, 0.29166666666667
87240, 1.4916666666667, 0.225, 0.29166666666667
87241, 1.4916666666667, 0.2, 0.27083333333333
87242, 1.4708333333333, 0.2, 0.29166666666667
87243, 1.4916666666667, 0.175, 0.29166666666667
87244, 1.5333333333333, 1.325, 0.29166666666667
87245, 1.5333333333333, 1.3, 0.27083333333333
87246, 1.5125, 1.3, 0.29166666666667
87247, 1.5333333333333, 1.275, 0.29166666666667
87248, 1.5333333333333, 1.25, 0.27083333333333
87249, 1.5125, 1.25, 0.29166666666667
87250, 1.5333333333333, 1.225, 0.29166666666667
87251, 1.5333333333333, 1.2, 0.27083333333333
87252, 1.5125, 1.2, 0.29166666666667
87253, 1.5333333333333, 1.175, 0.29166666666667
87254, 1.5333333333333, 1.15, 0.27083333333333
87255, 1.5125, 1.15, 0.29166666666667
87256, 1.5333333333333, 1.125, 0.29166666666667
87257, 1.5333333333333, 1.1, 0.27083333333333
87258, 1.5125, 1.1, 0.29166666666667
87259, 1.5333333333333, 1.075, 0.29166666666667
87260, 1.5333333333333, 1.05, 0.27083333333333
87261, 1.5125, 1.05, 0.29166666666667
87262, 1.5333333333333, 1.025, 0.29166666666667
87263, 1.5333333333333, 1, 0.27083333333333
87264, 1.5125, 1, 0.29166666666667
87265, 1.5333333333333, 0.975, 0.29166666666667
87266, 1.5333333333333, 0.95, 0.27083333333333
87267, 1.5125, 0.95, 0.29166666666667
87268, 1.5333333333333, 0.925, 0.29166666666667
87269, 1.5333333333333, 0.9, 0.27083333333333
87270, 1.5125, 0.9, 0.29166666666667
87271, 1.5333333333333, 0.875, 0.29166666666667
87272, 1.5333333333333, 0.85, 0.27083333333333
87273, 1.5125, 0.85, 0.29166666666667
87274, 1.5333333333333, 0.825, 0.29166666666667
87275, 1.5333333333333, 0.8, 0.27083333333333
87276, 1.5125, 0.8, 0.29166666666667
87277, 1.5333333333333, 0.775, 0.29166666666667
87278, 1.5333333333333, 0.75, 0.27083333333333
87279, 1.5125, 0.75, 0.29166666666667
87280, 1.5333333333333, 0.725, 0.29166666666667
87281, 1.5333333333333, 0.7, 0.27083333333333
87282, 1.5125, 0.7, 0.29166666666667
87283, 1.5333333333333, 0.675, 0.29166666666667
87284, 1.5333333333333, 0.65, 0.27083333333333
87285, 1.5125, 0.65, 0.29166666666667
87286, 1.5333333333333, 0.625, 0.29166666666667
87287, 1.5333333333333, 0.6, 0.27083333333333
87288, 1.5125, 0.6, 0.29166666666667
87289, 1.5333333333333, 0.575, 0.29166666666667
87290, 1.5333333333333, 0.55, 0.27083333333333
87291, 1.5125, 0.55, 0.29166666666667
87292, 1.5333333333333, 0.525, 0.29166666666667
87293, 1.5333333333333, 0.5, 0.27083333333333
87294, 1.5125, 0.5, 0.29166666666667
87295, 1.5333333333333, 0.475, 0.29166666666667
87296, 1.5333333333333, 0.45, 0.27083333333333
87297, 1.5125, 0.45, 0.29166666666667
87298, 1.5333333333333, 0.425, 0.29166666666667
87299, 1.5333333333333, 0.4, 0.27083333333333
87300, 1.5125, 0.4, 0.29166666666667
87301, 1.5333333333333, 0.375, 0.29166666666667
87302, 1.5333333333333, 0.35, 0.27083333333333
87303, 1.5125, 0.35, 0.29166666666667
87304, 1.5333333333333, 0.325, 0.29166666666667
87305, 1.5333333333333, 0.3, 0.27083333333333
87306, 1.5125, 0.3, 0.29166666666667
87307, 1.5333333333333, 0.275, 0.29166666666667
87308, 1.5333333333333, 0.25, 0.27083333333333
87309, 1.5125, 0.25, 0.29166666666667
87310, 1.5333333333333, 0.225, 0.29166666666667
87311, 1.5333333333333, 0.2, 0.27083333333333
87312, 1.5125, 0.2, 0.29166666666667
87313, 1.5333333333333, 0.175, 0.29166666666667
87314, 1.575, 1.325, 0.29166666666667
87315, 1.575, 1.3, 0.27083333333333
87316, 1.5541666666667, 1.3, 0.29166666666667
87317, 1.575, 1.275, 0.29166666666667
87318, 1.575, 1.25, 0.27083333333333
87319, 1.5541666666667, 1.25, 0.29166666666667
87320, 1.575, 1.225, 0.29166666666667
87321, 1.575, 1.2, 0.27083333333333
87322, 1.5541666666667, 1.2, 0.29166666666667
87323, 1.575, 1.175, 0.29166666666667
87324, 1.575, 1.15, 0.27083333333333
87325, 1.5541666666667, 1.15, 0.29166666666667
87326, 1.575, 1.125, 0.29166666666667
87327, 1.575, 1.1, 0.27083333333333
87328, 1.5541666666667, 1.1, 0.29166666666667
87329, 1.575, 1.075, 0.29166666666667
87330, 1.575, 1.05, 0.27083333333333
87331, 1.5541666666667, 1.05, 0.29166666666667
87332, 1.575, 1.025, 0.29166666666667
87333, 1.575, 1, 0.27083333333333
87334, 1.5541666666667, 1, 0.29166666666667
87335, 1.575, 0.975, 0.29166666666667
87336, 1.575, 0.95, 0.27083333333333
87337, 1.5541666666667, 0.95, 0.29166666666667
87338, 1.575, 0.925, 0.29166666666667
87339, 1.575, 0.9, 0.27083333333333
87340, 1.5541666666667, 0.9, 0.29166666666667
87341, 1.575, 0.875, 0.29166666666667
87342, 1.575, 0.85, 0.27083333333333
87343, 1.5541666666667, 0.85, 0.29166666666667
87344, 1.575, 0.825, 0.29166666666667
87345, 1.575, 0.8, 0.27083333333333
87346, 1.5541666666667, 0.8, 0.29166666666667
87347, 1.575, 0.775, 0.29166666666667
87348, 1.575, 0.75, 0.27083333333333
87349, 1.5541666666667, 0.75, 0.29166666666667
87350, 1.575, 0.725, 0.29166666666667
87351, 1.575, 0.7, 0.27083333333333
87352, 1.5541666666667, 0.7, 0.29166666666667
87353, 1.575, 0.675, 0.29166666666667
87354, 1.575, 0.65, 0.27083333333333
87355, 1.5541666666667, 0.65, 0.29166666666667
87356, 1.575, 0.625, 0.29166666666667
87357, 1.575, 0.6, 0.27083333333333
87358, 1.5541666666667, 0.6, 0.29166666666667
87359, 1.575, 0.575, 0.29166666666667
87360, 1.575, 0.55, 0.27083333333333
87361, 1.5541666666667, 0.55, 0.29166666666667
87362, 1.575, 0.525, 0.29166666666667
87363, 1.575, 0.5, 0.27083333333333
87364, 1.5541666666667, 0.5, 0.29166666666667
87365, 1.575, 0.475, 0.29166666666667
87366, 1.575, 0.45, 0.27083333333333
87367, 1.5541666666667, 0.45, 0.29166666666667
87368, 1.575, 0.425, 0.29166666666667
87369, 1.575, 0.4, 0.27083333333333
87370, 1.5541666666667, 0.4, 0.29166666666667
87371, 1.575, 0.375, 0.29166666666667
87372, 1.575, 0.35, 0.27083333333333
87373, 1.5541666666667, 0.35, 0.29166666666667
87374, 1.575, 0.325, 0.29166666666667
87375, 1.575, 0.3, 0.27083333333333
87376, 1.5541666666667, 0.3, 0.29166666666667
87377, 1.575, 0.275, 0.29166666666667
87378, 1.575, 0.25, 0.27083333333333
87379, 1.5541666666667, 0.25, 0.29166666666667
87380, 1.575, 0.225, 0.29166666666667
87381, 1.575, 0.2, 0.27083333333333
87382, 1.5541666666667, 0.2, 0.29166666666667
87383, 1.575, 0.175, 0.29166666666667
87384, 1.6166666666667, 1.325, 0.29166666666667
87385, 1.6166666666667, 1.3, 0.27083333333333
87386, 1.5958333333333, 1.3, 0.29166666666667
87387, 1.6166666666667, 1.275, 0.29166666666667
87388, 1.6166666666667, 1.25, 0.27083333333333
87389, 1.5958333333333, 1.25, 0.29166666666667
87390, 1.6166666666667, 1.225, 0.29166666666667
87391, 1.6166666666667, 1.2, 0.27083333333333
87392, 1.5958333333333, 1.2, 0.29166666666667
87393, 1.6166666666667, 1.175, 0.29166666666667
87394, 1.6166666666667, 1.15, 0.27083333333333
87395, 1.5958333333333, 1.15, 0.29166666666667
87396, 1.6166666666667, 1.125, 0.29166666666667
87397, 1.6166666666667, 1.1, 0.27083333333333
87398, 1.5958333333333, 1.1, 0.29166666666667
87399, 1.6166666666667, 1.075, 0.29166666666667
87400, 1.6166666666667, 1.05, 0.27083333333333
87401, 1.5958333333333, 1.05, 0.29166666666667
87402, 1.6166666666667, 1.025, 0.29166666666667
87403, 1.6166666666667, 1, 0.27083333333333
87404, 1.5958333333333, 1, 0.29166666666667
87405, 1.6166666666667, 0.975, 0.29166666666667
87406, 1.6166666666667, 0.95, 0.27083333333333
87407, 1.5958333333333, 0.95, 0.29166666666667
87408, 1.6166666666667, 0.925, 0.29166666666667
87409, 1.6166666666667, 0.9, 0.27083333333333
87410, 1.5958333333333, 0.9, 0.29166666666667
87411, 1.6166666666667, 0.875, 0.29166666666667
87412, 1.6166666666667, 0.85, 0.27083333333333
87413, 1.5958333333333, 0.85, 0.29166666666667
87414, 1.6166666666667, 0.825, 0.29166666666667
87415, 1.6166666666667, 0.8, 0.27083333333333
87416, 1.5958333333333, 0.8, 0.29166666666667
87417, 1.6166666666667, 0.775, 0.29166666666667
87418, 1.6166666666667, 0.75, 0.27083333333333
87419, 1.5958333333333, 0.75, 0.29166666666667
87420, 1.6166666666667, 0.725, 0.29166666666667
87421, 1.6166666666667, 0.7, 0.27083333333333
87422, 1.5958333333333, 0.7, 0.29166666666667
87423, 1.6166666666667, 0.675, 0.29166666666667
87424, 1.6166666666667, 0.65, 0.27083333333333
87425, 1.5958333333333, 0.65, 0.29166666666667
87426, 1.6166666666667, 0.625, 0.29166666666667
87427, 1.6166666666667, 0.6, 0.27083333333333
87428, 1.5958333333333, 0.6, 0.29166666666667
87429, 1.6166666666667, 0.575, 0.29166666666667
87430, 1.6166666666667, 0.55, 0.27083333333333
87431, 1.5958333333333, 0.55, 0.29166666666667
87432, 1.6166666666667, 0.525, 0.29166666666667
87433, 1.6166666666667, 0.5, 0.27083333333333
87434, 1.5958333333333, 0.5, 0.29166666666667
87435, 1.6166666666667, 0.475, 0.29166666666667
87436, 1.6166666666667, 0.45, 0.27083333333333
87437, 1.5958333333333, 0.45, 0.29166666666667
87438, 1.6166666666667, 0.425, 0.29166666666667
87439, 1.6166666666667, 0.4, 0.27083333333333
87440, 1.5958333333333, 0.4, 0.29166666666667
87441, 1.6166666666667, 0.375, 0.29166666666667
87442, 1.6166666666667, 0.35, 0.27083333333333
87443, 1.5958333333333, 0.35, 0.29166666666667
87444, 1.6166666666667, 0.325, 0.29166666666667
87445, 1.6166666666667, 0.3, 0.27083333333333
87446, 1.5958333333333, 0.3, 0.29166666666667
87447, 1.6166666666667, 0.275, 0.29166666666667
87448, 1.6166666666667, 0.25, 0.27083333333333
87449, 1.5958333333333, 0.25, 0.29166666666667
87450, 1.6166666666667, 0.225, 0.29166666666667
87451, 1.6166666666667, 0.2, 0.27083333333333
87452, 1.5958333333333, 0.2, 0.29166666666667
87453, 1.6166666666667, 0.175, 0.29166666666667
87454, 1.6583333333333, 1.325, 0.29166666666667
87455, 1.6583333333333, 1.3, 0.27083333333333
87456, 1.6375, 1.3, 0.29166666666667
87457, 1.6583333333333, 1.275, 0.29166666666667
87458, 1.6583333333333, 1.25, 0.27083333333333
87459, 1.6375, 1.25, 0.29166666666667
87460, 1.6583333333333, 1.225, 0.29166666666667
87461, 1.6583333333333, 1.2, 0.27083333333333
87462, 1.6375, 1.2, 0.29166666666667
87463, 1.6583333333333, 1.175, 0.29166666666667
87464, 1.6583333333333, 1.15, 0.27083333333333
87465, 1.6375, 1.15, 0.29166666666667
87466, 1.6583333333333, 1.125, 0.29166666666667
87467, 1.6583333333333, 1.1, 0.27083333333333
87468, 1.6375, 1.1, 0.29166666666667
87469, 1.6583333333333, 1.075, 0.29166666666667
87470, 1.6583333333333, 1.05, 0.27083333333333
87471, 1.6375, 1.05, 0.29166666666667
87472, 1.6583333333333, 1.025, 0.29166666666667
87473, 1.6583333333333, 1, 0.27083333333333
87474, 1.6375, 1, 0.29166666666667
