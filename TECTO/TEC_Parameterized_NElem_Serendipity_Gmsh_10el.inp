29380, 0.9375, 0.8, -0.1
29381, 0.95833333333333, 0.775, -0.1
29382, 0.9375, 0.85, -0.1
29383, 0.95833333333333, 0.825, -0.1
29384, 0.9375, 0.9, -0.1
29385, 0.95833333333333, 0.875, -0.1
29386, 0.9375, 0.95, -0.1
29387, 0.95833333333333, 0.925, -0.1
29388, 0.9375, 1, -0.1
29389, 0.95833333333333, 0.975, -0.1
29390, 0.9375, 1.05, -0.1
29391, 0.95833333333333, 1.025, -0.1
29392, 0.9375, 1.1, -0.1
29393, 0.95833333333333, 1.075, -0.1
29394, 0.9375, 1.15, -0.1
29395, 0.95833333333333, 1.125, -0.1
29396, 0.9375, 1.2, -0.1
29397, 0.95833333333333, 1.175, -0.1
29398, 0.9375, 1.25, -0.1
29399, 0.95833333333333, 1.225, -0.1
29400, 0.9375, 1.3, -0.1
29401, 0.95833333333333, 1.275, -0.1
29402, 0.95833333333333, 1.325, -0.1
29403, 0.97916666666667, 0.2, -0.1
29404, 0.97916666666667, 0.25, -0.1
29405, 0.97916666666667, 0.3, -0.1
29406, 0.97916666666667, 0.35, -0.1
29407, 0.97916666666667, 0.4, -0.1
29408, 0.97916666666667, 0.45, -0.1
29409, 0.97916666666667, 0.5, -0.1
29410, 0.97916666666667, 0.55, -0.1
29411, 0.97916666666667, 0.6, -0.1
29412, 0.97916666666667, 0.65, -0.1
29413, 0.97916666666667, 0.7, -0.1
29414, 0.97916666666667, 0.75, -0.1
29415, 0.97916666666667, 0.8, -0.1
29416, 0.97916666666667, 0.85, -0.1
29417, 0.97916666666667, 0.9, -0.1
29418, 0.97916666666667, 0.95, -0.1
29419, 0.97916666666667, 1, -0.1
29420, 0.97916666666667, 1.05, -0.1
29421, 0.97916666666667, 1.1, -0.1
29422, 0.97916666666667, 1.15, -0.1
29423, 0.97916666666667, 1.2, -0.1
29424, 0.97916666666667, 1.25, -0.1
29425, 0.97916666666667, 1.3, -0.1
29426, 1.2, 1.3, -0.05
29427, 1.2, 1.25, -0.05
29428, 1.2, 1.2, -0.05
29429, 1.2, 1.15, -0.05
29430, 1.2, 1.1, -0.05
29431, 1.2, 1.05, -0.05
29432, 1.2, 1, -0.05
29433, 1.2, 0.95, -0.05
29434, 1.2, 0.9, -0.05
29435, 1.2, 0.85, -0.05
29436, 1.2, 0.8, -0.05
29437, 1.2, 0.75, -0.05
29438, 1.2, 0.7, -0.05
29439, 1.2, 0.65, -0.05
29440, 1.2, 0.6, -0.05
29441, 1.2, 0.55, -0.05
29442, 1.2, 0.5, -0.05
29443, 1.2, 0.45, -0.05
29444, 1.2, 0.4, -0.05
29445, 1.2, 0.35, -0.05
29446, 1.2, 0.3, -0.05
29447, 1.2, 0.25, -0.05
29448, 1.2, 0.2, -0.05
29449, 2.2, 1.3, -0.05
29450, 2.2, 1.25, -0.05
29451, 2.2, 1.2, -0.05
29452, 2.2, 1.15, -0.05
29453, 2.2, 1.1, -0.05
29454, 2.2, 1.05, -0.05
29455, 2.2, 1, -0.05
29456, 2.2, 0.95, -0.05
29457, 2.2, 0.9, -0.05
29458, 2.2, 0.85, -0.05
29459, 2.2, 0.8, -0.05
29460, 2.2, 0.75, -0.05
29461, 2.2, 0.7, -0.05
29462, 2.2, 0.65, -0.05
29463, 2.2, 0.6, -0.05
29464, 2.2, 0.55, -0.05
29465, 2.2, 0.5, -0.05
29466, 2.2, 0.45, -0.05
29467, 2.2, 0.4, -0.05
29468, 2.2, 0.35, -0.05
29469, 2.2, 0.3, -0.05
29470, 2.2, 0.25, -0.05
29471, 2.2, 0.2, -0.05
29472, 1.2416666666667, 1.35, -0.05
29473, 1.2833333333333, 1.35, -0.05
29474, 1.325, 1.35, -0.05
29475, 1.3666666666667, 1.35, -0.05
29476, 1.4083333333333, 1.35, -0.05
29477, 1.45, 1.35, -0.05
29478, 1.4916666666667, 1.35, -0.05
29479, 1.5333333333333, 1.35, -0.05
29480, 1.575, 1.35, -0.05
29481, 1.6166666666667, 1.35, -0.05
29482, 1.6583333333333, 1.35, -0.05
29483, 1.7, 1.35, -0.05
29484, 1.7416666666667, 1.35, -0.05
29485, 1.7833333333333, 1.35, -0.05
29486, 1.825, 1.35, -0.05
29487, 1.8666666666667, 1.35, -0.05
29488, 1.9083333333333, 1.35, -0.05
29489, 1.95, 1.35, -0.05
29490, 1.9916666666667, 1.35, -0.05
29491, 2.0333333333333, 1.35, -0.05
29492, 2.075, 1.35, -0.05
29493, 2.1166666666667, 1.35, -0.05
29494, 2.1583333333333, 1.35, -0.05
29495, 1.2416666666667, 0.15, -0.05
29496, 1.2833333333333, 0.15, -0.05
29497, 1.325, 0.15, -0.05
29498, 1.3666666666667, 0.15, -0.05
29499, 1.4083333333333, 0.15, -0.05
29500, 1.45, 0.15, -0.05
29501, 1.4916666666667, 0.15, -0.05
29502, 1.5333333333333, 0.15, -0.05
29503, 1.575, 0.15, -0.05
29504, 1.6166666666667, 0.15, -0.05
29505, 1.6583333333333, 0.15, -0.05
29506, 1.7, 0.15, -0.05
29507, 1.7416666666667, 0.15, -0.05
29508, 1.7833333333333, 0.15, -0.05
29509, 1.825, 0.15, -0.05
29510, 1.8666666666667, 0.15, -0.05
29511, 1.9083333333333, 0.15, -0.05
29512, 1.95, 0.15, -0.05
29513, 1.9916666666667, 0.15, -0.05
29514, 2.0333333333333, 0.15, -0.05
29515, 2.075, 0.15, -0.05
29516, 2.1166666666667, 0.15, -0.05
29517, 2.1583333333333, 0.15, -0.05
29518, 1.2416666666667, 1.3, -0.1
29519, 1.2416666666667, 1.25, -0.1
29520, 1.2416666666667, 1.2, -0.1
29521, 1.2416666666667, 1.15, -0.1
29522, 1.2416666666667, 1.1, -0.1
29523, 1.2416666666667, 1.05, -0.1
29524, 1.2416666666667, 1, -0.1
29525, 1.2416666666667, 0.95, -0.1
29526, 1.2416666666667, 0.9, -0.1
29527, 1.2416666666667, 0.85, -0.1
29528, 1.2416666666667, 0.8, -0.1
29529, 1.2416666666667, 0.75, -0.1
29530, 1.2416666666667, 0.7, -0.1
29531, 1.2416666666667, 0.65, -0.1
29532, 1.2416666666667, 0.6, -0.1
29533, 1.2416666666667, 0.55, -0.1
29534, 1.2416666666667, 0.5, -0.1
29535, 1.2416666666667, 0.45, -0.1
29536, 1.2416666666667, 0.4, -0.1
29537, 1.2416666666667, 0.35, -0.1
29538, 1.2416666666667, 0.3, -0.1
29539, 1.2416666666667, 0.25, -0.1
29540, 1.2416666666667, 0.2, -0.1
29541, 1.2833333333333, 1.3, -0.1
29542, 1.2833333333333, 1.25, -0.1
29543, 1.2833333333333, 1.2, -0.1
29544, 1.2833333333333, 1.15, -0.1
29545, 1.2833333333333, 1.1, -0.1
29546, 1.2833333333333, 1.05, -0.1
29547, 1.2833333333333, 1, -0.1
29548, 1.2833333333333, 0.95, -0.1
29549, 1.2833333333333, 0.9, -0.1
29550, 1.2833333333333, 0.85, -0.1
29551, 1.2833333333333, 0.8, -0.1
29552, 1.2833333333333, 0.75, -0.1
29553, 1.2833333333333, 0.7, -0.1
29554, 1.2833333333333, 0.65, -0.1
29555, 1.2833333333333, 0.6, -0.1
29556, 1.2833333333333, 0.55, -0.1
29557, 1.2833333333333, 0.5, -0.1
29558, 1.2833333333333, 0.45, -0.1
29559, 1.2833333333333, 0.4, -0.1
29560, 1.2833333333333, 0.35, -0.1
29561, 1.2833333333333, 0.3, -0.1
29562, 1.2833333333333, 0.25, -0.1
29563, 1.2833333333333, 0.2, -0.1
29564, 1.325, 1.3, -0.1
29565, 1.325, 1.25, -0.1
29566, 1.325, 1.2, -0.1
29567, 1.325, 1.15, -0.1
29568, 1.325, 1.1, -0.1
29569, 1.325, 1.05, -0.1
29570, 1.325, 1, -0.1
29571, 1.325, 0.95, -0.1
29572, 1.325, 0.9, -0.1
29573, 1.325, 0.85, -0.1
29574, 1.325, 0.8, -0.1
29575, 1.325, 0.75, -0.1
29576, 1.325, 0.7, -0.1
29577, 1.325, 0.65, -0.1
29578, 1.325, 0.6, -0.1
29579, 1.325, 0.55, -0.1
29580, 1.325, 0.5, -0.1
29581, 1.325, 0.45, -0.1
29582, 1.325, 0.4, -0.1
29583, 1.325, 0.35, -0.1
29584, 1.325, 0.3, -0.1
29585, 1.325, 0.25, -0.1
29586, 1.325, 0.2, -0.1
29587, 1.3666666666667, 1.3, -0.1
29588, 1.3666666666667, 1.25, -0.1
29589, 1.3666666666667, 1.2, -0.1
29590, 1.3666666666667, 1.15, -0.1
29591, 1.3666666666667, 1.1, -0.1
29592, 1.3666666666667, 1.05, -0.1
29593, 1.3666666666667, 1, -0.1
29594, 1.3666666666667, 0.95, -0.1
29595, 1.3666666666667, 0.9, -0.1
29596, 1.3666666666667, 0.85, -0.1
29597, 1.3666666666667, 0.8, -0.1
29598, 1.3666666666667, 0.75, -0.1
29599, 1.3666666666667, 0.7, -0.1
29600, 1.3666666666667, 0.65, -0.1
29601, 1.3666666666667, 0.6, -0.1
29602, 1.3666666666667, 0.55, -0.1
29603, 1.3666666666667, 0.5, -0.1
29604, 1.3666666666667, 0.45, -0.1
29605, 1.3666666666667, 0.4, -0.1
29606, 1.3666666666667, 0.35, -0.1
29607, 1.3666666666667, 0.3, -0.1
29608, 1.3666666666667, 0.25, -0.1
29609, 1.3666666666667, 0.2, -0.1
29610, 1.4083333333333, 1.3, -0.1
29611, 1.4083333333333, 1.25, -0.1
29612, 1.4083333333333, 1.2, -0.1
29613, 1.4083333333333, 1.15, -0.1
29614, 1.4083333333333, 1.1, -0.1
29615, 1.4083333333333, 1.05, -0.1
29616, 1.4083333333333, 1, -0.1
29617, 1.4083333333333, 0.95, -0.1
29618, 1.4083333333333, 0.9, -0.1
29619, 1.4083333333333, 0.85, -0.1
29620, 1.4083333333333, 0.8, -0.1
29621, 1.4083333333333, 0.75, -0.1
29622, 1.4083333333333, 0.7, -0.1
29623, 1.4083333333333, 0.65, -0.1
29624, 1.4083333333333, 0.6, -0.1
29625, 1.4083333333333, 0.55, -0.1
29626, 1.4083333333333, 0.5, -0.1
29627, 1.4083333333333, 0.45, -0.1
29628, 1.4083333333333, 0.4, -0.1
29629, 1.4083333333333, 0.35, -0.1
29630, 1.4083333333333, 0.3, -0.1
29631, 1.4083333333333, 0.25, -0.1
29632, 1.4083333333333, 0.2, -0.1
29633, 1.45, 1.3, -0.1
29634, 1.45, 1.25, -0.1
29635, 1.45, 1.2, -0.1
29636, 1.45, 1.15, -0.1
29637, 1.45, 1.1, -0.1
29638, 1.45, 1.05, -0.1
29639, 1.45, 1, -0.1
29640, 1.45, 0.95, -0.1
29641, 1.45, 0.9, -0.1
29642, 1.45, 0.85, -0.1
29643, 1.45, 0.8, -0.1
29644, 1.45, 0.75, -0.1
29645, 1.45, 0.7, -0.1
29646, 1.45, 0.65, -0.1
29647, 1.45, 0.6, -0.1
29648, 1.45, 0.55, -0.1
29649, 1.45, 0.5, -0.1
29650, 1.45, 0.45, -0.1
29651, 1.45, 0.4, -0.1
29652, 1.45, 0.35, -0.1
29653, 1.45, 0.3, -0.1
29654, 1.45, 0.25, -0.1
29655, 1.45, 0.2, -0.1
29656, 1.4916666666667, 1.3, -0.1
29657, 1.4916666666667, 1.25, -0.1
29658, 1.4916666666667, 1.2, -0.1
29659, 1.4916666666667, 1.15, -0.1
29660, 1.4916666666667, 1.1, -0.1
29661, 1.4916666666667, 1.05, -0.1
29662, 1.4916666666667, 1, -0.1
29663, 1.4916666666667, 0.95, -0.1
29664, 1.4916666666667, 0.9, -0.1
29665, 1.4916666666667, 0.85, -0.1
29666, 1.4916666666667, 0.8, -0.1
29667, 1.4916666666667, 0.75, -0.1
29668, 1.4916666666667, 0.7, -0.1
29669, 1.4916666666667, 0.65, -0.1
29670, 1.4916666666667, 0.6, -0.1
29671, 1.4916666666667, 0.55, -0.1
29672, 1.4916666666667, 0.5, -0.1
29673, 1.4916666666667, 0.45, -0.1
29674, 1.4916666666667, 0.4, -0.1
29675, 1.4916666666667, 0.35, -0.1
29676, 1.4916666666667, 0.3, -0.1
29677, 1.4916666666667, 0.25, -0.1
29678, 1.4916666666667, 0.2, -0.1
29679, 1.5333333333333, 1.3, -0.1
29680, 1.5333333333333, 1.25, -0.1
29681, 1.5333333333333, 1.2, -0.1
29682, 1.5333333333333, 1.15, -0.1
29683, 1.5333333333333, 1.1, -0.1
29684, 1.5333333333333, 1.05, -0.1
29685, 1.5333333333333, 1, -0.1
29686, 1.5333333333333, 0.95, -0.1
29687, 1.5333333333333, 0.9, -0.1
29688, 1.5333333333333, 0.85, -0.1
29689, 1.5333333333333, 0.8, -0.1
29690, 1.5333333333333, 0.75, -0.1
29691, 1.5333333333333, 0.7, -0.1
29692, 1.5333333333333, 0.65, -0.1
29693, 1.5333333333333, 0.6, -0.1
29694, 1.5333333333333, 0.55, -0.1
29695, 1.5333333333333, 0.5, -0.1
29696, 1.5333333333333, 0.45, -0.1
29697, 1.5333333333333, 0.4, -0.1
29698, 1.5333333333333, 0.35, -0.1
29699, 1.5333333333333, 0.3, -0.1
29700, 1.5333333333333, 0.25, -0.1
29701, 1.5333333333333, 0.2, -0.1
29702, 1.575, 1.3, -0.1
29703, 1.575, 1.25, -0.1
29704, 1.575, 1.2, -0.1
29705, 1.575, 1.15, -0.1
29706, 1.575, 1.1, -0.1
29707, 1.575, 1.05, -0.1
29708, 1.575, 1, -0.1
29709, 1.575, 0.95, -0.1
29710, 1.575, 0.9, -0.1
29711, 1.575, 0.85, -0.1
29712, 1.575, 0.8, -0.1
29713, 1.575, 0.75, -0.1
29714, 1.575, 0.7, -0.1
29715, 1.575, 0.65, -0.1
29716, 1.575, 0.6, -0.1
29717, 1.575, 0.55, -0.1
29718, 1.575, 0.5, -0.1
29719, 1.575, 0.45, -0.1
29720, 1.575, 0.4, -0.1
29721, 1.575, 0.35, -0.1
29722, 1.575, 0.3, -0.1
29723, 1.575, 0.25, -0.1
29724, 1.575, 0.2, -0.1
29725, 1.6166666666667, 1.3, -0.1
29726, 1.6166666666667, 1.25, -0.1
29727, 1.6166666666667, 1.2, -0.1
29728, 1.6166666666667, 1.15, -0.1
29729, 1.6166666666667, 1.1, -0.1
29730, 1.6166666666667, 1.05, -0.1
29731, 1.6166666666667, 1, -0.1
29732, 1.6166666666667, 0.95, -0.1
29733, 1.6166666666667, 0.9, -0.1
29734, 1.6166666666667, 0.85, -0.1
29735, 1.6166666666667, 0.8, -0.1
29736, 1.6166666666667, 0.75, -0.1
29737, 1.6166666666667, 0.7, -0.1
29738, 1.6166666666667, 0.65, -0.1
29739, 1.6166666666667, 0.6, -0.1
29740, 1.6166666666667, 0.55, -0.1
29741, 1.6166666666667, 0.5, -0.1
29742, 1.6166666666667, 0.45, -0.1
29743, 1.6166666666667, 0.4, -0.1
29744, 1.6166666666667, 0.35, -0.1
29745, 1.6166666666667, 0.3, -0.1
29746, 1.6166666666667, 0.25, -0.1
29747, 1.6166666666667, 0.2, -0.1
29748, 1.6583333333333, 1.3, -0.1
29749, 1.6583333333333, 1.25, -0.1
29750, 1.6583333333333, 1.2, -0.1
29751, 1.6583333333333, 1.15, -0.1
29752, 1.6583333333333, 1.1, -0.1
29753, 1.6583333333333, 1.05, -0.1
29754, 1.6583333333333, 1, -0.1
29755, 1.6583333333333, 0.95, -0.1
29756, 1.6583333333333, 0.9, -0.1
29757, 1.6583333333333, 0.85, -0.1
29758, 1.6583333333333, 0.8, -0.1
29759, 1.6583333333333, 0.75, -0.1
29760, 1.6583333333333, 0.7, -0.1
29761, 1.6583333333333, 0.65, -0.1
29762, 1.6583333333333, 0.6, -0.1
29763, 1.6583333333333, 0.55, -0.1
29764, 1.6583333333333, 0.5, -0.1
29765, 1.6583333333333, 0.45, -0.1
29766, 1.6583333333333, 0.4, -0.1
29767, 1.6583333333333, 0.35, -0.1
29768, 1.6583333333333, 0.3, -0.1
29769, 1.6583333333333, 0.25, -0.1
29770, 1.6583333333333, 0.2, -0.1
29771, 1.7, 1.3, -0.1
29772, 1.7, 1.25, -0.1
29773, 1.7, 1.2, -0.1
29774, 1.7, 1.15, -0.1
29775, 1.7, 1.1, -0.1
29776, 1.7, 1.05, -0.1
29777, 1.7, 1, -0.1
29778, 1.7, 0.95, -0.1
29779, 1.7, 0.9, -0.1
29780, 1.7, 0.85, -0.1
29781, 1.7, 0.8, -0.1
29782, 1.7, 0.75, -0.1
29783, 1.7, 0.7, -0.1
29784, 1.7, 0.65, -0.1
29785, 1.7, 0.6, -0.1
29786, 1.7, 0.55, -0.1
29787, 1.7, 0.5, -0.1
29788, 1.7, 0.45, -0.1
29789, 1.7, 0.4, -0.1
29790, 1.7, 0.35, -0.1
29791, 1.7, 0.3, -0.1
29792, 1.7, 0.25, -0.1
29793, 1.7, 0.2, -0.1
29794, 1.7416666666667, 1.3, -0.1
29795, 1.7416666666667, 1.25, -0.1
29796, 1.7416666666667, 1.2, -0.1
29797, 1.7416666666667, 1.15, -0.1
29798, 1.7416666666667, 1.1, -0.1
29799, 1.7416666666667, 1.05, -0.1
29800, 1.7416666666667, 1, -0.1
29801, 1.7416666666667, 0.95, -0.1
29802, 1.7416666666667, 0.9, -0.1
29803, 1.7416666666667, 0.85, -0.1
29804, 1.7416666666667, 0.8, -0.1
29805, 1.7416666666667, 0.75, -0.1
29806, 1.7416666666667, 0.7, -0.1
29807, 1.7416666666667, 0.65, -0.1
29808, 1.7416666666667, 0.6, -0.1
29809, 1.7416666666667, 0.55, -0.1
29810, 1.7416666666667, 0.5, -0.1
29811, 1.7416666666667, 0.45, -0.1
29812, 1.7416666666667, 0.4, -0.1
29813, 1.7416666666667, 0.35, -0.1
29814, 1.7416666666667, 0.3, -0.1
29815, 1.7416666666667, 0.25, -0.1
29816, 1.7416666666667, 0.2, -0.1
29817, 1.7833333333333, 1.3, -0.1
29818, 1.7833333333333, 1.25, -0.1
29819, 1.7833333333333, 1.2, -0.1
29820, 1.7833333333333, 1.15, -0.1
29821, 1.7833333333333, 1.1, -0.1
29822, 1.7833333333333, 1.05, -0.1
29823, 1.7833333333333, 1, -0.1
29824, 1.7833333333333, 0.95, -0.1
29825, 1.7833333333333, 0.9, -0.1
29826, 1.7833333333333, 0.85, -0.1
29827, 1.7833333333333, 0.8, -0.1
29828, 1.7833333333333, 0.75, -0.1
29829, 1.7833333333333, 0.7, -0.1
29830, 1.7833333333333, 0.65, -0.1
29831, 1.7833333333333, 0.6, -0.1
29832, 1.7833333333333, 0.55, -0.1
29833, 1.7833333333333, 0.5, -0.1
29834, 1.7833333333333, 0.45, -0.1
29835, 1.7833333333333, 0.4, -0.1
29836, 1.7833333333333, 0.35, -0.1
29837, 1.7833333333333, 0.3, -0.1
29838, 1.7833333333333, 0.25, -0.1
29839, 1.7833333333333, 0.2, -0.1
29840, 1.825, 1.3, -0.1
29841, 1.825, 1.25, -0.1
29842, 1.825, 1.2, -0.1
29843, 1.825, 1.15, -0.1
29844, 1.825, 1.1, -0.1
29845, 1.825, 1.05, -0.1
29846, 1.825, 1, -0.1
29847, 1.825, 0.95, -0.1
29848, 1.825, 0.9, -0.1
29849, 1.825, 0.85, -0.1
29850, 1.825, 0.8, -0.1
29851, 1.825, 0.75, -0.1
29852, 1.825, 0.7, -0.1
29853, 1.825, 0.65, -0.1
29854, 1.825, 0.6, -0.1
29855, 1.825, 0.55, -0.1
29856, 1.825, 0.5, -0.1
29857, 1.825, 0.45, -0.1
29858, 1.825, 0.4, -0.1
29859, 1.825, 0.35, -0.1
29860, 1.825, 0.3, -0.1
29861, 1.825, 0.25, -0.1
29862, 1.825, 0.2, -0.1
29863, 1.8666666666667, 1.3, -0.1
29864, 1.8666666666667, 1.25, -0.1
29865, 1.8666666666667, 1.2, -0.1
29866, 1.8666666666667, 1.15, -0.1
29867, 1.8666666666667, 1.1, -0.1
29868, 1.8666666666667, 1.05, -0.1
29869, 1.8666666666667, 1, -0.1
29870, 1.8666666666667, 0.95, -0.1
29871, 1.8666666666667, 0.9, -0.1
29872, 1.8666666666667, 0.85, -0.1
29873, 1.8666666666667, 0.8, -0.1
29874, 1.8666666666667, 0.75, -0.1
29875, 1.8666666666667, 0.7, -0.1
29876, 1.8666666666667, 0.65, -0.1
29877, 1.8666666666667, 0.6, -0.1
29878, 1.8666666666667, 0.55, -0.1
29879, 1.8666666666667, 0.5, -0.1
29880, 1.8666666666667, 0.45, -0.1
29881, 1.8666666666667, 0.4, -0.1
29882, 1.8666666666667, 0.35, -0.1
29883, 1.8666666666667, 0.3, -0.1
29884, 1.8666666666667, 0.25, -0.1
29885, 1.8666666666667, 0.2, -0.1
29886, 1.9083333333333, 1.3, -0.1
29887, 1.9083333333333, 1.25, -0.1
29888, 1.9083333333333, 1.2, -0.1
29889, 1.9083333333333, 1.15, -0.1
29890, 1.9083333333333, 1.1, -0.1
29891, 1.9083333333333, 1.05, -0.1
29892, 1.9083333333333, 1, -0.1
29893, 1.9083333333333, 0.95, -0.1
29894, 1.9083333333333, 0.9, -0.1
29895, 1.9083333333333, 0.85, -0.1
29896, 1.9083333333333, 0.8, -0.1
29897, 1.9083333333333, 0.75, -0.1
29898, 1.9083333333333, 0.7, -0.1
29899, 1.9083333333333, 0.65, -0.1
29900, 1.9083333333333, 0.6, -0.1
29901, 1.9083333333333, 0.55, -0.1
29902, 1.9083333333333, 0.5, -0.1
29903, 1.9083333333333, 0.45, -0.1
29904, 1.9083333333333, 0.4, -0.1
29905, 1.9083333333333, 0.35, -0.1
29906, 1.9083333333333, 0.3, -0.1
29907, 1.9083333333333, 0.25, -0.1
29908, 1.9083333333333, 0.2, -0.1
29909, 1.95, 1.3, -0.1
29910, 1.95, 1.25, -0.1
29911, 1.95, 1.2, -0.1
29912, 1.95, 1.15, -0.1
29913, 1.95, 1.1, -0.1
29914, 1.95, 1.05, -0.1
29915, 1.95, 1, -0.1
29916, 1.95, 0.95, -0.1
29917, 1.95, 0.9, -0.1
29918, 1.95, 0.85, -0.1
29919, 1.95, 0.8, -0.1
29920, 1.95, 0.75, -0.1
29921, 1.95, 0.7, -0.1
29922, 1.95, 0.65, -0.1
29923, 1.95, 0.6, -0.1
29924, 1.95, 0.55, -0.1
29925, 1.95, 0.5, -0.1
29926, 1.95, 0.45, -0.1
29927, 1.95, 0.4, -0.1
29928, 1.95, 0.35, -0.1
29929, 1.95, 0.3, -0.1
29930, 1.95, 0.25, -0.1
29931, 1.95, 0.2, -0.1
29932, 1.9916666666667, 1.3, -0.1
29933, 1.9916666666667, 1.25, -0.1
29934, 1.9916666666667, 1.2, -0.1
29935, 1.9916666666667, 1.15, -0.1
29936, 1.9916666666667, 1.1, -0.1
29937, 1.9916666666667, 1.05, -0.1
29938, 1.9916666666667, 1, -0.1
29939, 1.9916666666667, 0.95, -0.1
29940, 1.9916666666667, 0.9, -0.1
29941, 1.9916666666667, 0.85, -0.1
29942, 1.9916666666667, 0.8, -0.1
29943, 1.9916666666667, 0.75, -0.1
29944, 1.9916666666667, 0.7, -0.1
29945, 1.9916666666667, 0.65, -0.1
29946, 1.9916666666667, 0.6, -0.1
29947, 1.9916666666667, 0.55, -0.1
29948, 1.9916666666667, 0.5, -0.1
29949, 1.9916666666667, 0.45, -0.1
29950, 1.9916666666667, 0.4, -0.1
29951, 1.9916666666667, 0.35, -0.1
29952, 1.9916666666667, 0.3, -0.1
29953, 1.9916666666667, 0.25, -0.1
29954, 1.9916666666667, 0.2, -0.1
29955, 2.0333333333333, 1.3, -0.1
29956, 2.0333333333333, 1.25, -0.1
29957, 2.0333333333333, 1.2, -0.1
29958, 2.0333333333333, 1.15, -0.1
29959, 2.0333333333333, 1.1, -0.1
29960, 2.0333333333333, 1.05, -0.1
29961, 2.0333333333333, 1, -0.1
29962, 2.0333333333333, 0.95, -0.1
29963, 2.0333333333333, 0.9, -0.1
29964, 2.0333333333333, 0.85, -0.1
29965, 2.0333333333333, 0.8, -0.1
29966, 2.0333333333333, 0.75, -0.1
29967, 2.0333333333333, 0.7, -0.1
29968, 2.0333333333333, 0.65, -0.1
29969, 2.0333333333333, 0.6, -0.1
29970, 2.0333333333333, 0.55, -0.1
29971, 2.0333333333333, 0.5, -0.1
29972, 2.0333333333333, 0.45, -0.1
29973, 2.0333333333333, 0.4, -0.1
29974, 2.0333333333333, 0.35, -0.1
29975, 2.0333333333333, 0.3, -0.1
29976, 2.0333333333333, 0.25, -0.1
29977, 2.0333333333333, 0.2, -0.1
29978, 2.075, 1.3, -0.1
29979, 2.075, 1.25, -0.1
29980, 2.075, 1.2, -0.1
29981, 2.075, 1.15, -0.1
29982, 2.075, 1.1, -0.1
29983, 2.075, 1.05, -0.1
29984, 2.075, 1, -0.1
29985, 2.075, 0.95, -0.1
29986, 2.075, 0.9, -0.1
29987, 2.075, 0.85, -0.1
29988, 2.075, 0.8, -0.1
29989, 2.075, 0.75, -0.1
29990, 2.075, 0.7, -0.1
29991, 2.075, 0.65, -0.1
29992, 2.075, 0.6, -0.1
29993, 2.075, 0.55, -0.1
29994, 2.075, 0.5, -0.1
29995, 2.075, 0.45, -0.1
29996, 2.075, 0.4, -0.1
29997, 2.075, 0.35, -0.1
29998, 2.075, 0.3, -0.1
29999, 2.075, 0.25, -0.1
30000, 2.075, 0.2, -0.1
30001, 2.1166666666667, 1.3, -0.1
30002, 2.1166666666667, 1.25, -0.1
30003, 2.1166666666667, 1.2, -0.1
30004, 2.1166666666667, 1.15, -0.1
30005, 2.1166666666667, 1.1, -0.1
30006, 2.1166666666667, 1.05, -0.1
30007, 2.1166666666667, 1, -0.1
30008, 2.1166666666667, 0.95, -0.1
30009, 2.1166666666667, 0.9, -0.1
30010, 2.1166666666667, 0.85, -0.1
30011, 2.1166666666667, 0.8, -0.1
30012, 2.1166666666667, 0.75, -0.1
30013, 2.1166666666667, 0.7, -0.1
30014, 2.1166666666667, 0.65, -0.1
30015, 2.1166666666667, 0.6, -0.1
30016, 2.1166666666667, 0.55, -0.1
30017, 2.1166666666667, 0.5, -0.1
30018, 2.1166666666667, 0.45, -0.1
30019, 2.1166666666667, 0.4, -0.1
30020, 2.1166666666667, 0.35, -0.1
30021, 2.1166666666667, 0.3, -0.1
30022, 2.1166666666667, 0.25, -0.1
30023, 2.1166666666667, 0.2, -0.1
30024, 2.1583333333333, 1.3, -0.1
30025, 2.1583333333333, 1.25, -0.1
30026, 2.1583333333333, 1.2, -0.1
30027, 2.1583333333333, 1.15, -0.1
30028, 2.1583333333333, 1.1, -0.1
30029, 2.1583333333333, 1.05, -0.1
30030, 2.1583333333333, 1, -0.1
30031, 2.1583333333333, 0.95, -0.1
30032, 2.1583333333333, 0.9, -0.1
30033, 2.1583333333333, 0.85, -0.1
30034, 2.1583333333333, 0.8, -0.1
30035, 2.1583333333333, 0.75, -0.1
30036, 2.1583333333333, 0.7, -0.1
30037, 2.1583333333333, 0.65, -0.1
30038, 2.1583333333333, 0.6, -0.1
30039, 2.1583333333333, 0.55, -0.1
30040, 2.1583333333333, 0.5, -0.1
30041, 2.1583333333333, 0.45, -0.1
30042, 2.1583333333333, 0.4, -0.1
30043, 2.1583333333333, 0.35, -0.1
30044, 2.1583333333333, 0.3, -0.1
30045, 2.1583333333333, 0.25, -0.1
30046, 2.1583333333333, 0.2, -0.1
30047, 1.2416666666667, 1.325, -0.1
30048, 1.2208333333333, 1.3, -0.1
30049, 1.2416666666667, 1.275, -0.1
30050, 1.2208333333333, 1.25, -0.1
30051, 1.2416666666667, 1.225, -0.1
30052, 1.2208333333333, 1.2, -0.1
30053, 1.2416666666667, 1.175, -0.1
30054, 1.2208333333333, 1.15, -0.1
30055, 1.2416666666667, 1.125, -0.1
30056, 1.2208333333333, 1.1, -0.1
30057, 1.2416666666667, 1.075, -0.1
30058, 1.2208333333333, 1.05, -0.1
30059, 1.2416666666667, 1.025, -0.1
30060, 1.2208333333333, 1, -0.1
30061, 1.2416666666667, 0.975, -0.1
30062, 1.2208333333333, 0.95, -0.1
30063, 1.2416666666667, 0.925, -0.1
30064, 1.2208333333333, 0.9, -0.1
30065, 1.2416666666667, 0.875, -0.1
30066, 1.2208333333333, 0.85, -0.1
30067, 1.2416666666667, 0.825, -0.1
30068, 1.2208333333333, 0.8, -0.1
30069, 1.2416666666667, 0.775, -0.1
30070, 1.2208333333333, 0.75, -0.1
30071, 1.2416666666667, 0.725, -0.1
30072, 1.2208333333333, 0.7, -0.1
30073, 1.2416666666667, 0.675, -0.1
30074, 1.2208333333333, 0.65, -0.1
30075, 1.2416666666667, 0.625, -0.1
30076, 1.2208333333333, 0.6, -0.1
30077, 1.2416666666667, 0.575, -0.1
30078, 1.2208333333333, 0.55, -0.1
30079, 1.2416666666667, 0.525, -0.1
30080, 1.2208333333333, 0.5, -0.1
30081, 1.2416666666667, 0.475, -0.1
30082, 1.2208333333333, 0.45, -0.1
30083, 1.2416666666667, 0.425, -0.1
30084, 1.2208333333333, 0.4, -0.1
30085, 1.2416666666667, 0.375, -0.1
30086, 1.2208333333333, 0.35, -0.1
30087, 1.2416666666667, 0.325, -0.1
30088, 1.2208333333333, 0.3, -0.1
30089, 1.2416666666667, 0.275, -0.1
30090, 1.2208333333333, 0.25, -0.1
30091, 1.2416666666667, 0.225, -0.1
30092, 1.2208333333333, 0.2, -0.1
30093, 1.2416666666667, 0.175, -0.1
30094, 1.2833333333333, 1.325, -0.1
30095, 1.2625, 1.3, -0.1
30096, 1.2833333333333, 1.275, -0.1
30097, 1.2625, 1.25, -0.1
30098, 1.2833333333333, 1.225, -0.1
30099, 1.2625, 1.2, -0.1
30100, 1.2833333333333, 1.175, -0.1
30101, 1.2625, 1.15, -0.1
30102, 1.2833333333333, 1.125, -0.1
30103, 1.2625, 1.1, -0.1
30104, 1.2833333333333, 1.075, -0.1
30105, 1.2625, 1.05, -0.1
30106, 1.2833333333333, 1.025, -0.1
30107, 1.2625, 1, -0.1
30108, 1.2833333333333, 0.975, -0.1
30109, 1.2625, 0.95, -0.1
30110, 1.2833333333333, 0.925, -0.1
30111, 1.2625, 0.9, -0.1
30112, 1.2833333333333, 0.875, -0.1
30113, 1.2625, 0.85, -0.1
30114, 1.2833333333333, 0.825, -0.1
30115, 1.2625, 0.8, -0.1
30116, 1.2833333333333, 0.775, -0.1
30117, 1.2625, 0.75, -0.1
30118, 1.2833333333333, 0.725, -0.1
30119, 1.2625, 0.7, -0.1
30120, 1.2833333333333, 0.675, -0.1
30121, 1.2625, 0.65, -0.1
30122, 1.2833333333333, 0.625, -0.1
30123, 1.2625, 0.6, -0.1
30124, 1.2833333333333, 0.575, -0.1
30125, 1.2625, 0.55, -0.1
30126, 1.2833333333333, 0.525, -0.1
30127, 1.2625, 0.5, -0.1
30128, 1.2833333333333, 0.475, -0.1
30129, 1.2625, 0.45, -0.1
30130, 1.2833333333333, 0.425, -0.1
30131, 1.2625, 0.4, -0.1
30132, 1.2833333333333, 0.375, -0.1
30133, 1.2625, 0.35, -0.1
30134, 1.2833333333333, 0.325, -0.1
30135, 1.2625, 0.3, -0.1
30136, 1.2833333333333, 0.275, -0.1
30137, 1.2625, 0.25, -0.1
30138, 1.2833333333333, 0.225, -0.1
30139, 1.2625, 0.2, -0.1
30140, 1.2833333333333, 0.175, -0.1
30141, 1.325, 1.325, -0.1
30142, 1.3041666666667, 1.3, -0.1
30143, 1.325, 1.275, -0.1
30144, 1.3041666666667, 1.25, -0.1
30145, 1.325, 1.225, -0.1
30146, 1.3041666666667, 1.2, -0.1
30147, 1.325, 1.175, -0.1
30148, 1.3041666666667, 1.15, -0.1
30149, 1.325, 1.125, -0.1
30150, 1.3041666666667, 1.1, -0.1
30151, 1.325, 1.075, -0.1
30152, 1.3041666666667, 1.05, -0.1
30153, 1.325, 1.025, -0.1
30154, 1.3041666666667, 1, -0.1
30155, 1.325, 0.975, -0.1
30156, 1.3041666666667, 0.95, -0.1
30157, 1.325, 0.925, -0.1
30158, 1.3041666666667, 0.9, -0.1
30159, 1.325, 0.875, -0.1
30160, 1.3041666666667, 0.85, -0.1
30161, 1.325, 0.825, -0.1
30162, 1.3041666666667, 0.8, -0.1
30163, 1.325, 0.775, -0.1
30164, 1.3041666666667, 0.75, -0.1
30165, 1.325, 0.725, -0.1
30166, 1.3041666666667, 0.7, -0.1
30167, 1.325, 0.675, -0.1
30168, 1.3041666666667, 0.65, -0.1
30169, 1.325, 0.625, -0.1
30170, 1.3041666666667, 0.6, -0.1
30171, 1.325, 0.575, -0.1
30172, 1.3041666666667, 0.55, -0.1
30173, 1.325, 0.525, -0.1
30174, 1.3041666666667, 0.5, -0.1
30175, 1.325, 0.475, -0.1
30176, 1.3041666666667, 0.45, -0.1
30177, 1.325, 0.425, -0.1
30178, 1.3041666666667, 0.4, -0.1
30179, 1.325, 0.375, -0.1
30180, 1.3041666666667, 0.35, -0.1
30181, 1.325, 0.325, -0.1
30182, 1.3041666666667, 0.3, -0.1
30183, 1.325, 0.275, -0.1
30184, 1.3041666666667, 0.25, -0.1
30185, 1.325, 0.225, -0.1
30186, 1.3041666666667, 0.2, -0.1
30187, 1.325, 0.175, -0.1
30188, 1.3666666666667, 1.325, -0.1
30189, 1.3458333333333, 1.3, -0.1
30190, 1.3666666666667, 1.275, -0.1
30191, 1.3458333333333, 1.25, -0.1
30192, 1.3666666666667, 1.225, -0.1
30193, 1.3458333333333, 1.2, -0.1
30194, 1.3666666666667, 1.175, -0.1
30195, 1.3458333333333, 1.15, -0.1
30196, 1.3666666666667, 1.125, -0.1
30197, 1.3458333333333, 1.1, -0.1
30198, 1.3666666666667, 1.075, -0.1
30199, 1.3458333333333, 1.05, -0.1
30200, 1.3666666666667, 1.025, -0.1
30201, 1.3458333333333, 1, -0.1
30202, 1.3666666666667, 0.975, -0.1
30203, 1.3458333333333, 0.95, -0.1
30204, 1.3666666666667, 0.925, -0.1
30205, 1.3458333333333, 0.9, -0.1
30206, 1.3666666666667, 0.875, -0.1
30207, 1.3458333333333, 0.85, -0.1
30208, 1.3666666666667, 0.825, -0.1
30209, 1.3458333333333, 0.8, -0.1
30210, 1.3666666666667, 0.775, -0.1
30211, 1.3458333333333, 0.75, -0.1
30212, 1.3666666666667, 0.725, -0.1
30213, 1.3458333333333, 0.7, -0.1
30214, 1.3666666666667, 0.675, -0.1
30215, 1.3458333333333, 0.65, -0.1
30216, 1.3666666666667, 0.625, -0.1
30217, 1.3458333333333, 0.6, -0.1
30218, 1.3666666666667, 0.575, -0.1
30219, 1.3458333333333, 0.55, -0.1
30220, 1.3666666666667, 0.525, -0.1
30221, 1.3458333333333, 0.5, -0.1
30222, 1.3666666666667, 0.475, -0.1
30223, 1.3458333333333, 0.45, -0.1
30224, 1.3666666666667, 0.425, -0.1
30225, 1.3458333333333, 0.4, -0.1
30226, 1.3666666666667, 0.375, -0.1
30227, 1.3458333333333, 0.35, -0.1
30228, 1.3666666666667, 0.325, -0.1
30229, 1.3458333333333, 0.3, -0.1
30230, 1.3666666666667, 0.275, -0.1
30231, 1.3458333333333, 0.25, -0.1
30232, 1.3666666666667, 0.225, -0.1
30233, 1.3458333333333, 0.2, -0.1
30234, 1.3666666666667, 0.175, -0.1
30235, 1.4083333333333, 1.325, -0.1
30236, 1.3875, 1.3, -0.1
30237, 1.4083333333333, 1.275, -0.1
30238, 1.3875, 1.25, -0.1
30239, 1.4083333333333, 1.225, -0.1
30240, 1.3875, 1.2, -0.1
30241, 1.4083333333333, 1.175, -0.1
30242, 1.3875, 1.15, -0.1
30243, 1.4083333333333, 1.125, -0.1
30244, 1.3875, 1.1, -0.1
30245, 1.4083333333333, 1.075, -0.1
30246, 1.3875, 1.05, -0.1
30247, 1.4083333333333, 1.025, -0.1
30248, 1.3875, 1, -0.1
30249, 1.4083333333333, 0.975, -0.1
30250, 1.3875, 0.95, -0.1
30251, 1.4083333333333, 0.925, -0.1
30252, 1.3875, 0.9, -0.1
30253, 1.4083333333333, 0.875, -0.1
30254, 1.3875, 0.85, -0.1
30255, 1.4083333333333, 0.825, -0.1
30256, 1.3875, 0.8, -0.1
30257, 1.4083333333333, 0.775, -0.1
30258, 1.3875, 0.75, -0.1
30259, 1.4083333333333, 0.725, -0.1
30260, 1.3875, 0.7, -0.1
30261, 1.4083333333333, 0.675, -0.1
30262, 1.3875, 0.65, -0.1
30263, 1.4083333333333, 0.625, -0.1
30264, 1.3875, 0.6, -0.1
30265, 1.4083333333333, 0.575, -0.1
30266, 1.3875, 0.55, -0.1
30267, 1.4083333333333, 0.525, -0.1
30268, 1.3875, 0.5, -0.1
30269, 1.4083333333333, 0.475, -0.1
30270, 1.3875, 0.45, -0.1
30271, 1.4083333333333, 0.425, -0.1
30272, 1.3875, 0.4, -0.1
30273, 1.4083333333333, 0.375, -0.1
30274, 1.3875, 0.35, -0.1
30275, 1.4083333333333, 0.325, -0.1
30276, 1.3875, 0.3, -0.1
30277, 1.4083333333333, 0.275, -0.1
30278, 1.3875, 0.25, -0.1
30279, 1.4083333333333, 0.225, -0.1
30280, 1.3875, 0.2, -0.1
30281, 1.4083333333333, 0.175, -0.1
30282, 1.45, 1.325, -0.1
30283, 1.4291666666667, 1.3, -0.1
30284, 1.45, 1.275, -0.1
30285, 1.4291666666667, 1.25, -0.1
30286, 1.45, 1.225, -0.1
30287, 1.4291666666667, 1.2, -0.1
30288, 1.45, 1.175, -0.1
30289, 1.4291666666667, 1.15, -0.1
30290, 1.45, 1.125, -0.1
30291, 1.4291666666667, 1.1, -0.1
30292, 1.45, 1.075, -0.1
30293, 1.4291666666667, 1.05, -0.1
30294, 1.45, 1.025, -0.1
30295, 1.4291666666667, 1, -0.1
30296, 1.45, 0.975, -0.1
30297, 1.4291666666667, 0.95, -0.1
30298, 1.45, 0.925, -0.1
30299, 1.4291666666667, 0.9, -0.1
30300, 1.45, 0.875, -0.1
30301, 1.4291666666667, 0.85, -0.1
30302, 1.45, 0.825, -0.1
30303, 1.4291666666667, 0.8, -0.1
30304, 1.45, 0.775, -0.1
30305, 1.4291666666667, 0.75, -0.1
30306, 1.45, 0.725, -0.1
30307, 1.4291666666667, 0.7, -0.1
30308, 1.45, 0.675, -0.1
30309, 1.4291666666667, 0.65, -0.1
30310, 1.45, 0.625, -0.1
30311, 1.4291666666667, 0.6, -0.1
30312, 1.45, 0.575, -0.1
30313, 1.4291666666667, 0.55, -0.1
30314, 1.45, 0.525, -0.1
30315, 1.4291666666667, 0.5, -0.1
30316, 1.45, 0.475, -0.1
30317, 1.4291666666667, 0.45, -0.1
30318, 1.45, 0.425, -0.1
30319, 1.4291666666667, 0.4, -0.1
30320, 1.45, 0.375, -0.1
30321, 1.4291666666667, 0.35, -0.1
30322, 1.45, 0.325, -0.1
30323, 1.4291666666667, 0.3, -0.1
30324, 1.45, 0.275, -0.1
30325, 1.4291666666667, 0.25, -0.1
30326, 1.45, 0.225, -0.1
30327, 1.4291666666667, 0.2, -0.1
30328, 1.45, 0.175, -0.1
30329, 1.4916666666667, 1.325, -0.1
30330, 1.4708333333333, 1.3, -0.1
30331, 1.4916666666667, 1.275, -0.1
30332, 1.4708333333333, 1.25, -0.1
30333, 1.4916666666667, 1.225, -0.1
30334, 1.4708333333333, 1.2, -0.1
30335, 1.4916666666667, 1.175, -0.1
30336, 1.4708333333333, 1.15, -0.1
30337, 1.4916666666667, 1.125, -0.1
30338, 1.4708333333333, 1.1, -0.1
30339, 1.4916666666667, 1.075, -0.1
30340, 1.4708333333333, 1.05, -0.1
30341, 1.4916666666667, 1.025, -0.1
30342, 1.4708333333333, 1, -0.1
30343, 1.4916666666667, 0.975, -0.1
30344, 1.4708333333333, 0.95, -0.1
30345, 1.4916666666667, 0.925, -0.1
30346, 1.4708333333333, 0.9, -0.1
30347, 1.4916666666667, 0.875, -0.1
30348, 1.4708333333333, 0.85, -0.1
30349, 1.4916666666667, 0.825, -0.1
30350, 1.4708333333333, 0.8, -0.1
30351, 1.4916666666667, 0.775, -0.1
30352, 1.4708333333333, 0.75, -0.1
30353, 1.4916666666667, 0.725, -0.1
30354, 1.4708333333333, 0.7, -0.1
30355, 1.4916666666667, 0.675, -0.1
30356, 1.4708333333333, 0.65, -0.1
30357, 1.4916666666667, 0.625, -0.1
30358, 1.4708333333333, 0.6, -0.1
30359, 1.4916666666667, 0.575, -0.1
30360, 1.4708333333333, 0.55, -0.1
30361, 1.4916666666667, 0.525, -0.1
30362, 1.4708333333333, 0.5, -0.1
30363, 1.4916666666667, 0.475, -0.1
30364, 1.4708333333333, 0.45, -0.1
30365, 1.4916666666667, 0.425, -0.1
30366, 1.4708333333333, 0.4, -0.1
30367, 1.4916666666667, 0.375, -0.1
30368, 1.4708333333333, 0.35, -0.1
30369, 1.4916666666667, 0.325, -0.1
30370, 1.4708333333333, 0.3, -0.1
30371, 1.4916666666667, 0.275, -0.1
30372, 1.4708333333333, 0.25, -0.1
30373, 1.4916666666667, 0.225, -0.1
30374, 1.4708333333333, 0.2, -0.1
30375, 1.4916666666667, 0.175, -0.1
30376, 1.5333333333333, 1.325, -0.1
30377, 1.5125, 1.3, -0.1
30378, 1.5333333333333, 1.275, -0.1
30379, 1.5125, 1.25, -0.1
30380, 1.5333333333333, 1.225, -0.1
30381, 1.5125, 1.2, -0.1
30382, 1.5333333333333, 1.175, -0.1
30383, 1.5125, 1.15, -0.1
30384, 1.5333333333333, 1.125, -0.1
30385, 1.5125, 1.1, -0.1
30386, 1.5333333333333, 1.075, -0.1
30387, 1.5125, 1.05, -0.1
30388, 1.5333333333333, 1.025, -0.1
30389, 1.5125, 1, -0.1
30390, 1.5333333333333, 0.975, -0.1
30391, 1.5125, 0.95, -0.1
30392, 1.5333333333333, 0.925, -0.1
30393, 1.5125, 0.9, -0.1
30394, 1.5333333333333, 0.875, -0.1
30395, 1.5125, 0.85, -0.1
30396, 1.5333333333333, 0.825, -0.1
30397, 1.5125, 0.8, -0.1
30398, 1.5333333333333, 0.775, -0.1
30399, 1.5125, 0.75, -0.1
30400, 1.5333333333333, 0.725, -0.1
30401, 1.5125, 0.7, -0.1
30402, 1.5333333333333, 0.675, -0.1
30403, 1.5125, 0.65, -0.1
30404, 1.5333333333333, 0.625, -0.1
30405, 1.5125, 0.6, -0.1
30406, 1.5333333333333, 0.575, -0.1
30407, 1.5125, 0.55, -0.1
30408, 1.5333333333333, 0.525, -0.1
30409, 1.5125, 0.5, -0.1
30410, 1.5333333333333, 0.475, -0.1
30411, 1.5125, 0.45, -0.1
30412, 1.5333333333333, 0.425, -0.1
30413, 1.5125, 0.4, -0.1
30414, 1.5333333333333, 0.375, -0.1
30415, 1.5125, 0.35, -0.1
30416, 1.5333333333333, 0.325, -0.1
30417, 1.5125, 0.3, -0.1
30418, 1.5333333333333, 0.275, -0.1
30419, 1.5125, 0.25, -0.1
30420, 1.5333333333333, 0.225, -0.1
30421, 1.5125, 0.2, -0.1
30422, 1.5333333333333, 0.175, -0.1
30423, 1.575, 1.325, -0.1
30424, 1.5541666666667, 1.3, -0.1
30425, 1.575, 1.275, -0.1
30426, 1.5541666666667, 1.25, -0.1
30427, 1.575, 1.225, -0.1
30428, 1.5541666666667, 1.2, -0.1
30429, 1.575, 1.175, -0.1
30430, 1.5541666666667, 1.15, -0.1
30431, 1.575, 1.125, -0.1
30432, 1.5541666666667, 1.1, -0.1
30433, 1.575, 1.075, -0.1
30434, 1.5541666666667, 1.05, -0.1
30435, 1.575, 1.025, -0.1
30436, 1.5541666666667, 1, -0.1
30437, 1.575, 0.975, -0.1
30438, 1.5541666666667, 0.95, -0.1
30439, 1.575, 0.925, -0.1
30440, 1.5541666666667, 0.9, -0.1
30441, 1.575, 0.875, -0.1
30442, 1.5541666666667, 0.85, -0.1
30443, 1.575, 0.825, -0.1
30444, 1.5541666666667, 0.8, -0.1
30445, 1.575, 0.775, -0.1
30446, 1.5541666666667, 0.75, -0.1
30447, 1.575, 0.725, -0.1
30448, 1.5541666666667, 0.7, -0.1
30449, 1.575, 0.675, -0.1
30450, 1.5541666666667, 0.65, -0.1
30451, 1.575, 0.625, -0.1
30452, 1.5541666666667, 0.6, -0.1
30453, 1.575, 0.575, -0.1
30454, 1.5541666666667, 0.55, -0.1
30455, 1.575, 0.525, -0.1
30456, 1.5541666666667, 0.5, -0.1
30457, 1.575, 0.475, -0.1
30458, 1.5541666666667, 0.45, -0.1
30459, 1.575, 0.425, -0.1
30460, 1.5541666666667, 0.4, -0.1
30461, 1.575, 0.375, -0.1
30462, 1.5541666666667, 0.35, -0.1
30463, 1.575, 0.325, -0.1
30464, 1.5541666666667, 0.3, -0.1
30465, 1.575, 0.275, -0.1
30466, 1.5541666666667, 0.25, -0.1
30467, 1.575, 0.225, -0.1
30468, 1.5541666666667, 0.2, -0.1
30469, 1.575, 0.175, -0.1
30470, 1.6166666666667, 1.325, -0.1
30471, 1.5958333333333, 1.3, -0.1
30472, 1.6166666666667, 1.275, -0.1
30473, 1.5958333333333, 1.25, -0.1
30474, 1.6166666666667, 1.225, -0.1
30475, 1.5958333333333, 1.2, -0.1
30476, 1.6166666666667, 1.175, -0.1
30477, 1.5958333333333, 1.15, -0.1
30478, 1.6166666666667, 1.125, -0.1
30479, 1.5958333333333, 1.1, -0.1
30480, 1.6166666666667, 1.075, -0.1
30481, 1.5958333333333, 1.05, -0.1
30482, 1.6166666666667, 1.025, -0.1
30483, 1.5958333333333, 1, -0.1
30484, 1.6166666666667, 0.975, -0.1
30485, 1.5958333333333, 0.95, -0.1
30486, 1.6166666666667, 0.925, -0.1
30487, 1.5958333333333, 0.9, -0.1
30488, 1.6166666666667, 0.875, -0.1
30489, 1.5958333333333, 0.85, -0.1
30490, 1.6166666666667, 0.825, -0.1
30491, 1.5958333333333, 0.8, -0.1
30492, 1.6166666666667, 0.775, -0.1
30493, 1.5958333333333, 0.75, -0.1
30494, 1.6166666666667, 0.725, -0.1
30495, 1.5958333333333, 0.7, -0.1
30496, 1.6166666666667, 0.675, -0.1
30497, 1.5958333333333, 0.65, -0.1
30498, 1.6166666666667, 0.625, -0.1
30499, 1.5958333333333, 0.6, -0.1
30500, 1.6166666666667, 0.575, -0.1
30501, 1.5958333333333, 0.55, -0.1
30502, 1.6166666666667, 0.525, -0.1
30503, 1.5958333333333, 0.5, -0.1
30504, 1.6166666666667, 0.475, -0.1
30505, 1.5958333333333, 0.45, -0.1
30506, 1.6166666666667, 0.425, -0.1
30507, 1.5958333333333, 0.4, -0.1
30508, 1.6166666666667, 0.375, -0.1
30509, 1.5958333333333, 0.35, -0.1
30510, 1.6166666666667, 0.325, -0.1
30511, 1.5958333333333, 0.3, -0.1
30512, 1.6166666666667, 0.275, -0.1
30513, 1.5958333333333, 0.25, -0.1
30514, 1.6166666666667, 0.225, -0.1
30515, 1.5958333333333, 0.2, -0.1
30516, 1.6166666666667, 0.175, -0.1
30517, 1.6583333333333, 1.325, -0.1
30518, 1.6375, 1.3, -0.1
30519, 1.6583333333333, 1.275, -0.1
30520, 1.6375, 1.25, -0.1
30521, 1.6583333333333, 1.225, -0.1
30522, 1.6375, 1.2, -0.1
30523, 1.6583333333333, 1.175, -0.1
30524, 1.6375, 1.15, -0.1
30525, 1.6583333333333, 1.125, -0.1
30526, 1.6375, 1.1, -0.1
30527, 1.6583333333333, 1.075, -0.1
30528, 1.6375, 1.05, -0.1
30529, 1.6583333333333, 1.025, -0.1
30530, 1.6375, 1, -0.1
30531, 1.6583333333333, 0.975, -0.1
30532, 1.6375, 0.95, -0.1
30533, 1.6583333333333, 0.925, -0.1
30534, 1.6375, 0.9, -0.1
30535, 1.6583333333333, 0.875, -0.1
30536, 1.6375, 0.85, -0.1
30537, 1.6583333333333, 0.825, -0.1
30538, 1.6375, 0.8, -0.1
30539, 1.6583333333333, 0.775, -0.1
30540, 1.6375, 0.75, -0.1
30541, 1.6583333333333, 0.725, -0.1
30542, 1.6375, 0.7, -0.1
30543, 1.6583333333333, 0.675, -0.1
30544, 1.6375, 0.65, -0.1
30545, 1.6583333333333, 0.625, -0.1
30546, 1.6375, 0.6, -0.1
30547, 1.6583333333333, 0.575, -0.1
30548, 1.6375, 0.55, -0.1
30549, 1.6583333333333, 0.525, -0.1
30550, 1.6375, 0.5, -0.1
30551, 1.6583333333333, 0.475, -0.1
30552, 1.6375, 0.45, -0.1
30553, 1.6583333333333, 0.425, -0.1
30554, 1.6375, 0.4, -0.1
30555, 1.6583333333333, 0.375, -0.1
30556, 1.6375, 0.35, -0.1
30557, 1.6583333333333, 0.325, -0.1
30558, 1.6375, 0.3, -0.1
30559, 1.6583333333333, 0.275, -0.1
30560, 1.6375, 0.25, -0.1
30561, 1.6583333333333, 0.225, -0.1
30562, 1.6375, 0.2, -0.1
30563, 1.6583333333333, 0.175, -0.1
30564, 1.7, 1.325, -0.1
30565, 1.6791666666667, 1.3, -0.1
30566, 1.7, 1.275, -0.1
30567, 1.6791666666667, 1.25, -0.1
30568, 1.7, 1.225, -0.1
30569, 1.6791666666667, 1.2, -0.1
30570, 1.7, 1.175, -0.1
30571, 1.6791666666667, 1.15, -0.1
30572, 1.7, 1.125, -0.1
30573, 1.6791666666667, 1.1, -0.1
30574, 1.7, 1.075, -0.1
30575, 1.6791666666667, 1.05, -0.1
30576, 1.7, 1.025, -0.1
30577, 1.6791666666667, 1, -0.1
30578, 1.7, 0.975, -0.1
30579, 1.6791666666667, 0.95, -0.1
30580, 1.7, 0.925, -0.1
30581, 1.6791666666667, 0.9, -0.1
30582, 1.7, 0.875, -0.1
30583, 1.6791666666667, 0.85, -0.1
30584, 1.7, 0.825, -0.1
30585, 1.6791666666667, 0.8, -0.1
30586, 1.7, 0.775, -0.1
30587, 1.6791666666667, 0.75, -0.1
30588, 1.7, 0.725, -0.1
30589, 1.6791666666667, 0.7, -0.1
30590, 1.7, 0.675, -0.1
30591, 1.6791666666667, 0.65, -0.1
30592, 1.7, 0.625, -0.1
30593, 1.6791666666667, 0.6, -0.1
30594, 1.7, 0.575, -0.1
30595, 1.6791666666667, 0.55, -0.1
30596, 1.7, 0.525, -0.1
30597, 1.6791666666667, 0.5, -0.1
30598, 1.7, 0.475, -0.1
30599, 1.6791666666667, 0.45, -0.1
30600, 1.7, 0.425, -0.1
30601, 1.6791666666667, 0.4, -0.1
30602, 1.7, 0.375, -0.1
30603, 1.6791666666667, 0.35, -0.1
30604, 1.7, 0.325, -0.1
30605, 1.6791666666667, 0.3, -0.1
30606, 1.7, 0.275, -0.1
30607, 1.6791666666667, 0.25, -0.1
30608, 1.7, 0.225, -0.1
30609, 1.6791666666667, 0.2, -0.1
30610, 1.7, 0.175, -0.1
30611, 1.7416666666667, 1.325, -0.1
30612, 1.7208333333333, 1.3, -0.1
30613, 1.7416666666667, 1.275, -0.1
30614, 1.7208333333333, 1.25, -0.1
30615, 1.7416666666667, 1.225, -0.1
30616, 1.7208333333333, 1.2, -0.1
30617, 1.7416666666667, 1.175, -0.1
30618, 1.7208333333333, 1.15, -0.1
30619, 1.7416666666667, 1.125, -0.1
30620, 1.7208333333333, 1.1, -0.1
30621, 1.7416666666667, 1.075, -0.1
30622, 1.7208333333333, 1.05, -0.1
30623, 1.7416666666667, 1.025, -0.1
30624, 1.7208333333333, 1, -0.1
30625, 1.7416666666667, 0.975, -0.1
30626, 1.7208333333333, 0.95, -0.1
30627, 1.7416666666667, 0.925, -0.1
30628, 1.7208333333333, 0.9, -0.1
30629, 1.7416666666667, 0.875, -0.1
30630, 1.7208333333333, 0.85, -0.1
30631, 1.7416666666667, 0.825, -0.1
30632, 1.7208333333333, 0.8, -0.1
30633, 1.7416666666667, 0.775, -0.1
30634, 1.7208333333333, 0.75, -0.1
30635, 1.7416666666667, 0.725, -0.1
30636, 1.7208333333333, 0.7, -0.1
30637, 1.7416666666667, 0.675, -0.1
30638, 1.7208333333333, 0.65, -0.1
30639, 1.7416666666667, 0.625, -0.1
30640, 1.7208333333333, 0.6, -0.1
30641, 1.7416666666667, 0.575, -0.1
30642, 1.7208333333333, 0.55, -0.1
30643, 1.7416666666667, 0.525, -0.1
30644, 1.7208333333333, 0.5, -0.1
30645, 1.7416666666667, 0.475, -0.1
30646, 1.7208333333333, 0.45, -0.1
30647, 1.7416666666667, 0.425, -0.1
30648, 1.7208333333333, 0.4, -0.1
30649, 1.7416666666667, 0.375, -0.1
30650, 1.7208333333333, 0.35, -0.1
30651, 1.7416666666667, 0.325, -0.1
30652, 1.7208333333333, 0.3, -0.1
30653, 1.7416666666667, 0.275, -0.1
30654, 1.7208333333333, 0.25, -0.1
30655, 1.7416666666667, 0.225, -0.1
30656, 1.7208333333333, 0.2, -0.1
30657, 1.7416666666667, 0.175, -0.1
30658, 1.7833333333333, 1.325, -0.1
30659, 1.7625, 1.3, -0.1
30660, 1.7833333333333, 1.275, -0.1
30661, 1.7625, 1.25, -0.1
30662, 1.7833333333333, 1.225, -0.1
30663, 1.7625, 1.2, -0.1
30664, 1.7833333333333, 1.175, -0.1
30665, 1.7625, 1.15, -0.1
30666, 1.7833333333333, 1.125, -0.1
30667, 1.7625, 1.1, -0.1
30668, 1.7833333333333, 1.075, -0.1
30669, 1.7625, 1.05, -0.1
30670, 1.7833333333333, 1.025, -0.1
30671, 1.7625, 1, -0.1
30672, 1.7833333333333, 0.975, -0.1
30673, 1.7625, 0.95, -0.1
30674, 1.7833333333333, 0.925, -0.1
30675, 1.7625, 0.9, -0.1
30676, 1.7833333333333, 0.875, -0.1
30677, 1.7625, 0.85, -0.1
30678, 1.7833333333333, 0.825, -0.1
30679, 1.7625, 0.8, -0.1
30680, 1.7833333333333, 0.775, -0.1
30681, 1.7625, 0.75, -0.1
30682, 1.7833333333333, 0.725, -0.1
30683, 1.7625, 0.7, -0.1
30684, 1.7833333333333, 0.675, -0.1
30685, 1.7625, 0.65, -0.1
30686, 1.7833333333333, 0.625, -0.1
30687, 1.7625, 0.6, -0.1
30688, 1.7833333333333, 0.575, -0.1
30689, 1.7625, 0.55, -0.1
30690, 1.7833333333333, 0.525, -0.1
30691, 1.7625, 0.5, -0.1
30692, 1.7833333333333, 0.475, -0.1
30693, 1.7625, 0.45, -0.1
30694, 1.7833333333333, 0.425, -0.1
30695, 1.7625, 0.4, -0.1
30696, 1.7833333333333, 0.375, -0.1
30697, 1.7625, 0.35, -0.1
30698, 1.7833333333333, 0.325, -0.1
30699, 1.7625, 0.3, -0.1
30700, 1.7833333333333, 0.275, -0.1
30701, 1.7625, 0.25, -0.1
30702, 1.7833333333333, 0.225, -0.1
30703, 1.7625, 0.2, -0.1
30704, 1.7833333333333, 0.175, -0.1
30705, 1.825, 1.325, -0.1
30706, 1.8041666666667, 1.3, -0.1
30707, 1.825, 1.275, -0.1
30708, 1.8041666666667, 1.25, -0.1
30709, 1.825, 1.225, -0.1
30710, 1.8041666666667, 1.2, -0.1
30711, 1.825, 1.175, -0.1
30712, 1.8041666666667, 1.15, -0.1
30713, 1.825, 1.125, -0.1
30714, 1.8041666666667, 1.1, -0.1
30715, 1.825, 1.075, -0.1
30716, 1.8041666666667, 1.05, -0.1
30717, 1.825, 1.025, -0.1
30718, 1.8041666666667, 1, -0.1
30719, 1.825, 0.975, -0.1
30720, 1.8041666666667, 0.95, -0.1
30721, 1.825, 0.925, -0.1
30722, 1.8041666666667, 0.9, -0.1
30723, 1.825, 0.875, -0.1
30724, 1.8041666666667, 0.85, -0.1
30725, 1.825, 0.825, -0.1
30726, 1.8041666666667, 0.8, -0.1
30727, 1.825, 0.775, -0.1
30728, 1.8041666666667, 0.75, -0.1
30729, 1.825, 0.725, -0.1
30730, 1.8041666666667, 0.7, -0.1
30731, 1.825, 0.675, -0.1
30732, 1.8041666666667, 0.65, -0.1
30733, 1.825, 0.625, -0.1
30734, 1.8041666666667, 0.6, -0.1
30735, 1.825, 0.575, -0.1
30736, 1.8041666666667, 0.55, -0.1
30737, 1.825, 0.525, -0.1
30738, 1.8041666666667, 0.5, -0.1
30739, 1.825, 0.475, -0.1
30740, 1.8041666666667, 0.45, -0.1
30741, 1.825, 0.425, -0.1
30742, 1.8041666666667, 0.4, -0.1
30743, 1.825, 0.375, -0.1
30744, 1.8041666666667, 0.35, -0.1
30745, 1.825, 0.325, -0.1
30746, 1.8041666666667, 0.3, -0.1
30747, 1.825, 0.275, -0.1
30748, 1.8041666666667, 0.25, -0.1
30749, 1.825, 0.225, -0.1
30750, 1.8041666666667, 0.2, -0.1
30751, 1.825, 0.175, -0.1
30752, 1.8666666666667, 1.325, -0.1
30753, 1.8458333333333, 1.3, -0.1
30754, 1.8666666666667, 1.275, -0.1
30755, 1.8458333333333, 1.25, -0.1
30756, 1.8666666666667, 1.225, -0.1
30757, 1.8458333333333, 1.2, -0.1
30758, 1.8666666666667, 1.175, -0.1
30759, 1.8458333333333, 1.15, -0.1
30760, 1.8666666666667, 1.125, -0.1
30761, 1.8458333333333, 1.1, -0.1
30762, 1.8666666666667, 1.075, -0.1
30763, 1.8458333333333, 1.05, -0.1
30764, 1.8666666666667, 1.025, -0.1
30765, 1.8458333333333, 1, -0.1
30766, 1.8666666666667, 0.975, -0.1
30767, 1.8458333333333, 0.95, -0.1
30768, 1.8666666666667, 0.925, -0.1
30769, 1.8458333333333, 0.9, -0.1
30770, 1.8666666666667, 0.875, -0.1
30771, 1.8458333333333, 0.85, -0.1
30772, 1.8666666666667, 0.825, -0.1
30773, 1.8458333333333, 0.8, -0.1
30774, 1.8666666666667, 0.775, -0.1
30775, 1.8458333333333, 0.75, -0.1
30776, 1.8666666666667, 0.725, -0.1
30777, 1.8458333333333, 0.7, -0.1
30778, 1.8666666666667, 0.675, -0.1
30779, 1.8458333333333, 0.65, -0.1
30780, 1.8666666666667, 0.625, -0.1
30781, 1.8458333333333, 0.6, -0.1
30782, 1.8666666666667, 0.575, -0.1
30783, 1.8458333333333, 0.55, -0.1
30784, 1.8666666666667, 0.525, -0.1
30785, 1.8458333333333, 0.5, -0.1
30786, 1.8666666666667, 0.475, -0.1
30787, 1.8458333333333, 0.45, -0.1
30788, 1.8666666666667, 0.425, -0.1
30789, 1.8458333333333, 0.4, -0.1
30790, 1.8666666666667, 0.375, -0.1
30791, 1.8458333333333, 0.35, -0.1
30792, 1.8666666666667, 0.325, -0.1
30793, 1.8458333333333, 0.3, -0.1
30794, 1.8666666666667, 0.275, -0.1
30795, 1.8458333333333, 0.25, -0.1
30796, 1.8666666666667, 0.225, -0.1
30797, 1.8458333333333, 0.2, -0.1
30798, 1.8666666666667, 0.175, -0.1
30799, 1.9083333333333, 1.325, -0.1
30800, 1.8875, 1.3, -0.1
30801, 1.9083333333333, 1.275, -0.1
30802, 1.8875, 1.25, -0.1
30803, 1.9083333333333, 1.225, -0.1
30804, 1.8875, 1.2, -0.1
30805, 1.9083333333333, 1.175, -0.1
30806, 1.8875, 1.15, -0.1
30807, 1.9083333333333, 1.125, -0.1
30808, 1.8875, 1.1, -0.1
30809, 1.9083333333333, 1.075, -0.1
30810, 1.8875, 1.05, -0.1
30811, 1.9083333333333, 1.025, -0.1
30812, 1.8875, 1, -0.1
30813, 1.9083333333333, 0.975, -0.1
30814, 1.8875, 0.95, -0.1
30815, 1.9083333333333, 0.925, -0.1
30816, 1.8875, 0.9, -0.1
30817, 1.9083333333333, 0.875, -0.1
30818, 1.8875, 0.85, -0.1
30819, 1.9083333333333, 0.825, -0.1
30820, 1.8875, 0.8, -0.1
30821, 1.9083333333333, 0.775, -0.1
30822, 1.8875, 0.75, -0.1
30823, 1.9083333333333, 0.725, -0.1
30824, 1.8875, 0.7, -0.1
30825, 1.9083333333333, 0.675, -0.1
30826, 1.8875, 0.65, -0.1
30827, 1.9083333333333, 0.625, -0.1
30828, 1.8875, 0.6, -0.1
30829, 1.9083333333333, 0.575, -0.1
30830, 1.8875, 0.55, -0.1
30831, 1.9083333333333, 0.525, -0.1
30832, 1.8875, 0.5, -0.1
30833, 1.9083333333333, 0.475, -0.1
30834, 1.8875, 0.45, -0.1
30835, 1.9083333333333, 0.425, -0.1
30836, 1.8875, 0.4, -0.1
30837, 1.9083333333333, 0.375, -0.1
30838, 1.8875, 0.35, -0.1
30839, 1.9083333333333, 0.325, -0.1
30840, 1.8875, 0.3, -0.1
30841, 1.9083333333333, 0.275, -0.1
30842, 1.8875, 0.25, -0.1
30843, 1.9083333333333, 0.225, -0.1
30844, 1.8875, 0.2, -0.1
30845, 1.9083333333333, 0.175, -0.1
30846, 1.95, 1.325, -0.1
30847, 1.9291666666667, 1.3, -0.1
30848, 1.95, 1.275, -0.1
30849, 1.9291666666667, 1.25, -0.1
30850, 1.95, 1.225, -0.1
30851, 1.9291666666667, 1.2, -0.1
30852, 1.95, 1.175, -0.1
30853, 1.9291666666667, 1.15, -0.1
30854, 1.95, 1.125, -0.1
30855, 1.9291666666667, 1.1, -0.1
30856, 1.95, 1.075, -0.1
30857, 1.9291666666667, 1.05, -0.1
30858, 1.95, 1.025, -0.1
30859, 1.9291666666667, 1, -0.1
30860, 1.95, 0.975, -0.1
30861, 1.9291666666667, 0.95, -0.1
30862, 1.95, 0.925, -0.1
30863, 1.9291666666667, 0.9, -0.1
30864, 1.95, 0.875, -0.1
30865, 1.9291666666667, 0.85, -0.1
30866, 1.95, 0.825, -0.1
30867, 1.9291666666667, 0.8, -0.1
30868, 1.95, 0.775, -0.1
30869, 1.9291666666667, 0.75, -0.1
30870, 1.95, 0.725, -0.1
30871, 1.9291666666667, 0.7, -0.1
30872, 1.95, 0.675, -0.1
30873, 1.9291666666667, 0.65, -0.1
30874, 1.95, 0.625, -0.1
30875, 1.9291666666667, 0.6, -0.1
30876, 1.95, 0.575, -0.1
30877, 1.9291666666667, 0.55, -0.1
30878, 1.95, 0.525, -0.1
30879, 1.9291666666667, 0.5, -0.1
30880, 1.95, 0.475, -0.1
30881, 1.9291666666667, 0.45, -0.1
30882, 1.95, 0.425, -0.1
30883, 1.9291666666667, 0.4, -0.1
30884, 1.95, 0.375, -0.1
30885, 1.9291666666667, 0.35, -0.1
30886, 1.95, 0.325, -0.1
30887, 1.9291666666667, 0.3, -0.1
30888, 1.95, 0.275, -0.1
30889, 1.9291666666667, 0.25, -0.1
30890, 1.95, 0.225, -0.1
30891, 1.9291666666667, 0.2, -0.1
30892, 1.95, 0.175, -0.1
30893, 1.9916666666667, 1.325, -0.1
30894, 1.9708333333333, 1.3, -0.1
30895, 1.9916666666667, 1.275, -0.1
30896, 1.9708333333333, 1.25, -0.1
30897, 1.9916666666667, 1.225, -0.1
30898, 1.9708333333333, 1.2, -0.1
30899, 1.9916666666667, 1.175, -0.1
30900, 1.9708333333333, 1.15, -0.1
30901, 1.9916666666667, 1.125, -0.1
30902, 1.9708333333333, 1.1, -0.1
30903, 1.9916666666667, 1.075, -0.1
30904, 1.9708333333333, 1.05, -0.1
30905, 1.9916666666667, 1.025, -0.1
30906, 1.9708333333333, 1, -0.1
30907, 1.9916666666667, 0.975, -0.1
30908, 1.9708333333333, 0.95, -0.1
30909, 1.9916666666667, 0.925, -0.1
30910, 1.9708333333333, 0.9, -0.1
30911, 1.9916666666667, 0.875, -0.1
30912, 1.9708333333333, 0.85, -0.1
30913, 1.9916666666667, 0.825, -0.1
30914, 1.9708333333333, 0.8, -0.1
30915, 1.9916666666667, 0.775, -0.1
30916, 1.9708333333333, 0.75, -0.1
30917, 1.9916666666667, 0.725, -0.1
30918, 1.9708333333333, 0.7, -0.1
30919, 1.9916666666667, 0.675, -0.1
30920, 1.9708333333333, 0.65, -0.1
30921, 1.9916666666667, 0.625, -0.1
30922, 1.9708333333333, 0.6, -0.1
30923, 1.9916666666667, 0.575, -0.1
30924, 1.9708333333333, 0.55, -0.1
30925, 1.9916666666667, 0.525, -0.1
30926, 1.9708333333333, 0.5, -0.1
30927, 1.9916666666667, 0.475, -0.1
30928, 1.9708333333333, 0.45, -0.1
30929, 1.9916666666667, 0.425, -0.1
30930, 1.9708333333333, 0.4, -0.1
30931, 1.9916666666667, 0.375, -0.1
30932, 1.9708333333333, 0.35, -0.1
30933, 1.9916666666667, 0.325, -0.1
30934, 1.9708333333333, 0.3, -0.1
30935, 1.9916666666667, 0.275, -0.1
30936, 1.9708333333333, 0.25, -0.1
30937, 1.9916666666667, 0.225, -0.1
30938, 1.9708333333333, 0.2, -0.1
30939, 1.9916666666667, 0.175, -0.1
30940, 2.0333333333333, 1.325, -0.1
30941, 2.0125, 1.3, -0.1
30942, 2.0333333333333, 1.275, -0.1
30943, 2.0125, 1.25, -0.1
30944, 2.0333333333333, 1.225, -0.1
30945, 2.0125, 1.2, -0.1
30946, 2.0333333333333, 1.175, -0.1
30947, 2.0125, 1.15, -0.1
30948, 2.0333333333333, 1.125, -0.1
30949, 2.0125, 1.1, -0.1
30950, 2.0333333333333, 1.075, -0.1
30951, 2.0125, 1.05, -0.1
30952, 2.0333333333333, 1.025, -0.1
30953, 2.0125, 1, -0.1
30954, 2.0333333333333, 0.975, -0.1
30955, 2.0125, 0.95, -0.1
30956, 2.0333333333333, 0.925, -0.1
30957, 2.0125, 0.9, -0.1
30958, 2.0333333333333, 0.875, -0.1
30959, 2.0125, 0.85, -0.1
30960, 2.0333333333333, 0.825, -0.1
30961, 2.0125, 0.8, -0.1
30962, 2.0333333333333, 0.775, -0.1
30963, 2.0125, 0.75, -0.1
30964, 2.0333333333333, 0.725, -0.1
30965, 2.0125, 0.7, -0.1
30966, 2.0333333333333, 0.675, -0.1
30967, 2.0125, 0.65, -0.1
30968, 2.0333333333333, 0.625, -0.1
30969, 2.0125, 0.6, -0.1
30970, 2.0333333333333, 0.575, -0.1
30971, 2.0125, 0.55, -0.1
30972, 2.0333333333333, 0.525, -0.1
30973, 2.0125, 0.5, -0.1
30974, 2.0333333333333, 0.475, -0.1
30975, 2.0125, 0.45, -0.1
30976, 2.0333333333333, 0.425, -0.1
30977, 2.0125, 0.4, -0.1
30978, 2.0333333333333, 0.375, -0.1
30979, 2.0125, 0.35, -0.1
30980, 2.0333333333333, 0.325, -0.1
30981, 2.0125, 0.3, -0.1
30982, 2.0333333333333, 0.275, -0.1
30983, 2.0125, 0.25, -0.1
30984, 2.0333333333333, 0.225, -0.1
30985, 2.0125, 0.2, -0.1
30986, 2.0333333333333, 0.175, -0.1
30987, 2.075, 1.325, -0.1
30988, 2.0541666666667, 1.3, -0.1
30989, 2.075, 1.275, -0.1
30990, 2.0541666666667, 1.25, -0.1
30991, 2.075, 1.225, -0.1
30992, 2.0541666666667, 1.2, -0.1
30993, 2.075, 1.175, -0.1
30994, 2.0541666666667, 1.15, -0.1
30995, 2.075, 1.125, -0.1
30996, 2.0541666666667, 1.1, -0.1
30997, 2.075, 1.075, -0.1
30998, 2.0541666666667, 1.05, -0.1
30999, 2.075, 1.025, -0.1
31000, 2.0541666666667, 1, -0.1
31001, 2.075, 0.975, -0.1
31002, 2.0541666666667, 0.95, -0.1
31003, 2.075, 0.925, -0.1
31004, 2.0541666666667, 0.9, -0.1
31005, 2.075, 0.875, -0.1
31006, 2.0541666666667, 0.85, -0.1
31007, 2.075, 0.825, -0.1
31008, 2.0541666666667, 0.8, -0.1
31009, 2.075, 0.775, -0.1
31010, 2.0541666666667, 0.75, -0.1
31011, 2.075, 0.725, -0.1
31012, 2.0541666666667, 0.7, -0.1
31013, 2.075, 0.675, -0.1
31014, 2.0541666666667, 0.65, -0.1
31015, 2.075, 0.625, -0.1
31016, 2.0541666666667, 0.6, -0.1
31017, 2.075, 0.575, -0.1
31018, 2.0541666666667, 0.55, -0.1
31019, 2.075, 0.525, -0.1
31020, 2.0541666666667, 0.5, -0.1
31021, 2.075, 0.475, -0.1
31022, 2.0541666666667, 0.45, -0.1
31023, 2.075, 0.425, -0.1
31024, 2.0541666666667, 0.4, -0.1
31025, 2.075, 0.375, -0.1
31026, 2.0541666666667, 0.35, -0.1
31027, 2.075, 0.325, -0.1
31028, 2.0541666666667, 0.3, -0.1
31029, 2.075, 0.275, -0.1
31030, 2.0541666666667, 0.25, -0.1
31031, 2.075, 0.225, -0.1
31032, 2.0541666666667, 0.2, -0.1
31033, 2.075, 0.175, -0.1
31034, 2.1166666666667, 1.325, -0.1
31035, 2.0958333333333, 1.3, -0.1
31036, 2.1166666666667, 1.275, -0.1
31037, 2.0958333333333, 1.25, -0.1
31038, 2.1166666666667, 1.225, -0.1
31039, 2.0958333333333, 1.2, -0.1
31040, 2.1166666666667, 1.175, -0.1
31041, 2.0958333333333, 1.15, -0.1
31042, 2.1166666666667, 1.125, -0.1
31043, 2.0958333333333, 1.1, -0.1
31044, 2.1166666666667, 1.075, -0.1
31045, 2.0958333333333, 1.05, -0.1
31046, 2.1166666666667, 1.025, -0.1
31047, 2.0958333333333, 1, -0.1
31048, 2.1166666666667, 0.975, -0.1
31049, 2.0958333333333, 0.95, -0.1
31050, 2.1166666666667, 0.925, -0.1
31051, 2.0958333333333, 0.9, -0.1
31052, 2.1166666666667, 0.875, -0.1
31053, 2.0958333333333, 0.85, -0.1
31054, 2.1166666666667, 0.825, -0.1
31055, 2.0958333333333, 0.8, -0.1
31056, 2.1166666666667, 0.775, -0.1
31057, 2.0958333333333, 0.75, -0.1
31058, 2.1166666666667, 0.725, -0.1
31059, 2.0958333333333, 0.7, -0.1
31060, 2.1166666666667, 0.675, -0.1
31061, 2.0958333333333, 0.65, -0.1
31062, 2.1166666666667, 0.625, -0.1
31063, 2.0958333333333, 0.6, -0.1
31064, 2.1166666666667, 0.575, -0.1
31065, 2.0958333333333, 0.55, -0.1
31066, 2.1166666666667, 0.525, -0.1
31067, 2.0958333333333, 0.5, -0.1
31068, 2.1166666666667, 0.475, -0.1
31069, 2.0958333333333, 0.45, -0.1
31070, 2.1166666666667, 0.425, -0.1
31071, 2.0958333333333, 0.4, -0.1
31072, 2.1166666666667, 0.375, -0.1
31073, 2.0958333333333, 0.35, -0.1
31074, 2.1166666666667, 0.325, -0.1
31075, 2.0958333333333, 0.3, -0.1
31076, 2.1166666666667, 0.275, -0.1
31077, 2.0958333333333, 0.25, -0.1
31078, 2.1166666666667, 0.225, -0.1
31079, 2.0958333333333, 0.2, -0.1
31080, 2.1166666666667, 0.175, -0.1
31081, 2.1583333333333, 1.325, -0.1
31082, 2.1375, 1.3, -0.1
31083, 2.1583333333333, 1.275, -0.1
31084, 2.1375, 1.25, -0.1
31085, 2.1583333333333, 1.225, -0.1
31086, 2.1375, 1.2, -0.1
31087, 2.1583333333333, 1.175, -0.1
31088, 2.1375, 1.15, -0.1
31089, 2.1583333333333, 1.125, -0.1
31090, 2.1375, 1.1, -0.1
31091, 2.1583333333333, 1.075, -0.1
31092, 2.1375, 1.05, -0.1
31093, 2.1583333333333, 1.025, -0.1
31094, 2.1375, 1, -0.1
31095, 2.1583333333333, 0.975, -0.1
31096, 2.1375, 0.95, -0.1
31097, 2.1583333333333, 0.925, -0.1
31098, 2.1375, 0.9, -0.1
31099, 2.1583333333333, 0.875, -0.1
31100, 2.1375, 0.85, -0.1
31101, 2.1583333333333, 0.825, -0.1
31102, 2.1375, 0.8, -0.1
31103, 2.1583333333333, 0.775, -0.1
31104, 2.1375, 0.75, -0.1
31105, 2.1583333333333, 0.725, -0.1
31106, 2.1375, 0.7, -0.1
31107, 2.1583333333333, 0.675, -0.1
31108, 2.1375, 0.65, -0.1
31109, 2.1583333333333, 0.625, -0.1
31110, 2.1375, 0.6, -0.1
31111, 2.1583333333333, 0.575, -0.1
31112, 2.1375, 0.55, -0.1
31113, 2.1583333333333, 0.525, -0.1
31114, 2.1375, 0.5, -0.1
31115, 2.1583333333333, 0.475, -0.1
31116, 2.1375, 0.45, -0.1
31117, 2.1583333333333, 0.425, -0.1
31118, 2.1375, 0.4, -0.1
31119, 2.1583333333333, 0.375, -0.1
31120, 2.1375, 0.35, -0.1
31121, 2.1583333333333, 0.325, -0.1
31122, 2.1375, 0.3, -0.1
31123, 2.1583333333333, 0.275, -0.1
31124, 2.1375, 0.25, -0.1
31125, 2.1583333333333, 0.225, -0.1
31126, 2.1375, 0.2, -0.1
31127, 2.1583333333333, 0.175, -0.1
31128, 2.1791666666667, 1.3, -0.1
31129, 2.1791666666667, 1.25, -0.1
31130, 2.1791666666667, 1.2, -0.1
31131, 2.1791666666667, 1.15, -0.1
31132, 2.1791666666667, 1.1, -0.1
31133, 2.1791666666667, 1.05, -0.1
31134, 2.1791666666667, 1, -0.1
31135, 2.1791666666667, 0.95, -0.1
31136, 2.1791666666667, 0.9, -0.1
31137, 2.1791666666667, 0.85, -0.1
31138, 2.1791666666667, 0.8, -0.1
31139, 2.1791666666667, 0.75, -0.1
31140, 2.1791666666667, 0.7, -0.1
31141, 2.1791666666667, 0.65, -0.1
31142, 2.1791666666667, 0.6, -0.1
31143, 2.1791666666667, 0.55, -0.1
31144, 2.1791666666667, 0.5, -0.1
31145, 2.1791666666667, 0.45, -0.1
31146, 2.1791666666667, 0.4, -0.1
31147, 2.1791666666667, 0.35, -0.1
31148, 2.1791666666667, 0.3, -0.1
31149, 2.1791666666667, 0.25, -0.1
31150, 2.1791666666667, 0.2, -0.1
31151, 1.15, 1.3, -0.05
31152, 1.15, 1.25, -0.05
31153, 1.15, 1.2, -0.05
31154, 1.15, 1.15, -0.05
31155, 1.15, 1.1, -0.05
31156, 1.15, 1.05, -0.05
31157, 1.15, 1, -0.05
31158, 1.15, 0.95, -0.05
31159, 1.15, 0.9, -0.05
31160, 1.15, 0.85, -0.05
31161, 1.15, 0.8, -0.05
31162, 1.15, 0.75, -0.05
31163, 1.15, 0.7, -0.05
31164, 1.15, 0.65, -0.05
31165, 1.15, 0.6, -0.05
31166, 1.15, 0.55, -0.05
31167, 1.15, 0.5, -0.05
31168, 1.15, 0.45, -0.05
31169, 1.15, 0.4, -0.05
31170, 1.15, 0.35, -0.05
31171, 1.15, 0.3, -0.05
31172, 1.15, 0.25, -0.05
31173, 1.15, 0.2, -0.05
31174, 1.175, 1.3, -0.1
31175, 1.175, 1.25, -0.1
31176, 1.175, 1.2, -0.1
31177, 1.175, 1.15, -0.1
31178, 1.175, 1.1, -0.1
31179, 1.175, 1.05, -0.1
31180, 1.175, 1, -0.1
31181, 1.175, 0.95, -0.1
31182, 1.175, 0.9, -0.1
31183, 1.175, 0.85, -0.1
31184, 1.175, 0.8, -0.1
31185, 1.175, 0.75, -0.1
31186, 1.175, 0.7, -0.1
31187, 1.175, 0.65, -0.1
31188, 1.175, 0.6, -0.1
31189, 1.175, 0.55, -0.1
31190, 1.175, 0.5, -0.1
31191, 1.175, 0.45, -0.1
31192, 1.175, 0.4, -0.1
31193, 1.175, 0.35, -0.1
31194, 1.175, 0.3, -0.1
31195, 1.175, 0.25, -0.1
31196, 1.175, 0.2, -0.1
31197, 1.05, 0.2, -0.05
31198, 1.05, 0.25, -0.05
31199, 1.05, 0.3, -0.05
31200, 1.05, 0.35, -0.05
31201, 1.05, 0.4, -0.05
31202, 1.05, 0.45, -0.05
31203, 1.05, 0.5, -0.05
31204, 1.05, 0.55, -0.05
31205, 1.05, 0.6, -0.05
31206, 1.05, 0.65, -0.05
31207, 1.05, 0.7, -0.05
31208, 1.05, 0.75, -0.05
31209, 1.05, 0.8, -0.05
31210, 1.05, 0.85, -0.05
31211, 1.05, 0.9, -0.05
31212, 1.05, 0.95, -0.05
31213, 1.05, 1, -0.05
31214, 1.05, 1.05, -0.05
31215, 1.05, 1.1, -0.05
31216, 1.05, 1.15, -0.05
31217, 1.05, 1.2, -0.05
31218, 1.05, 1.25, -0.05
31219, 1.05, 1.3, -0.05
31220, 1.025, 0.2, -0.1
31221, 1.025, 0.25, -0.1
31222, 1.025, 0.3, -0.1
31223, 1.025, 0.35, -0.1
31224, 1.025, 0.4, -0.1
31225, 1.025, 0.45, -0.1
31226, 1.025, 0.5, -0.1
31227, 1.025, 0.55, -0.1
31228, 1.025, 0.6, -0.1
31229, 1.025, 0.65, -0.1
31230, 1.025, 0.7, -0.1
31231, 1.025, 0.75, -0.1
31232, 1.025, 0.8, -0.1
31233, 1.025, 0.85, -0.1
31234, 1.025, 0.9, -0.1
31235, 1.025, 0.95, -0.1
31236, 1.025, 1, -0.1
31237, 1.025, 1.05, -0.1
31238, 1.025, 1.1, -0.1
31239, 1.025, 1.15, -0.1
31240, 1.025, 1.2, -0.1
31241, 1.025, 1.25, -0.1
31242, 1.025, 1.3, -0.1
31243, 0.041666666666667, 1.54, 0
31244, 0.041666666666667, 1.58, 0
31245, 0.041666666666667, 1.62, 0
31246, 0.041666666666667, 1.66, 0
31247, 0.083333333333333, 1.54, 0
31248, 0.083333333333333, 1.58, 0
31249, 0.083333333333333, 1.62, 0
31250, 0.083333333333333, 1.66, 0
31251, 0.125, 1.54, 0
31252, 0.125, 1.58, 0
31253, 0.125, 1.62, 0
31254, 0.125, 1.66, 0
31255, 0.16666666666667, 1.54, 0
31256, 0.16666666666667, 1.58, 0
31257, 0.16666666666667, 1.62, 0
31258, 0.16666666666667, 1.66, 0
31259, 0.20833333333333, 1.54, 0
31260, 0.20833333333333, 1.58, 0
31261, 0.20833333333333, 1.62, 0
31262, 0.20833333333333, 1.66, 0
31263, 0.25, 1.54, 0
31264, 0.25, 1.58, 0
31265, 0.25, 1.62, 0
31266, 0.25, 1.66, 0
31267, 0.29166666666667, 1.54, 0
31268, 0.29166666666667, 1.58, 0
31269, 0.29166666666667, 1.62, 0
31270, 0.29166666666667, 1.66, 0
31271, 0.33333333333333, 1.54, 0
31272, 0.33333333333333, 1.58, 0
31273, 0.33333333333333, 1.62, 0
31274, 0.33333333333333, 1.66, 0
31275, 0.375, 1.54, 0
31276, 0.375, 1.58, 0
31277, 0.375, 1.62, 0
31278, 0.375, 1.66, 0
31279, 0.41666666666667, 1.54, 0
31280, 0.41666666666667, 1.58, 0
31281, 0.41666666666667, 1.62, 0
31282, 0.41666666666667, 1.66, 0
31283, 0.45833333333333, 1.54, 0
31284, 0.45833333333333, 1.58, 0
31285, 0.45833333333333, 1.62, 0
31286, 0.45833333333333, 1.66, 0
31287, 0.5, 1.54, 0
31288, 0.5, 1.58, 0
31289, 0.5, 1.62, 0
31290, 0.5, 1.66, 0
31291, 0.54166666666667, 1.54, 0
31292, 0.54166666666667, 1.58, 0
31293, 0.54166666666667, 1.62, 0
31294, 0.54166666666667, 1.66, 0
31295, 0.58333333333333, 1.54, 0
31296, 0.58333333333333, 1.58, 0
31297, 0.58333333333333, 1.62, 0
31298, 0.58333333333333, 1.66, 0
31299, 0.625, 1.54, 0
31300, 0.625, 1.58, 0
31301, 0.625, 1.62, 0
31302, 0.625, 1.66, 0
31303, 0.66666666666667, 1.54, 0
31304, 0.66666666666667, 1.58, 0
31305, 0.66666666666667, 1.62, 0
31306, 0.66666666666667, 1.66, 0
31307, 0.70833333333333, 1.54, 0
31308, 0.70833333333333, 1.58, 0
31309, 0.70833333333333, 1.62, 0
31310, 0.70833333333333, 1.66, 0
31311, 0.75, 1.54, 0
31312, 0.75, 1.58, 0
31313, 0.75, 1.62, 0
31314, 0.75, 1.66, 0
31315, 0.79166666666667, 1.54, 0
31316, 0.79166666666667, 1.58, 0
31317, 0.79166666666667, 1.62, 0
31318, 0.79166666666667, 1.66, 0
31319, 0.83333333333333, 1.54, 0
31320, 0.83333333333333, 1.58, 0
31321, 0.83333333333333, 1.62, 0
31322, 0.83333333333333, 1.66, 0
31323, 0.875, 1.54, 0
31324, 0.875, 1.58, 0
31325, 0.875, 1.62, 0
31326, 0.875, 1.66, 0
31327, 0.91666666666667, 1.54, 0
31328, 0.91666666666667, 1.58, 0
31329, 0.91666666666667, 1.62, 0
31330, 0.91666666666667, 1.66, 0
31331, 0.95833333333333, 1.54, 0
31332, 0.95833333333333, 1.58, 0
31333, 0.95833333333333, 1.62, 0
31334, 0.95833333333333, 1.66, 0
31335, 0.020833333333333, 1.54, 0
31336, 0.041666666666667, 1.52, 0
31337, 0.020833333333333, 1.58, 0
31338, 0.041666666666667, 1.56, 0
31339, 0.020833333333333, 1.62, 0
31340, 0.041666666666667, 1.6, 0
31341, 0.020833333333333, 1.66, 0
31342, 0.041666666666667, 1.64, 0
31343, 0.041666666666667, 1.68, 0
31344, 0.0625, 1.54, 0
31345, 0.083333333333333, 1.52, 0
31346, 0.0625, 1.58, 0
31347, 0.083333333333333, 1.56, 0
31348, 0.0625, 1.62, 0
31349, 0.083333333333333, 1.6, 0
31350, 0.0625, 1.66, 0
31351, 0.083333333333333, 1.64, 0
31352, 0.083333333333333, 1.68, 0
31353, 0.10416666666667, 1.54, 0
31354, 0.125, 1.52, 0
31355, 0.10416666666667, 1.58, 0
31356, 0.125, 1.56, 0
31357, 0.10416666666667, 1.62, 0
31358, 0.125, 1.6, 0
31359, 0.10416666666667, 1.66, 0
31360, 0.125, 1.64, 0
31361, 0.125, 1.68, 0
31362, 0.14583333333333, 1.54, 0
31363, 0.16666666666667, 1.52, 0
31364, 0.14583333333333, 1.58, 0
31365, 0.16666666666667, 1.56, 0
31366, 0.14583333333333, 1.62, 0
31367, 0.16666666666667, 1.6, 0
31368, 0.14583333333333, 1.66, 0
31369, 0.16666666666667, 1.64, 0
31370, 0.16666666666667, 1.68, 0
31371, 0.1875, 1.54, 0
31372, 0.20833333333333, 1.52, 0
31373, 0.1875, 1.58, 0
31374, 0.20833333333333, 1.56, 0
31375, 0.1875, 1.62, 0
31376, 0.20833333333333, 1.6, 0
31377, 0.1875, 1.66, 0
31378, 0.20833333333333, 1.64, 0
31379, 0.20833333333333, 1.68, 0
31380, 0.22916666666667, 1.54, 0
31381, 0.25, 1.52, 0
31382, 0.22916666666667, 1.58, 0
31383, 0.25, 1.56, 0
31384, 0.22916666666667, 1.62, 0
31385, 0.25, 1.6, 0
31386, 0.22916666666667, 1.66, 0
31387, 0.25, 1.64, 0
31388, 0.25, 1.68, 0
31389, 0.27083333333333, 1.54, 0
31390, 0.29166666666667, 1.52, 0
31391, 0.27083333333333, 1.58, 0
31392, 0.29166666666667, 1.56, 0
31393, 0.27083333333333, 1.62, 0
31394, 0.29166666666667, 1.6, 0
31395, 0.27083333333333, 1.66, 0
31396, 0.29166666666667, 1.64, 0
31397, 0.29166666666667, 1.68, 0
31398, 0.3125, 1.54, 0
31399, 0.33333333333333, 1.52, 0
31400, 0.3125, 1.58, 0
31401, 0.33333333333333, 1.56, 0
31402, 0.3125, 1.62, 0
31403, 0.33333333333333, 1.6, 0
31404, 0.3125, 1.66, 0
31405, 0.33333333333333, 1.64, 0
31406, 0.33333333333333, 1.68, 0
31407, 0.35416666666667, 1.54, 0
31408, 0.375, 1.52, 0
31409, 0.35416666666667, 1.58, 0
31410, 0.375, 1.56, 0
31411, 0.35416666666667, 1.62, 0
31412, 0.375, 1.6, 0
31413, 0.35416666666667, 1.66, 0
31414, 0.375, 1.64, 0
31415, 0.375, 1.68, 0
31416, 0.39583333333333, 1.54, 0
31417, 0.41666666666667, 1.52, 0
31418, 0.39583333333333, 1.58, 0
31419, 0.41666666666667, 1.56, 0
31420, 0.39583333333333, 1.62, 0
31421, 0.41666666666667, 1.6, 0
31422, 0.39583333333333, 1.66, 0
31423, 0.41666666666667, 1.64, 0
31424, 0.41666666666667, 1.68, 0
31425, 0.4375, 1.54, 0
31426, 0.45833333333333, 1.52, 0
31427, 0.4375, 1.58, 0
31428, 0.45833333333333, 1.56, 0
31429, 0.4375, 1.62, 0
31430, 0.45833333333333, 1.6, 0
31431, 0.4375, 1.66, 0
31432, 0.45833333333333, 1.64, 0
31433, 0.45833333333333, 1.68, 0
31434, 0.47916666666667, 1.54, 0
31435, 0.5, 1.52, 0
31436, 0.47916666666667, 1.58, 0
31437, 0.5, 1.56, 0
31438, 0.47916666666667, 1.62, 0
31439, 0.5, 1.6, 0
31440, 0.47916666666667, 1.66, 0
31441, 0.5, 1.64, 0
31442, 0.5, 1.68, 0
31443, 0.52083333333333, 1.54, 0
31444, 0.54166666666667, 1.52, 0
31445, 0.52083333333333, 1.58, 0
31446, 0.54166666666667, 1.56, 0
31447, 0.52083333333333, 1.62, 0
31448, 0.54166666666667, 1.6, 0
31449, 0.52083333333333, 1.66, 0
31450, 0.54166666666667, 1.64, 0
31451, 0.54166666666667, 1.68, 0
31452, 0.5625, 1.54, 0
31453, 0.58333333333333, 1.52, 0
31454, 0.5625, 1.58, 0
31455, 0.58333333333333, 1.56, 0
31456, 0.5625, 1.62, 0
31457, 0.58333333333333, 1.6, 0
31458, 0.5625, 1.66, 0
31459, 0.58333333333333, 1.64, 0
31460, 0.58333333333333, 1.68, 0
31461, 0.60416666666667, 1.54, 0
31462, 0.625, 1.52, 0
31463, 0.60416666666667, 1.58, 0
31464, 0.625, 1.56, 0
31465, 0.60416666666667, 1.62, 0
31466, 0.625, 1.6, 0
31467, 0.60416666666667, 1.66, 0
31468, 0.625, 1.64, 0
31469, 0.625, 1.68, 0
31470, 0.64583333333333, 1.54, 0
31471, 0.66666666666667, 1.52, 0
31472, 0.64583333333333, 1.58, 0
31473, 0.66666666666667, 1.56, 0
31474, 0.64583333333333, 1.62, 0
31475, 0.66666666666667, 1.6, 0
31476, 0.64583333333333, 1.66, 0
31477, 0.66666666666667, 1.64, 0
31478, 0.66666666666667, 1.68, 0
31479, 0.6875, 1.54, 0
31480, 0.70833333333333, 1.52, 0
31481, 0.6875, 1.58, 0
31482, 0.70833333333333, 1.56, 0
31483, 0.6875, 1.62, 0
31484, 0.70833333333333, 1.6, 0
31485, 0.6875, 1.66, 0
31486, 0.70833333333333, 1.64, 0
31487, 0.70833333333333, 1.68, 0
31488, 0.72916666666667, 1.54, 0
31489, 0.75, 1.52, 0
31490, 0.72916666666667, 1.58, 0
31491, 0.75, 1.56, 0
31492, 0.72916666666667, 1.62, 0
31493, 0.75, 1.6, 0
31494, 0.72916666666667, 1.66, 0
31495, 0.75, 1.64, 0
31496, 0.75, 1.68, 0
31497, 0.77083333333333, 1.54, 0
31498, 0.79166666666667, 1.52, 0
31499, 0.77083333333333, 1.58, 0
31500, 0.79166666666667, 1.56, 0
31501, 0.77083333333333, 1.62, 0
31502, 0.79166666666667, 1.6, 0
31503, 0.77083333333333, 1.66, 0
31504, 0.79166666666667, 1.64, 0
31505, 0.79166666666667, 1.68, 0
31506, 0.8125, 1.54, 0
31507, 0.83333333333333, 1.52, 0
31508, 0.8125, 1.58, 0
31509, 0.83333333333333, 1.56, 0
31510, 0.8125, 1.62, 0
31511, 0.83333333333333, 1.6, 0
31512, 0.8125, 1.66, 0
31513, 0.83333333333333, 1.64, 0
31514, 0.83333333333333, 1.68, 0
31515, 0.85416666666667, 1.54, 0
31516, 0.875, 1.52, 0
31517, 0.85416666666667, 1.58, 0
31518, 0.875, 1.56, 0
31519, 0.85416666666667, 1.62, 0
31520, 0.875, 1.6, 0
31521, 0.85416666666667, 1.66, 0
31522, 0.875, 1.64, 0
31523, 0.875, 1.68, 0
31524, 0.89583333333333, 1.54, 0
31525, 0.91666666666667, 1.52, 0
31526, 0.89583333333333, 1.58, 0
31527, 0.91666666666667, 1.56, 0
31528, 0.89583333333333, 1.62, 0
31529, 0.91666666666667, 1.6, 0
31530, 0.89583333333333, 1.66, 0
31531, 0.91666666666667, 1.64, 0
31532, 0.91666666666667, 1.68, 0
31533, 0.9375, 1.54, 0
31534, 0.95833333333333, 1.52, 0
31535, 0.9375, 1.58, 0
31536, 0.95833333333333, 1.56, 0
31537, 0.9375, 1.62, 0
31538, 0.95833333333333, 1.6, 0
31539, 0.9375, 1.66, 0
31540, 0.95833333333333, 1.64, 0
31541, 0.95833333333333, 1.68, 0
31542, 0.97916666666667, 1.54, 0
31543, 0.97916666666667, 1.58, 0
31544, 0.97916666666667, 1.62, 0
31545, 0.97916666666667, 1.66, 0
31546, 1, 1.54, 0.041666666666667
31547, 1, 1.58, 0.041666666666667
31548, 1, 1.62, 0.041666666666667
31549, 1, 1.66, 0.041666666666667
31550, 1, 1.54, 0.083333333333333
31551, 1, 1.58, 0.083333333333333
31552, 1, 1.62, 0.083333333333333
31553, 1, 1.66, 0.083333333333333
31554, 1, 1.54, 0.125
31555, 1, 1.58, 0.125
31556, 1, 1.62, 0.125
31557, 1, 1.66, 0.125
31558, 1, 1.54, 0.16666666666667
31559, 1, 1.58, 0.16666666666667
31560, 1, 1.62, 0.16666666666667
31561, 1, 1.66, 0.16666666666667
31562, 1, 1.54, 0.20833333333333
31563, 1, 1.58, 0.20833333333333
31564, 1, 1.62, 0.20833333333333
31565, 1, 1.66, 0.20833333333333
31566, 1, 1.54, 0.25
31567, 1, 1.58, 0.25
31568, 1, 1.62, 0.25
31569, 1, 1.66, 0.25
31570, 1, 1.54, 0.29166666666667
31571, 1, 1.58, 0.29166666666667
31572, 1, 1.62, 0.29166666666667
31573, 1, 1.66, 0.29166666666667
31574, 1, 1.54, 0.33333333333333
31575, 1, 1.58, 0.33333333333333
31576, 1, 1.62, 0.33333333333333
31577, 1, 1.66, 0.33333333333333
31578, 1, 1.54, 0.375
31579, 1, 1.58, 0.375
31580, 1, 1.62, 0.375
31581, 1, 1.66, 0.375
31582, 1, 1.54, 0.41666666666667
31583, 1, 1.58, 0.41666666666667
31584, 1, 1.62, 0.41666666666667
31585, 1, 1.66, 0.41666666666667
31586, 1, 1.54, 0.45833333333333
31587, 1, 1.58, 0.45833333333333
31588, 1, 1.62, 0.45833333333333
31589, 1, 1.66, 0.45833333333333
31590, 1, 1.54, 0.020833333333333
31591, 1, 1.52, 0.041666666666667
31592, 1, 1.58, 0.020833333333333
31593, 1, 1.56, 0.041666666666667
31594, 1, 1.62, 0.020833333333333
31595, 1, 1.6, 0.041666666666667
31596, 1, 1.66, 0.020833333333333
31597, 1, 1.64, 0.041666666666667
31598, 1, 1.68, 0.041666666666667
31599, 1, 1.54, 0.0625
31600, 1, 1.52, 0.083333333333333
31601, 1, 1.58, 0.0625
31602, 1, 1.56, 0.083333333333333
31603, 1, 1.62, 0.0625
31604, 1, 1.6, 0.083333333333333
31605, 1, 1.66, 0.0625
31606, 1, 1.64, 0.083333333333333
31607, 1, 1.68, 0.083333333333333
31608, 1, 1.54, 0.10416666666667
31609, 1, 1.52, 0.125
31610, 1, 1.58, 0.10416666666667
31611, 1, 1.56, 0.125
31612, 1, 1.62, 0.10416666666667
31613, 1, 1.6, 0.125
31614, 1, 1.66, 0.10416666666667
31615, 1, 1.64, 0.125
31616, 1, 1.68, 0.125
31617, 1, 1.54, 0.14583333333333
31618, 1, 1.52, 0.16666666666667
31619, 1, 1.58, 0.14583333333333
31620, 1, 1.56, 0.16666666666667
31621, 1, 1.62, 0.14583333333333
31622, 1, 1.6, 0.16666666666667
31623, 1, 1.66, 0.14583333333333
31624, 1, 1.64, 0.16666666666667
31625, 1, 1.68, 0.16666666666667
31626, 1, 1.54, 0.1875
31627, 1, 1.52, 0.20833333333333
31628, 1, 1.58, 0.1875
31629, 1, 1.56, 0.20833333333333
31630, 1, 1.62, 0.1875
31631, 1, 1.6, 0.20833333333333
31632, 1, 1.66, 0.1875
31633, 1, 1.64, 0.20833333333333
31634, 1, 1.68, 0.20833333333333
31635, 1, 1.54, 0.22916666666667
31636, 1, 1.52, 0.25
31637, 1, 1.58, 0.22916666666667
31638, 1, 1.56, 0.25
31639, 1, 1.62, 0.22916666666667
31640, 1, 1.6, 0.25
31641, 1, 1.66, 0.22916666666667
31642, 1, 1.64, 0.25
31643, 1, 1.68, 0.25
31644, 1, 1.54, 0.27083333333333
31645, 1, 1.52, 0.29166666666667
31646, 1, 1.58, 0.27083333333333
31647, 1, 1.56, 0.29166666666667
31648, 1, 1.62, 0.27083333333333
31649, 1, 1.6, 0.29166666666667
31650, 1, 1.66, 0.27083333333333
31651, 1, 1.64, 0.29166666666667
31652, 1, 1.68, 0.29166666666667
31653, 1, 1.54, 0.3125
31654, 1, 1.52, 0.33333333333333
31655, 1, 1.58, 0.3125
31656, 1, 1.56, 0.33333333333333
31657, 1, 1.62, 0.3125
31658, 1, 1.6, 0.33333333333333
31659, 1, 1.66, 0.3125
31660, 1, 1.64, 0.33333333333333
31661, 1, 1.68, 0.33333333333333
31662, 1, 1.54, 0.35416666666667
31663, 1, 1.52, 0.375
31664, 1, 1.58, 0.35416666666667
31665, 1, 1.56, 0.375
31666, 1, 1.62, 0.35416666666667
31667, 1, 1.6, 0.375
31668, 1, 1.66, 0.35416666666667
31669, 1, 1.64, 0.375
31670, 1, 1.68, 0.375
31671, 1, 1.54, 0.39583333333333
31672, 1, 1.52, 0.41666666666667
31673, 1, 1.58, 0.39583333333333
31674, 1, 1.56, 0.41666666666667
31675, 1, 1.62, 0.39583333333333
31676, 1, 1.6, 0.41666666666667
31677, 1, 1.66, 0.39583333333333
31678, 1, 1.64, 0.41666666666667
31679, 1, 1.68, 0.41666666666667
31680, 1, 1.54, 0.4375
31681, 1, 1.52, 0.45833333333333
31682, 1, 1.58, 0.4375
31683, 1, 1.56, 0.45833333333333
31684, 1, 1.62, 0.4375
31685, 1, 1.6, 0.45833333333333
31686, 1, 1.66, 0.4375
31687, 1, 1.64, 0.45833333333333
31688, 1, 1.68, 0.45833333333333
31689, 1, 1.54, 0.47916666666667
31690, 1, 1.58, 0.47916666666667
31691, 1, 1.62, 0.47916666666667
31692, 1, 1.66, 0.47916666666667
31693, 0.041666666666667, 1.54, 0.5
31694, 0.041666666666667, 1.58, 0.5
31695, 0.041666666666667, 1.62, 0.5
31696, 0.041666666666667, 1.66, 0.5
31697, 0.083333333333333, 1.54, 0.5
31698, 0.083333333333333, 1.58, 0.5
31699, 0.083333333333333, 1.62, 0.5
31700, 0.083333333333333, 1.66, 0.5
31701, 0.125, 1.54, 0.5
31702, 0.125, 1.58, 0.5
31703, 0.125, 1.62, 0.5
31704, 0.125, 1.66, 0.5
31705, 0.16666666666667, 1.54, 0.5
31706, 0.16666666666667, 1.58, 0.5
31707, 0.16666666666667, 1.62, 0.5
31708, 0.16666666666667, 1.66, 0.5
31709, 0.20833333333333, 1.54, 0.5
31710, 0.20833333333333, 1.58, 0.5
31711, 0.20833333333333, 1.62, 0.5
31712, 0.20833333333333, 1.66, 0.5
31713, 0.25, 1.54, 0.5
31714, 0.25, 1.58, 0.5
31715, 0.25, 1.62, 0.5
31716, 0.25, 1.66, 0.5
31717, 0.29166666666667, 1.54, 0.5
31718, 0.29166666666667, 1.58, 0.5
31719, 0.29166666666667, 1.62, 0.5
31720, 0.29166666666667, 1.66, 0.5
31721, 0.33333333333333, 1.54, 0.5
31722, 0.33333333333333, 1.58, 0.5
31723, 0.33333333333333, 1.62, 0.5
31724, 0.33333333333333, 1.66, 0.5
31725, 0.375, 1.54, 0.5
31726, 0.375, 1.58, 0.5
31727, 0.375, 1.62, 0.5
31728, 0.375, 1.66, 0.5
31729, 0.41666666666667, 1.54, 0.5
31730, 0.41666666666667, 1.58, 0.5
31731, 0.41666666666667, 1.62, 0.5
31732, 0.41666666666667, 1.66, 0.5
31733, 0.45833333333333, 1.54, 0.5
31734, 0.45833333333333, 1.58, 0.5
31735, 0.45833333333333, 1.62, 0.5
31736, 0.45833333333333, 1.66, 0.5
31737, 0.5, 1.54, 0.5
31738, 0.5, 1.58, 0.5
31739, 0.5, 1.62, 0.5
31740, 0.5, 1.66, 0.5
31741, 0.54166666666667, 1.54, 0.5
31742, 0.54166666666667, 1.58, 0.5
31743, 0.54166666666667, 1.62, 0.5
31744, 0.54166666666667, 1.66, 0.5
31745, 0.58333333333333, 1.54, 0.5
31746, 0.58333333333333, 1.58, 0.5
31747, 0.58333333333333, 1.62, 0.5
31748, 0.58333333333333, 1.66, 0.5
31749, 0.625, 1.54, 0.5
31750, 0.625, 1.58, 0.5
31751, 0.625, 1.62, 0.5
31752, 0.625, 1.66, 0.5
31753, 0.66666666666667, 1.54, 0.5
31754, 0.66666666666667, 1.58, 0.5
31755, 0.66666666666667, 1.62, 0.5
31756, 0.66666666666667, 1.66, 0.5
31757, 0.70833333333333, 1.54, 0.5
31758, 0.70833333333333, 1.58, 0.5
31759, 0.70833333333333, 1.62, 0.5
31760, 0.70833333333333, 1.66, 0.5
31761, 0.75, 1.54, 0.5
31762, 0.75, 1.58, 0.5
31763, 0.75, 1.62, 0.5
31764, 0.75, 1.66, 0.5
31765, 0.79166666666667, 1.54, 0.5
31766, 0.79166666666667, 1.58, 0.5
31767, 0.79166666666667, 1.62, 0.5
31768, 0.79166666666667, 1.66, 0.5
31769, 0.83333333333333, 1.54, 0.5
31770, 0.83333333333333, 1.58, 0.5
31771, 0.83333333333333, 1.62, 0.5
31772, 0.83333333333333, 1.66, 0.5
31773, 0.875, 1.54, 0.5
31774, 0.875, 1.58, 0.5
31775, 0.875, 1.62, 0.5
31776, 0.875, 1.66, 0.5
31777, 0.91666666666667, 1.54, 0.5
31778, 0.91666666666667, 1.58, 0.5
31779, 0.91666666666667, 1.62, 0.5
31780, 0.91666666666667, 1.66, 0.5
31781, 0.95833333333333, 1.54, 0.5
31782, 0.95833333333333, 1.58, 0.5
31783, 0.95833333333333, 1.62, 0.5
31784, 0.95833333333333, 1.66, 0.5
31785, 0.041666666666667, 1.52, 0.5
31786, 0.020833333333333, 1.54, 0.5
31787, 0.041666666666667, 1.56, 0.5
31788, 0.020833333333333, 1.58, 0.5
31789, 0.041666666666667, 1.6, 0.5
31790, 0.020833333333333, 1.62, 0.5
31791, 0.041666666666667, 1.64, 0.5
31792, 0.020833333333333, 1.66, 0.5
31793, 0.041666666666667, 1.68, 0.5
31794, 0.083333333333333, 1.52, 0.5
31795, 0.0625, 1.54, 0.5
31796, 0.083333333333333, 1.56, 0.5
31797, 0.0625, 1.58, 0.5
31798, 0.083333333333333, 1.6, 0.5
31799, 0.0625, 1.62, 0.5
31800, 0.083333333333333, 1.64, 0.5
31801, 0.0625, 1.66, 0.5
31802, 0.083333333333333, 1.68, 0.5
31803, 0.125, 1.52, 0.5
31804, 0.10416666666667, 1.54, 0.5
31805, 0.125, 1.56, 0.5
31806, 0.10416666666667, 1.58, 0.5
31807, 0.125, 1.6, 0.5
31808, 0.10416666666667, 1.62, 0.5
31809, 0.125, 1.64, 0.5
31810, 0.10416666666667, 1.66, 0.5
31811, 0.125, 1.68, 0.5
31812, 0.16666666666667, 1.52, 0.5
31813, 0.14583333333333, 1.54, 0.5
31814, 0.16666666666667, 1.56, 0.5
31815, 0.14583333333333, 1.58, 0.5
31816, 0.16666666666667, 1.6, 0.5
31817, 0.14583333333333, 1.62, 0.5
31818, 0.16666666666667, 1.64, 0.5
31819, 0.14583333333333, 1.66, 0.5
31820, 0.16666666666667, 1.68, 0.5
31821, 0.20833333333333, 1.52, 0.5
31822, 0.1875, 1.54, 0.5
31823, 0.20833333333333, 1.56, 0.5
31824, 0.1875, 1.58, 0.5
31825, 0.20833333333333, 1.6, 0.5
31826, 0.1875, 1.62, 0.5
31827, 0.20833333333333, 1.64, 0.5
31828, 0.1875, 1.66, 0.5
31829, 0.20833333333333, 1.68, 0.5
31830, 0.25, 1.52, 0.5
31831, 0.22916666666667, 1.54, 0.5
31832, 0.25, 1.56, 0.5
31833, 0.22916666666667, 1.58, 0.5
31834, 0.25, 1.6, 0.5
31835, 0.22916666666667, 1.62, 0.5
31836, 0.25, 1.64, 0.5
31837, 0.22916666666667, 1.66, 0.5
31838, 0.25, 1.68, 0.5
31839, 0.29166666666667, 1.52, 0.5
31840, 0.27083333333333, 1.54, 0.5
31841, 0.29166666666667, 1.56, 0.5
31842, 0.27083333333333, 1.58, 0.5
31843, 0.29166666666667, 1.6, 0.5
31844, 0.27083333333333, 1.62, 0.5
31845, 0.29166666666667, 1.64, 0.5
31846, 0.27083333333333, 1.66, 0.5
31847, 0.29166666666667, 1.68, 0.5
31848, 0.33333333333333, 1.52, 0.5
31849, 0.3125, 1.54, 0.5
31850, 0.33333333333333, 1.56, 0.5
31851, 0.3125, 1.58, 0.5
31852, 0.33333333333333, 1.6, 0.5
31853, 0.3125, 1.62, 0.5
31854, 0.33333333333333, 1.64, 0.5
31855, 0.3125, 1.66, 0.5
31856, 0.33333333333333, 1.68, 0.5
31857, 0.375, 1.52, 0.5
31858, 0.35416666666667, 1.54, 0.5
31859, 0.375, 1.56, 0.5
31860, 0.35416666666667, 1.58, 0.5
31861, 0.375, 1.6, 0.5
31862, 0.35416666666667, 1.62, 0.5
31863, 0.375, 1.64, 0.5
31864, 0.35416666666667, 1.66, 0.5
31865, 0.375, 1.68, 0.5
31866, 0.41666666666667, 1.52, 0.5
31867, 0.39583333333333, 1.54, 0.5
31868, 0.41666666666667, 1.56, 0.5
31869, 0.39583333333333, 1.58, 0.5
31870, 0.41666666666667, 1.6, 0.5
31871, 0.39583333333333, 1.62, 0.5
31872, 0.41666666666667, 1.64, 0.5
31873, 0.39583333333333, 1.66, 0.5
31874, 0.41666666666667, 1.68, 0.5
31875, 0.45833333333333, 1.52, 0.5
31876, 0.4375, 1.54, 0.5
31877, 0.45833333333333, 1.56, 0.5
31878, 0.4375, 1.58, 0.5
31879, 0.45833333333333, 1.6, 0.5
31880, 0.4375, 1.62, 0.5
31881, 0.45833333333333, 1.64, 0.5
31882, 0.4375, 1.66, 0.5
31883, 0.45833333333333, 1.68, 0.5
31884, 0.5, 1.52, 0.5
31885, 0.47916666666667, 1.54, 0.5
31886, 0.5, 1.56, 0.5
31887, 0.47916666666667, 1.58, 0.5
31888, 0.5, 1.6, 0.5
31889, 0.47916666666667, 1.62, 0.5
31890, 0.5, 1.64, 0.5
31891, 0.47916666666667, 1.66, 0.5
31892, 0.5, 1.68, 0.5
31893, 0.54166666666667, 1.52, 0.5
31894, 0.52083333333333, 1.54, 0.5
31895, 0.54166666666667, 1.56, 0.5
31896, 0.52083333333333, 1.58, 0.5
31897, 0.54166666666667, 1.6, 0.5
31898, 0.52083333333333, 1.62, 0.5
31899, 0.54166666666667, 1.64, 0.5
31900, 0.52083333333333, 1.66, 0.5
31901, 0.54166666666667, 1.68, 0.5
31902, 0.58333333333333, 1.52, 0.5
31903, 0.5625, 1.54, 0.5
31904, 0.58333333333333, 1.56, 0.5
31905, 0.5625, 1.58, 0.5
31906, 0.58333333333333, 1.6, 0.5
31907, 0.5625, 1.62, 0.5
31908, 0.58333333333333, 1.64, 0.5
31909, 0.5625, 1.66, 0.5
31910, 0.58333333333333, 1.68, 0.5
31911, 0.625, 1.52, 0.5
31912, 0.60416666666667, 1.54, 0.5
31913, 0.625, 1.56, 0.5
31914, 0.60416666666667, 1.58, 0.5
31915, 0.625, 1.6, 0.5
31916, 0.60416666666667, 1.62, 0.5
31917, 0.625, 1.64, 0.5
31918, 0.60416666666667, 1.66, 0.5
31919, 0.625, 1.68, 0.5
31920, 0.66666666666667, 1.52, 0.5
31921, 0.64583333333333, 1.54, 0.5
31922, 0.66666666666667, 1.56, 0.5
31923, 0.64583333333333, 1.58, 0.5
31924, 0.66666666666667, 1.6, 0.5
31925, 0.64583333333333, 1.62, 0.5
31926, 0.66666666666667, 1.64, 0.5
31927, 0.64583333333333, 1.66, 0.5
31928, 0.66666666666667, 1.68, 0.5
31929, 0.70833333333333, 1.52, 0.5
31930, 0.6875, 1.54, 0.5
31931, 0.70833333333333, 1.56, 0.5
31932, 0.6875, 1.58, 0.5
31933, 0.70833333333333, 1.6, 0.5
31934, 0.6875, 1.62, 0.5
31935, 0.70833333333333, 1.64, 0.5
31936, 0.6875, 1.66, 0.5
31937, 0.70833333333333, 1.68, 0.5
31938, 0.75, 1.52, 0.5
31939, 0.72916666666667, 1.54, 0.5
31940, 0.75, 1.56, 0.5
31941, 0.72916666666667, 1.58, 0.5
31942, 0.75, 1.6, 0.5
31943, 0.72916666666667, 1.62, 0.5
31944, 0.75, 1.64, 0.5
31945, 0.72916666666667, 1.66, 0.5
31946, 0.75, 1.68, 0.5
31947, 0.79166666666667, 1.52, 0.5
31948, 0.77083333333333, 1.54, 0.5
31949, 0.79166666666667, 1.56, 0.5
31950, 0.77083333333333, 1.58, 0.5
31951, 0.79166666666667, 1.6, 0.5
31952, 0.77083333333333, 1.62, 0.5
31953, 0.79166666666667, 1.64, 0.5
31954, 0.77083333333333, 1.66, 0.5
31955, 0.79166666666667, 1.68, 0.5
31956, 0.83333333333333, 1.52, 0.5
31957, 0.8125, 1.54, 0.5
31958, 0.83333333333333, 1.56, 0.5
31959, 0.8125, 1.58, 0.5
31960, 0.83333333333333, 1.6, 0.5
31961, 0.8125, 1.62, 0.5
31962, 0.83333333333333, 1.64, 0.5
31963, 0.8125, 1.66, 0.5
31964, 0.83333333333333, 1.68, 0.5
31965, 0.875, 1.52, 0.5
31966, 0.85416666666667, 1.54, 0.5
31967, 0.875, 1.56, 0.5
31968, 0.85416666666667, 1.58, 0.5
31969, 0.875, 1.6, 0.5
31970, 0.85416666666667, 1.62, 0.5
31971, 0.875, 1.64, 0.5
31972, 0.85416666666667, 1.66, 0.5
31973, 0.875, 1.68, 0.5
31974, 0.91666666666667, 1.52, 0.5
31975, 0.89583333333333, 1.54, 0.5
31976, 0.91666666666667, 1.56, 0.5
31977, 0.89583333333333, 1.58, 0.5
31978, 0.91666666666667, 1.6, 0.5
31979, 0.89583333333333, 1.62, 0.5
31980, 0.91666666666667, 1.64, 0.5
31981, 0.89583333333333, 1.66, 0.5
31982, 0.91666666666667, 1.68, 0.5
31983, 0.95833333333333, 1.52, 0.5
31984, 0.9375, 1.54, 0.5
31985, 0.95833333333333, 1.56, 0.5
31986, 0.9375, 1.58, 0.5
31987, 0.95833333333333, 1.6, 0.5
31988, 0.9375, 1.62, 0.5
31989, 0.95833333333333, 1.64, 0.5
31990, 0.9375, 1.66, 0.5
31991, 0.95833333333333, 1.68, 0.5
31992, 0.97916666666667, 1.54, 0.5
31993, 0.97916666666667, 1.58, 0.5
31994, 0.97916666666667, 1.62, 0.5
31995, 0.97916666666667, 1.66, 0.5
31996, 0, 1.54, 0.041666666666667
31997, 0, 1.58, 0.041666666666667
31998, 0, 1.62, 0.041666666666667
31999, 0, 1.66, 0.041666666666667
32000, 0, 1.54, 0.083333333333333
32001, 0, 1.58, 0.083333333333333
32002, 0, 1.62, 0.083333333333333
32003, 0, 1.66, 0.083333333333333
32004, 0, 1.54, 0.125
32005, 0, 1.58, 0.125
32006, 0, 1.62, 0.125
32007, 0, 1.66, 0.125
32008, 0, 1.54, 0.16666666666667
32009, 0, 1.58, 0.16666666666667
32010, 0, 1.62, 0.16666666666667
32011, 0, 1.66, 0.16666666666667
32012, 0, 1.54, 0.20833333333333
32013, 0, 1.58, 0.20833333333333
32014, 0, 1.62, 0.20833333333333
32015, 0, 1.66, 0.20833333333333
32016, 0, 1.54, 0.25
32017, 0, 1.58, 0.25
32018, 0, 1.62, 0.25
32019, 0, 1.66, 0.25
32020, 0, 1.54, 0.29166666666667
32021, 0, 1.58, 0.29166666666667
32022, 0, 1.62, 0.29166666666667
32023, 0, 1.66, 0.29166666666667
32024, 0, 1.54, 0.33333333333333
32025, 0, 1.58, 0.33333333333333
32026, 0, 1.62, 0.33333333333333
32027, 0, 1.66, 0.33333333333333
32028, 0, 1.54, 0.375
32029, 0, 1.58, 0.375
32030, 0, 1.62, 0.375
32031, 0, 1.66, 0.375
32032, 0, 1.54, 0.41666666666667
32033, 0, 1.58, 0.41666666666667
32034, 0, 1.62, 0.41666666666667
32035, 0, 1.66, 0.41666666666667
32036, 0, 1.54, 0.45833333333333
32037, 0, 1.58, 0.45833333333333
32038, 0, 1.62, 0.45833333333333
32039, 0, 1.66, 0.45833333333333
32040, 0, 1.52, 0.041666666666667
32041, 0, 1.54, 0.020833333333333
32042, 0, 1.56, 0.041666666666667
32043, 0, 1.58, 0.020833333333333
32044, 0, 1.6, 0.041666666666667
32045, 0, 1.62, 0.020833333333333
32046, 0, 1.64, 0.041666666666667
32047, 0, 1.66, 0.020833333333333
32048, 0, 1.68, 0.041666666666667
32049, 0, 1.52, 0.083333333333333
32050, 0, 1.54, 0.0625
32051, 0, 1.56, 0.083333333333333
32052, 0, 1.58, 0.0625
32053, 0, 1.6, 0.083333333333333
32054, 0, 1.62, 0.0625
32055, 0, 1.64, 0.083333333333333
32056, 0, 1.66, 0.0625
32057, 0, 1.68, 0.083333333333333
32058, 0, 1.52, 0.125
32059, 0, 1.54, 0.10416666666667
32060, 0, 1.56, 0.125
32061, 0, 1.58, 0.10416666666667
32062, 0, 1.6, 0.125
32063, 0, 1.62, 0.10416666666667
32064, 0, 1.64, 0.125
32065, 0, 1.66, 0.10416666666667
32066, 0, 1.68, 0.125
32067, 0, 1.52, 0.16666666666667
32068, 0, 1.54, 0.14583333333333
32069, 0, 1.56, 0.16666666666667
32070, 0, 1.58, 0.14583333333333
32071, 0, 1.6, 0.16666666666667
32072, 0, 1.62, 0.14583333333333
32073, 0, 1.64, 0.16666666666667
32074, 0, 1.66, 0.14583333333333
32075, 0, 1.68, 0.16666666666667
32076, 0, 1.52, 0.20833333333333
32077, 0, 1.54, 0.1875
32078, 0, 1.56, 0.20833333333333
32079, 0, 1.58, 0.1875
32080, 0, 1.6, 0.20833333333333
32081, 0, 1.62, 0.1875
32082, 0, 1.64, 0.20833333333333
32083, 0, 1.66, 0.1875
32084, 0, 1.68, 0.20833333333333
32085, 0, 1.52, 0.25
32086, 0, 1.54, 0.22916666666667
32087, 0, 1.56, 0.25
32088, 0, 1.58, 0.22916666666667
32089, 0, 1.6, 0.25
32090, 0, 1.62, 0.22916666666667
32091, 0, 1.64, 0.25
32092, 0, 1.66, 0.22916666666667
32093, 0, 1.68, 0.25
32094, 0, 1.52, 0.29166666666667
32095, 0, 1.54, 0.27083333333333
32096, 0, 1.56, 0.29166666666667
32097, 0, 1.58, 0.27083333333333
32098, 0, 1.6, 0.29166666666667
32099, 0, 1.62, 0.27083333333333
32100, 0, 1.64, 0.29166666666667
32101, 0, 1.66, 0.27083333333333
32102, 0, 1.68, 0.29166666666667
32103, 0, 1.52, 0.33333333333333
32104, 0, 1.54, 0.3125
32105, 0, 1.56, 0.33333333333333
32106, 0, 1.58, 0.3125
32107, 0, 1.6, 0.33333333333333
32108, 0, 1.62, 0.3125
32109, 0, 1.64, 0.33333333333333
32110, 0, 1.66, 0.3125
32111, 0, 1.68, 0.33333333333333
32112, 0, 1.52, 0.375
32113, 0, 1.54, 0.35416666666667
32114, 0, 1.56, 0.375
32115, 0, 1.58, 0.35416666666667
32116, 0, 1.6, 0.375
32117, 0, 1.62, 0.35416666666667
32118, 0, 1.64, 0.375
32119, 0, 1.66, 0.35416666666667
32120, 0, 1.68, 0.375
32121, 0, 1.52, 0.41666666666667
32122, 0, 1.54, 0.39583333333333
32123, 0, 1.56, 0.41666666666667
32124, 0, 1.58, 0.39583333333333
32125, 0, 1.6, 0.41666666666667
32126, 0, 1.62, 0.39583333333333
32127, 0, 1.64, 0.41666666666667
32128, 0, 1.66, 0.39583333333333
32129, 0, 1.68, 0.41666666666667
32130, 0, 1.52, 0.45833333333333
32131, 0, 1.54, 0.4375
32132, 0, 1.56, 0.45833333333333
32133, 0, 1.58, 0.4375
32134, 0, 1.6, 0.45833333333333
32135, 0, 1.62, 0.4375
32136, 0, 1.64, 0.45833333333333
32137, 0, 1.66, 0.4375
32138, 0, 1.68, 0.45833333333333
32139, 0, 1.54, 0.47916666666667
32140, 0, 1.58, 0.47916666666667
32141, 0, 1.62, 0.47916666666667
32142, 0, 1.66, 0.47916666666667
32143, 0.041666666666667, 1.7, 0.041666666666667
32144, 0.041666666666667, 1.7, 0.083333333333333
32145, 0.041666666666667, 1.7, 0.125
32146, 0.041666666666667, 1.7, 0.16666666666667
32147, 0.041666666666667, 1.7, 0.20833333333333
32148, 0.041666666666667, 1.7, 0.25
32149, 0.041666666666667, 1.7, 0.29166666666667
32150, 0.041666666666667, 1.7, 0.33333333333333
32151, 0.041666666666667, 1.7, 0.375
32152, 0.041666666666667, 1.7, 0.41666666666667
32153, 0.041666666666667, 1.7, 0.45833333333333
32154, 0.083333333333333, 1.7, 0.041666666666667
32155, 0.083333333333333, 1.7, 0.083333333333333
32156, 0.083333333333333, 1.7, 0.125
32157, 0.083333333333333, 1.7, 0.16666666666667
32158, 0.083333333333333, 1.7, 0.20833333333333
32159, 0.083333333333333, 1.7, 0.25
32160, 0.083333333333333, 1.7, 0.29166666666667
32161, 0.083333333333333, 1.7, 0.33333333333333
32162, 0.083333333333333, 1.7, 0.375
32163, 0.083333333333333, 1.7, 0.41666666666667
32164, 0.083333333333333, 1.7, 0.45833333333333
32165, 0.125, 1.7, 0.041666666666667
32166, 0.125, 1.7, 0.083333333333333
32167, 0.125, 1.7, 0.125
32168, 0.125, 1.7, 0.16666666666667
32169, 0.125, 1.7, 0.20833333333333
32170, 0.125, 1.7, 0.25
32171, 0.125, 1.7, 0.29166666666667
32172, 0.125, 1.7, 0.33333333333333
32173, 0.125, 1.7, 0.375
32174, 0.125, 1.7, 0.41666666666667
32175, 0.125, 1.7, 0.45833333333333
32176, 0.16666666666667, 1.7, 0.041666666666667
32177, 0.16666666666667, 1.7, 0.083333333333333
32178, 0.16666666666667, 1.7, 0.125
32179, 0.16666666666667, 1.7, 0.16666666666667
32180, 0.16666666666667, 1.7, 0.20833333333333
32181, 0.16666666666667, 1.7, 0.25
32182, 0.16666666666667, 1.7, 0.29166666666667
32183, 0.16666666666667, 1.7, 0.33333333333333
32184, 0.16666666666667, 1.7, 0.375
32185, 0.16666666666667, 1.7, 0.41666666666667
32186, 0.16666666666667, 1.7, 0.45833333333333
32187, 0.20833333333333, 1.7, 0.041666666666667
32188, 0.20833333333333, 1.7, 0.083333333333333
32189, 0.20833333333333, 1.7, 0.125
32190, 0.20833333333333, 1.7, 0.16666666666667
32191, 0.20833333333333, 1.7, 0.20833333333333
32192, 0.20833333333333, 1.7, 0.25
32193, 0.20833333333333, 1.7, 0.29166666666667
32194, 0.20833333333333, 1.7, 0.33333333333333
32195, 0.20833333333333, 1.7, 0.375
32196, 0.20833333333333, 1.7, 0.41666666666667
32197, 0.20833333333333, 1.7, 0.45833333333333
32198, 0.25, 1.7, 0.041666666666667
32199, 0.25, 1.7, 0.083333333333333
32200, 0.25, 1.7, 0.125
32201, 0.25, 1.7, 0.16666666666667
32202, 0.25, 1.7, 0.20833333333333
32203, 0.25, 1.7, 0.25
32204, 0.25, 1.7, 0.29166666666667
32205, 0.25, 1.7, 0.33333333333333
32206, 0.25, 1.7, 0.375
32207, 0.25, 1.7, 0.41666666666667
32208, 0.25, 1.7, 0.45833333333333
32209, 0.29166666666667, 1.7, 0.041666666666667
32210, 0.29166666666667, 1.7, 0.083333333333333
32211, 0.29166666666667, 1.7, 0.125
32212, 0.29166666666667, 1.7, 0.16666666666667
32213, 0.29166666666667, 1.7, 0.20833333333333
32214, 0.29166666666667, 1.7, 0.25
32215, 0.29166666666667, 1.7, 0.29166666666667
32216, 0.29166666666667, 1.7, 0.33333333333333
32217, 0.29166666666667, 1.7, 0.375
32218, 0.29166666666667, 1.7, 0.41666666666667
32219, 0.29166666666667, 1.7, 0.45833333333333
32220, 0.33333333333333, 1.7, 0.041666666666667
32221, 0.33333333333333, 1.7, 0.083333333333333
32222, 0.33333333333333, 1.7, 0.125
32223, 0.33333333333333, 1.7, 0.16666666666667
32224, 0.33333333333333, 1.7, 0.20833333333333
32225, 0.33333333333333, 1.7, 0.25
32226, 0.33333333333333, 1.7, 0.29166666666667
32227, 0.33333333333333, 1.7, 0.33333333333333
32228, 0.33333333333333, 1.7, 0.375
32229, 0.33333333333333, 1.7, 0.41666666666667
32230, 0.33333333333333, 1.7, 0.45833333333333
32231, 0.375, 1.7, 0.041666666666667
32232, 0.375, 1.7, 0.083333333333333
32233, 0.375, 1.7, 0.125
32234, 0.375, 1.7, 0.16666666666667
32235, 0.375, 1.7, 0.20833333333333
32236, 0.375, 1.7, 0.25
32237, 0.375, 1.7, 0.29166666666667
32238, 0.375, 1.7, 0.33333333333333
32239, 0.375, 1.7, 0.375
32240, 0.375, 1.7, 0.41666666666667
32241, 0.375, 1.7, 0.45833333333333
32242, 0.41666666666667, 1.7, 0.041666666666667
32243, 0.41666666666667, 1.7, 0.083333333333333
32244, 0.41666666666667, 1.7, 0.125
32245, 0.41666666666667, 1.7, 0.16666666666667
32246, 0.41666666666667, 1.7, 0.20833333333333
32247, 0.41666666666667, 1.7, 0.25
32248, 0.41666666666667, 1.7, 0.29166666666667
32249, 0.41666666666667, 1.7, 0.33333333333333
32250, 0.41666666666667, 1.7, 0.375
32251, 0.41666666666667, 1.7, 0.41666666666667
32252, 0.41666666666667, 1.7, 0.45833333333333
32253, 0.45833333333333, 1.7, 0.041666666666667
32254, 0.45833333333333, 1.7, 0.083333333333333
32255, 0.45833333333333, 1.7, 0.125
32256, 0.45833333333333, 1.7, 0.16666666666667
32257, 0.45833333333333, 1.7, 0.20833333333333
32258, 0.45833333333333, 1.7, 0.25
32259, 0.45833333333333, 1.7, 0.29166666666667
32260, 0.45833333333333, 1.7, 0.33333333333333
32261, 0.45833333333333, 1.7, 0.375
32262, 0.45833333333333, 1.7, 0.41666666666667
32263, 0.45833333333333, 1.7, 0.45833333333333
32264, 0.5, 1.7, 0.041666666666667
32265, 0.5, 1.7, 0.083333333333333
32266, 0.5, 1.7, 0.125
32267, 0.5, 1.7, 0.16666666666667
32268, 0.5, 1.7, 0.20833333333333
32269, 0.5, 1.7, 0.25
32270, 0.5, 1.7, 0.29166666666667
32271, 0.5, 1.7, 0.33333333333333
32272, 0.5, 1.7, 0.375
32273, 0.5, 1.7, 0.41666666666667
32274, 0.5, 1.7, 0.45833333333333
32275, 0.54166666666667, 1.7, 0.041666666666667
32276, 0.54166666666667, 1.7, 0.083333333333333
32277, 0.54166666666667, 1.7, 0.125
32278, 0.54166666666667, 1.7, 0.16666666666667
32279, 0.54166666666667, 1.7, 0.20833333333333
32280, 0.54166666666667, 1.7, 0.25
32281, 0.54166666666667, 1.7, 0.29166666666667
32282, 0.54166666666667, 1.7, 0.33333333333333
32283, 0.54166666666667, 1.7, 0.375
32284, 0.54166666666667, 1.7, 0.41666666666667
32285, 0.54166666666667, 1.7, 0.45833333333333
32286, 0.58333333333333, 1.7, 0.041666666666667
32287, 0.58333333333333, 1.7, 0.083333333333333
32288, 0.58333333333333, 1.7, 0.125
32289, 0.58333333333333, 1.7, 0.16666666666667
32290, 0.58333333333333, 1.7, 0.20833333333333
32291, 0.58333333333333, 1.7, 0.25
32292, 0.58333333333333, 1.7, 0.29166666666667
32293, 0.58333333333333, 1.7, 0.33333333333333
32294, 0.58333333333333, 1.7, 0.375
32295, 0.58333333333333, 1.7, 0.41666666666667
32296, 0.58333333333333, 1.7, 0.45833333333333
32297, 0.625, 1.7, 0.041666666666667
32298, 0.625, 1.7, 0.083333333333333
32299, 0.625, 1.7, 0.125
32300, 0.625, 1.7, 0.16666666666667
32301, 0.625, 1.7, 0.20833333333333
32302, 0.625, 1.7, 0.25
32303, 0.625, 1.7, 0.29166666666667
32304, 0.625, 1.7, 0.33333333333333
32305, 0.625, 1.7, 0.375
32306, 0.625, 1.7, 0.41666666666667
32307, 0.625, 1.7, 0.45833333333333
32308, 0.66666666666667, 1.7, 0.041666666666667
32309, 0.66666666666667, 1.7, 0.083333333333333
32310, 0.66666666666667, 1.7, 0.125
32311, 0.66666666666667, 1.7, 0.16666666666667
32312, 0.66666666666667, 1.7, 0.20833333333333
32313, 0.66666666666667, 1.7, 0.25
32314, 0.66666666666667, 1.7, 0.29166666666667
32315, 0.66666666666667, 1.7, 0.33333333333333
32316, 0.66666666666667, 1.7, 0.375
32317, 0.66666666666667, 1.7, 0.41666666666667
32318, 0.66666666666667, 1.7, 0.45833333333333
32319, 0.70833333333333, 1.7, 0.041666666666667
32320, 0.70833333333333, 1.7, 0.083333333333333
32321, 0.70833333333333, 1.7, 0.125
32322, 0.70833333333333, 1.7, 0.16666666666667
32323, 0.70833333333333, 1.7, 0.20833333333333
32324, 0.70833333333333, 1.7, 0.25
32325, 0.70833333333333, 1.7, 0.29166666666667
32326, 0.70833333333333, 1.7, 0.33333333333333
32327, 0.70833333333333, 1.7, 0.375
32328, 0.70833333333333, 1.7, 0.41666666666667
32329, 0.70833333333333, 1.7, 0.45833333333333
32330, 0.75, 1.7, 0.041666666666667
32331, 0.75, 1.7, 0.083333333333333
32332, 0.75, 1.7, 0.125
32333, 0.75, 1.7, 0.16666666666667
32334, 0.75, 1.7, 0.20833333333333
32335, 0.75, 1.7, 0.25
32336, 0.75, 1.7, 0.29166666666667
32337, 0.75, 1.7, 0.33333333333333
32338, 0.75, 1.7, 0.375
32339, 0.75, 1.7, 0.41666666666667
32340, 0.75, 1.7, 0.45833333333333
32341, 0.79166666666667, 1.7, 0.041666666666667
32342, 0.79166666666667, 1.7, 0.083333333333333
32343, 0.79166666666667, 1.7, 0.125
32344, 0.79166666666667, 1.7, 0.16666666666667
32345, 0.79166666666667, 1.7, 0.20833333333333
32346, 0.79166666666667, 1.7, 0.25
32347, 0.79166666666667, 1.7, 0.29166666666667
32348, 0.79166666666667, 1.7, 0.33333333333333
32349, 0.79166666666667, 1.7, 0.375
32350, 0.79166666666667, 1.7, 0.41666666666667
32351, 0.79166666666667, 1.7, 0.45833333333333
32352, 0.83333333333333, 1.7, 0.041666666666667
32353, 0.83333333333333, 1.7, 0.083333333333333
32354, 0.83333333333333, 1.7, 0.125
32355, 0.83333333333333, 1.7, 0.16666666666667
32356, 0.83333333333333, 1.7, 0.20833333333333
32357, 0.83333333333333, 1.7, 0.25
32358, 0.83333333333333, 1.7, 0.29166666666667
32359, 0.83333333333333, 1.7, 0.33333333333333
32360, 0.83333333333333, 1.7, 0.375
32361, 0.83333333333333, 1.7, 0.41666666666667
32362, 0.83333333333333, 1.7, 0.45833333333333
32363, 0.875, 1.7, 0.041666666666667
32364, 0.875, 1.7, 0.083333333333333
32365, 0.875, 1.7, 0.125
32366, 0.875, 1.7, 0.16666666666667
32367, 0.875, 1.7, 0.20833333333333
32368, 0.875, 1.7, 0.25
32369, 0.875, 1.7, 0.29166666666667
32370, 0.875, 1.7, 0.33333333333333
32371, 0.875, 1.7, 0.375
32372, 0.875, 1.7, 0.41666666666667
32373, 0.875, 1.7, 0.45833333333333
32374, 0.91666666666667, 1.7, 0.041666666666667
32375, 0.91666666666667, 1.7, 0.083333333333333
32376, 0.91666666666667, 1.7, 0.125
32377, 0.91666666666667, 1.7, 0.16666666666667
32378, 0.91666666666667, 1.7, 0.20833333333333
32379, 0.91666666666667, 1.7, 0.25
32380, 0.91666666666667, 1.7, 0.29166666666667
32381, 0.91666666666667, 1.7, 0.33333333333333
32382, 0.91666666666667, 1.7, 0.375
32383, 0.91666666666667, 1.7, 0.41666666666667
32384, 0.91666666666667, 1.7, 0.45833333333333
32385, 0.95833333333333, 1.7, 0.041666666666667
32386, 0.95833333333333, 1.7, 0.083333333333333
32387, 0.95833333333333, 1.7, 0.125
32388, 0.95833333333333, 1.7, 0.16666666666667
32389, 0.95833333333333, 1.7, 0.20833333333333
32390, 0.95833333333333, 1.7, 0.25
32391, 0.95833333333333, 1.7, 0.29166666666667
32392, 0.95833333333333, 1.7, 0.33333333333333
32393, 0.95833333333333, 1.7, 0.375
32394, 0.95833333333333, 1.7, 0.41666666666667
32395, 0.95833333333333, 1.7, 0.45833333333333
32396, 0.020833333333333, 1.7, 0.041666666666667
32397, 0.041666666666667, 1.7, 0.020833333333333
32398, 0.020833333333333, 1.7, 0.083333333333333
32399, 0.041666666666667, 1.7, 0.0625
32400, 0.020833333333333, 1.7, 0.125
32401, 0.041666666666667, 1.7, 0.10416666666667
32402, 0.020833333333333, 1.7, 0.16666666666667
32403, 0.041666666666667, 1.7, 0.14583333333333
32404, 0.020833333333333, 1.7, 0.20833333333333
32405, 0.041666666666667, 1.7, 0.1875
32406, 0.020833333333333, 1.7, 0.25
32407, 0.041666666666667, 1.7, 0.22916666666667
32408, 0.020833333333333, 1.7, 0.29166666666667
32409, 0.041666666666667, 1.7, 0.27083333333333
32410, 0.020833333333333, 1.7, 0.33333333333333
32411, 0.041666666666667, 1.7, 0.3125
32412, 0.020833333333333, 1.7, 0.375
32413, 0.041666666666667, 1.7, 0.35416666666667
32414, 0.020833333333333, 1.7, 0.41666666666667
32415, 0.041666666666667, 1.7, 0.39583333333333
32416, 0.020833333333333, 1.7, 0.45833333333333
32417, 0.041666666666667, 1.7, 0.4375
32418, 0.041666666666667, 1.7, 0.47916666666667
32419, 0.0625, 1.7, 0.041666666666667
32420, 0.083333333333333, 1.7, 0.020833333333333
32421, 0.0625, 1.7, 0.083333333333333
32422, 0.083333333333333, 1.7, 0.0625
32423, 0.0625, 1.7, 0.125
32424, 0.083333333333333, 1.7, 0.10416666666667
32425, 0.0625, 1.7, 0.16666666666667
32426, 0.083333333333333, 1.7, 0.14583333333333
32427, 0.0625, 1.7, 0.20833333333333
32428, 0.083333333333333, 1.7, 0.1875
32429, 0.0625, 1.7, 0.25
32430, 0.083333333333333, 1.7, 0.22916666666667
32431, 0.0625, 1.7, 0.29166666666667
32432, 0.083333333333333, 1.7, 0.27083333333333
32433, 0.0625, 1.7, 0.33333333333333
32434, 0.083333333333333, 1.7, 0.3125
32435, 0.0625, 1.7, 0.375
32436, 0.083333333333333, 1.7, 0.35416666666667
32437, 0.0625, 1.7, 0.41666666666667
32438, 0.083333333333333, 1.7, 0.39583333333333
32439, 0.0625, 1.7, 0.45833333333333
32440, 0.083333333333333, 1.7, 0.4375
32441, 0.083333333333333, 1.7, 0.47916666666667
32442, 0.10416666666667, 1.7, 0.041666666666667
32443, 0.125, 1.7, 0.020833333333333
32444, 0.10416666666667, 1.7, 0.083333333333333
32445, 0.125, 1.7, 0.0625
32446, 0.10416666666667, 1.7, 0.125
32447, 0.125, 1.7, 0.10416666666667
32448, 0.10416666666667, 1.7, 0.16666666666667
32449, 0.125, 1.7, 0.14583333333333
32450, 0.10416666666667, 1.7, 0.20833333333333
32451, 0.125, 1.7, 0.1875
32452, 0.10416666666667, 1.7, 0.25
32453, 0.125, 1.7, 0.22916666666667
32454, 0.10416666666667, 1.7, 0.29166666666667
32455, 0.125, 1.7, 0.27083333333333
32456, 0.10416666666667, 1.7, 0.33333333333333
32457, 0.125, 1.7, 0.3125
32458, 0.10416666666667, 1.7, 0.375
32459, 0.125, 1.7, 0.35416666666667
32460, 0.10416666666667, 1.7, 0.41666666666667
32461, 0.125, 1.7, 0.39583333333333
32462, 0.10416666666667, 1.7, 0.45833333333333
32463, 0.125, 1.7, 0.4375
32464, 0.125, 1.7, 0.47916666666667
32465, 0.14583333333333, 1.7, 0.041666666666667
32466, 0.16666666666667, 1.7, 0.020833333333333
32467, 0.14583333333333, 1.7, 0.083333333333333
32468, 0.16666666666667, 1.7, 0.0625
32469, 0.14583333333333, 1.7, 0.125
32470, 0.16666666666667, 1.7, 0.10416666666667
32471, 0.14583333333333, 1.7, 0.16666666666667
32472, 0.16666666666667, 1.7, 0.14583333333333
32473, 0.14583333333333, 1.7, 0.20833333333333
32474, 0.16666666666667, 1.7, 0.1875
32475, 0.14583333333333, 1.7, 0.25
32476, 0.16666666666667, 1.7, 0.22916666666667
32477, 0.14583333333333, 1.7, 0.29166666666667
32478, 0.16666666666667, 1.7, 0.27083333333333
32479, 0.14583333333333, 1.7, 0.33333333333333
32480, 0.16666666666667, 1.7, 0.3125
32481, 0.14583333333333, 1.7, 0.375
32482, 0.16666666666667, 1.7, 0.35416666666667
32483, 0.14583333333333, 1.7, 0.41666666666667
32484, 0.16666666666667, 1.7, 0.39583333333333
32485, 0.14583333333333, 1.7, 0.45833333333333
32486, 0.16666666666667, 1.7, 0.4375
32487, 0.16666666666667, 1.7, 0.47916666666667
32488, 0.1875, 1.7, 0.041666666666667
32489, 0.20833333333333, 1.7, 0.020833333333333
32490, 0.1875, 1.7, 0.083333333333333
32491, 0.20833333333333, 1.7, 0.0625
32492, 0.1875, 1.7, 0.125
32493, 0.20833333333333, 1.7, 0.10416666666667
32494, 0.1875, 1.7, 0.16666666666667
