44784, 0.625, 0.95, 0.083333333333333
44785, 0.625, 1, 0.083333333333333
44786, 0.625, 1.05, 0.083333333333333
44787, 0.625, 1.1, 0.083333333333333
44788, 0.625, 1.15, 0.083333333333333
44789, 0.625, 1.2, 0.083333333333333
44790, 0.625, 1.25, 0.083333333333333
44791, 0.625, 1.3, 0.083333333333333
44792, 0.625, 0.2, 0.125
44793, 0.625, 0.25, 0.125
44794, 0.625, 0.3, 0.125
44795, 0.625, 0.35, 0.125
44796, 0.625, 0.4, 0.125
44797, 0.625, 0.45, 0.125
44798, 0.625, 0.5, 0.125
44799, 0.625, 0.55, 0.125
44800, 0.625, 0.6, 0.125
44801, 0.625, 0.65, 0.125
44802, 0.625, 0.7, 0.125
44803, 0.625, 0.75, 0.125
44804, 0.625, 0.8, 0.125
44805, 0.625, 0.85, 0.125
44806, 0.625, 0.9, 0.125
44807, 0.625, 0.95, 0.125
44808, 0.625, 1, 0.125
44809, 0.625, 1.05, 0.125
44810, 0.625, 1.1, 0.125
44811, 0.625, 1.15, 0.125
44812, 0.625, 1.2, 0.125
44813, 0.625, 1.25, 0.125
44814, 0.625, 1.3, 0.125
44815, 0.625, 0.2, 0.16666666666667
44816, 0.625, 0.25, 0.16666666666667
44817, 0.625, 0.3, 0.16666666666667
44818, 0.625, 0.35, 0.16666666666667
44819, 0.625, 0.4, 0.16666666666667
44820, 0.625, 0.45, 0.16666666666667
44821, 0.625, 0.5, 0.16666666666667
44822, 0.625, 0.55, 0.16666666666667
44823, 0.625, 0.6, 0.16666666666667
44824, 0.625, 0.65, 0.16666666666667
44825, 0.625, 0.7, 0.16666666666667
44826, 0.625, 0.75, 0.16666666666667
44827, 0.625, 0.8, 0.16666666666667
44828, 0.625, 0.85, 0.16666666666667
44829, 0.625, 0.9, 0.16666666666667
44830, 0.625, 0.95, 0.16666666666667
44831, 0.625, 1, 0.16666666666667
44832, 0.625, 1.05, 0.16666666666667
44833, 0.625, 1.1, 0.16666666666667
44834, 0.625, 1.15, 0.16666666666667
44835, 0.625, 1.2, 0.16666666666667
44836, 0.625, 1.25, 0.16666666666667
44837, 0.625, 1.3, 0.16666666666667
44838, 0.625, 0.2, 0.20833333333333
44839, 0.625, 0.25, 0.20833333333333
44840, 0.625, 0.3, 0.20833333333333
44841, 0.625, 0.35, 0.20833333333333
44842, 0.625, 0.4, 0.20833333333333
44843, 0.625, 0.45, 0.20833333333333
44844, 0.625, 0.5, 0.20833333333333
44845, 0.625, 0.55, 0.20833333333333
44846, 0.625, 0.6, 0.20833333333333
44847, 0.625, 0.65, 0.20833333333333
44848, 0.625, 0.7, 0.20833333333333
44849, 0.625, 0.75, 0.20833333333333
44850, 0.625, 0.8, 0.20833333333333
44851, 0.625, 0.85, 0.20833333333333
44852, 0.625, 0.9, 0.20833333333333
44853, 0.625, 0.95, 0.20833333333333
44854, 0.625, 1, 0.20833333333333
44855, 0.625, 1.05, 0.20833333333333
44856, 0.625, 1.1, 0.20833333333333
44857, 0.625, 1.15, 0.20833333333333
44858, 0.625, 1.2, 0.20833333333333
44859, 0.625, 1.25, 0.20833333333333
44860, 0.625, 1.3, 0.20833333333333
44861, 0.625, 0.2, 0.25
44862, 0.625, 0.25, 0.25
44863, 0.625, 0.3, 0.25
44864, 0.625, 0.35, 0.25
44865, 0.625, 0.4, 0.25
44866, 0.625, 0.45, 0.25
44867, 0.625, 0.5, 0.25
44868, 0.625, 0.55, 0.25
44869, 0.625, 0.6, 0.25
44870, 0.625, 0.65, 0.25
44871, 0.625, 0.7, 0.25
44872, 0.625, 0.75, 0.25
44873, 0.625, 0.8, 0.25
44874, 0.625, 0.85, 0.25
44875, 0.625, 0.9, 0.25
44876, 0.625, 0.95, 0.25
44877, 0.625, 1, 0.25
44878, 0.625, 1.05, 0.25
44879, 0.625, 1.1, 0.25
44880, 0.625, 1.15, 0.25
44881, 0.625, 1.2, 0.25
44882, 0.625, 1.25, 0.25
44883, 0.625, 1.3, 0.25
44884, 0.625, 0.2, 0.29166666666667
44885, 0.625, 0.25, 0.29166666666667
44886, 0.625, 0.3, 0.29166666666667
44887, 0.625, 0.35, 0.29166666666667
44888, 0.625, 0.4, 0.29166666666667
44889, 0.625, 0.45, 0.29166666666667
44890, 0.625, 0.5, 0.29166666666667
44891, 0.625, 0.55, 0.29166666666667
44892, 0.625, 0.6, 0.29166666666667
44893, 0.625, 0.65, 0.29166666666667
44894, 0.625, 0.7, 0.29166666666667
44895, 0.625, 0.75, 0.29166666666667
44896, 0.625, 0.8, 0.29166666666667
44897, 0.625, 0.85, 0.29166666666667
44898, 0.625, 0.9, 0.29166666666667
44899, 0.625, 0.95, 0.29166666666667
44900, 0.625, 1, 0.29166666666667
44901, 0.625, 1.05, 0.29166666666667
44902, 0.625, 1.1, 0.29166666666667
44903, 0.625, 1.15, 0.29166666666667
44904, 0.625, 1.2, 0.29166666666667
44905, 0.625, 1.25, 0.29166666666667
44906, 0.625, 1.3, 0.29166666666667
44907, 0.625, 0.2, 0.33333333333333
44908, 0.625, 0.25, 0.33333333333333
44909, 0.625, 0.3, 0.33333333333333
44910, 0.625, 0.35, 0.33333333333333
44911, 0.625, 0.4, 0.33333333333333
44912, 0.625, 0.45, 0.33333333333333
44913, 0.625, 0.5, 0.33333333333333
44914, 0.625, 0.55, 0.33333333333333
44915, 0.625, 0.6, 0.33333333333333
44916, 0.625, 0.65, 0.33333333333333
44917, 0.625, 0.7, 0.33333333333333
44918, 0.625, 0.75, 0.33333333333333
44919, 0.625, 0.8, 0.33333333333333
44920, 0.625, 0.85, 0.33333333333333
44921, 0.625, 0.9, 0.33333333333333
44922, 0.625, 0.95, 0.33333333333333
44923, 0.625, 1, 0.33333333333333
44924, 0.625, 1.05, 0.33333333333333
44925, 0.625, 1.1, 0.33333333333333
44926, 0.625, 1.15, 0.33333333333333
44927, 0.625, 1.2, 0.33333333333333
44928, 0.625, 1.25, 0.33333333333333
44929, 0.625, 1.3, 0.33333333333333
44930, 0.625, 0.2, 0.375
44931, 0.625, 0.25, 0.375
44932, 0.625, 0.3, 0.375
44933, 0.625, 0.35, 0.375
44934, 0.625, 0.4, 0.375
44935, 0.625, 0.45, 0.375
44936, 0.625, 0.5, 0.375
44937, 0.625, 0.55, 0.375
44938, 0.625, 0.6, 0.375
44939, 0.625, 0.65, 0.375
44940, 0.625, 0.7, 0.375
44941, 0.625, 0.75, 0.375
44942, 0.625, 0.8, 0.375
44943, 0.625, 0.85, 0.375
44944, 0.625, 0.9, 0.375
44945, 0.625, 0.95, 0.375
44946, 0.625, 1, 0.375
44947, 0.625, 1.05, 0.375
44948, 0.625, 1.1, 0.375
44949, 0.625, 1.15, 0.375
44950, 0.625, 1.2, 0.375
44951, 0.625, 1.25, 0.375
44952, 0.625, 1.3, 0.375
44953, 0.625, 0.2, 0.41666666666667
44954, 0.625, 0.25, 0.41666666666667
44955, 0.625, 0.3, 0.41666666666667
44956, 0.625, 0.35, 0.41666666666667
44957, 0.625, 0.4, 0.41666666666667
44958, 0.625, 0.45, 0.41666666666667
44959, 0.625, 0.5, 0.41666666666667
44960, 0.625, 0.55, 0.41666666666667
44961, 0.625, 0.6, 0.41666666666667
44962, 0.625, 0.65, 0.41666666666667
44963, 0.625, 0.7, 0.41666666666667
44964, 0.625, 0.75, 0.41666666666667
44965, 0.625, 0.8, 0.41666666666667
44966, 0.625, 0.85, 0.41666666666667
44967, 0.625, 0.9, 0.41666666666667
44968, 0.625, 0.95, 0.41666666666667
44969, 0.625, 1, 0.41666666666667
44970, 0.625, 1.05, 0.41666666666667
44971, 0.625, 1.1, 0.41666666666667
44972, 0.625, 1.15, 0.41666666666667
44973, 0.625, 1.2, 0.41666666666667
44974, 0.625, 1.25, 0.41666666666667
44975, 0.625, 1.3, 0.41666666666667
44976, 0.625, 0.2, 0.45833333333333
44977, 0.625, 0.25, 0.45833333333333
44978, 0.625, 0.3, 0.45833333333333
44979, 0.625, 0.35, 0.45833333333333
44980, 0.625, 0.4, 0.45833333333333
44981, 0.625, 0.45, 0.45833333333333
44982, 0.625, 0.5, 0.45833333333333
44983, 0.625, 0.55, 0.45833333333333
44984, 0.625, 0.6, 0.45833333333333
44985, 0.625, 0.65, 0.45833333333333
44986, 0.625, 0.7, 0.45833333333333
44987, 0.625, 0.75, 0.45833333333333
44988, 0.625, 0.8, 0.45833333333333
44989, 0.625, 0.85, 0.45833333333333
44990, 0.625, 0.9, 0.45833333333333
44991, 0.625, 0.95, 0.45833333333333
44992, 0.625, 1, 0.45833333333333
44993, 0.625, 1.05, 0.45833333333333
44994, 0.625, 1.1, 0.45833333333333
44995, 0.625, 1.15, 0.45833333333333
44996, 0.625, 1.2, 0.45833333333333
44997, 0.625, 1.25, 0.45833333333333
44998, 0.625, 1.3, 0.45833333333333
44999, 0.66666666666667, 0.2, 0.041666666666667
45000, 0.66666666666667, 0.25, 0.041666666666667
45001, 0.66666666666667, 0.3, 0.041666666666667
45002, 0.66666666666667, 0.35, 0.041666666666667
45003, 0.66666666666667, 0.4, 0.041666666666667
45004, 0.66666666666667, 0.45, 0.041666666666667
45005, 0.66666666666667, 0.5, 0.041666666666667
45006, 0.66666666666667, 0.55, 0.041666666666667
45007, 0.66666666666667, 0.6, 0.041666666666667
45008, 0.66666666666667, 0.65, 0.041666666666667
45009, 0.66666666666667, 0.7, 0.041666666666667
45010, 0.66666666666667, 0.75, 0.041666666666667
45011, 0.66666666666667, 0.8, 0.041666666666667
45012, 0.66666666666667, 0.85, 0.041666666666667
45013, 0.66666666666667, 0.9, 0.041666666666667
45014, 0.66666666666667, 0.95, 0.041666666666667
45015, 0.66666666666667, 1, 0.041666666666667
45016, 0.66666666666667, 1.05, 0.041666666666667
45017, 0.66666666666667, 1.1, 0.041666666666667
45018, 0.66666666666667, 1.15, 0.041666666666667
45019, 0.66666666666667, 1.2, 0.041666666666667
45020, 0.66666666666667, 1.25, 0.041666666666667
45021, 0.66666666666667, 1.3, 0.041666666666667
45022, 0.66666666666667, 0.2, 0.083333333333333
45023, 0.66666666666667, 0.25, 0.083333333333333
45024, 0.66666666666667, 0.3, 0.083333333333333
45025, 0.66666666666667, 0.35, 0.083333333333333
45026, 0.66666666666667, 0.4, 0.083333333333333
45027, 0.66666666666667, 0.45, 0.083333333333333
45028, 0.66666666666667, 0.5, 0.083333333333333
45029, 0.66666666666667, 0.55, 0.083333333333333
45030, 0.66666666666667, 0.6, 0.083333333333333
45031, 0.66666666666667, 0.65, 0.083333333333333
45032, 0.66666666666667, 0.7, 0.083333333333333
45033, 0.66666666666667, 0.75, 0.083333333333333
45034, 0.66666666666667, 0.8, 0.083333333333333
45035, 0.66666666666667, 0.85, 0.083333333333333
45036, 0.66666666666667, 0.9, 0.083333333333333
45037, 0.66666666666667, 0.95, 0.083333333333333
45038, 0.66666666666667, 1, 0.083333333333333
45039, 0.66666666666667, 1.05, 0.083333333333333
45040, 0.66666666666667, 1.1, 0.083333333333333
45041, 0.66666666666667, 1.15, 0.083333333333333
45042, 0.66666666666667, 1.2, 0.083333333333333
45043, 0.66666666666667, 1.25, 0.083333333333333
45044, 0.66666666666667, 1.3, 0.083333333333333
45045, 0.66666666666667, 0.2, 0.125
45046, 0.66666666666667, 0.25, 0.125
45047, 0.66666666666667, 0.3, 0.125
45048, 0.66666666666667, 0.35, 0.125
45049, 0.66666666666667, 0.4, 0.125
45050, 0.66666666666667, 0.45, 0.125
45051, 0.66666666666667, 0.5, 0.125
45052, 0.66666666666667, 0.55, 0.125
45053, 0.66666666666667, 0.6, 0.125
45054, 0.66666666666667, 0.65, 0.125
45055, 0.66666666666667, 0.7, 0.125
45056, 0.66666666666667, 0.75, 0.125
45057, 0.66666666666667, 0.8, 0.125
45058, 0.66666666666667, 0.85, 0.125
45059, 0.66666666666667, 0.9, 0.125
45060, 0.66666666666667, 0.95, 0.125
45061, 0.66666666666667, 1, 0.125
45062, 0.66666666666667, 1.05, 0.125
45063, 0.66666666666667, 1.1, 0.125
45064, 0.66666666666667, 1.15, 0.125
45065, 0.66666666666667, 1.2, 0.125
45066, 0.66666666666667, 1.25, 0.125
45067, 0.66666666666667, 1.3, 0.125
45068, 0.66666666666667, 0.2, 0.16666666666667
45069, 0.66666666666667, 0.25, 0.16666666666667
45070, 0.66666666666667, 0.3, 0.16666666666667
45071, 0.66666666666667, 0.35, 0.16666666666667
45072, 0.66666666666667, 0.4, 0.16666666666667
45073, 0.66666666666667, 0.45, 0.16666666666667
45074, 0.66666666666667, 0.5, 0.16666666666667
45075, 0.66666666666667, 0.55, 0.16666666666667
45076, 0.66666666666667, 0.6, 0.16666666666667
45077, 0.66666666666667, 0.65, 0.16666666666667
45078, 0.66666666666667, 0.7, 0.16666666666667
45079, 0.66666666666667, 0.75, 0.16666666666667
45080, 0.66666666666667, 0.8, 0.16666666666667
45081, 0.66666666666667, 0.85, 0.16666666666667
45082, 0.66666666666667, 0.9, 0.16666666666667
45083, 0.66666666666667, 0.95, 0.16666666666667
45084, 0.66666666666667, 1, 0.16666666666667
45085, 0.66666666666667, 1.05, 0.16666666666667
45086, 0.66666666666667, 1.1, 0.16666666666667
45087, 0.66666666666667, 1.15, 0.16666666666667
45088, 0.66666666666667, 1.2, 0.16666666666667
45089, 0.66666666666667, 1.25, 0.16666666666667
45090, 0.66666666666667, 1.3, 0.16666666666667
45091, 0.66666666666667, 0.2, 0.20833333333333
45092, 0.66666666666667, 0.25, 0.20833333333333
45093, 0.66666666666667, 0.3, 0.20833333333333
45094, 0.66666666666667, 0.35, 0.20833333333333
45095, 0.66666666666667, 0.4, 0.20833333333333
45096, 0.66666666666667, 0.45, 0.20833333333333
45097, 0.66666666666667, 0.5, 0.20833333333333
45098, 0.66666666666667, 0.55, 0.20833333333333
45099, 0.66666666666667, 0.6, 0.20833333333333
45100, 0.66666666666667, 0.65, 0.20833333333333
45101, 0.66666666666667, 0.7, 0.20833333333333
45102, 0.66666666666667, 0.75, 0.20833333333333
45103, 0.66666666666667, 0.8, 0.20833333333333
45104, 0.66666666666667, 0.85, 0.20833333333333
45105, 0.66666666666667, 0.9, 0.20833333333333
45106, 0.66666666666667, 0.95, 0.20833333333333
45107, 0.66666666666667, 1, 0.20833333333333
45108, 0.66666666666667, 1.05, 0.20833333333333
45109, 0.66666666666667, 1.1, 0.20833333333333
45110, 0.66666666666667, 1.15, 0.20833333333333
45111, 0.66666666666667, 1.2, 0.20833333333333
45112, 0.66666666666667, 1.25, 0.20833333333333
45113, 0.66666666666667, 1.3, 0.20833333333333
45114, 0.66666666666667, 0.2, 0.25
45115, 0.66666666666667, 0.25, 0.25
45116, 0.66666666666667, 0.3, 0.25
45117, 0.66666666666667, 0.35, 0.25
45118, 0.66666666666667, 0.4, 0.25
45119, 0.66666666666667, 0.45, 0.25
45120, 0.66666666666667, 0.5, 0.25
45121, 0.66666666666667, 0.55, 0.25
45122, 0.66666666666667, 0.6, 0.25
45123, 0.66666666666667, 0.65, 0.25
45124, 0.66666666666667, 0.7, 0.25
45125, 0.66666666666667, 0.75, 0.25
45126, 0.66666666666667, 0.8, 0.25
45127, 0.66666666666667, 0.85, 0.25
45128, 0.66666666666667, 0.9, 0.25
45129, 0.66666666666667, 0.95, 0.25
45130, 0.66666666666667, 1, 0.25
45131, 0.66666666666667, 1.05, 0.25
45132, 0.66666666666667, 1.1, 0.25
45133, 0.66666666666667, 1.15, 0.25
45134, 0.66666666666667, 1.2, 0.25
45135, 0.66666666666667, 1.25, 0.25
45136, 0.66666666666667, 1.3, 0.25
45137, 0.66666666666667, 0.2, 0.29166666666667
45138, 0.66666666666667, 0.25, 0.29166666666667
45139, 0.66666666666667, 0.3, 0.29166666666667
45140, 0.66666666666667, 0.35, 0.29166666666667
45141, 0.66666666666667, 0.4, 0.29166666666667
45142, 0.66666666666667, 0.45, 0.29166666666667
45143, 0.66666666666667, 0.5, 0.29166666666667
45144, 0.66666666666667, 0.55, 0.29166666666667
45145, 0.66666666666667, 0.6, 0.29166666666667
45146, 0.66666666666667, 0.65, 0.29166666666667
45147, 0.66666666666667, 0.7, 0.29166666666667
45148, 0.66666666666667, 0.75, 0.29166666666667
45149, 0.66666666666667, 0.8, 0.29166666666667
45150, 0.66666666666667, 0.85, 0.29166666666667
45151, 0.66666666666667, 0.9, 0.29166666666667
45152, 0.66666666666667, 0.95, 0.29166666666667
45153, 0.66666666666667, 1, 0.29166666666667
45154, 0.66666666666667, 1.05, 0.29166666666667
45155, 0.66666666666667, 1.1, 0.29166666666667
45156, 0.66666666666667, 1.15, 0.29166666666667
45157, 0.66666666666667, 1.2, 0.29166666666667
45158, 0.66666666666667, 1.25, 0.29166666666667
45159, 0.66666666666667, 1.3, 0.29166666666667
45160, 0.66666666666667, 0.2, 0.33333333333333
45161, 0.66666666666667, 0.25, 0.33333333333333
45162, 0.66666666666667, 0.3, 0.33333333333333
45163, 0.66666666666667, 0.35, 0.33333333333333
45164, 0.66666666666667, 0.4, 0.33333333333333
45165, 0.66666666666667, 0.45, 0.33333333333333
45166, 0.66666666666667, 0.5, 0.33333333333333
45167, 0.66666666666667, 0.55, 0.33333333333333
45168, 0.66666666666667, 0.6, 0.33333333333333
45169, 0.66666666666667, 0.65, 0.33333333333333
45170, 0.66666666666667, 0.7, 0.33333333333333
45171, 0.66666666666667, 0.75, 0.33333333333333
45172, 0.66666666666667, 0.8, 0.33333333333333
45173, 0.66666666666667, 0.85, 0.33333333333333
45174, 0.66666666666667, 0.9, 0.33333333333333
45175, 0.66666666666667, 0.95, 0.33333333333333
45176, 0.66666666666667, 1, 0.33333333333333
45177, 0.66666666666667, 1.05, 0.33333333333333
45178, 0.66666666666667, 1.1, 0.33333333333333
45179, 0.66666666666667, 1.15, 0.33333333333333
45180, 0.66666666666667, 1.2, 0.33333333333333
45181, 0.66666666666667, 1.25, 0.33333333333333
45182, 0.66666666666667, 1.3, 0.33333333333333
45183, 0.66666666666667, 0.2, 0.375
45184, 0.66666666666667, 0.25, 0.375
45185, 0.66666666666667, 0.3, 0.375
45186, 0.66666666666667, 0.35, 0.375
45187, 0.66666666666667, 0.4, 0.375
45188, 0.66666666666667, 0.45, 0.375
45189, 0.66666666666667, 0.5, 0.375
45190, 0.66666666666667, 0.55, 0.375
45191, 0.66666666666667, 0.6, 0.375
45192, 0.66666666666667, 0.65, 0.375
45193, 0.66666666666667, 0.7, 0.375
45194, 0.66666666666667, 0.75, 0.375
45195, 0.66666666666667, 0.8, 0.375
45196, 0.66666666666667, 0.85, 0.375
45197, 0.66666666666667, 0.9, 0.375
45198, 0.66666666666667, 0.95, 0.375
45199, 0.66666666666667, 1, 0.375
45200, 0.66666666666667, 1.05, 0.375
45201, 0.66666666666667, 1.1, 0.375
45202, 0.66666666666667, 1.15, 0.375
45203, 0.66666666666667, 1.2, 0.375
45204, 0.66666666666667, 1.25, 0.375
45205, 0.66666666666667, 1.3, 0.375
45206, 0.66666666666667, 0.2, 0.41666666666667
45207, 0.66666666666667, 0.25, 0.41666666666667
45208, 0.66666666666667, 0.3, 0.41666666666667
45209, 0.66666666666667, 0.35, 0.41666666666667
45210, 0.66666666666667, 0.4, 0.41666666666667
45211, 0.66666666666667, 0.45, 0.41666666666667
45212, 0.66666666666667, 0.5, 0.41666666666667
45213, 0.66666666666667, 0.55, 0.41666666666667
45214, 0.66666666666667, 0.6, 0.41666666666667
45215, 0.66666666666667, 0.65, 0.41666666666667
45216, 0.66666666666667, 0.7, 0.41666666666667
45217, 0.66666666666667, 0.75, 0.41666666666667
45218, 0.66666666666667, 0.8, 0.41666666666667
45219, 0.66666666666667, 0.85, 0.41666666666667
45220, 0.66666666666667, 0.9, 0.41666666666667
45221, 0.66666666666667, 0.95, 0.41666666666667
45222, 0.66666666666667, 1, 0.41666666666667
45223, 0.66666666666667, 1.05, 0.41666666666667
45224, 0.66666666666667, 1.1, 0.41666666666667
45225, 0.66666666666667, 1.15, 0.41666666666667
45226, 0.66666666666667, 1.2, 0.41666666666667
45227, 0.66666666666667, 1.25, 0.41666666666667
45228, 0.66666666666667, 1.3, 0.41666666666667
45229, 0.66666666666667, 0.2, 0.45833333333333
45230, 0.66666666666667, 0.25, 0.45833333333333
45231, 0.66666666666667, 0.3, 0.45833333333333
45232, 0.66666666666667, 0.35, 0.45833333333333
45233, 0.66666666666667, 0.4, 0.45833333333333
45234, 0.66666666666667, 0.45, 0.45833333333333
45235, 0.66666666666667, 0.5, 0.45833333333333
45236, 0.66666666666667, 0.55, 0.45833333333333
45237, 0.66666666666667, 0.6, 0.45833333333333
45238, 0.66666666666667, 0.65, 0.45833333333333
45239, 0.66666666666667, 0.7, 0.45833333333333
45240, 0.66666666666667, 0.75, 0.45833333333333
45241, 0.66666666666667, 0.8, 0.45833333333333
45242, 0.66666666666667, 0.85, 0.45833333333333
45243, 0.66666666666667, 0.9, 0.45833333333333
45244, 0.66666666666667, 0.95, 0.45833333333333
45245, 0.66666666666667, 1, 0.45833333333333
45246, 0.66666666666667, 1.05, 0.45833333333333
45247, 0.66666666666667, 1.1, 0.45833333333333
45248, 0.66666666666667, 1.15, 0.45833333333333
45249, 0.66666666666667, 1.2, 0.45833333333333
45250, 0.66666666666667, 1.25, 0.45833333333333
45251, 0.66666666666667, 1.3, 0.45833333333333
45252, 0.70833333333333, 0.2, 0.041666666666667
45253, 0.70833333333333, 0.25, 0.041666666666667
45254, 0.70833333333333, 0.3, 0.041666666666667
45255, 0.70833333333333, 0.35, 0.041666666666667
45256, 0.70833333333333, 0.4, 0.041666666666667
45257, 0.70833333333333, 0.45, 0.041666666666667
45258, 0.70833333333333, 0.5, 0.041666666666667
45259, 0.70833333333333, 0.55, 0.041666666666667
45260, 0.70833333333333, 0.6, 0.041666666666667
45261, 0.70833333333333, 0.65, 0.041666666666667
45262, 0.70833333333333, 0.7, 0.041666666666667
45263, 0.70833333333333, 0.75, 0.041666666666667
45264, 0.70833333333333, 0.8, 0.041666666666667
45265, 0.70833333333333, 0.85, 0.041666666666667
45266, 0.70833333333333, 0.9, 0.041666666666667
45267, 0.70833333333333, 0.95, 0.041666666666667
45268, 0.70833333333333, 1, 0.041666666666667
45269, 0.70833333333333, 1.05, 0.041666666666667
45270, 0.70833333333333, 1.1, 0.041666666666667
45271, 0.70833333333333, 1.15, 0.041666666666667
45272, 0.70833333333333, 1.2, 0.041666666666667
45273, 0.70833333333333, 1.25, 0.041666666666667
45274, 0.70833333333333, 1.3, 0.041666666666667
45275, 0.70833333333333, 0.2, 0.083333333333333
45276, 0.70833333333333, 0.25, 0.083333333333333
45277, 0.70833333333333, 0.3, 0.083333333333333
45278, 0.70833333333333, 0.35, 0.083333333333333
45279, 0.70833333333333, 0.4, 0.083333333333333
45280, 0.70833333333333, 0.45, 0.083333333333333
45281, 0.70833333333333, 0.5, 0.083333333333333
45282, 0.70833333333333, 0.55, 0.083333333333333
45283, 0.70833333333333, 0.6, 0.083333333333333
45284, 0.70833333333333, 0.65, 0.083333333333333
45285, 0.70833333333333, 0.7, 0.083333333333333
45286, 0.70833333333333, 0.75, 0.083333333333333
45287, 0.70833333333333, 0.8, 0.083333333333333
45288, 0.70833333333333, 0.85, 0.083333333333333
45289, 0.70833333333333, 0.9, 0.083333333333333
45290, 0.70833333333333, 0.95, 0.083333333333333
45291, 0.70833333333333, 1, 0.083333333333333
45292, 0.70833333333333, 1.05, 0.083333333333333
45293, 0.70833333333333, 1.1, 0.083333333333333
45294, 0.70833333333333, 1.15, 0.083333333333333
45295, 0.70833333333333, 1.2, 0.083333333333333
45296, 0.70833333333333, 1.25, 0.083333333333333
45297, 0.70833333333333, 1.3, 0.083333333333333
45298, 0.70833333333333, 0.2, 0.125
45299, 0.70833333333333, 0.25, 0.125
45300, 0.70833333333333, 0.3, 0.125
45301, 0.70833333333333, 0.35, 0.125
45302, 0.70833333333333, 0.4, 0.125
45303, 0.70833333333333, 0.45, 0.125
45304, 0.70833333333333, 0.5, 0.125
45305, 0.70833333333333, 0.55, 0.125
45306, 0.70833333333333, 0.6, 0.125
45307, 0.70833333333333, 0.65, 0.125
45308, 0.70833333333333, 0.7, 0.125
45309, 0.70833333333333, 0.75, 0.125
45310, 0.70833333333333, 0.8, 0.125
45311, 0.70833333333333, 0.85, 0.125
45312, 0.70833333333333, 0.9, 0.125
45313, 0.70833333333333, 0.95, 0.125
45314, 0.70833333333333, 1, 0.125
45315, 0.70833333333333, 1.05, 0.125
45316, 0.70833333333333, 1.1, 0.125
45317, 0.70833333333333, 1.15, 0.125
45318, 0.70833333333333, 1.2, 0.125
45319, 0.70833333333333, 1.25, 0.125
45320, 0.70833333333333, 1.3, 0.125
45321, 0.70833333333333, 0.2, 0.16666666666667
45322, 0.70833333333333, 0.25, 0.16666666666667
45323, 0.70833333333333, 0.3, 0.16666666666667
45324, 0.70833333333333, 0.35, 0.16666666666667
45325, 0.70833333333333, 0.4, 0.16666666666667
45326, 0.70833333333333, 0.45, 0.16666666666667
45327, 0.70833333333333, 0.5, 0.16666666666667
45328, 0.70833333333333, 0.55, 0.16666666666667
45329, 0.70833333333333, 0.6, 0.16666666666667
45330, 0.70833333333333, 0.65, 0.16666666666667
45331, 0.70833333333333, 0.7, 0.16666666666667
45332, 0.70833333333333, 0.75, 0.16666666666667
45333, 0.70833333333333, 0.8, 0.16666666666667
45334, 0.70833333333333, 0.85, 0.16666666666667
45335, 0.70833333333333, 0.9, 0.16666666666667
45336, 0.70833333333333, 0.95, 0.16666666666667
45337, 0.70833333333333, 1, 0.16666666666667
45338, 0.70833333333333, 1.05, 0.16666666666667
45339, 0.70833333333333, 1.1, 0.16666666666667
45340, 0.70833333333333, 1.15, 0.16666666666667
45341, 0.70833333333333, 1.2, 0.16666666666667
45342, 0.70833333333333, 1.25, 0.16666666666667
45343, 0.70833333333333, 1.3, 0.16666666666667
45344, 0.70833333333333, 0.2, 0.20833333333333
45345, 0.70833333333333, 0.25, 0.20833333333333
45346, 0.70833333333333, 0.3, 0.20833333333333
45347, 0.70833333333333, 0.35, 0.20833333333333
45348, 0.70833333333333, 0.4, 0.20833333333333
45349, 0.70833333333333, 0.45, 0.20833333333333
45350, 0.70833333333333, 0.5, 0.20833333333333
45351, 0.70833333333333, 0.55, 0.20833333333333
45352, 0.70833333333333, 0.6, 0.20833333333333
45353, 0.70833333333333, 0.65, 0.20833333333333
45354, 0.70833333333333, 0.7, 0.20833333333333
45355, 0.70833333333333, 0.75, 0.20833333333333
45356, 0.70833333333333, 0.8, 0.20833333333333
45357, 0.70833333333333, 0.85, 0.20833333333333
45358, 0.70833333333333, 0.9, 0.20833333333333
45359, 0.70833333333333, 0.95, 0.20833333333333
45360, 0.70833333333333, 1, 0.20833333333333
45361, 0.70833333333333, 1.05, 0.20833333333333
45362, 0.70833333333333, 1.1, 0.20833333333333
45363, 0.70833333333333, 1.15, 0.20833333333333
45364, 0.70833333333333, 1.2, 0.20833333333333
45365, 0.70833333333333, 1.25, 0.20833333333333
45366, 0.70833333333333, 1.3, 0.20833333333333
45367, 0.70833333333333, 0.2, 0.25
45368, 0.70833333333333, 0.25, 0.25
45369, 0.70833333333333, 0.3, 0.25
45370, 0.70833333333333, 0.35, 0.25
45371, 0.70833333333333, 0.4, 0.25
45372, 0.70833333333333, 0.45, 0.25
45373, 0.70833333333333, 0.5, 0.25
45374, 0.70833333333333, 0.55, 0.25
45375, 0.70833333333333, 0.6, 0.25
45376, 0.70833333333333, 0.65, 0.25
45377, 0.70833333333333, 0.7, 0.25
45378, 0.70833333333333, 0.75, 0.25
45379, 0.70833333333333, 0.8, 0.25
45380, 0.70833333333333, 0.85, 0.25
45381, 0.70833333333333, 0.9, 0.25
45382, 0.70833333333333, 0.95, 0.25
45383, 0.70833333333333, 1, 0.25
45384, 0.70833333333333, 1.05, 0.25
45385, 0.70833333333333, 1.1, 0.25
45386, 0.70833333333333, 1.15, 0.25
45387, 0.70833333333333, 1.2, 0.25
45388, 0.70833333333333, 1.25, 0.25
45389, 0.70833333333333, 1.3, 0.25
45390, 0.70833333333333, 0.2, 0.29166666666667
45391, 0.70833333333333, 0.25, 0.29166666666667
45392, 0.70833333333333, 0.3, 0.29166666666667
45393, 0.70833333333333, 0.35, 0.29166666666667
45394, 0.70833333333333, 0.4, 0.29166666666667
45395, 0.70833333333333, 0.45, 0.29166666666667
45396, 0.70833333333333, 0.5, 0.29166666666667
45397, 0.70833333333333, 0.55, 0.29166666666667
45398, 0.70833333333333, 0.6, 0.29166666666667
45399, 0.70833333333333, 0.65, 0.29166666666667
45400, 0.70833333333333, 0.7, 0.29166666666667
45401, 0.70833333333333, 0.75, 0.29166666666667
45402, 0.70833333333333, 0.8, 0.29166666666667
45403, 0.70833333333333, 0.85, 0.29166666666667
45404, 0.70833333333333, 0.9, 0.29166666666667
45405, 0.70833333333333, 0.95, 0.29166666666667
45406, 0.70833333333333, 1, 0.29166666666667
45407, 0.70833333333333, 1.05, 0.29166666666667
45408, 0.70833333333333, 1.1, 0.29166666666667
45409, 0.70833333333333, 1.15, 0.29166666666667
45410, 0.70833333333333, 1.2, 0.29166666666667
45411, 0.70833333333333, 1.25, 0.29166666666667
45412, 0.70833333333333, 1.3, 0.29166666666667
45413, 0.70833333333333, 0.2, 0.33333333333333
45414, 0.70833333333333, 0.25, 0.33333333333333
45415, 0.70833333333333, 0.3, 0.33333333333333
45416, 0.70833333333333, 0.35, 0.33333333333333
45417, 0.70833333333333, 0.4, 0.33333333333333
45418, 0.70833333333333, 0.45, 0.33333333333333
45419, 0.70833333333333, 0.5, 0.33333333333333
45420, 0.70833333333333, 0.55, 0.33333333333333
45421, 0.70833333333333, 0.6, 0.33333333333333
45422, 0.70833333333333, 0.65, 0.33333333333333
45423, 0.70833333333333, 0.7, 0.33333333333333
45424, 0.70833333333333, 0.75, 0.33333333333333
45425, 0.70833333333333, 0.8, 0.33333333333333
45426, 0.70833333333333, 0.85, 0.33333333333333
45427, 0.70833333333333, 0.9, 0.33333333333333
45428, 0.70833333333333, 0.95, 0.33333333333333
45429, 0.70833333333333, 1, 0.33333333333333
45430, 0.70833333333333, 1.05, 0.33333333333333
45431, 0.70833333333333, 1.1, 0.33333333333333
45432, 0.70833333333333, 1.15, 0.33333333333333
45433, 0.70833333333333, 1.2, 0.33333333333333
45434, 0.70833333333333, 1.25, 0.33333333333333
45435, 0.70833333333333, 1.3, 0.33333333333333
45436, 0.70833333333333, 0.2, 0.375
45437, 0.70833333333333, 0.25, 0.375
45438, 0.70833333333333, 0.3, 0.375
45439, 0.70833333333333, 0.35, 0.375
45440, 0.70833333333333, 0.4, 0.375
45441, 0.70833333333333, 0.45, 0.375
45442, 0.70833333333333, 0.5, 0.375
45443, 0.70833333333333, 0.55, 0.375
45444, 0.70833333333333, 0.6, 0.375
45445, 0.70833333333333, 0.65, 0.375
45446, 0.70833333333333, 0.7, 0.375
45447, 0.70833333333333, 0.75, 0.375
45448, 0.70833333333333, 0.8, 0.375
45449, 0.70833333333333, 0.85, 0.375
45450, 0.70833333333333, 0.9, 0.375
45451, 0.70833333333333, 0.95, 0.375
45452, 0.70833333333333, 1, 0.375
45453, 0.70833333333333, 1.05, 0.375
45454, 0.70833333333333, 1.1, 0.375
45455, 0.70833333333333, 1.15, 0.375
45456, 0.70833333333333, 1.2, 0.375
45457, 0.70833333333333, 1.25, 0.375
45458, 0.70833333333333, 1.3, 0.375
45459, 0.70833333333333, 0.2, 0.41666666666667
45460, 0.70833333333333, 0.25, 0.41666666666667
45461, 0.70833333333333, 0.3, 0.41666666666667
45462, 0.70833333333333, 0.35, 0.41666666666667
45463, 0.70833333333333, 0.4, 0.41666666666667
45464, 0.70833333333333, 0.45, 0.41666666666667
45465, 0.70833333333333, 0.5, 0.41666666666667
45466, 0.70833333333333, 0.55, 0.41666666666667
45467, 0.70833333333333, 0.6, 0.41666666666667
45468, 0.70833333333333, 0.65, 0.41666666666667
45469, 0.70833333333333, 0.7, 0.41666666666667
45470, 0.70833333333333, 0.75, 0.41666666666667
45471, 0.70833333333333, 0.8, 0.41666666666667
45472, 0.70833333333333, 0.85, 0.41666666666667
45473, 0.70833333333333, 0.9, 0.41666666666667
45474, 0.70833333333333, 0.95, 0.41666666666667
45475, 0.70833333333333, 1, 0.41666666666667
45476, 0.70833333333333, 1.05, 0.41666666666667
45477, 0.70833333333333, 1.1, 0.41666666666667
45478, 0.70833333333333, 1.15, 0.41666666666667
45479, 0.70833333333333, 1.2, 0.41666666666667
45480, 0.70833333333333, 1.25, 0.41666666666667
45481, 0.70833333333333, 1.3, 0.41666666666667
45482, 0.70833333333333, 0.2, 0.45833333333333
45483, 0.70833333333333, 0.25, 0.45833333333333
45484, 0.70833333333333, 0.3, 0.45833333333333
45485, 0.70833333333333, 0.35, 0.45833333333333
45486, 0.70833333333333, 0.4, 0.45833333333333
45487, 0.70833333333333, 0.45, 0.45833333333333
45488, 0.70833333333333, 0.5, 0.45833333333333
45489, 0.70833333333333, 0.55, 0.45833333333333
45490, 0.70833333333333, 0.6, 0.45833333333333
45491, 0.70833333333333, 0.65, 0.45833333333333
45492, 0.70833333333333, 0.7, 0.45833333333333
45493, 0.70833333333333, 0.75, 0.45833333333333
45494, 0.70833333333333, 0.8, 0.45833333333333
45495, 0.70833333333333, 0.85, 0.45833333333333
45496, 0.70833333333333, 0.9, 0.45833333333333
45497, 0.70833333333333, 0.95, 0.45833333333333
45498, 0.70833333333333, 1, 0.45833333333333
45499, 0.70833333333333, 1.05, 0.45833333333333
45500, 0.70833333333333, 1.1, 0.45833333333333
45501, 0.70833333333333, 1.15, 0.45833333333333
45502, 0.70833333333333, 1.2, 0.45833333333333
45503, 0.70833333333333, 1.25, 0.45833333333333
45504, 0.70833333333333, 1.3, 0.45833333333333
45505, 0.75, 0.2, 0.041666666666667
45506, 0.75, 0.25, 0.041666666666667
45507, 0.75, 0.3, 0.041666666666667
45508, 0.75, 0.35, 0.041666666666667
45509, 0.75, 0.4, 0.041666666666667
45510, 0.75, 0.45, 0.041666666666667
45511, 0.75, 0.5, 0.041666666666667
45512, 0.75, 0.55, 0.041666666666667
45513, 0.75, 0.6, 0.041666666666667
45514, 0.75, 0.65, 0.041666666666667
45515, 0.75, 0.7, 0.041666666666667
45516, 0.75, 0.75, 0.041666666666667
45517, 0.75, 0.8, 0.041666666666667
45518, 0.75, 0.85, 0.041666666666667
45519, 0.75, 0.9, 0.041666666666667
45520, 0.75, 0.95, 0.041666666666667
45521, 0.75, 1, 0.041666666666667
45522, 0.75, 1.05, 0.041666666666667
45523, 0.75, 1.1, 0.041666666666667
45524, 0.75, 1.15, 0.041666666666667
45525, 0.75, 1.2, 0.041666666666667
45526, 0.75, 1.25, 0.041666666666667
45527, 0.75, 1.3, 0.041666666666667
45528, 0.75, 0.2, 0.083333333333333
45529, 0.75, 0.25, 0.083333333333333
45530, 0.75, 0.3, 0.083333333333333
45531, 0.75, 0.35, 0.083333333333333
45532, 0.75, 0.4, 0.083333333333333
45533, 0.75, 0.45, 0.083333333333333
45534, 0.75, 0.5, 0.083333333333333
45535, 0.75, 0.55, 0.083333333333333
45536, 0.75, 0.6, 0.083333333333333
45537, 0.75, 0.65, 0.083333333333333
45538, 0.75, 0.7, 0.083333333333333
45539, 0.75, 0.75, 0.083333333333333
45540, 0.75, 0.8, 0.083333333333333
45541, 0.75, 0.85, 0.083333333333333
45542, 0.75, 0.9, 0.083333333333333
45543, 0.75, 0.95, 0.083333333333333
45544, 0.75, 1, 0.083333333333333
45545, 0.75, 1.05, 0.083333333333333
45546, 0.75, 1.1, 0.083333333333333
45547, 0.75, 1.15, 0.083333333333333
45548, 0.75, 1.2, 0.083333333333333
45549, 0.75, 1.25, 0.083333333333333
45550, 0.75, 1.3, 0.083333333333333
45551, 0.75, 0.2, 0.125
45552, 0.75, 0.25, 0.125
45553, 0.75, 0.3, 0.125
45554, 0.75, 0.35, 0.125
45555, 0.75, 0.4, 0.125
45556, 0.75, 0.45, 0.125
45557, 0.75, 0.5, 0.125
45558, 0.75, 0.55, 0.125
45559, 0.75, 0.6, 0.125
45560, 0.75, 0.65, 0.125
45561, 0.75, 0.7, 0.125
45562, 0.75, 0.75, 0.125
45563, 0.75, 0.8, 0.125
45564, 0.75, 0.85, 0.125
45565, 0.75, 0.9, 0.125
45566, 0.75, 0.95, 0.125
45567, 0.75, 1, 0.125
45568, 0.75, 1.05, 0.125
45569, 0.75, 1.1, 0.125
45570, 0.75, 1.15, 0.125
45571, 0.75, 1.2, 0.125
45572, 0.75, 1.25, 0.125
45573, 0.75, 1.3, 0.125
45574, 0.75, 0.2, 0.16666666666667
45575, 0.75, 0.25, 0.16666666666667
45576, 0.75, 0.3, 0.16666666666667
45577, 0.75, 0.35, 0.16666666666667
45578, 0.75, 0.4, 0.16666666666667
45579, 0.75, 0.45, 0.16666666666667
45580, 0.75, 0.5, 0.16666666666667
45581, 0.75, 0.55, 0.16666666666667
45582, 0.75, 0.6, 0.16666666666667
45583, 0.75, 0.65, 0.16666666666667
45584, 0.75, 0.7, 0.16666666666667
45585, 0.75, 0.75, 0.16666666666667
45586, 0.75, 0.8, 0.16666666666667
45587, 0.75, 0.85, 0.16666666666667
45588, 0.75, 0.9, 0.16666666666667
45589, 0.75, 0.95, 0.16666666666667
45590, 0.75, 1, 0.16666666666667
45591, 0.75, 1.05, 0.16666666666667
45592, 0.75, 1.1, 0.16666666666667
45593, 0.75, 1.15, 0.16666666666667
45594, 0.75, 1.2, 0.16666666666667
45595, 0.75, 1.25, 0.16666666666667
45596, 0.75, 1.3, 0.16666666666667
45597, 0.75, 0.2, 0.20833333333333
45598, 0.75, 0.25, 0.20833333333333
45599, 0.75, 0.3, 0.20833333333333
45600, 0.75, 0.35, 0.20833333333333
45601, 0.75, 0.4, 0.20833333333333
45602, 0.75, 0.45, 0.20833333333333
45603, 0.75, 0.5, 0.20833333333333
45604, 0.75, 0.55, 0.20833333333333
45605, 0.75, 0.6, 0.20833333333333
45606, 0.75, 0.65, 0.20833333333333
45607, 0.75, 0.7, 0.20833333333333
45608, 0.75, 0.75, 0.20833333333333
45609, 0.75, 0.8, 0.20833333333333
45610, 0.75, 0.85, 0.20833333333333
45611, 0.75, 0.9, 0.20833333333333
45612, 0.75, 0.95, 0.20833333333333
45613, 0.75, 1, 0.20833333333333
45614, 0.75, 1.05, 0.20833333333333
45615, 0.75, 1.1, 0.20833333333333
45616, 0.75, 1.15, 0.20833333333333
45617, 0.75, 1.2, 0.20833333333333
45618, 0.75, 1.25, 0.20833333333333
45619, 0.75, 1.3, 0.20833333333333
45620, 0.75, 0.2, 0.25
45621, 0.75, 0.25, 0.25
45622, 0.75, 0.3, 0.25
45623, 0.75, 0.35, 0.25
45624, 0.75, 0.4, 0.25
45625, 0.75, 0.45, 0.25
45626, 0.75, 0.5, 0.25
45627, 0.75, 0.55, 0.25
45628, 0.75, 0.6, 0.25
45629, 0.75, 0.65, 0.25
45630, 0.75, 0.7, 0.25
45631, 0.75, 0.75, 0.25
45632, 0.75, 0.8, 0.25
45633, 0.75, 0.85, 0.25
45634, 0.75, 0.9, 0.25
45635, 0.75, 0.95, 0.25
45636, 0.75, 1, 0.25
45637, 0.75, 1.05, 0.25
45638, 0.75, 1.1, 0.25
45639, 0.75, 1.15, 0.25
45640, 0.75, 1.2, 0.25
45641, 0.75, 1.25, 0.25
45642, 0.75, 1.3, 0.25
45643, 0.75, 0.2, 0.29166666666667
45644, 0.75, 0.25, 0.29166666666667
45645, 0.75, 0.3, 0.29166666666667
45646, 0.75, 0.35, 0.29166666666667
45647, 0.75, 0.4, 0.29166666666667
45648, 0.75, 0.45, 0.29166666666667
45649, 0.75, 0.5, 0.29166666666667
45650, 0.75, 0.55, 0.29166666666667
45651, 0.75, 0.6, 0.29166666666667
45652, 0.75, 0.65, 0.29166666666667
45653, 0.75, 0.7, 0.29166666666667
45654, 0.75, 0.75, 0.29166666666667
45655, 0.75, 0.8, 0.29166666666667
45656, 0.75, 0.85, 0.29166666666667
45657, 0.75, 0.9, 0.29166666666667
45658, 0.75, 0.95, 0.29166666666667
45659, 0.75, 1, 0.29166666666667
45660, 0.75, 1.05, 0.29166666666667
45661, 0.75, 1.1, 0.29166666666667
45662, 0.75, 1.15, 0.29166666666667
45663, 0.75, 1.2, 0.29166666666667
45664, 0.75, 1.25, 0.29166666666667
45665, 0.75, 1.3, 0.29166666666667
45666, 0.75, 0.2, 0.33333333333333
45667, 0.75, 0.25, 0.33333333333333
45668, 0.75, 0.3, 0.33333333333333
45669, 0.75, 0.35, 0.33333333333333
45670, 0.75, 0.4, 0.33333333333333
45671, 0.75, 0.45, 0.33333333333333
45672, 0.75, 0.5, 0.33333333333333
45673, 0.75, 0.55, 0.33333333333333
45674, 0.75, 0.6, 0.33333333333333
45675, 0.75, 0.65, 0.33333333333333
45676, 0.75, 0.7, 0.33333333333333
45677, 0.75, 0.75, 0.33333333333333
45678, 0.75, 0.8, 0.33333333333333
45679, 0.75, 0.85, 0.33333333333333
45680, 0.75, 0.9, 0.33333333333333
45681, 0.75, 0.95, 0.33333333333333
45682, 0.75, 1, 0.33333333333333
45683, 0.75, 1.05, 0.33333333333333
45684, 0.75, 1.1, 0.33333333333333
45685, 0.75, 1.15, 0.33333333333333
45686, 0.75, 1.2, 0.33333333333333
45687, 0.75, 1.25, 0.33333333333333
45688, 0.75, 1.3, 0.33333333333333
45689, 0.75, 0.2, 0.375
45690, 0.75, 0.25, 0.375
45691, 0.75, 0.3, 0.375
45692, 0.75, 0.35, 0.375
45693, 0.75, 0.4, 0.375
45694, 0.75, 0.45, 0.375
45695, 0.75, 0.5, 0.375
45696, 0.75, 0.55, 0.375
45697, 0.75, 0.6, 0.375
45698, 0.75, 0.65, 0.375
45699, 0.75, 0.7, 0.375
45700, 0.75, 0.75, 0.375
45701, 0.75, 0.8, 0.375
45702, 0.75, 0.85, 0.375
45703, 0.75, 0.9, 0.375
45704, 0.75, 0.95, 0.375
45705, 0.75, 1, 0.375
45706, 0.75, 1.05, 0.375
45707, 0.75, 1.1, 0.375
45708, 0.75, 1.15, 0.375
45709, 0.75, 1.2, 0.375
45710, 0.75, 1.25, 0.375
45711, 0.75, 1.3, 0.375
45712, 0.75, 0.2, 0.41666666666667
45713, 0.75, 0.25, 0.41666666666667
45714, 0.75, 0.3, 0.41666666666667
45715, 0.75, 0.35, 0.41666666666667
45716, 0.75, 0.4, 0.41666666666667
45717, 0.75, 0.45, 0.41666666666667
45718, 0.75, 0.5, 0.41666666666667
45719, 0.75, 0.55, 0.41666666666667
45720, 0.75, 0.6, 0.41666666666667
45721, 0.75, 0.65, 0.41666666666667
45722, 0.75, 0.7, 0.41666666666667
45723, 0.75, 0.75, 0.41666666666667
45724, 0.75, 0.8, 0.41666666666667
45725, 0.75, 0.85, 0.41666666666667
45726, 0.75, 0.9, 0.41666666666667
45727, 0.75, 0.95, 0.41666666666667
45728, 0.75, 1, 0.41666666666667
45729, 0.75, 1.05, 0.41666666666667
45730, 0.75, 1.1, 0.41666666666667
45731, 0.75, 1.15, 0.41666666666667
45732, 0.75, 1.2, 0.41666666666667
45733, 0.75, 1.25, 0.41666666666667
45734, 0.75, 1.3, 0.41666666666667
45735, 0.75, 0.2, 0.45833333333333
45736, 0.75, 0.25, 0.45833333333333
45737, 0.75, 0.3, 0.45833333333333
45738, 0.75, 0.35, 0.45833333333333
45739, 0.75, 0.4, 0.45833333333333
45740, 0.75, 0.45, 0.45833333333333
45741, 0.75, 0.5, 0.45833333333333
45742, 0.75, 0.55, 0.45833333333333
45743, 0.75, 0.6, 0.45833333333333
45744, 0.75, 0.65, 0.45833333333333
45745, 0.75, 0.7, 0.45833333333333
45746, 0.75, 0.75, 0.45833333333333
45747, 0.75, 0.8, 0.45833333333333
45748, 0.75, 0.85, 0.45833333333333
45749, 0.75, 0.9, 0.45833333333333
45750, 0.75, 0.95, 0.45833333333333
45751, 0.75, 1, 0.45833333333333
45752, 0.75, 1.05, 0.45833333333333
45753, 0.75, 1.1, 0.45833333333333
45754, 0.75, 1.15, 0.45833333333333
45755, 0.75, 1.2, 0.45833333333333
45756, 0.75, 1.25, 0.45833333333333
45757, 0.75, 1.3, 0.45833333333333
45758, 0.79166666666667, 0.2, 0.041666666666667
45759, 0.79166666666667, 0.25, 0.041666666666667
45760, 0.79166666666667, 0.3, 0.041666666666667
45761, 0.79166666666667, 0.35, 0.041666666666667
45762, 0.79166666666667, 0.4, 0.041666666666667
45763, 0.79166666666667, 0.45, 0.041666666666667
45764, 0.79166666666667, 0.5, 0.041666666666667
45765, 0.79166666666667, 0.55, 0.041666666666667
45766, 0.79166666666667, 0.6, 0.041666666666667
45767, 0.79166666666667, 0.65, 0.041666666666667
45768, 0.79166666666667, 0.7, 0.041666666666667
45769, 0.79166666666667, 0.75, 0.041666666666667
45770, 0.79166666666667, 0.8, 0.041666666666667
45771, 0.79166666666667, 0.85, 0.041666666666667
45772, 0.79166666666667, 0.9, 0.041666666666667
45773, 0.79166666666667, 0.95, 0.041666666666667
45774, 0.79166666666667, 1, 0.041666666666667
45775, 0.79166666666667, 1.05, 0.041666666666667
45776, 0.79166666666667, 1.1, 0.041666666666667
45777, 0.79166666666667, 1.15, 0.041666666666667
45778, 0.79166666666667, 1.2, 0.041666666666667
45779, 0.79166666666667, 1.25, 0.041666666666667
45780, 0.79166666666667, 1.3, 0.041666666666667
45781, 0.79166666666667, 0.2, 0.083333333333333
45782, 0.79166666666667, 0.25, 0.083333333333333
45783, 0.79166666666667, 0.3, 0.083333333333333
45784, 0.79166666666667, 0.35, 0.083333333333333
45785, 0.79166666666667, 0.4, 0.083333333333333
45786, 0.79166666666667, 0.45, 0.083333333333333
45787, 0.79166666666667, 0.5, 0.083333333333333
45788, 0.79166666666667, 0.55, 0.083333333333333
45789, 0.79166666666667, 0.6, 0.083333333333333
45790, 0.79166666666667, 0.65, 0.083333333333333
45791, 0.79166666666667, 0.7, 0.083333333333333
45792, 0.79166666666667, 0.75, 0.083333333333333
45793, 0.79166666666667, 0.8, 0.083333333333333
45794, 0.79166666666667, 0.85, 0.083333333333333
45795, 0.79166666666667, 0.9, 0.083333333333333
45796, 0.79166666666667, 0.95, 0.083333333333333
45797, 0.79166666666667, 1, 0.083333333333333
45798, 0.79166666666667, 1.05, 0.083333333333333
45799, 0.79166666666667, 1.1, 0.083333333333333
45800, 0.79166666666667, 1.15, 0.083333333333333
45801, 0.79166666666667, 1.2, 0.083333333333333
45802, 0.79166666666667, 1.25, 0.083333333333333
45803, 0.79166666666667, 1.3, 0.083333333333333
45804, 0.79166666666667, 0.2, 0.125
45805, 0.79166666666667, 0.25, 0.125
45806, 0.79166666666667, 0.3, 0.125
45807, 0.79166666666667, 0.35, 0.125
45808, 0.79166666666667, 0.4, 0.125
45809, 0.79166666666667, 0.45, 0.125
45810, 0.79166666666667, 0.5, 0.125
45811, 0.79166666666667, 0.55, 0.125
45812, 0.79166666666667, 0.6, 0.125
45813, 0.79166666666667, 0.65, 0.125
45814, 0.79166666666667, 0.7, 0.125
45815, 0.79166666666667, 0.75, 0.125
45816, 0.79166666666667, 0.8, 0.125
45817, 0.79166666666667, 0.85, 0.125
45818, 0.79166666666667, 0.9, 0.125
45819, 0.79166666666667, 0.95, 0.125
45820, 0.79166666666667, 1, 0.125
45821, 0.79166666666667, 1.05, 0.125
45822, 0.79166666666667, 1.1, 0.125
45823, 0.79166666666667, 1.15, 0.125
45824, 0.79166666666667, 1.2, 0.125
45825, 0.79166666666667, 1.25, 0.125
45826, 0.79166666666667, 1.3, 0.125
45827, 0.79166666666667, 0.2, 0.16666666666667
45828, 0.79166666666667, 0.25, 0.16666666666667
45829, 0.79166666666667, 0.3, 0.16666666666667
45830, 0.79166666666667, 0.35, 0.16666666666667
45831, 0.79166666666667, 0.4, 0.16666666666667
45832, 0.79166666666667, 0.45, 0.16666666666667
45833, 0.79166666666667, 0.5, 0.16666666666667
45834, 0.79166666666667, 0.55, 0.16666666666667
45835, 0.79166666666667, 0.6, 0.16666666666667
45836, 0.79166666666667, 0.65, 0.16666666666667
45837, 0.79166666666667, 0.7, 0.16666666666667
45838, 0.79166666666667, 0.75, 0.16666666666667
45839, 0.79166666666667, 0.8, 0.16666666666667
45840, 0.79166666666667, 0.85, 0.16666666666667
45841, 0.79166666666667, 0.9, 0.16666666666667
45842, 0.79166666666667, 0.95, 0.16666666666667
45843, 0.79166666666667, 1, 0.16666666666667
45844, 0.79166666666667, 1.05, 0.16666666666667
45845, 0.79166666666667, 1.1, 0.16666666666667
45846, 0.79166666666667, 1.15, 0.16666666666667
45847, 0.79166666666667, 1.2, 0.16666666666667
45848, 0.79166666666667, 1.25, 0.16666666666667
45849, 0.79166666666667, 1.3, 0.16666666666667
45850, 0.79166666666667, 0.2, 0.20833333333333
45851, 0.79166666666667, 0.25, 0.20833333333333
45852, 0.79166666666667, 0.3, 0.20833333333333
45853, 0.79166666666667, 0.35, 0.20833333333333
45854, 0.79166666666667, 0.4, 0.20833333333333
45855, 0.79166666666667, 0.45, 0.20833333333333
45856, 0.79166666666667, 0.5, 0.20833333333333
45857, 0.79166666666667, 0.55, 0.20833333333333
45858, 0.79166666666667, 0.6, 0.20833333333333
45859, 0.79166666666667, 0.65, 0.20833333333333
45860, 0.79166666666667, 0.7, 0.20833333333333
45861, 0.79166666666667, 0.75, 0.20833333333333
45862, 0.79166666666667, 0.8, 0.20833333333333
45863, 0.79166666666667, 0.85, 0.20833333333333
45864, 0.79166666666667, 0.9, 0.20833333333333
45865, 0.79166666666667, 0.95, 0.20833333333333
45866, 0.79166666666667, 1, 0.20833333333333
45867, 0.79166666666667, 1.05, 0.20833333333333
45868, 0.79166666666667, 1.1, 0.20833333333333
45869, 0.79166666666667, 1.15, 0.20833333333333
45870, 0.79166666666667, 1.2, 0.20833333333333
45871, 0.79166666666667, 1.25, 0.20833333333333
45872, 0.79166666666667, 1.3, 0.20833333333333
45873, 0.79166666666667, 0.2, 0.25
45874, 0.79166666666667, 0.25, 0.25
45875, 0.79166666666667, 0.3, 0.25
45876, 0.79166666666667, 0.35, 0.25
45877, 0.79166666666667, 0.4, 0.25
45878, 0.79166666666667, 0.45, 0.25
45879, 0.79166666666667, 0.5, 0.25
45880, 0.79166666666667, 0.55, 0.25
45881, 0.79166666666667, 0.6, 0.25
45882, 0.79166666666667, 0.65, 0.25
45883, 0.79166666666667, 0.7, 0.25
45884, 0.79166666666667, 0.75, 0.25
45885, 0.79166666666667, 0.8, 0.25
45886, 0.79166666666667, 0.85, 0.25
45887, 0.79166666666667, 0.9, 0.25
45888, 0.79166666666667, 0.95, 0.25
45889, 0.79166666666667, 1, 0.25
45890, 0.79166666666667, 1.05, 0.25
45891, 0.79166666666667, 1.1, 0.25
45892, 0.79166666666667, 1.15, 0.25
45893, 0.79166666666667, 1.2, 0.25
45894, 0.79166666666667, 1.25, 0.25
45895, 0.79166666666667, 1.3, 0.25
45896, 0.79166666666667, 0.2, 0.29166666666667
45897, 0.79166666666667, 0.25, 0.29166666666667
45898, 0.79166666666667, 0.3, 0.29166666666667
45899, 0.79166666666667, 0.35, 0.29166666666667
45900, 0.79166666666667, 0.4, 0.29166666666667
45901, 0.79166666666667, 0.45, 0.29166666666667
45902, 0.79166666666667, 0.5, 0.29166666666667
45903, 0.79166666666667, 0.55, 0.29166666666667
45904, 0.79166666666667, 0.6, 0.29166666666667
45905, 0.79166666666667, 0.65, 0.29166666666667
45906, 0.79166666666667, 0.7, 0.29166666666667
45907, 0.79166666666667, 0.75, 0.29166666666667
45908, 0.79166666666667, 0.8, 0.29166666666667
45909, 0.79166666666667, 0.85, 0.29166666666667
45910, 0.79166666666667, 0.9, 0.29166666666667
45911, 0.79166666666667, 0.95, 0.29166666666667
45912, 0.79166666666667, 1, 0.29166666666667
45913, 0.79166666666667, 1.05, 0.29166666666667
45914, 0.79166666666667, 1.1, 0.29166666666667
45915, 0.79166666666667, 1.15, 0.29166666666667
45916, 0.79166666666667, 1.2, 0.29166666666667
45917, 0.79166666666667, 1.25, 0.29166666666667
45918, 0.79166666666667, 1.3, 0.29166666666667
45919, 0.79166666666667, 0.2, 0.33333333333333
45920, 0.79166666666667, 0.25, 0.33333333333333
45921, 0.79166666666667, 0.3, 0.33333333333333
45922, 0.79166666666667, 0.35, 0.33333333333333
45923, 0.79166666666667, 0.4, 0.33333333333333
45924, 0.79166666666667, 0.45, 0.33333333333333
45925, 0.79166666666667, 0.5, 0.33333333333333
45926, 0.79166666666667, 0.55, 0.33333333333333
45927, 0.79166666666667, 0.6, 0.33333333333333
45928, 0.79166666666667, 0.65, 0.33333333333333
45929, 0.79166666666667, 0.7, 0.33333333333333
45930, 0.79166666666667, 0.75, 0.33333333333333
45931, 0.79166666666667, 0.8, 0.33333333333333
45932, 0.79166666666667, 0.85, 0.33333333333333
45933, 0.79166666666667, 0.9, 0.33333333333333
45934, 0.79166666666667, 0.95, 0.33333333333333
45935, 0.79166666666667, 1, 0.33333333333333
45936, 0.79166666666667, 1.05, 0.33333333333333
45937, 0.79166666666667, 1.1, 0.33333333333333
45938, 0.79166666666667, 1.15, 0.33333333333333
45939, 0.79166666666667, 1.2, 0.33333333333333
45940, 0.79166666666667, 1.25, 0.33333333333333
45941, 0.79166666666667, 1.3, 0.33333333333333
45942, 0.79166666666667, 0.2, 0.375
45943, 0.79166666666667, 0.25, 0.375
45944, 0.79166666666667, 0.3, 0.375
45945, 0.79166666666667, 0.35, 0.375
45946, 0.79166666666667, 0.4, 0.375
45947, 0.79166666666667, 0.45, 0.375
45948, 0.79166666666667, 0.5, 0.375
45949, 0.79166666666667, 0.55, 0.375
45950, 0.79166666666667, 0.6, 0.375
45951, 0.79166666666667, 0.65, 0.375
45952, 0.79166666666667, 0.7, 0.375
45953, 0.79166666666667, 0.75, 0.375
45954, 0.79166666666667, 0.8, 0.375
45955, 0.79166666666667, 0.85, 0.375
45956, 0.79166666666667, 0.9, 0.375
45957, 0.79166666666667, 0.95, 0.375
45958, 0.79166666666667, 1, 0.375
45959, 0.79166666666667, 1.05, 0.375
45960, 0.79166666666667, 1.1, 0.375
45961, 0.79166666666667, 1.15, 0.375
45962, 0.79166666666667, 1.2, 0.375
45963, 0.79166666666667, 1.25, 0.375
45964, 0.79166666666667, 1.3, 0.375
45965, 0.79166666666667, 0.2, 0.41666666666667
45966, 0.79166666666667, 0.25, 0.41666666666667
45967, 0.79166666666667, 0.3, 0.41666666666667
45968, 0.79166666666667, 0.35, 0.41666666666667
45969, 0.79166666666667, 0.4, 0.41666666666667
45970, 0.79166666666667, 0.45, 0.41666666666667
45971, 0.79166666666667, 0.5, 0.41666666666667
45972, 0.79166666666667, 0.55, 0.41666666666667
45973, 0.79166666666667, 0.6, 0.41666666666667
45974, 0.79166666666667, 0.65, 0.41666666666667
45975, 0.79166666666667, 0.7, 0.41666666666667
45976, 0.79166666666667, 0.75, 0.41666666666667
45977, 0.79166666666667, 0.8, 0.41666666666667
45978, 0.79166666666667, 0.85, 0.41666666666667
45979, 0.79166666666667, 0.9, 0.41666666666667
45980, 0.79166666666667, 0.95, 0.41666666666667
45981, 0.79166666666667, 1, 0.41666666666667
45982, 0.79166666666667, 1.05, 0.41666666666667
45983, 0.79166666666667, 1.1, 0.41666666666667
45984, 0.79166666666667, 1.15, 0.41666666666667
45985, 0.79166666666667, 1.2, 0.41666666666667
45986, 0.79166666666667, 1.25, 0.41666666666667
45987, 0.79166666666667, 1.3, 0.41666666666667
45988, 0.79166666666667, 0.2, 0.45833333333333
45989, 0.79166666666667, 0.25, 0.45833333333333
45990, 0.79166666666667, 0.3, 0.45833333333333
45991, 0.79166666666667, 0.35, 0.45833333333333
45992, 0.79166666666667, 0.4, 0.45833333333333
45993, 0.79166666666667, 0.45, 0.45833333333333
45994, 0.79166666666667, 0.5, 0.45833333333333
45995, 0.79166666666667, 0.55, 0.45833333333333
45996, 0.79166666666667, 0.6, 0.45833333333333
45997, 0.79166666666667, 0.65, 0.45833333333333
45998, 0.79166666666667, 0.7, 0.45833333333333
45999, 0.79166666666667, 0.75, 0.45833333333333
46000, 0.79166666666667, 0.8, 0.45833333333333
46001, 0.79166666666667, 0.85, 0.45833333333333
46002, 0.79166666666667, 0.9, 0.45833333333333
46003, 0.79166666666667, 0.95, 0.45833333333333
46004, 0.79166666666667, 1, 0.45833333333333
46005, 0.79166666666667, 1.05, 0.45833333333333
46006, 0.79166666666667, 1.1, 0.45833333333333
46007, 0.79166666666667, 1.15, 0.45833333333333
46008, 0.79166666666667, 1.2, 0.45833333333333
46009, 0.79166666666667, 1.25, 0.45833333333333
46010, 0.79166666666667, 1.3, 0.45833333333333
46011, 0.83333333333333, 0.2, 0.041666666666667
46012, 0.83333333333333, 0.25, 0.041666666666667
46013, 0.83333333333333, 0.3, 0.041666666666667
46014, 0.83333333333333, 0.35, 0.041666666666667
46015, 0.83333333333333, 0.4, 0.041666666666667
46016, 0.83333333333333, 0.45, 0.041666666666667
46017, 0.83333333333333, 0.5, 0.041666666666667
46018, 0.83333333333333, 0.55, 0.041666666666667
46019, 0.83333333333333, 0.6, 0.041666666666667
46020, 0.83333333333333, 0.65, 0.041666666666667
46021, 0.83333333333333, 0.7, 0.041666666666667
46022, 0.83333333333333, 0.75, 0.041666666666667
46023, 0.83333333333333, 0.8, 0.041666666666667
46024, 0.83333333333333, 0.85, 0.041666666666667
46025, 0.83333333333333, 0.9, 0.041666666666667
46026, 0.83333333333333, 0.95, 0.041666666666667
46027, 0.83333333333333, 1, 0.041666666666667
46028, 0.83333333333333, 1.05, 0.041666666666667
46029, 0.83333333333333, 1.1, 0.041666666666667
46030, 0.83333333333333, 1.15, 0.041666666666667
46031, 0.83333333333333, 1.2, 0.041666666666667
46032, 0.83333333333333, 1.25, 0.041666666666667
46033, 0.83333333333333, 1.3, 0.041666666666667
46034, 0.83333333333333, 0.2, 0.083333333333333
46035, 0.83333333333333, 0.25, 0.083333333333333
46036, 0.83333333333333, 0.3, 0.083333333333333
46037, 0.83333333333333, 0.35, 0.083333333333333
46038, 0.83333333333333, 0.4, 0.083333333333333
46039, 0.83333333333333, 0.45, 0.083333333333333
46040, 0.83333333333333, 0.5, 0.083333333333333
46041, 0.83333333333333, 0.55, 0.083333333333333
46042, 0.83333333333333, 0.6, 0.083333333333333
46043, 0.83333333333333, 0.65, 0.083333333333333
46044, 0.83333333333333, 0.7, 0.083333333333333
46045, 0.83333333333333, 0.75, 0.083333333333333
46046, 0.83333333333333, 0.8, 0.083333333333333
46047, 0.83333333333333, 0.85, 0.083333333333333
46048, 0.83333333333333, 0.9, 0.083333333333333
46049, 0.83333333333333, 0.95, 0.083333333333333
46050, 0.83333333333333, 1, 0.083333333333333
46051, 0.83333333333333, 1.05, 0.083333333333333
46052, 0.83333333333333, 1.1, 0.083333333333333
46053, 0.83333333333333, 1.15, 0.083333333333333
46054, 0.83333333333333, 1.2, 0.083333333333333
46055, 0.83333333333333, 1.25, 0.083333333333333
46056, 0.83333333333333, 1.3, 0.083333333333333
46057, 0.83333333333333, 0.2, 0.125
46058, 0.83333333333333, 0.25, 0.125
46059, 0.83333333333333, 0.3, 0.125
46060, 0.83333333333333, 0.35, 0.125
46061, 0.83333333333333, 0.4, 0.125
46062, 0.83333333333333, 0.45, 0.125
46063, 0.83333333333333, 0.5, 0.125
46064, 0.83333333333333, 0.55, 0.125
46065, 0.83333333333333, 0.6, 0.125
46066, 0.83333333333333, 0.65, 0.125
46067, 0.83333333333333, 0.7, 0.125
46068, 0.83333333333333, 0.75, 0.125
46069, 0.83333333333333, 0.8, 0.125
46070, 0.83333333333333, 0.85, 0.125
46071, 0.83333333333333, 0.9, 0.125
46072, 0.83333333333333, 0.95, 0.125
46073, 0.83333333333333, 1, 0.125
46074, 0.83333333333333, 1.05, 0.125
46075, 0.83333333333333, 1.1, 0.125
46076, 0.83333333333333, 1.15, 0.125
46077, 0.83333333333333, 1.2, 0.125
46078, 0.83333333333333, 1.25, 0.125
46079, 0.83333333333333, 1.3, 0.125
46080, 0.83333333333333, 0.2, 0.16666666666667
46081, 0.83333333333333, 0.25, 0.16666666666667
46082, 0.83333333333333, 0.3, 0.16666666666667
46083, 0.83333333333333, 0.35, 0.16666666666667
46084, 0.83333333333333, 0.4, 0.16666666666667
46085, 0.83333333333333, 0.45, 0.16666666666667
46086, 0.83333333333333, 0.5, 0.16666666666667
46087, 0.83333333333333, 0.55, 0.16666666666667
46088, 0.83333333333333, 0.6, 0.16666666666667
46089, 0.83333333333333, 0.65, 0.16666666666667
46090, 0.83333333333333, 0.7, 0.16666666666667
46091, 0.83333333333333, 0.75, 0.16666666666667
46092, 0.83333333333333, 0.8, 0.16666666666667
46093, 0.83333333333333, 0.85, 0.16666666666667
46094, 0.83333333333333, 0.9, 0.16666666666667
46095, 0.83333333333333, 0.95, 0.16666666666667
46096, 0.83333333333333, 1, 0.16666666666667
46097, 0.83333333333333, 1.05, 0.16666666666667
46098, 0.83333333333333, 1.1, 0.16666666666667
46099, 0.83333333333333, 1.15, 0.16666666666667
46100, 0.83333333333333, 1.2, 0.16666666666667
46101, 0.83333333333333, 1.25, 0.16666666666667
46102, 0.83333333333333, 1.3, 0.16666666666667
46103, 0.83333333333333, 0.2, 0.20833333333333
46104, 0.83333333333333, 0.25, 0.20833333333333
46105, 0.83333333333333, 0.3, 0.20833333333333
46106, 0.83333333333333, 0.35, 0.20833333333333
46107, 0.83333333333333, 0.4, 0.20833333333333
46108, 0.83333333333333, 0.45, 0.20833333333333
46109, 0.83333333333333, 0.5, 0.20833333333333
46110, 0.83333333333333, 0.55, 0.20833333333333
46111, 0.83333333333333, 0.6, 0.20833333333333
46112, 0.83333333333333, 0.65, 0.20833333333333
46113, 0.83333333333333, 0.7, 0.20833333333333
46114, 0.83333333333333, 0.75, 0.20833333333333
46115, 0.83333333333333, 0.8, 0.20833333333333
46116, 0.83333333333333, 0.85, 0.20833333333333
46117, 0.83333333333333, 0.9, 0.20833333333333
46118, 0.83333333333333, 0.95, 0.20833333333333
46119, 0.83333333333333, 1, 0.20833333333333
46120, 0.83333333333333, 1.05, 0.20833333333333
46121, 0.83333333333333, 1.1, 0.20833333333333
46122, 0.83333333333333, 1.15, 0.20833333333333
46123, 0.83333333333333, 1.2, 0.20833333333333
46124, 0.83333333333333, 1.25, 0.20833333333333
46125, 0.83333333333333, 1.3, 0.20833333333333
46126, 0.83333333333333, 0.2, 0.25
46127, 0.83333333333333, 0.25, 0.25
46128, 0.83333333333333, 0.3, 0.25
46129, 0.83333333333333, 0.35, 0.25
46130, 0.83333333333333, 0.4, 0.25
46131, 0.83333333333333, 0.45, 0.25
46132, 0.83333333333333, 0.5, 0.25
46133, 0.83333333333333, 0.55, 0.25
46134, 0.83333333333333, 0.6, 0.25
46135, 0.83333333333333, 0.65, 0.25
46136, 0.83333333333333, 0.7, 0.25
46137, 0.83333333333333, 0.75, 0.25
46138, 0.83333333333333, 0.8, 0.25
46139, 0.83333333333333, 0.85, 0.25
46140, 0.83333333333333, 0.9, 0.25
46141, 0.83333333333333, 0.95, 0.25
46142, 0.83333333333333, 1, 0.25
46143, 0.83333333333333, 1.05, 0.25
46144, 0.83333333333333, 1.1, 0.25
46145, 0.83333333333333, 1.15, 0.25
46146, 0.83333333333333, 1.2, 0.25
46147, 0.83333333333333, 1.25, 0.25
46148, 0.83333333333333, 1.3, 0.25
46149, 0.83333333333333, 0.2, 0.29166666666667
46150, 0.83333333333333, 0.25, 0.29166666666667
46151, 0.83333333333333, 0.3, 0.29166666666667
46152, 0.83333333333333, 0.35, 0.29166666666667
46153, 0.83333333333333, 0.4, 0.29166666666667
46154, 0.83333333333333, 0.45, 0.29166666666667
46155, 0.83333333333333, 0.5, 0.29166666666667
46156, 0.83333333333333, 0.55, 0.29166666666667
46157, 0.83333333333333, 0.6, 0.29166666666667
46158, 0.83333333333333, 0.65, 0.29166666666667
46159, 0.83333333333333, 0.7, 0.29166666666667
46160, 0.83333333333333, 0.75, 0.29166666666667
46161, 0.83333333333333, 0.8, 0.29166666666667
46162, 0.83333333333333, 0.85, 0.29166666666667
46163, 0.83333333333333, 0.9, 0.29166666666667
46164, 0.83333333333333, 0.95, 0.29166666666667
46165, 0.83333333333333, 1, 0.29166666666667
46166, 0.83333333333333, 1.05, 0.29166666666667
46167, 0.83333333333333, 1.1, 0.29166666666667
46168, 0.83333333333333, 1.15, 0.29166666666667
46169, 0.83333333333333, 1.2, 0.29166666666667
46170, 0.83333333333333, 1.25, 0.29166666666667
46171, 0.83333333333333, 1.3, 0.29166666666667
46172, 0.83333333333333, 0.2, 0.33333333333333
46173, 0.83333333333333, 0.25, 0.33333333333333
46174, 0.83333333333333, 0.3, 0.33333333333333
46175, 0.83333333333333, 0.35, 0.33333333333333
46176, 0.83333333333333, 0.4, 0.33333333333333
46177, 0.83333333333333, 0.45, 0.33333333333333
46178, 0.83333333333333, 0.5, 0.33333333333333
46179, 0.83333333333333, 0.55, 0.33333333333333
46180, 0.83333333333333, 0.6, 0.33333333333333
46181, 0.83333333333333, 0.65, 0.33333333333333
46182, 0.83333333333333, 0.7, 0.33333333333333
46183, 0.83333333333333, 0.75, 0.33333333333333
46184, 0.83333333333333, 0.8, 0.33333333333333
46185, 0.83333333333333, 0.85, 0.33333333333333
46186, 0.83333333333333, 0.9, 0.33333333333333
46187, 0.83333333333333, 0.95, 0.33333333333333
46188, 0.83333333333333, 1, 0.33333333333333
46189, 0.83333333333333, 1.05, 0.33333333333333
46190, 0.83333333333333, 1.1, 0.33333333333333
46191, 0.83333333333333, 1.15, 0.33333333333333
46192, 0.83333333333333, 1.2, 0.33333333333333
46193, 0.83333333333333, 1.25, 0.33333333333333
46194, 0.83333333333333, 1.3, 0.33333333333333
46195, 0.83333333333333, 0.2, 0.375
46196, 0.83333333333333, 0.25, 0.375
46197, 0.83333333333333, 0.3, 0.375
46198, 0.83333333333333, 0.35, 0.375
46199, 0.83333333333333, 0.4, 0.375
46200, 0.83333333333333, 0.45, 0.375
46201, 0.83333333333333, 0.5, 0.375
46202, 0.83333333333333, 0.55, 0.375
46203, 0.83333333333333, 0.6, 0.375
46204, 0.83333333333333, 0.65, 0.375
46205, 0.83333333333333, 0.7, 0.375
46206, 0.83333333333333, 0.75, 0.375
46207, 0.83333333333333, 0.8, 0.375
46208, 0.83333333333333, 0.85, 0.375
46209, 0.83333333333333, 0.9, 0.375
46210, 0.83333333333333, 0.95, 0.375
46211, 0.83333333333333, 1, 0.375
46212, 0.83333333333333, 1.05, 0.375
46213, 0.83333333333333, 1.1, 0.375
46214, 0.83333333333333, 1.15, 0.375
46215, 0.83333333333333, 1.2, 0.375
46216, 0.83333333333333, 1.25, 0.375
46217, 0.83333333333333, 1.3, 0.375
46218, 0.83333333333333, 0.2, 0.41666666666667
46219, 0.83333333333333, 0.25, 0.41666666666667
46220, 0.83333333333333, 0.3, 0.41666666666667
46221, 0.83333333333333, 0.35, 0.41666666666667
46222, 0.83333333333333, 0.4, 0.41666666666667
46223, 0.83333333333333, 0.45, 0.41666666666667
46224, 0.83333333333333, 0.5, 0.41666666666667
46225, 0.83333333333333, 0.55, 0.41666666666667
46226, 0.83333333333333, 0.6, 0.41666666666667
46227, 0.83333333333333, 0.65, 0.41666666666667
46228, 0.83333333333333, 0.7, 0.41666666666667
46229, 0.83333333333333, 0.75, 0.41666666666667
46230, 0.83333333333333, 0.8, 0.41666666666667
46231, 0.83333333333333, 0.85, 0.41666666666667
46232, 0.83333333333333, 0.9, 0.41666666666667
46233, 0.83333333333333, 0.95, 0.41666666666667
46234, 0.83333333333333, 1, 0.41666666666667
46235, 0.83333333333333, 1.05, 0.41666666666667
46236, 0.83333333333333, 1.1, 0.41666666666667
46237, 0.83333333333333, 1.15, 0.41666666666667
46238, 0.83333333333333, 1.2, 0.41666666666667
46239, 0.83333333333333, 1.25, 0.41666666666667
46240, 0.83333333333333, 1.3, 0.41666666666667
46241, 0.83333333333333, 0.2, 0.45833333333333
46242, 0.83333333333333, 0.25, 0.45833333333333
46243, 0.83333333333333, 0.3, 0.45833333333333
46244, 0.83333333333333, 0.35, 0.45833333333333
46245, 0.83333333333333, 0.4, 0.45833333333333
46246, 0.83333333333333, 0.45, 0.45833333333333
46247, 0.83333333333333, 0.5, 0.45833333333333
46248, 0.83333333333333, 0.55, 0.45833333333333
46249, 0.83333333333333, 0.6, 0.45833333333333
46250, 0.83333333333333, 0.65, 0.45833333333333
46251, 0.83333333333333, 0.7, 0.45833333333333
46252, 0.83333333333333, 0.75, 0.45833333333333
46253, 0.83333333333333, 0.8, 0.45833333333333
46254, 0.83333333333333, 0.85, 0.45833333333333
46255, 0.83333333333333, 0.9, 0.45833333333333
46256, 0.83333333333333, 0.95, 0.45833333333333
46257, 0.83333333333333, 1, 0.45833333333333
46258, 0.83333333333333, 1.05, 0.45833333333333
46259, 0.83333333333333, 1.1, 0.45833333333333
46260, 0.83333333333333, 1.15, 0.45833333333333
46261, 0.83333333333333, 1.2, 0.45833333333333
46262, 0.83333333333333, 1.25, 0.45833333333333
46263, 0.83333333333333, 1.3, 0.45833333333333
46264, 0.875, 0.2, 0.041666666666667
46265, 0.875, 0.25, 0.041666666666667
46266, 0.875, 0.3, 0.041666666666667
46267, 0.875, 0.35, 0.041666666666667
46268, 0.875, 0.4, 0.041666666666667
46269, 0.875, 0.45, 0.041666666666667
46270, 0.875, 0.5, 0.041666666666667
46271, 0.875, 0.55, 0.041666666666667
46272, 0.875, 0.6, 0.041666666666667
46273, 0.875, 0.65, 0.041666666666667
46274, 0.875, 0.7, 0.041666666666667
46275, 0.875, 0.75, 0.041666666666667
46276, 0.875, 0.8, 0.041666666666667
46277, 0.875, 0.85, 0.041666666666667
46278, 0.875, 0.9, 0.041666666666667
46279, 0.875, 0.95, 0.041666666666667
46280, 0.875, 1, 0.041666666666667
46281, 0.875, 1.05, 0.041666666666667
46282, 0.875, 1.1, 0.041666666666667
46283, 0.875, 1.15, 0.041666666666667
46284, 0.875, 1.2, 0.041666666666667
46285, 0.875, 1.25, 0.041666666666667
46286, 0.875, 1.3, 0.041666666666667
46287, 0.875, 0.2, 0.083333333333333
46288, 0.875, 0.25, 0.083333333333333
46289, 0.875, 0.3, 0.083333333333333
46290, 0.875, 0.35, 0.083333333333333
46291, 0.875, 0.4, 0.083333333333333
46292, 0.875, 0.45, 0.083333333333333
46293, 0.875, 0.5, 0.083333333333333
46294, 0.875, 0.55, 0.083333333333333
46295, 0.875, 0.6, 0.083333333333333
46296, 0.875, 0.65, 0.083333333333333
46297, 0.875, 0.7, 0.083333333333333
46298, 0.875, 0.75, 0.083333333333333
46299, 0.875, 0.8, 0.083333333333333
46300, 0.875, 0.85, 0.083333333333333
46301, 0.875, 0.9, 0.083333333333333
46302, 0.875, 0.95, 0.083333333333333
46303, 0.875, 1, 0.083333333333333
46304, 0.875, 1.05, 0.083333333333333
46305, 0.875, 1.1, 0.083333333333333
46306, 0.875, 1.15, 0.083333333333333
46307, 0.875, 1.2, 0.083333333333333
46308, 0.875, 1.25, 0.083333333333333
46309, 0.875, 1.3, 0.083333333333333
46310, 0.875, 0.2, 0.125
46311, 0.875, 0.25, 0.125
46312, 0.875, 0.3, 0.125
46313, 0.875, 0.35, 0.125
46314, 0.875, 0.4, 0.125
46315, 0.875, 0.45, 0.125
46316, 0.875, 0.5, 0.125
46317, 0.875, 0.55, 0.125
46318, 0.875, 0.6, 0.125
46319, 0.875, 0.65, 0.125
46320, 0.875, 0.7, 0.125
46321, 0.875, 0.75, 0.125
46322, 0.875, 0.8, 0.125
46323, 0.875, 0.85, 0.125
46324, 0.875, 0.9, 0.125
46325, 0.875, 0.95, 0.125
46326, 0.875, 1, 0.125
46327, 0.875, 1.05, 0.125
46328, 0.875, 1.1, 0.125
46329, 0.875, 1.15, 0.125
46330, 0.875, 1.2, 0.125
46331, 0.875, 1.25, 0.125
46332, 0.875, 1.3, 0.125
46333, 0.875, 0.2, 0.16666666666667
46334, 0.875, 0.25, 0.16666666666667
46335, 0.875, 0.3, 0.16666666666667
46336, 0.875, 0.35, 0.16666666666667
46337, 0.875, 0.4, 0.16666666666667
46338, 0.875, 0.45, 0.16666666666667
46339, 0.875, 0.5, 0.16666666666667
46340, 0.875, 0.55, 0.16666666666667
46341, 0.875, 0.6, 0.16666666666667
46342, 0.875, 0.65, 0.16666666666667
46343, 0.875, 0.7, 0.16666666666667
46344, 0.875, 0.75, 0.16666666666667
46345, 0.875, 0.8, 0.16666666666667
46346, 0.875, 0.85, 0.16666666666667
46347, 0.875, 0.9, 0.16666666666667
46348, 0.875, 0.95, 0.16666666666667
46349, 0.875, 1, 0.16666666666667
46350, 0.875, 1.05, 0.16666666666667
46351, 0.875, 1.1, 0.16666666666667
46352, 0.875, 1.15, 0.16666666666667
46353, 0.875, 1.2, 0.16666666666667
46354, 0.875, 1.25, 0.16666666666667
46355, 0.875, 1.3, 0.16666666666667
46356, 0.875, 0.2, 0.20833333333333
46357, 0.875, 0.25, 0.20833333333333
46358, 0.875, 0.3, 0.20833333333333
46359, 0.875, 0.35, 0.20833333333333
46360, 0.875, 0.4, 0.20833333333333
46361, 0.875, 0.45, 0.20833333333333
46362, 0.875, 0.5, 0.20833333333333
46363, 0.875, 0.55, 0.20833333333333
46364, 0.875, 0.6, 0.20833333333333
46365, 0.875, 0.65, 0.20833333333333
46366, 0.875, 0.7, 0.20833333333333
46367, 0.875, 0.75, 0.20833333333333
46368, 0.875, 0.8, 0.20833333333333
46369, 0.875, 0.85, 0.20833333333333
46370, 0.875, 0.9, 0.20833333333333
46371, 0.875, 0.95, 0.20833333333333
46372, 0.875, 1, 0.20833333333333
46373, 0.875, 1.05, 0.20833333333333
46374, 0.875, 1.1, 0.20833333333333
46375, 0.875, 1.15, 0.20833333333333
46376, 0.875, 1.2, 0.20833333333333
46377, 0.875, 1.25, 0.20833333333333
46378, 0.875, 1.3, 0.20833333333333
46379, 0.875, 0.2, 0.25
46380, 0.875, 0.25, 0.25
46381, 0.875, 0.3, 0.25
46382, 0.875, 0.35, 0.25
46383, 0.875, 0.4, 0.25
46384, 0.875, 0.45, 0.25
46385, 0.875, 0.5, 0.25
46386, 0.875, 0.55, 0.25
46387, 0.875, 0.6, 0.25
46388, 0.875, 0.65, 0.25
46389, 0.875, 0.7, 0.25
46390, 0.875, 0.75, 0.25
46391, 0.875, 0.8, 0.25
46392, 0.875, 0.85, 0.25
46393, 0.875, 0.9, 0.25
46394, 0.875, 0.95, 0.25
46395, 0.875, 1, 0.25
46396, 0.875, 1.05, 0.25
46397, 0.875, 1.1, 0.25
46398, 0.875, 1.15, 0.25
46399, 0.875, 1.2, 0.25
46400, 0.875, 1.25, 0.25
46401, 0.875, 1.3, 0.25
46402, 0.875, 0.2, 0.29166666666667
46403, 0.875, 0.25, 0.29166666666667
46404, 0.875, 0.3, 0.29166666666667
46405, 0.875, 0.35, 0.29166666666667
46406, 0.875, 0.4, 0.29166666666667
46407, 0.875, 0.45, 0.29166666666667
46408, 0.875, 0.5, 0.29166666666667
46409, 0.875, 0.55, 0.29166666666667
46410, 0.875, 0.6, 0.29166666666667
46411, 0.875, 0.65, 0.29166666666667
46412, 0.875, 0.7, 0.29166666666667
46413, 0.875, 0.75, 0.29166666666667
46414, 0.875, 0.8, 0.29166666666667
46415, 0.875, 0.85, 0.29166666666667
46416, 0.875, 0.9, 0.29166666666667
46417, 0.875, 0.95, 0.29166666666667
46418, 0.875, 1, 0.29166666666667
46419, 0.875, 1.05, 0.29166666666667
46420, 0.875, 1.1, 0.29166666666667
46421, 0.875, 1.15, 0.29166666666667
46422, 0.875, 1.2, 0.29166666666667
46423, 0.875, 1.25, 0.29166666666667
46424, 0.875, 1.3, 0.29166666666667
46425, 0.875, 0.2, 0.33333333333333
46426, 0.875, 0.25, 0.33333333333333
46427, 0.875, 0.3, 0.33333333333333
46428, 0.875, 0.35, 0.33333333333333
46429, 0.875, 0.4, 0.33333333333333
46430, 0.875, 0.45, 0.33333333333333
46431, 0.875, 0.5, 0.33333333333333
46432, 0.875, 0.55, 0.33333333333333
46433, 0.875, 0.6, 0.33333333333333
46434, 0.875, 0.65, 0.33333333333333
46435, 0.875, 0.7, 0.33333333333333
46436, 0.875, 0.75, 0.33333333333333
46437, 0.875, 0.8, 0.33333333333333
46438, 0.875, 0.85, 0.33333333333333
46439, 0.875, 0.9, 0.33333333333333
46440, 0.875, 0.95, 0.33333333333333
46441, 0.875, 1, 0.33333333333333
46442, 0.875, 1.05, 0.33333333333333
46443, 0.875, 1.1, 0.33333333333333
46444, 0.875, 1.15, 0.33333333333333
46445, 0.875, 1.2, 0.33333333333333
46446, 0.875, 1.25, 0.33333333333333
46447, 0.875, 1.3, 0.33333333333333
46448, 0.875, 0.2, 0.375
46449, 0.875, 0.25, 0.375
46450, 0.875, 0.3, 0.375
46451, 0.875, 0.35, 0.375
46452, 0.875, 0.4, 0.375
46453, 0.875, 0.45, 0.375
46454, 0.875, 0.5, 0.375
46455, 0.875, 0.55, 0.375
46456, 0.875, 0.6, 0.375
46457, 0.875, 0.65, 0.375
46458, 0.875, 0.7, 0.375
46459, 0.875, 0.75, 0.375
46460, 0.875, 0.8, 0.375
46461, 0.875, 0.85, 0.375
46462, 0.875, 0.9, 0.375
46463, 0.875, 0.95, 0.375
46464, 0.875, 1, 0.375
46465, 0.875, 1.05, 0.375
46466, 0.875, 1.1, 0.375
46467, 0.875, 1.15, 0.375
46468, 0.875, 1.2, 0.375
46469, 0.875, 1.25, 0.375
46470, 0.875, 1.3, 0.375
46471, 0.875, 0.2, 0.41666666666667
46472, 0.875, 0.25, 0.41666666666667
46473, 0.875, 0.3, 0.41666666666667
46474, 0.875, 0.35, 0.41666666666667
46475, 0.875, 0.4, 0.41666666666667
46476, 0.875, 0.45, 0.41666666666667
46477, 0.875, 0.5, 0.41666666666667
46478, 0.875, 0.55, 0.41666666666667
46479, 0.875, 0.6, 0.41666666666667
46480, 0.875, 0.65, 0.41666666666667
46481, 0.875, 0.7, 0.41666666666667
46482, 0.875, 0.75, 0.41666666666667
46483, 0.875, 0.8, 0.41666666666667
46484, 0.875, 0.85, 0.41666666666667
46485, 0.875, 0.9, 0.41666666666667
46486, 0.875, 0.95, 0.41666666666667
46487, 0.875, 1, 0.41666666666667
46488, 0.875, 1.05, 0.41666666666667
46489, 0.875, 1.1, 0.41666666666667
46490, 0.875, 1.15, 0.41666666666667
46491, 0.875, 1.2, 0.41666666666667
46492, 0.875, 1.25, 0.41666666666667
46493, 0.875, 1.3, 0.41666666666667
46494, 0.875, 0.2, 0.45833333333333
46495, 0.875, 0.25, 0.45833333333333
46496, 0.875, 0.3, 0.45833333333333
46497, 0.875, 0.35, 0.45833333333333
46498, 0.875, 0.4, 0.45833333333333
46499, 0.875, 0.45, 0.45833333333333
46500, 0.875, 0.5, 0.45833333333333
46501, 0.875, 0.55, 0.45833333333333
46502, 0.875, 0.6, 0.45833333333333
46503, 0.875, 0.65, 0.45833333333333
46504, 0.875, 0.7, 0.45833333333333
46505, 0.875, 0.75, 0.45833333333333
46506, 0.875, 0.8, 0.45833333333333
46507, 0.875, 0.85, 0.45833333333333
46508, 0.875, 0.9, 0.45833333333333
46509, 0.875, 0.95, 0.45833333333333
46510, 0.875, 1, 0.45833333333333
46511, 0.875, 1.05, 0.45833333333333
46512, 0.875, 1.1, 0.45833333333333
46513, 0.875, 1.15, 0.45833333333333
46514, 0.875, 1.2, 0.45833333333333
46515, 0.875, 1.25, 0.45833333333333
46516, 0.875, 1.3, 0.45833333333333
46517, 0.91666666666667, 0.2, 0.041666666666667
46518, 0.91666666666667, 0.25, 0.041666666666667
46519, 0.91666666666667, 0.3, 0.041666666666667
46520, 0.91666666666667, 0.35, 0.041666666666667
46521, 0.91666666666667, 0.4, 0.041666666666667
46522, 0.91666666666667, 0.45, 0.041666666666667
46523, 0.91666666666667, 0.5, 0.041666666666667
46524, 0.91666666666667, 0.55, 0.041666666666667
46525, 0.91666666666667, 0.6, 0.041666666666667
46526, 0.91666666666667, 0.65, 0.041666666666667
46527, 0.91666666666667, 0.7, 0.041666666666667
46528, 0.91666666666667, 0.75, 0.041666666666667
46529, 0.91666666666667, 0.8, 0.041666666666667
46530, 0.91666666666667, 0.85, 0.041666666666667
46531, 0.91666666666667, 0.9, 0.041666666666667
46532, 0.91666666666667, 0.95, 0.041666666666667
46533, 0.91666666666667, 1, 0.041666666666667
46534, 0.91666666666667, 1.05, 0.041666666666667
46535, 0.91666666666667, 1.1, 0.041666666666667
46536, 0.91666666666667, 1.15, 0.041666666666667
46537, 0.91666666666667, 1.2, 0.041666666666667
46538, 0.91666666666667, 1.25, 0.041666666666667
46539, 0.91666666666667, 1.3, 0.041666666666667
46540, 0.91666666666667, 0.2, 0.083333333333333
46541, 0.91666666666667, 0.25, 0.083333333333333
46542, 0.91666666666667, 0.3, 0.083333333333333
46543, 0.91666666666667, 0.35, 0.083333333333333
46544, 0.91666666666667, 0.4, 0.083333333333333
46545, 0.91666666666667, 0.45, 0.083333333333333
46546, 0.91666666666667, 0.5, 0.083333333333333
46547, 0.91666666666667, 0.55, 0.083333333333333
46548, 0.91666666666667, 0.6, 0.083333333333333
46549, 0.91666666666667, 0.65, 0.083333333333333
46550, 0.91666666666667, 0.7, 0.083333333333333
46551, 0.91666666666667, 0.75, 0.083333333333333
46552, 0.91666666666667, 0.8, 0.083333333333333
46553, 0.91666666666667, 0.85, 0.083333333333333
46554, 0.91666666666667, 0.9, 0.083333333333333
46555, 0.91666666666667, 0.95, 0.083333333333333
46556, 0.91666666666667, 1, 0.083333333333333
46557, 0.91666666666667, 1.05, 0.083333333333333
46558, 0.91666666666667, 1.1, 0.083333333333333
46559, 0.91666666666667, 1.15, 0.083333333333333
46560, 0.91666666666667, 1.2, 0.083333333333333
46561, 0.91666666666667, 1.25, 0.083333333333333
46562, 0.91666666666667, 1.3, 0.083333333333333
46563, 0.91666666666667, 0.2, 0.125
46564, 0.91666666666667, 0.25, 0.125
46565, 0.91666666666667, 0.3, 0.125
46566, 0.91666666666667, 0.35, 0.125
46567, 0.91666666666667, 0.4, 0.125
46568, 0.91666666666667, 0.45, 0.125
46569, 0.91666666666667, 0.5, 0.125
46570, 0.91666666666667, 0.55, 0.125
46571, 0.91666666666667, 0.6, 0.125
46572, 0.91666666666667, 0.65, 0.125
46573, 0.91666666666667, 0.7, 0.125
46574, 0.91666666666667, 0.75, 0.125
46575, 0.91666666666667, 0.8, 0.125
46576, 0.91666666666667, 0.85, 0.125
46577, 0.91666666666667, 0.9, 0.125
46578, 0.91666666666667, 0.95, 0.125
46579, 0.91666666666667, 1, 0.125
46580, 0.91666666666667, 1.05, 0.125
46581, 0.91666666666667, 1.1, 0.125
46582, 0.91666666666667, 1.15, 0.125
46583, 0.91666666666667, 1.2, 0.125
46584, 0.91666666666667, 1.25, 0.125
46585, 0.91666666666667, 1.3, 0.125
46586, 0.91666666666667, 0.2, 0.16666666666667
46587, 0.91666666666667, 0.25, 0.16666666666667
46588, 0.91666666666667, 0.3, 0.16666666666667
46589, 0.91666666666667, 0.35, 0.16666666666667
46590, 0.91666666666667, 0.4, 0.16666666666667
46591, 0.91666666666667, 0.45, 0.16666666666667
46592, 0.91666666666667, 0.5, 0.16666666666667
46593, 0.91666666666667, 0.55, 0.16666666666667
46594, 0.91666666666667, 0.6, 0.16666666666667
46595, 0.91666666666667, 0.65, 0.16666666666667
46596, 0.91666666666667, 0.7, 0.16666666666667
46597, 0.91666666666667, 0.75, 0.16666666666667
46598, 0.91666666666667, 0.8, 0.16666666666667
46599, 0.91666666666667, 0.85, 0.16666666666667
46600, 0.91666666666667, 0.9, 0.16666666666667
46601, 0.91666666666667, 0.95, 0.16666666666667
46602, 0.91666666666667, 1, 0.16666666666667
46603, 0.91666666666667, 1.05, 0.16666666666667
46604, 0.91666666666667, 1.1, 0.16666666666667
46605, 0.91666666666667, 1.15, 0.16666666666667
46606, 0.91666666666667, 1.2, 0.16666666666667
46607, 0.91666666666667, 1.25, 0.16666666666667
46608, 0.91666666666667, 1.3, 0.16666666666667
46609, 0.91666666666667, 0.2, 0.20833333333333
46610, 0.91666666666667, 0.25, 0.20833333333333
46611, 0.91666666666667, 0.3, 0.20833333333333
46612, 0.91666666666667, 0.35, 0.20833333333333
46613, 0.91666666666667, 0.4, 0.20833333333333
46614, 0.91666666666667, 0.45, 0.20833333333333
46615, 0.91666666666667, 0.5, 0.20833333333333
46616, 0.91666666666667, 0.55, 0.20833333333333
46617, 0.91666666666667, 0.6, 0.20833333333333
46618, 0.91666666666667, 0.65, 0.20833333333333
46619, 0.91666666666667, 0.7, 0.20833333333333
46620, 0.91666666666667, 0.75, 0.20833333333333
46621, 0.91666666666667, 0.8, 0.20833333333333
46622, 0.91666666666667, 0.85, 0.20833333333333
46623, 0.91666666666667, 0.9, 0.20833333333333
46624, 0.91666666666667, 0.95, 0.20833333333333
46625, 0.91666666666667, 1, 0.20833333333333
46626, 0.91666666666667, 1.05, 0.20833333333333
46627, 0.91666666666667, 1.1, 0.20833333333333
46628, 0.91666666666667, 1.15, 0.20833333333333
46629, 0.91666666666667, 1.2, 0.20833333333333
46630, 0.91666666666667, 1.25, 0.20833333333333
46631, 0.91666666666667, 1.3, 0.20833333333333
46632, 0.91666666666667, 0.2, 0.25
46633, 0.91666666666667, 0.25, 0.25
46634, 0.91666666666667, 0.3, 0.25
46635, 0.91666666666667, 0.35, 0.25
46636, 0.91666666666667, 0.4, 0.25
46637, 0.91666666666667, 0.45, 0.25
46638, 0.91666666666667, 0.5, 0.25
46639, 0.91666666666667, 0.55, 0.25
46640, 0.91666666666667, 0.6, 0.25
46641, 0.91666666666667, 0.65, 0.25
46642, 0.91666666666667, 0.7, 0.25
46643, 0.91666666666667, 0.75, 0.25
46644, 0.91666666666667, 0.8, 0.25
46645, 0.91666666666667, 0.85, 0.25
46646, 0.91666666666667, 0.9, 0.25
46647, 0.91666666666667, 0.95, 0.25
46648, 0.91666666666667, 1, 0.25
46649, 0.91666666666667, 1.05, 0.25
46650, 0.91666666666667, 1.1, 0.25
46651, 0.91666666666667, 1.15, 0.25
46652, 0.91666666666667, 1.2, 0.25
46653, 0.91666666666667, 1.25, 0.25
46654, 0.91666666666667, 1.3, 0.25
46655, 0.91666666666667, 0.2, 0.29166666666667
46656, 0.91666666666667, 0.25, 0.29166666666667
46657, 0.91666666666667, 0.3, 0.29166666666667
46658, 0.91666666666667, 0.35, 0.29166666666667
46659, 0.91666666666667, 0.4, 0.29166666666667
46660, 0.91666666666667, 0.45, 0.29166666666667
46661, 0.91666666666667, 0.5, 0.29166666666667
46662, 0.91666666666667, 0.55, 0.29166666666667
46663, 0.91666666666667, 0.6, 0.29166666666667
46664, 0.91666666666667, 0.65, 0.29166666666667
46665, 0.91666666666667, 0.7, 0.29166666666667
46666, 0.91666666666667, 0.75, 0.29166666666667
46667, 0.91666666666667, 0.8, 0.29166666666667
46668, 0.91666666666667, 0.85, 0.29166666666667
46669, 0.91666666666667, 0.9, 0.29166666666667
46670, 0.91666666666667, 0.95, 0.29166666666667
46671, 0.91666666666667, 1, 0.29166666666667
46672, 0.91666666666667, 1.05, 0.29166666666667
46673, 0.91666666666667, 1.1, 0.29166666666667
46674, 0.91666666666667, 1.15, 0.29166666666667
46675, 0.91666666666667, 1.2, 0.29166666666667
46676, 0.91666666666667, 1.25, 0.29166666666667
46677, 0.91666666666667, 1.3, 0.29166666666667
46678, 0.91666666666667, 0.2, 0.33333333333333
46679, 0.91666666666667, 0.25, 0.33333333333333
46680, 0.91666666666667, 0.3, 0.33333333333333
46681, 0.91666666666667, 0.35, 0.33333333333333
46682, 0.91666666666667, 0.4, 0.33333333333333
46683, 0.91666666666667, 0.45, 0.33333333333333
46684, 0.91666666666667, 0.5, 0.33333333333333
46685, 0.91666666666667, 0.55, 0.33333333333333
46686, 0.91666666666667, 0.6, 0.33333333333333
46687, 0.91666666666667, 0.65, 0.33333333333333
46688, 0.91666666666667, 0.7, 0.33333333333333
46689, 0.91666666666667, 0.75, 0.33333333333333
46690, 0.91666666666667, 0.8, 0.33333333333333
46691, 0.91666666666667, 0.85, 0.33333333333333
46692, 0.91666666666667, 0.9, 0.33333333333333
46693, 0.91666666666667, 0.95, 0.33333333333333
46694, 0.91666666666667, 1, 0.33333333333333
46695, 0.91666666666667, 1.05, 0.33333333333333
46696, 0.91666666666667, 1.1, 0.33333333333333
46697, 0.91666666666667, 1.15, 0.33333333333333
46698, 0.91666666666667, 1.2, 0.33333333333333
46699, 0.91666666666667, 1.25, 0.33333333333333
46700, 0.91666666666667, 1.3, 0.33333333333333
46701, 0.91666666666667, 0.2, 0.375
46702, 0.91666666666667, 0.25, 0.375
46703, 0.91666666666667, 0.3, 0.375
46704, 0.91666666666667, 0.35, 0.375
46705, 0.91666666666667, 0.4, 0.375
46706, 0.91666666666667, 0.45, 0.375
46707, 0.91666666666667, 0.5, 0.375
46708, 0.91666666666667, 0.55, 0.375
46709, 0.91666666666667, 0.6, 0.375
46710, 0.91666666666667, 0.65, 0.375
46711, 0.91666666666667, 0.7, 0.375
46712, 0.91666666666667, 0.75, 0.375
46713, 0.91666666666667, 0.8, 0.375
46714, 0.91666666666667, 0.85, 0.375
46715, 0.91666666666667, 0.9, 0.375
46716, 0.91666666666667, 0.95, 0.375
46717, 0.91666666666667, 1, 0.375
46718, 0.91666666666667, 1.05, 0.375
46719, 0.91666666666667, 1.1, 0.375
46720, 0.91666666666667, 1.15, 0.375
46721, 0.91666666666667, 1.2, 0.375
46722, 0.91666666666667, 1.25, 0.375
46723, 0.91666666666667, 1.3, 0.375
46724, 0.91666666666667, 0.2, 0.41666666666667
46725, 0.91666666666667, 0.25, 0.41666666666667
46726, 0.91666666666667, 0.3, 0.41666666666667
46727, 0.91666666666667, 0.35, 0.41666666666667
46728, 0.91666666666667, 0.4, 0.41666666666667
46729, 0.91666666666667, 0.45, 0.41666666666667
46730, 0.91666666666667, 0.5, 0.41666666666667
46731, 0.91666666666667, 0.55, 0.41666666666667
46732, 0.91666666666667, 0.6, 0.41666666666667
46733, 0.91666666666667, 0.65, 0.41666666666667
46734, 0.91666666666667, 0.7, 0.41666666666667
46735, 0.91666666666667, 0.75, 0.41666666666667
46736, 0.91666666666667, 0.8, 0.41666666666667
46737, 0.91666666666667, 0.85, 0.41666666666667
46738, 0.91666666666667, 0.9, 0.41666666666667
46739, 0.91666666666667, 0.95, 0.41666666666667
46740, 0.91666666666667, 1, 0.41666666666667
46741, 0.91666666666667, 1.05, 0.41666666666667
46742, 0.91666666666667, 1.1, 0.41666666666667
46743, 0.91666666666667, 1.15, 0.41666666666667
46744, 0.91666666666667, 1.2, 0.41666666666667
46745, 0.91666666666667, 1.25, 0.41666666666667
46746, 0.91666666666667, 1.3, 0.41666666666667
46747, 0.91666666666667, 0.2, 0.45833333333333
46748, 0.91666666666667, 0.25, 0.45833333333333
46749, 0.91666666666667, 0.3, 0.45833333333333
46750, 0.91666666666667, 0.35, 0.45833333333333
46751, 0.91666666666667, 0.4, 0.45833333333333
46752, 0.91666666666667, 0.45, 0.45833333333333
46753, 0.91666666666667, 0.5, 0.45833333333333
46754, 0.91666666666667, 0.55, 0.45833333333333
46755, 0.91666666666667, 0.6, 0.45833333333333
46756, 0.91666666666667, 0.65, 0.45833333333333
46757, 0.91666666666667, 0.7, 0.45833333333333
46758, 0.91666666666667, 0.75, 0.45833333333333
46759, 0.91666666666667, 0.8, 0.45833333333333
46760, 0.91666666666667, 0.85, 0.45833333333333
46761, 0.91666666666667, 0.9, 0.45833333333333
46762, 0.91666666666667, 0.95, 0.45833333333333
46763, 0.91666666666667, 1, 0.45833333333333
46764, 0.91666666666667, 1.05, 0.45833333333333
46765, 0.91666666666667, 1.1, 0.45833333333333
46766, 0.91666666666667, 1.15, 0.45833333333333
46767, 0.91666666666667, 1.2, 0.45833333333333
46768, 0.91666666666667, 1.25, 0.45833333333333
46769, 0.91666666666667, 1.3, 0.45833333333333
46770, 0.95833333333333, 0.2, 0.041666666666667
46771, 0.95833333333333, 0.25, 0.041666666666667
46772, 0.95833333333333, 0.3, 0.041666666666667
46773, 0.95833333333333, 0.35, 0.041666666666667
46774, 0.95833333333333, 0.4, 0.041666666666667
46775, 0.95833333333333, 0.45, 0.041666666666667
46776, 0.95833333333333, 0.5, 0.041666666666667
46777, 0.95833333333333, 0.55, 0.041666666666667
46778, 0.95833333333333, 0.6, 0.041666666666667
46779, 0.95833333333333, 0.65, 0.041666666666667
46780, 0.95833333333333, 0.7, 0.041666666666667
46781, 0.95833333333333, 0.75, 0.041666666666667
46782, 0.95833333333333, 0.8, 0.041666666666667
46783, 0.95833333333333, 0.85, 0.041666666666667
46784, 0.95833333333333, 0.9, 0.041666666666667
46785, 0.95833333333333, 0.95, 0.041666666666667
46786, 0.95833333333333, 1, 0.041666666666667
46787, 0.95833333333333, 1.05, 0.041666666666667
46788, 0.95833333333333, 1.1, 0.041666666666667
46789, 0.95833333333333, 1.15, 0.041666666666667
46790, 0.95833333333333, 1.2, 0.041666666666667
46791, 0.95833333333333, 1.25, 0.041666666666667
46792, 0.95833333333333, 1.3, 0.041666666666667
46793, 0.95833333333333, 0.2, 0.083333333333333
46794, 0.95833333333333, 0.25, 0.083333333333333
46795, 0.95833333333333, 0.3, 0.083333333333333
46796, 0.95833333333333, 0.35, 0.083333333333333
46797, 0.95833333333333, 0.4, 0.083333333333333
46798, 0.95833333333333, 0.45, 0.083333333333333
46799, 0.95833333333333, 0.5, 0.083333333333333
46800, 0.95833333333333, 0.55, 0.083333333333333
46801, 0.95833333333333, 0.6, 0.083333333333333
46802, 0.95833333333333, 0.65, 0.083333333333333
46803, 0.95833333333333, 0.7, 0.083333333333333
46804, 0.95833333333333, 0.75, 0.083333333333333
46805, 0.95833333333333, 0.8, 0.083333333333333
46806, 0.95833333333333, 0.85, 0.083333333333333
46807, 0.95833333333333, 0.9, 0.083333333333333
46808, 0.95833333333333, 0.95, 0.083333333333333
46809, 0.95833333333333, 1, 0.083333333333333
46810, 0.95833333333333, 1.05, 0.083333333333333
46811, 0.95833333333333, 1.1, 0.083333333333333
46812, 0.95833333333333, 1.15, 0.083333333333333
46813, 0.95833333333333, 1.2, 0.083333333333333
46814, 0.95833333333333, 1.25, 0.083333333333333
46815, 0.95833333333333, 1.3, 0.083333333333333
46816, 0.95833333333333, 0.2, 0.125
46817, 0.95833333333333, 0.25, 0.125
46818, 0.95833333333333, 0.3, 0.125
46819, 0.95833333333333, 0.35, 0.125
46820, 0.95833333333333, 0.4, 0.125
46821, 0.95833333333333, 0.45, 0.125
46822, 0.95833333333333, 0.5, 0.125
46823, 0.95833333333333, 0.55, 0.125
46824, 0.95833333333333, 0.6, 0.125
46825, 0.95833333333333, 0.65, 0.125
46826, 0.95833333333333, 0.7, 0.125
46827, 0.95833333333333, 0.75, 0.125
46828, 0.95833333333333, 0.8, 0.125
46829, 0.95833333333333, 0.85, 0.125
46830, 0.95833333333333, 0.9, 0.125
46831, 0.95833333333333, 0.95, 0.125
46832, 0.95833333333333, 1, 0.125
46833, 0.95833333333333, 1.05, 0.125
46834, 0.95833333333333, 1.1, 0.125
46835, 0.95833333333333, 1.15, 0.125
46836, 0.95833333333333, 1.2, 0.125
46837, 0.95833333333333, 1.25, 0.125
46838, 0.95833333333333, 1.3, 0.125
46839, 0.95833333333333, 0.2, 0.16666666666667
46840, 0.95833333333333, 0.25, 0.16666666666667
46841, 0.95833333333333, 0.3, 0.16666666666667
46842, 0.95833333333333, 0.35, 0.16666666666667
46843, 0.95833333333333, 0.4, 0.16666666666667
46844, 0.95833333333333, 0.45, 0.16666666666667
46845, 0.95833333333333, 0.5, 0.16666666666667
46846, 0.95833333333333, 0.55, 0.16666666666667
46847, 0.95833333333333, 0.6, 0.16666666666667
46848, 0.95833333333333, 0.65, 0.16666666666667
46849, 0.95833333333333, 0.7, 0.16666666666667
46850, 0.95833333333333, 0.75, 0.16666666666667
46851, 0.95833333333333, 0.8, 0.16666666666667
46852, 0.95833333333333, 0.85, 0.16666666666667
46853, 0.95833333333333, 0.9, 0.16666666666667
46854, 0.95833333333333, 0.95, 0.16666666666667
46855, 0.95833333333333, 1, 0.16666666666667
46856, 0.95833333333333, 1.05, 0.16666666666667
46857, 0.95833333333333, 1.1, 0.16666666666667
46858, 0.95833333333333, 1.15, 0.16666666666667
46859, 0.95833333333333, 1.2, 0.16666666666667
46860, 0.95833333333333, 1.25, 0.16666666666667
46861, 0.95833333333333, 1.3, 0.16666666666667
46862, 0.95833333333333, 0.2, 0.20833333333333
46863, 0.95833333333333, 0.25, 0.20833333333333
46864, 0.95833333333333, 0.3, 0.20833333333333
46865, 0.95833333333333, 0.35, 0.20833333333333
46866, 0.95833333333333, 0.4, 0.20833333333333
46867, 0.95833333333333, 0.45, 0.20833333333333
46868, 0.95833333333333, 0.5, 0.20833333333333
46869, 0.95833333333333, 0.55, 0.20833333333333
46870, 0.95833333333333, 0.6, 0.20833333333333
46871, 0.95833333333333, 0.65, 0.20833333333333
46872, 0.95833333333333, 0.7, 0.20833333333333
46873, 0.95833333333333, 0.75, 0.20833333333333
46874, 0.95833333333333, 0.8, 0.20833333333333
46875, 0.95833333333333, 0.85, 0.20833333333333
46876, 0.95833333333333, 0.9, 0.20833333333333
46877, 0.95833333333333, 0.95, 0.20833333333333
46878, 0.95833333333333, 1, 0.20833333333333
46879, 0.95833333333333, 1.05, 0.20833333333333
46880, 0.95833333333333, 1.1, 0.20833333333333
46881, 0.95833333333333, 1.15, 0.20833333333333
46882, 0.95833333333333, 1.2, 0.20833333333333
46883, 0.95833333333333, 1.25, 0.20833333333333
46884, 0.95833333333333, 1.3, 0.20833333333333
46885, 0.95833333333333, 0.2, 0.25
46886, 0.95833333333333, 0.25, 0.25
46887, 0.95833333333333, 0.3, 0.25
46888, 0.95833333333333, 0.35, 0.25
46889, 0.95833333333333, 0.4, 0.25
46890, 0.95833333333333, 0.45, 0.25
46891, 0.95833333333333, 0.5, 0.25
46892, 0.95833333333333, 0.55, 0.25
46893, 0.95833333333333, 0.6, 0.25
46894, 0.95833333333333, 0.65, 0.25
46895, 0.95833333333333, 0.7, 0.25
46896, 0.95833333333333, 0.75, 0.25
46897, 0.95833333333333, 0.8, 0.25
46898, 0.95833333333333, 0.85, 0.25
46899, 0.95833333333333, 0.9, 0.25
46900, 0.95833333333333, 0.95, 0.25
46901, 0.95833333333333, 1, 0.25
46902, 0.95833333333333, 1.05, 0.25
46903, 0.95833333333333, 1.1, 0.25
46904, 0.95833333333333, 1.15, 0.25
46905, 0.95833333333333, 1.2, 0.25
46906, 0.95833333333333, 1.25, 0.25
46907, 0.95833333333333, 1.3, 0.25
46908, 0.95833333333333, 0.2, 0.29166666666667
46909, 0.95833333333333, 0.25, 0.29166666666667
46910, 0.95833333333333, 0.3, 0.29166666666667
46911, 0.95833333333333, 0.35, 0.29166666666667
46912, 0.95833333333333, 0.4, 0.29166666666667
46913, 0.95833333333333, 0.45, 0.29166666666667
46914, 0.95833333333333, 0.5, 0.29166666666667
46915, 0.95833333333333, 0.55, 0.29166666666667
46916, 0.95833333333333, 0.6, 0.29166666666667
46917, 0.95833333333333, 0.65, 0.29166666666667
46918, 0.95833333333333, 0.7, 0.29166666666667
46919, 0.95833333333333, 0.75, 0.29166666666667
46920, 0.95833333333333, 0.8, 0.29166666666667
46921, 0.95833333333333, 0.85, 0.29166666666667
46922, 0.95833333333333, 0.9, 0.29166666666667
46923, 0.95833333333333, 0.95, 0.29166666666667
46924, 0.95833333333333, 1, 0.29166666666667
46925, 0.95833333333333, 1.05, 0.29166666666667
46926, 0.95833333333333, 1.1, 0.29166666666667
46927, 0.95833333333333, 1.15, 0.29166666666667
46928, 0.95833333333333, 1.2, 0.29166666666667
46929, 0.95833333333333, 1.25, 0.29166666666667
46930, 0.95833333333333, 1.3, 0.29166666666667
46931, 0.95833333333333, 0.2, 0.33333333333333
46932, 0.95833333333333, 0.25, 0.33333333333333
46933, 0.95833333333333, 0.3, 0.33333333333333
46934, 0.95833333333333, 0.35, 0.33333333333333
46935, 0.95833333333333, 0.4, 0.33333333333333
46936, 0.95833333333333, 0.45, 0.33333333333333
46937, 0.95833333333333, 0.5, 0.33333333333333
46938, 0.95833333333333, 0.55, 0.33333333333333
46939, 0.95833333333333, 0.6, 0.33333333333333
46940, 0.95833333333333, 0.65, 0.33333333333333
46941, 0.95833333333333, 0.7, 0.33333333333333
46942, 0.95833333333333, 0.75, 0.33333333333333
46943, 0.95833333333333, 0.8, 0.33333333333333
46944, 0.95833333333333, 0.85, 0.33333333333333
46945, 0.95833333333333, 0.9, 0.33333333333333
46946, 0.95833333333333, 0.95, 0.33333333333333
46947, 0.95833333333333, 1, 0.33333333333333
46948, 0.95833333333333, 1.05, 0.33333333333333
46949, 0.95833333333333, 1.1, 0.33333333333333
46950, 0.95833333333333, 1.15, 0.33333333333333
46951, 0.95833333333333, 1.2, 0.33333333333333
46952, 0.95833333333333, 1.25, 0.33333333333333
46953, 0.95833333333333, 1.3, 0.33333333333333
46954, 0.95833333333333, 0.2, 0.375
46955, 0.95833333333333, 0.25, 0.375
46956, 0.95833333333333, 0.3, 0.375
46957, 0.95833333333333, 0.35, 0.375
46958, 0.95833333333333, 0.4, 0.375
46959, 0.95833333333333, 0.45, 0.375
46960, 0.95833333333333, 0.5, 0.375
46961, 0.95833333333333, 0.55, 0.375
46962, 0.95833333333333, 0.6, 0.375
46963, 0.95833333333333, 0.65, 0.375
46964, 0.95833333333333, 0.7, 0.375
46965, 0.95833333333333, 0.75, 0.375
46966, 0.95833333333333, 0.8, 0.375
46967, 0.95833333333333, 0.85, 0.375
46968, 0.95833333333333, 0.9, 0.375
46969, 0.95833333333333, 0.95, 0.375
46970, 0.95833333333333, 1, 0.375
46971, 0.95833333333333, 1.05, 0.375
46972, 0.95833333333333, 1.1, 0.375
46973, 0.95833333333333, 1.15, 0.375
46974, 0.95833333333333, 1.2, 0.375
46975, 0.95833333333333, 1.25, 0.375
46976, 0.95833333333333, 1.3, 0.375
46977, 0.95833333333333, 0.2, 0.41666666666667
46978, 0.95833333333333, 0.25, 0.41666666666667
46979, 0.95833333333333, 0.3, 0.41666666666667
46980, 0.95833333333333, 0.35, 0.41666666666667
46981, 0.95833333333333, 0.4, 0.41666666666667
46982, 0.95833333333333, 0.45, 0.41666666666667
46983, 0.95833333333333, 0.5, 0.41666666666667
46984, 0.95833333333333, 0.55, 0.41666666666667
46985, 0.95833333333333, 0.6, 0.41666666666667
46986, 0.95833333333333, 0.65, 0.41666666666667
46987, 0.95833333333333, 0.7, 0.41666666666667
46988, 0.95833333333333, 0.75, 0.41666666666667
46989, 0.95833333333333, 0.8, 0.41666666666667
46990, 0.95833333333333, 0.85, 0.41666666666667
46991, 0.95833333333333, 0.9, 0.41666666666667
46992, 0.95833333333333, 0.95, 0.41666666666667
46993, 0.95833333333333, 1, 0.41666666666667
46994, 0.95833333333333, 1.05, 0.41666666666667
46995, 0.95833333333333, 1.1, 0.41666666666667
46996, 0.95833333333333, 1.15, 0.41666666666667
46997, 0.95833333333333, 1.2, 0.41666666666667
46998, 0.95833333333333, 1.25, 0.41666666666667
46999, 0.95833333333333, 1.3, 0.41666666666667
47000, 0.95833333333333, 0.2, 0.45833333333333
47001, 0.95833333333333, 0.25, 0.45833333333333
47002, 0.95833333333333, 0.3, 0.45833333333333
47003, 0.95833333333333, 0.35, 0.45833333333333
47004, 0.95833333333333, 0.4, 0.45833333333333
47005, 0.95833333333333, 0.45, 0.45833333333333
47006, 0.95833333333333, 0.5, 0.45833333333333
47007, 0.95833333333333, 0.55, 0.45833333333333
47008, 0.95833333333333, 0.6, 0.45833333333333
47009, 0.95833333333333, 0.65, 0.45833333333333
47010, 0.95833333333333, 0.7, 0.45833333333333
47011, 0.95833333333333, 0.75, 0.45833333333333
47012, 0.95833333333333, 0.8, 0.45833333333333
47013, 0.95833333333333, 0.85, 0.45833333333333
47014, 0.95833333333333, 0.9, 0.45833333333333
47015, 0.95833333333333, 0.95, 0.45833333333333
47016, 0.95833333333333, 1, 0.45833333333333
47017, 0.95833333333333, 1.05, 0.45833333333333
47018, 0.95833333333333, 1.1, 0.45833333333333
47019, 0.95833333333333, 1.15, 0.45833333333333
47020, 0.95833333333333, 1.2, 0.45833333333333
47021, 0.95833333333333, 1.25, 0.45833333333333
47022, 0.95833333333333, 1.3, 0.45833333333333
47023, 0.041666666666667, 0.175, 0.041666666666667
47024, 0.020833333333333, 0.2, 0.041666666666667
47025, 0.041666666666667, 0.2, 0.020833333333333
47026, 0.041666666666667, 0.225, 0.041666666666667
47027, 0.020833333333333, 0.25, 0.041666666666667
47028, 0.041666666666667, 0.25, 0.020833333333333
47029, 0.041666666666667, 0.275, 0.041666666666667
47030, 0.020833333333333, 0.3, 0.041666666666667
47031, 0.041666666666667, 0.3, 0.020833333333333
47032, 0.041666666666667, 0.325, 0.041666666666667
47033, 0.020833333333333, 0.35, 0.041666666666667
47034, 0.041666666666667, 0.35, 0.020833333333333
47035, 0.041666666666667, 0.375, 0.041666666666667
47036, 0.020833333333333, 0.4, 0.041666666666667
47037, 0.041666666666667, 0.4, 0.020833333333333
47038, 0.041666666666667, 0.425, 0.041666666666667
47039, 0.020833333333333, 0.45, 0.041666666666667
47040, 0.041666666666667, 0.45, 0.020833333333333
47041, 0.041666666666667, 0.475, 0.041666666666667
47042, 0.020833333333333, 0.5, 0.041666666666667
47043, 0.041666666666667, 0.5, 0.020833333333333
47044, 0.041666666666667, 0.525, 0.041666666666667
47045, 0.020833333333333, 0.55, 0.041666666666667
47046, 0.041666666666667, 0.55, 0.020833333333333
47047, 0.041666666666667, 0.575, 0.041666666666667
47048, 0.020833333333333, 0.6, 0.041666666666667
47049, 0.041666666666667, 0.6, 0.020833333333333
47050, 0.041666666666667, 0.625, 0.041666666666667
47051, 0.020833333333333, 0.65, 0.041666666666667
47052, 0.041666666666667, 0.65, 0.020833333333333
47053, 0.041666666666667, 0.675, 0.041666666666667
47054, 0.020833333333333, 0.7, 0.041666666666667
47055, 0.041666666666667, 0.7, 0.020833333333333
47056, 0.041666666666667, 0.725, 0.041666666666667
47057, 0.020833333333333, 0.75, 0.041666666666667
47058, 0.041666666666667, 0.75, 0.020833333333333
47059, 0.041666666666667, 0.775, 0.041666666666667
47060, 0.020833333333333, 0.8, 0.041666666666667
47061, 0.041666666666667, 0.8, 0.020833333333333
47062, 0.041666666666667, 0.825, 0.041666666666667
47063, 0.020833333333333, 0.85, 0.041666666666667
47064, 0.041666666666667, 0.85, 0.020833333333333
47065, 0.041666666666667, 0.875, 0.041666666666667
47066, 0.020833333333333, 0.9, 0.041666666666667
47067, 0.041666666666667, 0.9, 0.020833333333333
47068, 0.041666666666667, 0.925, 0.041666666666667
47069, 0.020833333333333, 0.95, 0.041666666666667
47070, 0.041666666666667, 0.95, 0.020833333333333
47071, 0.041666666666667, 0.975, 0.041666666666667
47072, 0.020833333333333, 1, 0.041666666666667
47073, 0.041666666666667, 1, 0.020833333333333
47074, 0.041666666666667, 1.025, 0.041666666666667
47075, 0.020833333333333, 1.05, 0.041666666666667
47076, 0.041666666666667, 1.05, 0.020833333333333
47077, 0.041666666666667, 1.075, 0.041666666666667
47078, 0.020833333333333, 1.1, 0.041666666666667
47079, 0.041666666666667, 1.1, 0.020833333333333
47080, 0.041666666666667, 1.125, 0.041666666666667
47081, 0.020833333333333, 1.15, 0.041666666666667
47082, 0.041666666666667, 1.15, 0.020833333333333
47083, 0.041666666666667, 1.175, 0.041666666666667
47084, 0.020833333333333, 1.2, 0.041666666666667
47085, 0.041666666666667, 1.2, 0.020833333333333
47086, 0.041666666666667, 1.225, 0.041666666666667
47087, 0.020833333333333, 1.25, 0.041666666666667
47088, 0.041666666666667, 1.25, 0.020833333333333
47089, 0.041666666666667, 1.275, 0.041666666666667
47090, 0.020833333333333, 1.3, 0.041666666666667
47091, 0.041666666666667, 1.3, 0.020833333333333
47092, 0.041666666666667, 1.325, 0.041666666666667
47093, 0.041666666666667, 0.175, 0.083333333333333
47094, 0.020833333333333, 0.2, 0.083333333333333
47095, 0.041666666666667, 0.2, 0.0625
47096, 0.041666666666667, 0.225, 0.083333333333333
47097, 0.020833333333333, 0.25, 0.083333333333333
47098, 0.041666666666667, 0.25, 0.0625
47099, 0.041666666666667, 0.275, 0.083333333333333
47100, 0.020833333333333, 0.3, 0.083333333333333
47101, 0.041666666666667, 0.3, 0.0625
47102, 0.041666666666667, 0.325, 0.083333333333333
47103, 0.020833333333333, 0.35, 0.083333333333333
47104, 0.041666666666667, 0.35, 0.0625
47105, 0.041666666666667, 0.375, 0.083333333333333
47106, 0.020833333333333, 0.4, 0.083333333333333
47107, 0.041666666666667, 0.4, 0.0625
47108, 0.041666666666667, 0.425, 0.083333333333333
47109, 0.020833333333333, 0.45, 0.083333333333333
47110, 0.041666666666667, 0.45, 0.0625
47111, 0.041666666666667, 0.475, 0.083333333333333
47112, 0.020833333333333, 0.5, 0.083333333333333
47113, 0.041666666666667, 0.5, 0.0625
47114, 0.041666666666667, 0.525, 0.083333333333333
47115, 0.020833333333333, 0.55, 0.083333333333333
47116, 0.041666666666667, 0.55, 0.0625
47117, 0.041666666666667, 0.575, 0.083333333333333
47118, 0.020833333333333, 0.6, 0.083333333333333
47119, 0.041666666666667, 0.6, 0.0625
47120, 0.041666666666667, 0.625, 0.083333333333333
47121, 0.020833333333333, 0.65, 0.083333333333333
47122, 0.041666666666667, 0.65, 0.0625
47123, 0.041666666666667, 0.675, 0.083333333333333
47124, 0.020833333333333, 0.7, 0.083333333333333
47125, 0.041666666666667, 0.7, 0.0625
47126, 0.041666666666667, 0.725, 0.083333333333333
47127, 0.020833333333333, 0.75, 0.083333333333333
47128, 0.041666666666667, 0.75, 0.0625
47129, 0.041666666666667, 0.775, 0.083333333333333
47130, 0.020833333333333, 0.8, 0.083333333333333
47131, 0.041666666666667, 0.8, 0.0625
47132, 0.041666666666667, 0.825, 0.083333333333333
47133, 0.020833333333333, 0.85, 0.083333333333333
47134, 0.041666666666667, 0.85, 0.0625
47135, 0.041666666666667, 0.875, 0.083333333333333
47136, 0.020833333333333, 0.9, 0.083333333333333
47137, 0.041666666666667, 0.9, 0.0625
47138, 0.041666666666667, 0.925, 0.083333333333333
47139, 0.020833333333333, 0.95, 0.083333333333333
47140, 0.041666666666667, 0.95, 0.0625
47141, 0.041666666666667, 0.975, 0.083333333333333
47142, 0.020833333333333, 1, 0.083333333333333
47143, 0.041666666666667, 1, 0.0625
47144, 0.041666666666667, 1.025, 0.083333333333333
47145, 0.020833333333333, 1.05, 0.083333333333333
47146, 0.041666666666667, 1.05, 0.0625
47147, 0.041666666666667, 1.075, 0.083333333333333
47148, 0.020833333333333, 1.1, 0.083333333333333
47149, 0.041666666666667, 1.1, 0.0625
47150, 0.041666666666667, 1.125, 0.083333333333333
47151, 0.020833333333333, 1.15, 0.083333333333333
47152, 0.041666666666667, 1.15, 0.0625
47153, 0.041666666666667, 1.175, 0.083333333333333
47154, 0.020833333333333, 1.2, 0.083333333333333
47155, 0.041666666666667, 1.2, 0.0625
47156, 0.041666666666667, 1.225, 0.083333333333333
47157, 0.020833333333333, 1.25, 0.083333333333333
47158, 0.041666666666667, 1.25, 0.0625
47159, 0.041666666666667, 1.275, 0.083333333333333
47160, 0.020833333333333, 1.3, 0.083333333333333
47161, 0.041666666666667, 1.3, 0.0625
47162, 0.041666666666667, 1.325, 0.083333333333333
47163, 0.041666666666667, 0.175, 0.125
47164, 0.020833333333333, 0.2, 0.125
47165, 0.041666666666667, 0.2, 0.10416666666667
47166, 0.041666666666667, 0.225, 0.125
47167, 0.020833333333333, 0.25, 0.125
47168, 0.041666666666667, 0.25, 0.10416666666667
47169, 0.041666666666667, 0.275, 0.125
47170, 0.020833333333333, 0.3, 0.125
47171, 0.041666666666667, 0.3, 0.10416666666667
47172, 0.041666666666667, 0.325, 0.125
47173, 0.020833333333333, 0.35, 0.125
47174, 0.041666666666667, 0.35, 0.10416666666667
47175, 0.041666666666667, 0.375, 0.125
47176, 0.020833333333333, 0.4, 0.125
47177, 0.041666666666667, 0.4, 0.10416666666667
47178, 0.041666666666667, 0.425, 0.125
47179, 0.020833333333333, 0.45, 0.125
47180, 0.041666666666667, 0.45, 0.10416666666667
47181, 0.041666666666667, 0.475, 0.125
47182, 0.020833333333333, 0.5, 0.125
47183, 0.041666666666667, 0.5, 0.10416666666667
47184, 0.041666666666667, 0.525, 0.125
47185, 0.020833333333333, 0.55, 0.125
47186, 0.041666666666667, 0.55, 0.10416666666667
47187, 0.041666666666667, 0.575, 0.125
47188, 0.020833333333333, 0.6, 0.125
47189, 0.041666666666667, 0.6, 0.10416666666667
47190, 0.041666666666667, 0.625, 0.125
47191, 0.020833333333333, 0.65, 0.125
47192, 0.041666666666667, 0.65, 0.10416666666667
47193, 0.041666666666667, 0.675, 0.125
47194, 0.020833333333333, 0.7, 0.125
47195, 0.041666666666667, 0.7, 0.10416666666667
47196, 0.041666666666667, 0.725, 0.125
47197, 0.020833333333333, 0.75, 0.125
47198, 0.041666666666667, 0.75, 0.10416666666667
47199, 0.041666666666667, 0.775, 0.125
47200, 0.020833333333333, 0.8, 0.125
47201, 0.041666666666667, 0.8, 0.10416666666667
47202, 0.041666666666667, 0.825, 0.125
47203, 0.020833333333333, 0.85, 0.125
47204, 0.041666666666667, 0.85, 0.10416666666667
47205, 0.041666666666667, 0.875, 0.125
47206, 0.020833333333333, 0.9, 0.125
47207, 0.041666666666667, 0.9, 0.10416666666667
47208, 0.041666666666667, 0.925, 0.125
47209, 0.020833333333333, 0.95, 0.125
