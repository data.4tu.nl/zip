104057, 0.97916666666667, 1.62, 0.125
104058, 0.97916666666667, 1.66, 0.125
104059, 0.97916666666667, 1.54, 0.16666666666667
104060, 0.97916666666667, 1.58, 0.16666666666667
104061, 0.97916666666667, 1.62, 0.16666666666667
104062, 0.97916666666667, 1.66, 0.16666666666667
104063, 0.97916666666667, 1.54, 0.20833333333333
104064, 0.97916666666667, 1.58, 0.20833333333333
104065, 0.97916666666667, 1.62, 0.20833333333333
104066, 0.97916666666667, 1.66, 0.20833333333333
104067, 0.97916666666667, 1.54, 0.25
104068, 0.97916666666667, 1.58, 0.25
104069, 0.97916666666667, 1.62, 0.25
104070, 0.97916666666667, 1.66, 0.25
104071, 0.97916666666667, 1.54, 0.29166666666667
104072, 0.97916666666667, 1.58, 0.29166666666667
104073, 0.97916666666667, 1.62, 0.29166666666667
104074, 0.97916666666667, 1.66, 0.29166666666667
104075, 0.97916666666667, 1.54, 0.33333333333333
104076, 0.97916666666667, 1.58, 0.33333333333333
104077, 0.97916666666667, 1.62, 0.33333333333333
104078, 0.97916666666667, 1.66, 0.33333333333333
104079, 0.97916666666667, 1.54, 0.375
104080, 0.97916666666667, 1.58, 0.375
104081, 0.97916666666667, 1.62, 0.375
104082, 0.97916666666667, 1.66, 0.375
104083, 0.97916666666667, 1.54, 0.41666666666667
104084, 0.97916666666667, 1.58, 0.41666666666667
104085, 0.97916666666667, 1.62, 0.41666666666667
104086, 0.97916666666667, 1.66, 0.41666666666667
104087, 0.97916666666667, 1.54, 0.45833333333333
104088, 0.97916666666667, 1.58, 0.45833333333333
104089, 0.97916666666667, 1.62, 0.45833333333333
104090, 0.97916666666667, 1.66, 0.45833333333333
104091, 1.04, 1.54, 0.041666666666667
104092, 1.04, 1.58, 0.041666666666667
104093, 1.04, 1.62, 0.041666666666667
104094, 1.04, 1.66, 0.041666666666667
104095, 1.08, 1.54, 0.041666666666667
104096, 1.08, 1.58, 0.041666666666667
104097, 1.08, 1.62, 0.041666666666667
104098, 1.08, 1.66, 0.041666666666667
104099, 1.12, 1.54, 0.041666666666667
104100, 1.12, 1.58, 0.041666666666667
104101, 1.12, 1.62, 0.041666666666667
104102, 1.12, 1.66, 0.041666666666667
104103, 1.16, 1.54, 0.041666666666667
104104, 1.16, 1.58, 0.041666666666667
104105, 1.16, 1.62, 0.041666666666667
104106, 1.16, 1.66, 0.041666666666667
104107, 1.04, 1.54, 0.083333333333333
104108, 1.04, 1.58, 0.083333333333333
104109, 1.04, 1.62, 0.083333333333333
104110, 1.04, 1.66, 0.083333333333333
104111, 1.08, 1.54, 0.083333333333333
104112, 1.08, 1.58, 0.083333333333333
104113, 1.08, 1.62, 0.083333333333333
104114, 1.08, 1.66, 0.083333333333333
104115, 1.12, 1.54, 0.083333333333333
104116, 1.12, 1.58, 0.083333333333333
104117, 1.12, 1.62, 0.083333333333333
104118, 1.12, 1.66, 0.083333333333333
104119, 1.16, 1.54, 0.083333333333333
104120, 1.16, 1.58, 0.083333333333333
104121, 1.16, 1.62, 0.083333333333333
104122, 1.16, 1.66, 0.083333333333333
104123, 1.04, 1.54, 0.125
104124, 1.04, 1.58, 0.125
104125, 1.04, 1.62, 0.125
104126, 1.04, 1.66, 0.125
104127, 1.08, 1.54, 0.125
104128, 1.08, 1.58, 0.125
104129, 1.08, 1.62, 0.125
104130, 1.08, 1.66, 0.125
104131, 1.12, 1.54, 0.125
104132, 1.12, 1.58, 0.125
104133, 1.12, 1.62, 0.125
104134, 1.12, 1.66, 0.125
104135, 1.16, 1.54, 0.125
104136, 1.16, 1.58, 0.125
104137, 1.16, 1.62, 0.125
104138, 1.16, 1.66, 0.125
104139, 1.04, 1.54, 0.16666666666667
104140, 1.04, 1.58, 0.16666666666667
104141, 1.04, 1.62, 0.16666666666667
104142, 1.04, 1.66, 0.16666666666667
104143, 1.08, 1.54, 0.16666666666667
104144, 1.08, 1.58, 0.16666666666667
104145, 1.08, 1.62, 0.16666666666667
104146, 1.08, 1.66, 0.16666666666667
104147, 1.12, 1.54, 0.16666666666667
104148, 1.12, 1.58, 0.16666666666667
104149, 1.12, 1.62, 0.16666666666667
104150, 1.12, 1.66, 0.16666666666667
104151, 1.16, 1.54, 0.16666666666667
104152, 1.16, 1.58, 0.16666666666667
104153, 1.16, 1.62, 0.16666666666667
104154, 1.16, 1.66, 0.16666666666667
104155, 1.04, 1.54, 0.20833333333333
104156, 1.04, 1.58, 0.20833333333333
104157, 1.04, 1.62, 0.20833333333333
104158, 1.04, 1.66, 0.20833333333333
104159, 1.08, 1.54, 0.20833333333333
104160, 1.08, 1.58, 0.20833333333333
104161, 1.08, 1.62, 0.20833333333333
104162, 1.08, 1.66, 0.20833333333333
104163, 1.12, 1.54, 0.20833333333333
104164, 1.12, 1.58, 0.20833333333333
104165, 1.12, 1.62, 0.20833333333333
104166, 1.12, 1.66, 0.20833333333333
104167, 1.16, 1.54, 0.20833333333333
104168, 1.16, 1.58, 0.20833333333333
104169, 1.16, 1.62, 0.20833333333333
104170, 1.16, 1.66, 0.20833333333333
104171, 1.04, 1.54, 0.25
104172, 1.04, 1.58, 0.25
104173, 1.04, 1.62, 0.25
104174, 1.04, 1.66, 0.25
104175, 1.08, 1.54, 0.25
104176, 1.08, 1.58, 0.25
104177, 1.08, 1.62, 0.25
104178, 1.08, 1.66, 0.25
104179, 1.12, 1.54, 0.25
104180, 1.12, 1.58, 0.25
104181, 1.12, 1.62, 0.25
104182, 1.12, 1.66, 0.25
104183, 1.16, 1.54, 0.25
104184, 1.16, 1.58, 0.25
104185, 1.16, 1.62, 0.25
104186, 1.16, 1.66, 0.25
104187, 1.04, 1.54, 0.29166666666667
104188, 1.04, 1.58, 0.29166666666667
104189, 1.04, 1.62, 0.29166666666667
104190, 1.04, 1.66, 0.29166666666667
104191, 1.08, 1.54, 0.29166666666667
104192, 1.08, 1.58, 0.29166666666667
104193, 1.08, 1.62, 0.29166666666667
104194, 1.08, 1.66, 0.29166666666667
104195, 1.12, 1.54, 0.29166666666667
104196, 1.12, 1.58, 0.29166666666667
104197, 1.12, 1.62, 0.29166666666667
104198, 1.12, 1.66, 0.29166666666667
104199, 1.16, 1.54, 0.29166666666667
104200, 1.16, 1.58, 0.29166666666667
104201, 1.16, 1.62, 0.29166666666667
104202, 1.16, 1.66, 0.29166666666667
104203, 1.04, 1.54, 0.33333333333333
104204, 1.04, 1.58, 0.33333333333333
104205, 1.04, 1.62, 0.33333333333333
104206, 1.04, 1.66, 0.33333333333333
104207, 1.08, 1.54, 0.33333333333333
104208, 1.08, 1.58, 0.33333333333333
104209, 1.08, 1.62, 0.33333333333333
104210, 1.08, 1.66, 0.33333333333333
104211, 1.12, 1.54, 0.33333333333333
104212, 1.12, 1.58, 0.33333333333333
104213, 1.12, 1.62, 0.33333333333333
104214, 1.12, 1.66, 0.33333333333333
104215, 1.16, 1.54, 0.33333333333333
104216, 1.16, 1.58, 0.33333333333333
104217, 1.16, 1.62, 0.33333333333333
104218, 1.16, 1.66, 0.33333333333333
104219, 1.04, 1.54, 0.375
104220, 1.04, 1.58, 0.375
104221, 1.04, 1.62, 0.375
104222, 1.04, 1.66, 0.375
104223, 1.08, 1.54, 0.375
104224, 1.08, 1.58, 0.375
104225, 1.08, 1.62, 0.375
104226, 1.08, 1.66, 0.375
104227, 1.12, 1.54, 0.375
104228, 1.12, 1.58, 0.375
104229, 1.12, 1.62, 0.375
104230, 1.12, 1.66, 0.375
104231, 1.16, 1.54, 0.375
104232, 1.16, 1.58, 0.375
104233, 1.16, 1.62, 0.375
104234, 1.16, 1.66, 0.375
104235, 1.04, 1.54, 0.41666666666667
104236, 1.04, 1.58, 0.41666666666667
104237, 1.04, 1.62, 0.41666666666667
104238, 1.04, 1.66, 0.41666666666667
104239, 1.08, 1.54, 0.41666666666667
104240, 1.08, 1.58, 0.41666666666667
104241, 1.08, 1.62, 0.41666666666667
104242, 1.08, 1.66, 0.41666666666667
104243, 1.12, 1.54, 0.41666666666667
104244, 1.12, 1.58, 0.41666666666667
104245, 1.12, 1.62, 0.41666666666667
104246, 1.12, 1.66, 0.41666666666667
104247, 1.16, 1.54, 0.41666666666667
104248, 1.16, 1.58, 0.41666666666667
104249, 1.16, 1.62, 0.41666666666667
104250, 1.16, 1.66, 0.41666666666667
104251, 1.04, 1.54, 0.45833333333333
104252, 1.04, 1.58, 0.45833333333333
104253, 1.04, 1.62, 0.45833333333333
104254, 1.04, 1.66, 0.45833333333333
104255, 1.08, 1.54, 0.45833333333333
104256, 1.08, 1.58, 0.45833333333333
104257, 1.08, 1.62, 0.45833333333333
104258, 1.08, 1.66, 0.45833333333333
104259, 1.12, 1.54, 0.45833333333333
104260, 1.12, 1.58, 0.45833333333333
104261, 1.12, 1.62, 0.45833333333333
104262, 1.12, 1.66, 0.45833333333333
104263, 1.16, 1.54, 0.45833333333333
104264, 1.16, 1.58, 0.45833333333333
104265, 1.16, 1.62, 0.45833333333333
104266, 1.16, 1.66, 0.45833333333333
104267, 1.04, 1.52, 0.041666666666667
104268, 1.02, 1.54, 0.041666666666667
104269, 1.04, 1.54, 0.020833333333333
104270, 1.04, 1.56, 0.041666666666667
104271, 1.02, 1.58, 0.041666666666667
104272, 1.04, 1.58, 0.020833333333333
104273, 1.04, 1.6, 0.041666666666667
104274, 1.02, 1.62, 0.041666666666667
104275, 1.04, 1.62, 0.020833333333333
104276, 1.04, 1.64, 0.041666666666667
104277, 1.02, 1.66, 0.041666666666667
104278, 1.04, 1.66, 0.020833333333333
104279, 1.04, 1.68, 0.041666666666667
104280, 1.08, 1.52, 0.041666666666667
104281, 1.06, 1.54, 0.041666666666667
104282, 1.08, 1.54, 0.020833333333333
104283, 1.08, 1.56, 0.041666666666667
104284, 1.06, 1.58, 0.041666666666667
104285, 1.08, 1.58, 0.020833333333333
104286, 1.08, 1.6, 0.041666666666667
104287, 1.06, 1.62, 0.041666666666667
104288, 1.08, 1.62, 0.020833333333333
104289, 1.08, 1.64, 0.041666666666667
104290, 1.06, 1.66, 0.041666666666667
104291, 1.08, 1.66, 0.020833333333333
104292, 1.08, 1.68, 0.041666666666667
104293, 1.12, 1.52, 0.041666666666667
104294, 1.1, 1.54, 0.041666666666667
104295, 1.12, 1.54, 0.020833333333333
104296, 1.12, 1.56, 0.041666666666667
104297, 1.1, 1.58, 0.041666666666667
104298, 1.12, 1.58, 0.020833333333333
104299, 1.12, 1.6, 0.041666666666667
104300, 1.1, 1.62, 0.041666666666667
104301, 1.12, 1.62, 0.020833333333333
104302, 1.12, 1.64, 0.041666666666667
104303, 1.1, 1.66, 0.041666666666667
104304, 1.12, 1.66, 0.020833333333333
104305, 1.12, 1.68, 0.041666666666667
104306, 1.16, 1.52, 0.041666666666667
104307, 1.14, 1.54, 0.041666666666667
104308, 1.16, 1.54, 0.020833333333333
104309, 1.16, 1.56, 0.041666666666667
104310, 1.14, 1.58, 0.041666666666667
104311, 1.16, 1.58, 0.020833333333333
104312, 1.16, 1.6, 0.041666666666667
104313, 1.14, 1.62, 0.041666666666667
104314, 1.16, 1.62, 0.020833333333333
104315, 1.16, 1.64, 0.041666666666667
104316, 1.14, 1.66, 0.041666666666667
104317, 1.16, 1.66, 0.020833333333333
104318, 1.16, 1.68, 0.041666666666667
104319, 1.18, 1.54, 0.041666666666667
104320, 1.18, 1.58, 0.041666666666667
104321, 1.18, 1.62, 0.041666666666667
104322, 1.18, 1.66, 0.041666666666667
104323, 1.04, 1.52, 0.083333333333333
104324, 1.02, 1.54, 0.083333333333333
104325, 1.04, 1.54, 0.0625
104326, 1.04, 1.56, 0.083333333333333
104327, 1.02, 1.58, 0.083333333333333
104328, 1.04, 1.58, 0.0625
104329, 1.04, 1.6, 0.083333333333333
104330, 1.02, 1.62, 0.083333333333333
104331, 1.04, 1.62, 0.0625
104332, 1.04, 1.64, 0.083333333333333
104333, 1.02, 1.66, 0.083333333333333
104334, 1.04, 1.66, 0.0625
104335, 1.04, 1.68, 0.083333333333333
104336, 1.08, 1.52, 0.083333333333333
104337, 1.06, 1.54, 0.083333333333333
104338, 1.08, 1.54, 0.0625
104339, 1.08, 1.56, 0.083333333333333
104340, 1.06, 1.58, 0.083333333333333
104341, 1.08, 1.58, 0.0625
104342, 1.08, 1.6, 0.083333333333333
104343, 1.06, 1.62, 0.083333333333333
104344, 1.08, 1.62, 0.0625
104345, 1.08, 1.64, 0.083333333333333
104346, 1.06, 1.66, 0.083333333333333
104347, 1.08, 1.66, 0.0625
104348, 1.08, 1.68, 0.083333333333333
104349, 1.12, 1.52, 0.083333333333333
104350, 1.1, 1.54, 0.083333333333333
104351, 1.12, 1.54, 0.0625
104352, 1.12, 1.56, 0.083333333333333
104353, 1.1, 1.58, 0.083333333333333
104354, 1.12, 1.58, 0.0625
104355, 1.12, 1.6, 0.083333333333333
104356, 1.1, 1.62, 0.083333333333333
104357, 1.12, 1.62, 0.0625
104358, 1.12, 1.64, 0.083333333333333
104359, 1.1, 1.66, 0.083333333333333
104360, 1.12, 1.66, 0.0625
104361, 1.12, 1.68, 0.083333333333333
104362, 1.16, 1.52, 0.083333333333333
104363, 1.14, 1.54, 0.083333333333333
104364, 1.16, 1.54, 0.0625
104365, 1.16, 1.56, 0.083333333333333
104366, 1.14, 1.58, 0.083333333333333
104367, 1.16, 1.58, 0.0625
104368, 1.16, 1.6, 0.083333333333333
104369, 1.14, 1.62, 0.083333333333333
104370, 1.16, 1.62, 0.0625
104371, 1.16, 1.64, 0.083333333333333
104372, 1.14, 1.66, 0.083333333333333
104373, 1.16, 1.66, 0.0625
104374, 1.16, 1.68, 0.083333333333333
104375, 1.18, 1.54, 0.083333333333333
104376, 1.18, 1.58, 0.083333333333333
104377, 1.18, 1.62, 0.083333333333333
104378, 1.18, 1.66, 0.083333333333333
104379, 1.04, 1.52, 0.125
104380, 1.02, 1.54, 0.125
104381, 1.04, 1.54, 0.10416666666667
104382, 1.04, 1.56, 0.125
104383, 1.02, 1.58, 0.125
104384, 1.04, 1.58, 0.10416666666667
104385, 1.04, 1.6, 0.125
104386, 1.02, 1.62, 0.125
104387, 1.04, 1.62, 0.10416666666667
104388, 1.04, 1.64, 0.125
104389, 1.02, 1.66, 0.125
104390, 1.04, 1.66, 0.10416666666667
104391, 1.04, 1.68, 0.125
104392, 1.08, 1.52, 0.125
104393, 1.06, 1.54, 0.125
104394, 1.08, 1.54, 0.10416666666667
104395, 1.08, 1.56, 0.125
104396, 1.06, 1.58, 0.125
104397, 1.08, 1.58, 0.10416666666667
104398, 1.08, 1.6, 0.125
104399, 1.06, 1.62, 0.125
104400, 1.08, 1.62, 0.10416666666667
104401, 1.08, 1.64, 0.125
104402, 1.06, 1.66, 0.125
104403, 1.08, 1.66, 0.10416666666667
104404, 1.08, 1.68, 0.125
104405, 1.12, 1.52, 0.125
104406, 1.1, 1.54, 0.125
104407, 1.12, 1.54, 0.10416666666667
104408, 1.12, 1.56, 0.125
104409, 1.1, 1.58, 0.125
104410, 1.12, 1.58, 0.10416666666667
104411, 1.12, 1.6, 0.125
104412, 1.1, 1.62, 0.125
104413, 1.12, 1.62, 0.10416666666667
104414, 1.12, 1.64, 0.125
104415, 1.1, 1.66, 0.125
104416, 1.12, 1.66, 0.10416666666667
104417, 1.12, 1.68, 0.125
104418, 1.16, 1.52, 0.125
104419, 1.14, 1.54, 0.125
104420, 1.16, 1.54, 0.10416666666667
104421, 1.16, 1.56, 0.125
104422, 1.14, 1.58, 0.125
104423, 1.16, 1.58, 0.10416666666667
104424, 1.16, 1.6, 0.125
104425, 1.14, 1.62, 0.125
104426, 1.16, 1.62, 0.10416666666667
104427, 1.16, 1.64, 0.125
104428, 1.14, 1.66, 0.125
104429, 1.16, 1.66, 0.10416666666667
104430, 1.16, 1.68, 0.125
104431, 1.18, 1.54, 0.125
104432, 1.18, 1.58, 0.125
104433, 1.18, 1.62, 0.125
104434, 1.18, 1.66, 0.125
104435, 1.04, 1.52, 0.16666666666667
104436, 1.02, 1.54, 0.16666666666667
104437, 1.04, 1.54, 0.14583333333333
104438, 1.04, 1.56, 0.16666666666667
104439, 1.02, 1.58, 0.16666666666667
104440, 1.04, 1.58, 0.14583333333333
104441, 1.04, 1.6, 0.16666666666667
104442, 1.02, 1.62, 0.16666666666667
104443, 1.04, 1.62, 0.14583333333333
104444, 1.04, 1.64, 0.16666666666667
104445, 1.02, 1.66, 0.16666666666667
104446, 1.04, 1.66, 0.14583333333333
104447, 1.04, 1.68, 0.16666666666667
104448, 1.08, 1.52, 0.16666666666667
104449, 1.06, 1.54, 0.16666666666667
104450, 1.08, 1.54, 0.14583333333333
104451, 1.08, 1.56, 0.16666666666667
104452, 1.06, 1.58, 0.16666666666667
104453, 1.08, 1.58, 0.14583333333333
104454, 1.08, 1.6, 0.16666666666667
104455, 1.06, 1.62, 0.16666666666667
104456, 1.08, 1.62, 0.14583333333333
104457, 1.08, 1.64, 0.16666666666667
104458, 1.06, 1.66, 0.16666666666667
104459, 1.08, 1.66, 0.14583333333333
104460, 1.08, 1.68, 0.16666666666667
104461, 1.12, 1.52, 0.16666666666667
104462, 1.1, 1.54, 0.16666666666667
104463, 1.12, 1.54, 0.14583333333333
104464, 1.12, 1.56, 0.16666666666667
104465, 1.1, 1.58, 0.16666666666667
104466, 1.12, 1.58, 0.14583333333333
104467, 1.12, 1.6, 0.16666666666667
104468, 1.1, 1.62, 0.16666666666667
104469, 1.12, 1.62, 0.14583333333333
104470, 1.12, 1.64, 0.16666666666667
104471, 1.1, 1.66, 0.16666666666667
104472, 1.12, 1.66, 0.14583333333333
104473, 1.12, 1.68, 0.16666666666667
104474, 1.16, 1.52, 0.16666666666667
104475, 1.14, 1.54, 0.16666666666667
104476, 1.16, 1.54, 0.14583333333333
104477, 1.16, 1.56, 0.16666666666667
104478, 1.14, 1.58, 0.16666666666667
104479, 1.16, 1.58, 0.14583333333333
104480, 1.16, 1.6, 0.16666666666667
104481, 1.14, 1.62, 0.16666666666667
104482, 1.16, 1.62, 0.14583333333333
104483, 1.16, 1.64, 0.16666666666667
104484, 1.14, 1.66, 0.16666666666667
104485, 1.16, 1.66, 0.14583333333333
104486, 1.16, 1.68, 0.16666666666667
104487, 1.18, 1.54, 0.16666666666667
104488, 1.18, 1.58, 0.16666666666667
104489, 1.18, 1.62, 0.16666666666667
104490, 1.18, 1.66, 0.16666666666667
104491, 1.04, 1.52, 0.20833333333333
104492, 1.02, 1.54, 0.20833333333333
104493, 1.04, 1.54, 0.1875
104494, 1.04, 1.56, 0.20833333333333
104495, 1.02, 1.58, 0.20833333333333
104496, 1.04, 1.58, 0.1875
104497, 1.04, 1.6, 0.20833333333333
104498, 1.02, 1.62, 0.20833333333333
104499, 1.04, 1.62, 0.1875
104500, 1.04, 1.64, 0.20833333333333
104501, 1.02, 1.66, 0.20833333333333
104502, 1.04, 1.66, 0.1875
104503, 1.04, 1.68, 0.20833333333333
104504, 1.08, 1.52, 0.20833333333333
104505, 1.06, 1.54, 0.20833333333333
104506, 1.08, 1.54, 0.1875
104507, 1.08, 1.56, 0.20833333333333
104508, 1.06, 1.58, 0.20833333333333
104509, 1.08, 1.58, 0.1875
104510, 1.08, 1.6, 0.20833333333333
104511, 1.06, 1.62, 0.20833333333333
104512, 1.08, 1.62, 0.1875
104513, 1.08, 1.64, 0.20833333333333
104514, 1.06, 1.66, 0.20833333333333
104515, 1.08, 1.66, 0.1875
104516, 1.08, 1.68, 0.20833333333333
104517, 1.12, 1.52, 0.20833333333333
104518, 1.1, 1.54, 0.20833333333333
104519, 1.12, 1.54, 0.1875
104520, 1.12, 1.56, 0.20833333333333
104521, 1.1, 1.58, 0.20833333333333
104522, 1.12, 1.58, 0.1875
104523, 1.12, 1.6, 0.20833333333333
104524, 1.1, 1.62, 0.20833333333333
104525, 1.12, 1.62, 0.1875
104526, 1.12, 1.64, 0.20833333333333
104527, 1.1, 1.66, 0.20833333333333
104528, 1.12, 1.66, 0.1875
104529, 1.12, 1.68, 0.20833333333333
104530, 1.16, 1.52, 0.20833333333333
104531, 1.14, 1.54, 0.20833333333333
104532, 1.16, 1.54, 0.1875
104533, 1.16, 1.56, 0.20833333333333
104534, 1.14, 1.58, 0.20833333333333
104535, 1.16, 1.58, 0.1875
104536, 1.16, 1.6, 0.20833333333333
104537, 1.14, 1.62, 0.20833333333333
104538, 1.16, 1.62, 0.1875
104539, 1.16, 1.64, 0.20833333333333
104540, 1.14, 1.66, 0.20833333333333
104541, 1.16, 1.66, 0.1875
104542, 1.16, 1.68, 0.20833333333333
104543, 1.18, 1.54, 0.20833333333333
104544, 1.18, 1.58, 0.20833333333333
104545, 1.18, 1.62, 0.20833333333333
104546, 1.18, 1.66, 0.20833333333333
104547, 1.04, 1.52, 0.25
104548, 1.02, 1.54, 0.25
104549, 1.04, 1.54, 0.22916666666667
104550, 1.04, 1.56, 0.25
104551, 1.02, 1.58, 0.25
104552, 1.04, 1.58, 0.22916666666667
104553, 1.04, 1.6, 0.25
104554, 1.02, 1.62, 0.25
104555, 1.04, 1.62, 0.22916666666667
104556, 1.04, 1.64, 0.25
104557, 1.02, 1.66, 0.25
104558, 1.04, 1.66, 0.22916666666667
104559, 1.04, 1.68, 0.25
104560, 1.08, 1.52, 0.25
104561, 1.06, 1.54, 0.25
104562, 1.08, 1.54, 0.22916666666667
104563, 1.08, 1.56, 0.25
104564, 1.06, 1.58, 0.25
104565, 1.08, 1.58, 0.22916666666667
104566, 1.08, 1.6, 0.25
104567, 1.06, 1.62, 0.25
104568, 1.08, 1.62, 0.22916666666667
104569, 1.08, 1.64, 0.25
104570, 1.06, 1.66, 0.25
104571, 1.08, 1.66, 0.22916666666667
104572, 1.08, 1.68, 0.25
104573, 1.12, 1.52, 0.25
104574, 1.1, 1.54, 0.25
104575, 1.12, 1.54, 0.22916666666667
104576, 1.12, 1.56, 0.25
104577, 1.1, 1.58, 0.25
104578, 1.12, 1.58, 0.22916666666667
104579, 1.12, 1.6, 0.25
104580, 1.1, 1.62, 0.25
104581, 1.12, 1.62, 0.22916666666667
104582, 1.12, 1.64, 0.25
104583, 1.1, 1.66, 0.25
104584, 1.12, 1.66, 0.22916666666667
104585, 1.12, 1.68, 0.25
104586, 1.16, 1.52, 0.25
104587, 1.14, 1.54, 0.25
104588, 1.16, 1.54, 0.22916666666667
104589, 1.16, 1.56, 0.25
104590, 1.14, 1.58, 0.25
104591, 1.16, 1.58, 0.22916666666667
104592, 1.16, 1.6, 0.25
104593, 1.14, 1.62, 0.25
104594, 1.16, 1.62, 0.22916666666667
104595, 1.16, 1.64, 0.25
104596, 1.14, 1.66, 0.25
104597, 1.16, 1.66, 0.22916666666667
104598, 1.16, 1.68, 0.25
104599, 1.18, 1.54, 0.25
104600, 1.18, 1.58, 0.25
104601, 1.18, 1.62, 0.25
104602, 1.18, 1.66, 0.25
104603, 1.04, 1.52, 0.29166666666667
104604, 1.02, 1.54, 0.29166666666667
104605, 1.04, 1.54, 0.27083333333333
104606, 1.04, 1.56, 0.29166666666667
104607, 1.02, 1.58, 0.29166666666667
104608, 1.04, 1.58, 0.27083333333333
104609, 1.04, 1.6, 0.29166666666667
104610, 1.02, 1.62, 0.29166666666667
104611, 1.04, 1.62, 0.27083333333333
104612, 1.04, 1.64, 0.29166666666667
104613, 1.02, 1.66, 0.29166666666667
104614, 1.04, 1.66, 0.27083333333333
104615, 1.04, 1.68, 0.29166666666667
104616, 1.08, 1.52, 0.29166666666667
104617, 1.06, 1.54, 0.29166666666667
104618, 1.08, 1.54, 0.27083333333333
104619, 1.08, 1.56, 0.29166666666667
104620, 1.06, 1.58, 0.29166666666667
104621, 1.08, 1.58, 0.27083333333333
104622, 1.08, 1.6, 0.29166666666667
104623, 1.06, 1.62, 0.29166666666667
104624, 1.08, 1.62, 0.27083333333333
104625, 1.08, 1.64, 0.29166666666667
104626, 1.06, 1.66, 0.29166666666667
104627, 1.08, 1.66, 0.27083333333333
104628, 1.08, 1.68, 0.29166666666667
104629, 1.12, 1.52, 0.29166666666667
104630, 1.1, 1.54, 0.29166666666667
104631, 1.12, 1.54, 0.27083333333333
104632, 1.12, 1.56, 0.29166666666667
104633, 1.1, 1.58, 0.29166666666667
104634, 1.12, 1.58, 0.27083333333333
104635, 1.12, 1.6, 0.29166666666667
104636, 1.1, 1.62, 0.29166666666667
104637, 1.12, 1.62, 0.27083333333333
104638, 1.12, 1.64, 0.29166666666667
104639, 1.1, 1.66, 0.29166666666667
104640, 1.12, 1.66, 0.27083333333333
104641, 1.12, 1.68, 0.29166666666667
104642, 1.16, 1.52, 0.29166666666667
104643, 1.14, 1.54, 0.29166666666667
104644, 1.16, 1.54, 0.27083333333333
104645, 1.16, 1.56, 0.29166666666667
104646, 1.14, 1.58, 0.29166666666667
104647, 1.16, 1.58, 0.27083333333333
104648, 1.16, 1.6, 0.29166666666667
104649, 1.14, 1.62, 0.29166666666667
104650, 1.16, 1.62, 0.27083333333333
104651, 1.16, 1.64, 0.29166666666667
104652, 1.14, 1.66, 0.29166666666667
104653, 1.16, 1.66, 0.27083333333333
104654, 1.16, 1.68, 0.29166666666667
104655, 1.18, 1.54, 0.29166666666667
104656, 1.18, 1.58, 0.29166666666667
104657, 1.18, 1.62, 0.29166666666667
104658, 1.18, 1.66, 0.29166666666667
104659, 1.04, 1.52, 0.33333333333333
104660, 1.02, 1.54, 0.33333333333333
104661, 1.04, 1.54, 0.3125
104662, 1.04, 1.56, 0.33333333333333
104663, 1.02, 1.58, 0.33333333333333
104664, 1.04, 1.58, 0.3125
104665, 1.04, 1.6, 0.33333333333333
104666, 1.02, 1.62, 0.33333333333333
104667, 1.04, 1.62, 0.3125
104668, 1.04, 1.64, 0.33333333333333
104669, 1.02, 1.66, 0.33333333333333
104670, 1.04, 1.66, 0.3125
104671, 1.04, 1.68, 0.33333333333333
104672, 1.08, 1.52, 0.33333333333333
104673, 1.06, 1.54, 0.33333333333333
104674, 1.08, 1.54, 0.3125
104675, 1.08, 1.56, 0.33333333333333
104676, 1.06, 1.58, 0.33333333333333
104677, 1.08, 1.58, 0.3125
104678, 1.08, 1.6, 0.33333333333333
104679, 1.06, 1.62, 0.33333333333333
104680, 1.08, 1.62, 0.3125
104681, 1.08, 1.64, 0.33333333333333
104682, 1.06, 1.66, 0.33333333333333
104683, 1.08, 1.66, 0.3125
104684, 1.08, 1.68, 0.33333333333333
104685, 1.12, 1.52, 0.33333333333333
104686, 1.1, 1.54, 0.33333333333333
104687, 1.12, 1.54, 0.3125
104688, 1.12, 1.56, 0.33333333333333
104689, 1.1, 1.58, 0.33333333333333
104690, 1.12, 1.58, 0.3125
104691, 1.12, 1.6, 0.33333333333333
104692, 1.1, 1.62, 0.33333333333333
104693, 1.12, 1.62, 0.3125
104694, 1.12, 1.64, 0.33333333333333
104695, 1.1, 1.66, 0.33333333333333
104696, 1.12, 1.66, 0.3125
104697, 1.12, 1.68, 0.33333333333333
104698, 1.16, 1.52, 0.33333333333333
104699, 1.14, 1.54, 0.33333333333333
104700, 1.16, 1.54, 0.3125
104701, 1.16, 1.56, 0.33333333333333
104702, 1.14, 1.58, 0.33333333333333
104703, 1.16, 1.58, 0.3125
104704, 1.16, 1.6, 0.33333333333333
104705, 1.14, 1.62, 0.33333333333333
104706, 1.16, 1.62, 0.3125
104707, 1.16, 1.64, 0.33333333333333
104708, 1.14, 1.66, 0.33333333333333
104709, 1.16, 1.66, 0.3125
104710, 1.16, 1.68, 0.33333333333333
104711, 1.18, 1.54, 0.33333333333333
104712, 1.18, 1.58, 0.33333333333333
104713, 1.18, 1.62, 0.33333333333333
104714, 1.18, 1.66, 0.33333333333333
104715, 1.04, 1.52, 0.375
104716, 1.02, 1.54, 0.375
104717, 1.04, 1.54, 0.35416666666667
104718, 1.04, 1.56, 0.375
104719, 1.02, 1.58, 0.375
104720, 1.04, 1.58, 0.35416666666667
104721, 1.04, 1.6, 0.375
104722, 1.02, 1.62, 0.375
104723, 1.04, 1.62, 0.35416666666667
104724, 1.04, 1.64, 0.375
104725, 1.02, 1.66, 0.375
104726, 1.04, 1.66, 0.35416666666667
104727, 1.04, 1.68, 0.375
104728, 1.08, 1.52, 0.375
104729, 1.06, 1.54, 0.375
104730, 1.08, 1.54, 0.35416666666667
104731, 1.08, 1.56, 0.375
104732, 1.06, 1.58, 0.375
104733, 1.08, 1.58, 0.35416666666667
104734, 1.08, 1.6, 0.375
104735, 1.06, 1.62, 0.375
104736, 1.08, 1.62, 0.35416666666667
104737, 1.08, 1.64, 0.375
104738, 1.06, 1.66, 0.375
104739, 1.08, 1.66, 0.35416666666667
104740, 1.08, 1.68, 0.375
104741, 1.12, 1.52, 0.375
104742, 1.1, 1.54, 0.375
104743, 1.12, 1.54, 0.35416666666667
104744, 1.12, 1.56, 0.375
104745, 1.1, 1.58, 0.375
104746, 1.12, 1.58, 0.35416666666667
104747, 1.12, 1.6, 0.375
104748, 1.1, 1.62, 0.375
104749, 1.12, 1.62, 0.35416666666667
104750, 1.12, 1.64, 0.375
104751, 1.1, 1.66, 0.375
104752, 1.12, 1.66, 0.35416666666667
104753, 1.12, 1.68, 0.375
104754, 1.16, 1.52, 0.375
104755, 1.14, 1.54, 0.375
104756, 1.16, 1.54, 0.35416666666667
104757, 1.16, 1.56, 0.375
104758, 1.14, 1.58, 0.375
104759, 1.16, 1.58, 0.35416666666667
104760, 1.16, 1.6, 0.375
104761, 1.14, 1.62, 0.375
104762, 1.16, 1.62, 0.35416666666667
104763, 1.16, 1.64, 0.375
104764, 1.14, 1.66, 0.375
104765, 1.16, 1.66, 0.35416666666667
104766, 1.16, 1.68, 0.375
104767, 1.18, 1.54, 0.375
104768, 1.18, 1.58, 0.375
104769, 1.18, 1.62, 0.375
104770, 1.18, 1.66, 0.375
104771, 1.04, 1.52, 0.41666666666667
104772, 1.02, 1.54, 0.41666666666667
104773, 1.04, 1.54, 0.39583333333333
104774, 1.04, 1.56, 0.41666666666667
104775, 1.02, 1.58, 0.41666666666667
104776, 1.04, 1.58, 0.39583333333333
104777, 1.04, 1.6, 0.41666666666667
104778, 1.02, 1.62, 0.41666666666667
104779, 1.04, 1.62, 0.39583333333333
104780, 1.04, 1.64, 0.41666666666667
104781, 1.02, 1.66, 0.41666666666667
104782, 1.04, 1.66, 0.39583333333333
104783, 1.04, 1.68, 0.41666666666667
104784, 1.08, 1.52, 0.41666666666667
104785, 1.06, 1.54, 0.41666666666667
104786, 1.08, 1.54, 0.39583333333333
104787, 1.08, 1.56, 0.41666666666667
104788, 1.06, 1.58, 0.41666666666667
104789, 1.08, 1.58, 0.39583333333333
104790, 1.08, 1.6, 0.41666666666667
104791, 1.06, 1.62, 0.41666666666667
104792, 1.08, 1.62, 0.39583333333333
104793, 1.08, 1.64, 0.41666666666667
104794, 1.06, 1.66, 0.41666666666667
104795, 1.08, 1.66, 0.39583333333333
104796, 1.08, 1.68, 0.41666666666667
104797, 1.12, 1.52, 0.41666666666667
104798, 1.1, 1.54, 0.41666666666667
104799, 1.12, 1.54, 0.39583333333333
104800, 1.12, 1.56, 0.41666666666667
104801, 1.1, 1.58, 0.41666666666667
104802, 1.12, 1.58, 0.39583333333333
104803, 1.12, 1.6, 0.41666666666667
104804, 1.1, 1.62, 0.41666666666667
104805, 1.12, 1.62, 0.39583333333333
104806, 1.12, 1.64, 0.41666666666667
104807, 1.1, 1.66, 0.41666666666667
104808, 1.12, 1.66, 0.39583333333333
104809, 1.12, 1.68, 0.41666666666667
104810, 1.16, 1.52, 0.41666666666667
104811, 1.14, 1.54, 0.41666666666667
104812, 1.16, 1.54, 0.39583333333333
104813, 1.16, 1.56, 0.41666666666667
104814, 1.14, 1.58, 0.41666666666667
104815, 1.16, 1.58, 0.39583333333333
104816, 1.16, 1.6, 0.41666666666667
104817, 1.14, 1.62, 0.41666666666667
104818, 1.16, 1.62, 0.39583333333333
104819, 1.16, 1.64, 0.41666666666667
104820, 1.14, 1.66, 0.41666666666667
104821, 1.16, 1.66, 0.39583333333333
104822, 1.16, 1.68, 0.41666666666667
104823, 1.18, 1.54, 0.41666666666667
104824, 1.18, 1.58, 0.41666666666667
104825, 1.18, 1.62, 0.41666666666667
104826, 1.18, 1.66, 0.41666666666667
104827, 1.04, 1.52, 0.45833333333333
104828, 1.02, 1.54, 0.45833333333333
104829, 1.04, 1.54, 0.4375
104830, 1.04, 1.56, 0.45833333333333
104831, 1.02, 1.58, 0.45833333333333
104832, 1.04, 1.58, 0.4375
104833, 1.04, 1.6, 0.45833333333333
104834, 1.02, 1.62, 0.45833333333333
104835, 1.04, 1.62, 0.4375
104836, 1.04, 1.64, 0.45833333333333
104837, 1.02, 1.66, 0.45833333333333
104838, 1.04, 1.66, 0.4375
104839, 1.04, 1.68, 0.45833333333333
104840, 1.08, 1.52, 0.45833333333333
104841, 1.06, 1.54, 0.45833333333333
104842, 1.08, 1.54, 0.4375
104843, 1.08, 1.56, 0.45833333333333
104844, 1.06, 1.58, 0.45833333333333
104845, 1.08, 1.58, 0.4375
104846, 1.08, 1.6, 0.45833333333333
104847, 1.06, 1.62, 0.45833333333333
104848, 1.08, 1.62, 0.4375
104849, 1.08, 1.64, 0.45833333333333
104850, 1.06, 1.66, 0.45833333333333
104851, 1.08, 1.66, 0.4375
104852, 1.08, 1.68, 0.45833333333333
104853, 1.12, 1.52, 0.45833333333333
104854, 1.1, 1.54, 0.45833333333333
104855, 1.12, 1.54, 0.4375
104856, 1.12, 1.56, 0.45833333333333
104857, 1.1, 1.58, 0.45833333333333
104858, 1.12, 1.58, 0.4375
104859, 1.12, 1.6, 0.45833333333333
104860, 1.1, 1.62, 0.45833333333333
104861, 1.12, 1.62, 0.4375
104862, 1.12, 1.64, 0.45833333333333
104863, 1.1, 1.66, 0.45833333333333
104864, 1.12, 1.66, 0.4375
104865, 1.12, 1.68, 0.45833333333333
104866, 1.16, 1.52, 0.45833333333333
104867, 1.14, 1.54, 0.45833333333333
104868, 1.16, 1.54, 0.4375
104869, 1.16, 1.56, 0.45833333333333
104870, 1.14, 1.58, 0.45833333333333
104871, 1.16, 1.58, 0.4375
104872, 1.16, 1.6, 0.45833333333333
104873, 1.14, 1.62, 0.45833333333333
104874, 1.16, 1.62, 0.4375
104875, 1.16, 1.64, 0.45833333333333
104876, 1.14, 1.66, 0.45833333333333
104877, 1.16, 1.66, 0.4375
104878, 1.16, 1.68, 0.45833333333333
104879, 1.18, 1.54, 0.45833333333333
104880, 1.18, 1.58, 0.45833333333333
104881, 1.18, 1.62, 0.45833333333333
104882, 1.18, 1.66, 0.45833333333333
104883, 1.04, 1.54, 0.47916666666667
104884, 1.04, 1.58, 0.47916666666667
104885, 1.04, 1.62, 0.47916666666667
104886, 1.04, 1.66, 0.47916666666667
104887, 1.08, 1.54, 0.47916666666667
104888, 1.08, 1.58, 0.47916666666667
104889, 1.08, 1.62, 0.47916666666667
104890, 1.08, 1.66, 0.47916666666667
104891, 1.12, 1.54, 0.47916666666667
104892, 1.12, 1.58, 0.47916666666667
104893, 1.12, 1.62, 0.47916666666667
104894, 1.12, 1.66, 0.47916666666667
104895, 1.16, 1.54, 0.47916666666667
104896, 1.16, 1.58, 0.47916666666667
104897, 1.16, 1.62, 0.47916666666667
104898, 1.16, 1.66, 0.47916666666667
104899, 1.2416666666667, 1.54, 0.041666666666667
104900, 1.2416666666667, 1.58, 0.041666666666667
104901, 1.2416666666667, 1.62, 0.041666666666667
104902, 1.2416666666667, 1.66, 0.041666666666667
104903, 1.2833333333333, 1.54, 0.041666666666667
104904, 1.2833333333333, 1.58, 0.041666666666667
104905, 1.2833333333333, 1.62, 0.041666666666667
104906, 1.2833333333333, 1.66, 0.041666666666667
104907, 1.325, 1.54, 0.041666666666667
104908, 1.325, 1.58, 0.041666666666667
104909, 1.325, 1.62, 0.041666666666667
104910, 1.325, 1.66, 0.041666666666667
104911, 1.3666666666667, 1.54, 0.041666666666667
104912, 1.3666666666667, 1.58, 0.041666666666667
104913, 1.3666666666667, 1.62, 0.041666666666667
104914, 1.3666666666667, 1.66, 0.041666666666667
104915, 1.4083333333333, 1.54, 0.041666666666667
104916, 1.4083333333333, 1.58, 0.041666666666667
104917, 1.4083333333333, 1.62, 0.041666666666667
104918, 1.4083333333333, 1.66, 0.041666666666667
104919, 1.45, 1.54, 0.041666666666667
104920, 1.45, 1.58, 0.041666666666667
104921, 1.45, 1.62, 0.041666666666667
104922, 1.45, 1.66, 0.041666666666667
104923, 1.4916666666667, 1.54, 0.041666666666667
104924, 1.4916666666667, 1.58, 0.041666666666667
104925, 1.4916666666667, 1.62, 0.041666666666667
104926, 1.4916666666667, 1.66, 0.041666666666667
104927, 1.5333333333333, 1.54, 0.041666666666667
104928, 1.5333333333333, 1.58, 0.041666666666667
104929, 1.5333333333333, 1.62, 0.041666666666667
104930, 1.5333333333333, 1.66, 0.041666666666667
104931, 1.575, 1.54, 0.041666666666667
104932, 1.575, 1.58, 0.041666666666667
104933, 1.575, 1.62, 0.041666666666667
104934, 1.575, 1.66, 0.041666666666667
104935, 1.6166666666667, 1.54, 0.041666666666667
104936, 1.6166666666667, 1.58, 0.041666666666667
104937, 1.6166666666667, 1.62, 0.041666666666667
104938, 1.6166666666667, 1.66, 0.041666666666667
104939, 1.6583333333333, 1.54, 0.041666666666667
104940, 1.6583333333333, 1.58, 0.041666666666667
104941, 1.6583333333333, 1.62, 0.041666666666667
104942, 1.6583333333333, 1.66, 0.041666666666667
104943, 1.7, 1.54, 0.041666666666667
104944, 1.7, 1.58, 0.041666666666667
104945, 1.7, 1.62, 0.041666666666667
104946, 1.7, 1.66, 0.041666666666667
104947, 1.7416666666667, 1.54, 0.041666666666667
104948, 1.7416666666667, 1.58, 0.041666666666667
104949, 1.7416666666667, 1.62, 0.041666666666667
104950, 1.7416666666667, 1.66, 0.041666666666667
104951, 1.7833333333333, 1.54, 0.041666666666667
104952, 1.7833333333333, 1.58, 0.041666666666667
104953, 1.7833333333333, 1.62, 0.041666666666667
104954, 1.7833333333333, 1.66, 0.041666666666667
104955, 1.825, 1.54, 0.041666666666667
104956, 1.825, 1.58, 0.041666666666667
104957, 1.825, 1.62, 0.041666666666667
104958, 1.825, 1.66, 0.041666666666667
104959, 1.8666666666667, 1.54, 0.041666666666667
104960, 1.8666666666667, 1.58, 0.041666666666667
104961, 1.8666666666667, 1.62, 0.041666666666667
104962, 1.8666666666667, 1.66, 0.041666666666667
104963, 1.9083333333333, 1.54, 0.041666666666667
104964, 1.9083333333333, 1.58, 0.041666666666667
104965, 1.9083333333333, 1.62, 0.041666666666667
104966, 1.9083333333333, 1.66, 0.041666666666667
104967, 1.95, 1.54, 0.041666666666667
104968, 1.95, 1.58, 0.041666666666667
104969, 1.95, 1.62, 0.041666666666667
104970, 1.95, 1.66, 0.041666666666667
104971, 1.9916666666667, 1.54, 0.041666666666667
104972, 1.9916666666667, 1.58, 0.041666666666667
104973, 1.9916666666667, 1.62, 0.041666666666667
104974, 1.9916666666667, 1.66, 0.041666666666667
104975, 2.0333333333333, 1.54, 0.041666666666667
104976, 2.0333333333333, 1.58, 0.041666666666667
104977, 2.0333333333333, 1.62, 0.041666666666667
104978, 2.0333333333333, 1.66, 0.041666666666667
104979, 2.075, 1.54, 0.041666666666667
104980, 2.075, 1.58, 0.041666666666667
104981, 2.075, 1.62, 0.041666666666667
104982, 2.075, 1.66, 0.041666666666667
104983, 2.1166666666667, 1.54, 0.041666666666667
104984, 2.1166666666667, 1.58, 0.041666666666667
104985, 2.1166666666667, 1.62, 0.041666666666667
104986, 2.1166666666667, 1.66, 0.041666666666667
104987, 2.1583333333333, 1.54, 0.041666666666667
104988, 2.1583333333333, 1.58, 0.041666666666667
104989, 2.1583333333333, 1.62, 0.041666666666667
104990, 2.1583333333333, 1.66, 0.041666666666667
104991, 1.2416666666667, 1.54, 0.083333333333333
104992, 1.2416666666667, 1.58, 0.083333333333333
104993, 1.2416666666667, 1.62, 0.083333333333333
104994, 1.2416666666667, 1.66, 0.083333333333333
104995, 1.2833333333333, 1.54, 0.083333333333333
104996, 1.2833333333333, 1.58, 0.083333333333333
104997, 1.2833333333333, 1.62, 0.083333333333333
104998, 1.2833333333333, 1.66, 0.083333333333333
104999, 1.325, 1.54, 0.083333333333333
105000, 1.325, 1.58, 0.083333333333333
105001, 1.325, 1.62, 0.083333333333333
105002, 1.325, 1.66, 0.083333333333333
105003, 1.3666666666667, 1.54, 0.083333333333333
105004, 1.3666666666667, 1.58, 0.083333333333333
105005, 1.3666666666667, 1.62, 0.083333333333333
105006, 1.3666666666667, 1.66, 0.083333333333333
105007, 1.4083333333333, 1.54, 0.083333333333333
105008, 1.4083333333333, 1.58, 0.083333333333333
105009, 1.4083333333333, 1.62, 0.083333333333333
105010, 1.4083333333333, 1.66, 0.083333333333333
105011, 1.45, 1.54, 0.083333333333333
105012, 1.45, 1.58, 0.083333333333333
105013, 1.45, 1.62, 0.083333333333333
105014, 1.45, 1.66, 0.083333333333333
105015, 1.4916666666667, 1.54, 0.083333333333333
105016, 1.4916666666667, 1.58, 0.083333333333333
105017, 1.4916666666667, 1.62, 0.083333333333333
105018, 1.4916666666667, 1.66, 0.083333333333333
105019, 1.5333333333333, 1.54, 0.083333333333333
105020, 1.5333333333333, 1.58, 0.083333333333333
105021, 1.5333333333333, 1.62, 0.083333333333333
105022, 1.5333333333333, 1.66, 0.083333333333333
105023, 1.575, 1.54, 0.083333333333333
105024, 1.575, 1.58, 0.083333333333333
105025, 1.575, 1.62, 0.083333333333333
105026, 1.575, 1.66, 0.083333333333333
105027, 1.6166666666667, 1.54, 0.083333333333333
105028, 1.6166666666667, 1.58, 0.083333333333333
105029, 1.6166666666667, 1.62, 0.083333333333333
105030, 1.6166666666667, 1.66, 0.083333333333333
105031, 1.6583333333333, 1.54, 0.083333333333333
105032, 1.6583333333333, 1.58, 0.083333333333333
105033, 1.6583333333333, 1.62, 0.083333333333333
105034, 1.6583333333333, 1.66, 0.083333333333333
105035, 1.7, 1.54, 0.083333333333333
105036, 1.7, 1.58, 0.083333333333333
105037, 1.7, 1.62, 0.083333333333333
105038, 1.7, 1.66, 0.083333333333333
105039, 1.7416666666667, 1.54, 0.083333333333333
105040, 1.7416666666667, 1.58, 0.083333333333333
105041, 1.7416666666667, 1.62, 0.083333333333333
105042, 1.7416666666667, 1.66, 0.083333333333333
105043, 1.7833333333333, 1.54, 0.083333333333333
105044, 1.7833333333333, 1.58, 0.083333333333333
105045, 1.7833333333333, 1.62, 0.083333333333333
105046, 1.7833333333333, 1.66, 0.083333333333333
105047, 1.825, 1.54, 0.083333333333333
105048, 1.825, 1.58, 0.083333333333333
105049, 1.825, 1.62, 0.083333333333333
105050, 1.825, 1.66, 0.083333333333333
105051, 1.8666666666667, 1.54, 0.083333333333333
105052, 1.8666666666667, 1.58, 0.083333333333333
105053, 1.8666666666667, 1.62, 0.083333333333333
105054, 1.8666666666667, 1.66, 0.083333333333333
105055, 1.9083333333333, 1.54, 0.083333333333333
105056, 1.9083333333333, 1.58, 0.083333333333333
105057, 1.9083333333333, 1.62, 0.083333333333333
105058, 1.9083333333333, 1.66, 0.083333333333333
105059, 1.95, 1.54, 0.083333333333333
105060, 1.95, 1.58, 0.083333333333333
105061, 1.95, 1.62, 0.083333333333333
105062, 1.95, 1.66, 0.083333333333333
105063, 1.9916666666667, 1.54, 0.083333333333333
105064, 1.9916666666667, 1.58, 0.083333333333333
105065, 1.9916666666667, 1.62, 0.083333333333333
105066, 1.9916666666667, 1.66, 0.083333333333333
105067, 2.0333333333333, 1.54, 0.083333333333333
105068, 2.0333333333333, 1.58, 0.083333333333333
105069, 2.0333333333333, 1.62, 0.083333333333333
105070, 2.0333333333333, 1.66, 0.083333333333333
105071, 2.075, 1.54, 0.083333333333333
105072, 2.075, 1.58, 0.083333333333333
105073, 2.075, 1.62, 0.083333333333333
105074, 2.075, 1.66, 0.083333333333333
105075, 2.1166666666667, 1.54, 0.083333333333333
105076, 2.1166666666667, 1.58, 0.083333333333333
105077, 2.1166666666667, 1.62, 0.083333333333333
105078, 2.1166666666667, 1.66, 0.083333333333333
105079, 2.1583333333333, 1.54, 0.083333333333333
105080, 2.1583333333333, 1.58, 0.083333333333333
105081, 2.1583333333333, 1.62, 0.083333333333333
105082, 2.1583333333333, 1.66, 0.083333333333333
105083, 1.2416666666667, 1.54, 0.125
105084, 1.2416666666667, 1.58, 0.125
105085, 1.2416666666667, 1.62, 0.125
105086, 1.2416666666667, 1.66, 0.125
105087, 1.2833333333333, 1.54, 0.125
105088, 1.2833333333333, 1.58, 0.125
105089, 1.2833333333333, 1.62, 0.125
105090, 1.2833333333333, 1.66, 0.125
105091, 1.325, 1.54, 0.125
105092, 1.325, 1.58, 0.125
105093, 1.325, 1.62, 0.125
105094, 1.325, 1.66, 0.125
105095, 1.3666666666667, 1.54, 0.125
105096, 1.3666666666667, 1.58, 0.125
105097, 1.3666666666667, 1.62, 0.125
105098, 1.3666666666667, 1.66, 0.125
105099, 1.4083333333333, 1.54, 0.125
105100, 1.4083333333333, 1.58, 0.125
105101, 1.4083333333333, 1.62, 0.125
105102, 1.4083333333333, 1.66, 0.125
105103, 1.45, 1.54, 0.125
105104, 1.45, 1.58, 0.125
105105, 1.45, 1.62, 0.125
105106, 1.45, 1.66, 0.125
105107, 1.4916666666667, 1.54, 0.125
105108, 1.4916666666667, 1.58, 0.125
105109, 1.4916666666667, 1.62, 0.125
105110, 1.4916666666667, 1.66, 0.125
105111, 1.5333333333333, 1.54, 0.125
105112, 1.5333333333333, 1.58, 0.125
105113, 1.5333333333333, 1.62, 0.125
105114, 1.5333333333333, 1.66, 0.125
105115, 1.575, 1.54, 0.125
105116, 1.575, 1.58, 0.125
105117, 1.575, 1.62, 0.125
105118, 1.575, 1.66, 0.125
105119, 1.6166666666667, 1.54, 0.125
105120, 1.6166666666667, 1.58, 0.125
105121, 1.6166666666667, 1.62, 0.125
105122, 1.6166666666667, 1.66, 0.125
105123, 1.6583333333333, 1.54, 0.125
105124, 1.6583333333333, 1.58, 0.125
105125, 1.6583333333333, 1.62, 0.125
105126, 1.6583333333333, 1.66, 0.125
105127, 1.7, 1.54, 0.125
105128, 1.7, 1.58, 0.125
105129, 1.7, 1.62, 0.125
105130, 1.7, 1.66, 0.125
105131, 1.7416666666667, 1.54, 0.125
105132, 1.7416666666667, 1.58, 0.125
105133, 1.7416666666667, 1.62, 0.125
105134, 1.7416666666667, 1.66, 0.125
105135, 1.7833333333333, 1.54, 0.125
105136, 1.7833333333333, 1.58, 0.125
105137, 1.7833333333333, 1.62, 0.125
105138, 1.7833333333333, 1.66, 0.125
105139, 1.825, 1.54, 0.125
105140, 1.825, 1.58, 0.125
105141, 1.825, 1.62, 0.125
105142, 1.825, 1.66, 0.125
105143, 1.8666666666667, 1.54, 0.125
105144, 1.8666666666667, 1.58, 0.125
105145, 1.8666666666667, 1.62, 0.125
105146, 1.8666666666667, 1.66, 0.125
105147, 1.9083333333333, 1.54, 0.125
105148, 1.9083333333333, 1.58, 0.125
105149, 1.9083333333333, 1.62, 0.125
105150, 1.9083333333333, 1.66, 0.125
105151, 1.95, 1.54, 0.125
105152, 1.95, 1.58, 0.125
105153, 1.95, 1.62, 0.125
105154, 1.95, 1.66, 0.125
105155, 1.9916666666667, 1.54, 0.125
105156, 1.9916666666667, 1.58, 0.125
105157, 1.9916666666667, 1.62, 0.125
105158, 1.9916666666667, 1.66, 0.125
105159, 2.0333333333333, 1.54, 0.125
105160, 2.0333333333333, 1.58, 0.125
105161, 2.0333333333333, 1.62, 0.125
105162, 2.0333333333333, 1.66, 0.125
105163, 2.075, 1.54, 0.125
105164, 2.075, 1.58, 0.125
105165, 2.075, 1.62, 0.125
105166, 2.075, 1.66, 0.125
105167, 2.1166666666667, 1.54, 0.125
105168, 2.1166666666667, 1.58, 0.125
105169, 2.1166666666667, 1.62, 0.125
105170, 2.1166666666667, 1.66, 0.125
105171, 2.1583333333333, 1.54, 0.125
105172, 2.1583333333333, 1.58, 0.125
105173, 2.1583333333333, 1.62, 0.125
105174, 2.1583333333333, 1.66, 0.125
105175, 1.2416666666667, 1.54, 0.16666666666667
105176, 1.2416666666667, 1.58, 0.16666666666667
105177, 1.2416666666667, 1.62, 0.16666666666667
105178, 1.2416666666667, 1.66, 0.16666666666667
105179, 1.2833333333333, 1.54, 0.16666666666667
105180, 1.2833333333333, 1.58, 0.16666666666667
105181, 1.2833333333333, 1.62, 0.16666666666667
105182, 1.2833333333333, 1.66, 0.16666666666667
105183, 1.325, 1.54, 0.16666666666667
105184, 1.325, 1.58, 0.16666666666667
105185, 1.325, 1.62, 0.16666666666667
105186, 1.325, 1.66, 0.16666666666667
105187, 1.3666666666667, 1.54, 0.16666666666667
105188, 1.3666666666667, 1.58, 0.16666666666667
105189, 1.3666666666667, 1.62, 0.16666666666667
105190, 1.3666666666667, 1.66, 0.16666666666667
105191, 1.4083333333333, 1.54, 0.16666666666667
105192, 1.4083333333333, 1.58, 0.16666666666667
105193, 1.4083333333333, 1.62, 0.16666666666667
105194, 1.4083333333333, 1.66, 0.16666666666667
105195, 1.45, 1.54, 0.16666666666667
105196, 1.45, 1.58, 0.16666666666667
105197, 1.45, 1.62, 0.16666666666667
105198, 1.45, 1.66, 0.16666666666667
105199, 1.4916666666667, 1.54, 0.16666666666667
105200, 1.4916666666667, 1.58, 0.16666666666667
105201, 1.4916666666667, 1.62, 0.16666666666667
105202, 1.4916666666667, 1.66, 0.16666666666667
105203, 1.5333333333333, 1.54, 0.16666666666667
105204, 1.5333333333333, 1.58, 0.16666666666667
105205, 1.5333333333333, 1.62, 0.16666666666667
105206, 1.5333333333333, 1.66, 0.16666666666667
105207, 1.575, 1.54, 0.16666666666667
105208, 1.575, 1.58, 0.16666666666667
105209, 1.575, 1.62, 0.16666666666667
105210, 1.575, 1.66, 0.16666666666667
105211, 1.6166666666667, 1.54, 0.16666666666667
105212, 1.6166666666667, 1.58, 0.16666666666667
105213, 1.6166666666667, 1.62, 0.16666666666667
105214, 1.6166666666667, 1.66, 0.16666666666667
105215, 1.6583333333333, 1.54, 0.16666666666667
105216, 1.6583333333333, 1.58, 0.16666666666667
105217, 1.6583333333333, 1.62, 0.16666666666667
105218, 1.6583333333333, 1.66, 0.16666666666667
105219, 1.7, 1.54, 0.16666666666667
105220, 1.7, 1.58, 0.16666666666667
105221, 1.7, 1.62, 0.16666666666667
105222, 1.7, 1.66, 0.16666666666667
105223, 1.7416666666667, 1.54, 0.16666666666667
105224, 1.7416666666667, 1.58, 0.16666666666667
105225, 1.7416666666667, 1.62, 0.16666666666667
105226, 1.7416666666667, 1.66, 0.16666666666667
105227, 1.7833333333333, 1.54, 0.16666666666667
105228, 1.7833333333333, 1.58, 0.16666666666667
105229, 1.7833333333333, 1.62, 0.16666666666667
105230, 1.7833333333333, 1.66, 0.16666666666667
105231, 1.825, 1.54, 0.16666666666667
105232, 1.825, 1.58, 0.16666666666667
105233, 1.825, 1.62, 0.16666666666667
105234, 1.825, 1.66, 0.16666666666667
105235, 1.8666666666667, 1.54, 0.16666666666667
105236, 1.8666666666667, 1.58, 0.16666666666667
105237, 1.8666666666667, 1.62, 0.16666666666667
105238, 1.8666666666667, 1.66, 0.16666666666667
105239, 1.9083333333333, 1.54, 0.16666666666667
105240, 1.9083333333333, 1.58, 0.16666666666667
105241, 1.9083333333333, 1.62, 0.16666666666667
105242, 1.9083333333333, 1.66, 0.16666666666667
105243, 1.95, 1.54, 0.16666666666667
105244, 1.95, 1.58, 0.16666666666667
105245, 1.95, 1.62, 0.16666666666667
105246, 1.95, 1.66, 0.16666666666667
105247, 1.9916666666667, 1.54, 0.16666666666667
105248, 1.9916666666667, 1.58, 0.16666666666667
105249, 1.9916666666667, 1.62, 0.16666666666667
105250, 1.9916666666667, 1.66, 0.16666666666667
105251, 2.0333333333333, 1.54, 0.16666666666667
105252, 2.0333333333333, 1.58, 0.16666666666667
105253, 2.0333333333333, 1.62, 0.16666666666667
105254, 2.0333333333333, 1.66, 0.16666666666667
105255, 2.075, 1.54, 0.16666666666667
105256, 2.075, 1.58, 0.16666666666667
105257, 2.075, 1.62, 0.16666666666667
105258, 2.075, 1.66, 0.16666666666667
105259, 2.1166666666667, 1.54, 0.16666666666667
105260, 2.1166666666667, 1.58, 0.16666666666667
105261, 2.1166666666667, 1.62, 0.16666666666667
105262, 2.1166666666667, 1.66, 0.16666666666667
105263, 2.1583333333333, 1.54, 0.16666666666667
105264, 2.1583333333333, 1.58, 0.16666666666667
105265, 2.1583333333333, 1.62, 0.16666666666667
105266, 2.1583333333333, 1.66, 0.16666666666667
105267, 1.2416666666667, 1.54, 0.20833333333333
105268, 1.2416666666667, 1.58, 0.20833333333333
105269, 1.2416666666667, 1.62, 0.20833333333333
105270, 1.2416666666667, 1.66, 0.20833333333333
105271, 1.2833333333333, 1.54, 0.20833333333333
105272, 1.2833333333333, 1.58, 0.20833333333333
105273, 1.2833333333333, 1.62, 0.20833333333333
105274, 1.2833333333333, 1.66, 0.20833333333333
105275, 1.325, 1.54, 0.20833333333333
105276, 1.325, 1.58, 0.20833333333333
105277, 1.325, 1.62, 0.20833333333333
105278, 1.325, 1.66, 0.20833333333333
105279, 1.3666666666667, 1.54, 0.20833333333333
105280, 1.3666666666667, 1.58, 0.20833333333333
105281, 1.3666666666667, 1.62, 0.20833333333333
105282, 1.3666666666667, 1.66, 0.20833333333333
105283, 1.4083333333333, 1.54, 0.20833333333333
105284, 1.4083333333333, 1.58, 0.20833333333333
105285, 1.4083333333333, 1.62, 0.20833333333333
105286, 1.4083333333333, 1.66, 0.20833333333333
105287, 1.45, 1.54, 0.20833333333333
105288, 1.45, 1.58, 0.20833333333333
105289, 1.45, 1.62, 0.20833333333333
105290, 1.45, 1.66, 0.20833333333333
105291, 1.4916666666667, 1.54, 0.20833333333333
105292, 1.4916666666667, 1.58, 0.20833333333333
105293, 1.4916666666667, 1.62, 0.20833333333333
105294, 1.4916666666667, 1.66, 0.20833333333333
105295, 1.5333333333333, 1.54, 0.20833333333333
105296, 1.5333333333333, 1.58, 0.20833333333333
105297, 1.5333333333333, 1.62, 0.20833333333333
105298, 1.5333333333333, 1.66, 0.20833333333333
105299, 1.575, 1.54, 0.20833333333333
105300, 1.575, 1.58, 0.20833333333333
105301, 1.575, 1.62, 0.20833333333333
105302, 1.575, 1.66, 0.20833333333333
105303, 1.6166666666667, 1.54, 0.20833333333333
105304, 1.6166666666667, 1.58, 0.20833333333333
105305, 1.6166666666667, 1.62, 0.20833333333333
105306, 1.6166666666667, 1.66, 0.20833333333333
105307, 1.6583333333333, 1.54, 0.20833333333333
105308, 1.6583333333333, 1.58, 0.20833333333333
105309, 1.6583333333333, 1.62, 0.20833333333333
105310, 1.6583333333333, 1.66, 0.20833333333333
105311, 1.7, 1.54, 0.20833333333333
105312, 1.7, 1.58, 0.20833333333333
105313, 1.7, 1.62, 0.20833333333333
105314, 1.7, 1.66, 0.20833333333333
105315, 1.7416666666667, 1.54, 0.20833333333333
105316, 1.7416666666667, 1.58, 0.20833333333333
105317, 1.7416666666667, 1.62, 0.20833333333333
105318, 1.7416666666667, 1.66, 0.20833333333333
105319, 1.7833333333333, 1.54, 0.20833333333333
105320, 1.7833333333333, 1.58, 0.20833333333333
105321, 1.7833333333333, 1.62, 0.20833333333333
105322, 1.7833333333333, 1.66, 0.20833333333333
105323, 1.825, 1.54, 0.20833333333333
105324, 1.825, 1.58, 0.20833333333333
105325, 1.825, 1.62, 0.20833333333333
105326, 1.825, 1.66, 0.20833333333333
105327, 1.8666666666667, 1.54, 0.20833333333333
105328, 1.8666666666667, 1.58, 0.20833333333333
105329, 1.8666666666667, 1.62, 0.20833333333333
105330, 1.8666666666667, 1.66, 0.20833333333333
105331, 1.9083333333333, 1.54, 0.20833333333333
105332, 1.9083333333333, 1.58, 0.20833333333333
105333, 1.9083333333333, 1.62, 0.20833333333333
105334, 1.9083333333333, 1.66, 0.20833333333333
105335, 1.95, 1.54, 0.20833333333333
105336, 1.95, 1.58, 0.20833333333333
105337, 1.95, 1.62, 0.20833333333333
105338, 1.95, 1.66, 0.20833333333333
105339, 1.9916666666667, 1.54, 0.20833333333333
105340, 1.9916666666667, 1.58, 0.20833333333333
105341, 1.9916666666667, 1.62, 0.20833333333333
105342, 1.9916666666667, 1.66, 0.20833333333333
105343, 2.0333333333333, 1.54, 0.20833333333333
105344, 2.0333333333333, 1.58, 0.20833333333333
105345, 2.0333333333333, 1.62, 0.20833333333333
105346, 2.0333333333333, 1.66, 0.20833333333333
105347, 2.075, 1.54, 0.20833333333333
105348, 2.075, 1.58, 0.20833333333333
105349, 2.075, 1.62, 0.20833333333333
105350, 2.075, 1.66, 0.20833333333333
105351, 2.1166666666667, 1.54, 0.20833333333333
105352, 2.1166666666667, 1.58, 0.20833333333333
105353, 2.1166666666667, 1.62, 0.20833333333333
105354, 2.1166666666667, 1.66, 0.20833333333333
105355, 2.1583333333333, 1.54, 0.20833333333333
105356, 2.1583333333333, 1.58, 0.20833333333333
105357, 2.1583333333333, 1.62, 0.20833333333333
105358, 2.1583333333333, 1.66, 0.20833333333333
105359, 1.2416666666667, 1.54, 0.25
105360, 1.2416666666667, 1.58, 0.25
105361, 1.2416666666667, 1.62, 0.25
105362, 1.2416666666667, 1.66, 0.25
105363, 1.2833333333333, 1.54, 0.25
105364, 1.2833333333333, 1.58, 0.25
105365, 1.2833333333333, 1.62, 0.25
105366, 1.2833333333333, 1.66, 0.25
105367, 1.325, 1.54, 0.25
105368, 1.325, 1.58, 0.25
105369, 1.325, 1.62, 0.25
105370, 1.325, 1.66, 0.25
105371, 1.3666666666667, 1.54, 0.25
105372, 1.3666666666667, 1.58, 0.25
105373, 1.3666666666667, 1.62, 0.25
105374, 1.3666666666667, 1.66, 0.25
105375, 1.4083333333333, 1.54, 0.25
105376, 1.4083333333333, 1.58, 0.25
105377, 1.4083333333333, 1.62, 0.25
105378, 1.4083333333333, 1.66, 0.25
105379, 1.45, 1.54, 0.25
105380, 1.45, 1.58, 0.25
105381, 1.45, 1.62, 0.25
105382, 1.45, 1.66, 0.25
105383, 1.4916666666667, 1.54, 0.25
105384, 1.4916666666667, 1.58, 0.25
105385, 1.4916666666667, 1.62, 0.25
105386, 1.4916666666667, 1.66, 0.25
105387, 1.5333333333333, 1.54, 0.25
105388, 1.5333333333333, 1.58, 0.25
105389, 1.5333333333333, 1.62, 0.25
105390, 1.5333333333333, 1.66, 0.25
105391, 1.575, 1.54, 0.25
105392, 1.575, 1.58, 0.25
105393, 1.575, 1.62, 0.25
105394, 1.575, 1.66, 0.25
105395, 1.6166666666667, 1.54, 0.25
105396, 1.6166666666667, 1.58, 0.25
105397, 1.6166666666667, 1.62, 0.25
105398, 1.6166666666667, 1.66, 0.25
105399, 1.6583333333333, 1.54, 0.25
105400, 1.6583333333333, 1.58, 0.25
105401, 1.6583333333333, 1.62, 0.25
105402, 1.6583333333333, 1.66, 0.25
105403, 1.7, 1.54, 0.25
105404, 1.7, 1.58, 0.25
105405, 1.7, 1.62, 0.25
105406, 1.7, 1.66, 0.25
105407, 1.7416666666667, 1.54, 0.25
105408, 1.7416666666667, 1.58, 0.25
105409, 1.7416666666667, 1.62, 0.25
105410, 1.7416666666667, 1.66, 0.25
105411, 1.7833333333333, 1.54, 0.25
105412, 1.7833333333333, 1.58, 0.25
105413, 1.7833333333333, 1.62, 0.25
105414, 1.7833333333333, 1.66, 0.25
105415, 1.825, 1.54, 0.25
105416, 1.825, 1.58, 0.25
105417, 1.825, 1.62, 0.25
105418, 1.825, 1.66, 0.25
105419, 1.8666666666667, 1.54, 0.25
105420, 1.8666666666667, 1.58, 0.25
105421, 1.8666666666667, 1.62, 0.25
105422, 1.8666666666667, 1.66, 0.25
105423, 1.9083333333333, 1.54, 0.25
105424, 1.9083333333333, 1.58, 0.25
105425, 1.9083333333333, 1.62, 0.25
105426, 1.9083333333333, 1.66, 0.25
105427, 1.95, 1.54, 0.25
105428, 1.95, 1.58, 0.25
105429, 1.95, 1.62, 0.25
105430, 1.95, 1.66, 0.25
105431, 1.9916666666667, 1.54, 0.25
105432, 1.9916666666667, 1.58, 0.25
105433, 1.9916666666667, 1.62, 0.25
105434, 1.9916666666667, 1.66, 0.25
105435, 2.0333333333333, 1.54, 0.25
105436, 2.0333333333333, 1.58, 0.25
105437, 2.0333333333333, 1.62, 0.25
105438, 2.0333333333333, 1.66, 0.25
105439, 2.075, 1.54, 0.25
105440, 2.075, 1.58, 0.25
105441, 2.075, 1.62, 0.25
105442, 2.075, 1.66, 0.25
105443, 2.1166666666667, 1.54, 0.25
105444, 2.1166666666667, 1.58, 0.25
105445, 2.1166666666667, 1.62, 0.25
105446, 2.1166666666667, 1.66, 0.25
105447, 2.1583333333333, 1.54, 0.25
105448, 2.1583333333333, 1.58, 0.25
105449, 2.1583333333333, 1.62, 0.25
105450, 2.1583333333333, 1.66, 0.25
105451, 1.2416666666667, 1.54, 0.29166666666667
105452, 1.2416666666667, 1.58, 0.29166666666667
105453, 1.2416666666667, 1.62, 0.29166666666667
105454, 1.2416666666667, 1.66, 0.29166666666667
105455, 1.2833333333333, 1.54, 0.29166666666667
105456, 1.2833333333333, 1.58, 0.29166666666667
105457, 1.2833333333333, 1.62, 0.29166666666667
105458, 1.2833333333333, 1.66, 0.29166666666667
105459, 1.325, 1.54, 0.29166666666667
105460, 1.325, 1.58, 0.29166666666667
105461, 1.325, 1.62, 0.29166666666667
105462, 1.325, 1.66, 0.29166666666667
105463, 1.3666666666667, 1.54, 0.29166666666667
105464, 1.3666666666667, 1.58, 0.29166666666667
105465, 1.3666666666667, 1.62, 0.29166666666667
105466, 1.3666666666667, 1.66, 0.29166666666667
105467, 1.4083333333333, 1.54, 0.29166666666667
105468, 1.4083333333333, 1.58, 0.29166666666667
105469, 1.4083333333333, 1.62, 0.29166666666667
105470, 1.4083333333333, 1.66, 0.29166666666667
105471, 1.45, 1.54, 0.29166666666667
105472, 1.45, 1.58, 0.29166666666667
105473, 1.45, 1.62, 0.29166666666667
105474, 1.45, 1.66, 0.29166666666667
105475, 1.4916666666667, 1.54, 0.29166666666667
105476, 1.4916666666667, 1.58, 0.29166666666667
105477, 1.4916666666667, 1.62, 0.29166666666667
105478, 1.4916666666667, 1.66, 0.29166666666667
105479, 1.5333333333333, 1.54, 0.29166666666667
105480, 1.5333333333333, 1.58, 0.29166666666667
105481, 1.5333333333333, 1.62, 0.29166666666667
105482, 1.5333333333333, 1.66, 0.29166666666667
105483, 1.575, 1.54, 0.29166666666667
105484, 1.575, 1.58, 0.29166666666667
105485, 1.575, 1.62, 0.29166666666667
105486, 1.575, 1.66, 0.29166666666667
105487, 1.6166666666667, 1.54, 0.29166666666667
105488, 1.6166666666667, 1.58, 0.29166666666667
105489, 1.6166666666667, 1.62, 0.29166666666667
105490, 1.6166666666667, 1.66, 0.29166666666667
105491, 1.6583333333333, 1.54, 0.29166666666667
105492, 1.6583333333333, 1.58, 0.29166666666667
105493, 1.6583333333333, 1.62, 0.29166666666667
105494, 1.6583333333333, 1.66, 0.29166666666667
105495, 1.7, 1.54, 0.29166666666667
105496, 1.7, 1.58, 0.29166666666667
105497, 1.7, 1.62, 0.29166666666667
105498, 1.7, 1.66, 0.29166666666667
105499, 1.7416666666667, 1.54, 0.29166666666667
105500, 1.7416666666667, 1.58, 0.29166666666667
105501, 1.7416666666667, 1.62, 0.29166666666667
105502, 1.7416666666667, 1.66, 0.29166666666667
105503, 1.7833333333333, 1.54, 0.29166666666667
105504, 1.7833333333333, 1.58, 0.29166666666667
105505, 1.7833333333333, 1.62, 0.29166666666667
105506, 1.7833333333333, 1.66, 0.29166666666667
105507, 1.825, 1.54, 0.29166666666667
105508, 1.825, 1.58, 0.29166666666667
105509, 1.825, 1.62, 0.29166666666667
105510, 1.825, 1.66, 0.29166666666667
105511, 1.8666666666667, 1.54, 0.29166666666667
105512, 1.8666666666667, 1.58, 0.29166666666667
105513, 1.8666666666667, 1.62, 0.29166666666667
105514, 1.8666666666667, 1.66, 0.29166666666667
105515, 1.9083333333333, 1.54, 0.29166666666667
105516, 1.9083333333333, 1.58, 0.29166666666667
105517, 1.9083333333333, 1.62, 0.29166666666667
105518, 1.9083333333333, 1.66, 0.29166666666667
105519, 1.95, 1.54, 0.29166666666667
105520, 1.95, 1.58, 0.29166666666667
105521, 1.95, 1.62, 0.29166666666667
105522, 1.95, 1.66, 0.29166666666667
105523, 1.9916666666667, 1.54, 0.29166666666667
105524, 1.9916666666667, 1.58, 0.29166666666667
105525, 1.9916666666667, 1.62, 0.29166666666667
105526, 1.9916666666667, 1.66, 0.29166666666667
105527, 2.0333333333333, 1.54, 0.29166666666667
105528, 2.0333333333333, 1.58, 0.29166666666667
105529, 2.0333333333333, 1.62, 0.29166666666667
105530, 2.0333333333333, 1.66, 0.29166666666667
105531, 2.075, 1.54, 0.29166666666667
105532, 2.075, 1.58, 0.29166666666667
105533, 2.075, 1.62, 0.29166666666667
105534, 2.075, 1.66, 0.29166666666667
105535, 2.1166666666667, 1.54, 0.29166666666667
105536, 2.1166666666667, 1.58, 0.29166666666667
105537, 2.1166666666667, 1.62, 0.29166666666667
105538, 2.1166666666667, 1.66, 0.29166666666667
105539, 2.1583333333333, 1.54, 0.29166666666667
105540, 2.1583333333333, 1.58, 0.29166666666667
105541, 2.1583333333333, 1.62, 0.29166666666667
105542, 2.1583333333333, 1.66, 0.29166666666667
105543, 1.2416666666667, 1.54, 0.33333333333333
105544, 1.2416666666667, 1.58, 0.33333333333333
105545, 1.2416666666667, 1.62, 0.33333333333333
105546, 1.2416666666667, 1.66, 0.33333333333333
105547, 1.2833333333333, 1.54, 0.33333333333333
105548, 1.2833333333333, 1.58, 0.33333333333333
105549, 1.2833333333333, 1.62, 0.33333333333333
105550, 1.2833333333333, 1.66, 0.33333333333333
105551, 1.325, 1.54, 0.33333333333333
105552, 1.325, 1.58, 0.33333333333333
105553, 1.325, 1.62, 0.33333333333333
105554, 1.325, 1.66, 0.33333333333333
105555, 1.3666666666667, 1.54, 0.33333333333333
105556, 1.3666666666667, 1.58, 0.33333333333333
105557, 1.3666666666667, 1.62, 0.33333333333333
105558, 1.3666666666667, 1.66, 0.33333333333333
105559, 1.4083333333333, 1.54, 0.33333333333333
105560, 1.4083333333333, 1.58, 0.33333333333333
105561, 1.4083333333333, 1.62, 0.33333333333333
105562, 1.4083333333333, 1.66, 0.33333333333333
105563, 1.45, 1.54, 0.33333333333333
105564, 1.45, 1.58, 0.33333333333333
105565, 1.45, 1.62, 0.33333333333333
105566, 1.45, 1.66, 0.33333333333333
105567, 1.4916666666667, 1.54, 0.33333333333333
105568, 1.4916666666667, 1.58, 0.33333333333333
105569, 1.4916666666667, 1.62, 0.33333333333333
105570, 1.4916666666667, 1.66, 0.33333333333333
105571, 1.5333333333333, 1.54, 0.33333333333333
105572, 1.5333333333333, 1.58, 0.33333333333333
105573, 1.5333333333333, 1.62, 0.33333333333333
105574, 1.5333333333333, 1.66, 0.33333333333333
105575, 1.575, 1.54, 0.33333333333333
105576, 1.575, 1.58, 0.33333333333333
105577, 1.575, 1.62, 0.33333333333333
105578, 1.575, 1.66, 0.33333333333333
105579, 1.6166666666667, 1.54, 0.33333333333333
105580, 1.6166666666667, 1.58, 0.33333333333333
105581, 1.6166666666667, 1.62, 0.33333333333333
105582, 1.6166666666667, 1.66, 0.33333333333333
105583, 1.6583333333333, 1.54, 0.33333333333333
105584, 1.6583333333333, 1.58, 0.33333333333333
105585, 1.6583333333333, 1.62, 0.33333333333333
105586, 1.6583333333333, 1.66, 0.33333333333333
105587, 1.7, 1.54, 0.33333333333333
105588, 1.7, 1.58, 0.33333333333333
105589, 1.7, 1.62, 0.33333333333333
105590, 1.7, 1.66, 0.33333333333333
105591, 1.7416666666667, 1.54, 0.33333333333333
105592, 1.7416666666667, 1.58, 0.33333333333333
105593, 1.7416666666667, 1.62, 0.33333333333333
105594, 1.7416666666667, 1.66, 0.33333333333333
105595, 1.7833333333333, 1.54, 0.33333333333333
105596, 1.7833333333333, 1.58, 0.33333333333333
105597, 1.7833333333333, 1.62, 0.33333333333333
105598, 1.7833333333333, 1.66, 0.33333333333333
105599, 1.825, 1.54, 0.33333333333333
105600, 1.825, 1.58, 0.33333333333333
105601, 1.825, 1.62, 0.33333333333333
105602, 1.825, 1.66, 0.33333333333333
105603, 1.8666666666667, 1.54, 0.33333333333333
105604, 1.8666666666667, 1.58, 0.33333333333333
105605, 1.8666666666667, 1.62, 0.33333333333333
105606, 1.8666666666667, 1.66, 0.33333333333333
105607, 1.9083333333333, 1.54, 0.33333333333333
105608, 1.9083333333333, 1.58, 0.33333333333333
105609, 1.9083333333333, 1.62, 0.33333333333333
105610, 1.9083333333333, 1.66, 0.33333333333333
105611, 1.95, 1.54, 0.33333333333333
105612, 1.95, 1.58, 0.33333333333333
105613, 1.95, 1.62, 0.33333333333333
105614, 1.95, 1.66, 0.33333333333333
105615, 1.9916666666667, 1.54, 0.33333333333333
105616, 1.9916666666667, 1.58, 0.33333333333333
105617, 1.9916666666667, 1.62, 0.33333333333333
105618, 1.9916666666667, 1.66, 0.33333333333333
105619, 2.0333333333333, 1.54, 0.33333333333333
105620, 2.0333333333333, 1.58, 0.33333333333333
105621, 2.0333333333333, 1.62, 0.33333333333333
105622, 2.0333333333333, 1.66, 0.33333333333333
105623, 2.075, 1.54, 0.33333333333333
105624, 2.075, 1.58, 0.33333333333333
105625, 2.075, 1.62, 0.33333333333333
105626, 2.075, 1.66, 0.33333333333333
105627, 2.1166666666667, 1.54, 0.33333333333333
105628, 2.1166666666667, 1.58, 0.33333333333333
105629, 2.1166666666667, 1.62, 0.33333333333333
105630, 2.1166666666667, 1.66, 0.33333333333333
105631, 2.1583333333333, 1.54, 0.33333333333333
105632, 2.1583333333333, 1.58, 0.33333333333333
105633, 2.1583333333333, 1.62, 0.33333333333333
105634, 2.1583333333333, 1.66, 0.33333333333333
105635, 1.2416666666667, 1.54, 0.375
105636, 1.2416666666667, 1.58, 0.375
105637, 1.2416666666667, 1.62, 0.375
105638, 1.2416666666667, 1.66, 0.375
105639, 1.2833333333333, 1.54, 0.375
105640, 1.2833333333333, 1.58, 0.375
105641, 1.2833333333333, 1.62, 0.375
105642, 1.2833333333333, 1.66, 0.375
105643, 1.325, 1.54, 0.375
105644, 1.325, 1.58, 0.375
105645, 1.325, 1.62, 0.375
105646, 1.325, 1.66, 0.375
105647, 1.3666666666667, 1.54, 0.375
105648, 1.3666666666667, 1.58, 0.375
105649, 1.3666666666667, 1.62, 0.375
105650, 1.3666666666667, 1.66, 0.375
105651, 1.4083333333333, 1.54, 0.375
105652, 1.4083333333333, 1.58, 0.375
105653, 1.4083333333333, 1.62, 0.375
105654, 1.4083333333333, 1.66, 0.375
105655, 1.45, 1.54, 0.375
105656, 1.45, 1.58, 0.375
105657, 1.45, 1.62, 0.375
105658, 1.45, 1.66, 0.375
105659, 1.4916666666667, 1.54, 0.375
105660, 1.4916666666667, 1.58, 0.375
105661, 1.4916666666667, 1.62, 0.375
105662, 1.4916666666667, 1.66, 0.375
105663, 1.5333333333333, 1.54, 0.375
105664, 1.5333333333333, 1.58, 0.375
105665, 1.5333333333333, 1.62, 0.375
105666, 1.5333333333333, 1.66, 0.375
105667, 1.575, 1.54, 0.375
105668, 1.575, 1.58, 0.375
105669, 1.575, 1.62, 0.375
105670, 1.575, 1.66, 0.375
105671, 1.6166666666667, 1.54, 0.375
105672, 1.6166666666667, 1.58, 0.375
105673, 1.6166666666667, 1.62, 0.375
105674, 1.6166666666667, 1.66, 0.375
105675, 1.6583333333333, 1.54, 0.375
105676, 1.6583333333333, 1.58, 0.375
105677, 1.6583333333333, 1.62, 0.375
105678, 1.6583333333333, 1.66, 0.375
105679, 1.7, 1.54, 0.375
105680, 1.7, 1.58, 0.375
105681, 1.7, 1.62, 0.375
105682, 1.7, 1.66, 0.375
105683, 1.7416666666667, 1.54, 0.375
105684, 1.7416666666667, 1.58, 0.375
105685, 1.7416666666667, 1.62, 0.375
105686, 1.7416666666667, 1.66, 0.375
105687, 1.7833333333333, 1.54, 0.375
105688, 1.7833333333333, 1.58, 0.375
105689, 1.7833333333333, 1.62, 0.375
105690, 1.7833333333333, 1.66, 0.375
105691, 1.825, 1.54, 0.375
105692, 1.825, 1.58, 0.375
105693, 1.825, 1.62, 0.375
105694, 1.825, 1.66, 0.375
105695, 1.8666666666667, 1.54, 0.375
105696, 1.8666666666667, 1.58, 0.375
105697, 1.8666666666667, 1.62, 0.375
105698, 1.8666666666667, 1.66, 0.375
105699, 1.9083333333333, 1.54, 0.375
105700, 1.9083333333333, 1.58, 0.375
105701, 1.9083333333333, 1.62, 0.375
105702, 1.9083333333333, 1.66, 0.375
105703, 1.95, 1.54, 0.375
105704, 1.95, 1.58, 0.375
105705, 1.95, 1.62, 0.375
105706, 1.95, 1.66, 0.375
105707, 1.9916666666667, 1.54, 0.375
105708, 1.9916666666667, 1.58, 0.375
105709, 1.9916666666667, 1.62, 0.375
105710, 1.9916666666667, 1.66, 0.375
105711, 2.0333333333333, 1.54, 0.375
105712, 2.0333333333333, 1.58, 0.375
105713, 2.0333333333333, 1.62, 0.375
105714, 2.0333333333333, 1.66, 0.375
105715, 2.075, 1.54, 0.375
105716, 2.075, 1.58, 0.375
105717, 2.075, 1.62, 0.375
105718, 2.075, 1.66, 0.375
105719, 2.1166666666667, 1.54, 0.375
105720, 2.1166666666667, 1.58, 0.375
105721, 2.1166666666667, 1.62, 0.375
105722, 2.1166666666667, 1.66, 0.375
105723, 2.1583333333333, 1.54, 0.375
105724, 2.1583333333333, 1.58, 0.375
105725, 2.1583333333333, 1.62, 0.375
105726, 2.1583333333333, 1.66, 0.375
105727, 1.2416666666667, 1.54, 0.41666666666667
105728, 1.2416666666667, 1.58, 0.41666666666667
105729, 1.2416666666667, 1.62, 0.41666666666667
105730, 1.2416666666667, 1.66, 0.41666666666667
105731, 1.2833333333333, 1.54, 0.41666666666667
105732, 1.2833333333333, 1.58, 0.41666666666667
105733, 1.2833333333333, 1.62, 0.41666666666667
105734, 1.2833333333333, 1.66, 0.41666666666667
105735, 1.325, 1.54, 0.41666666666667
105736, 1.325, 1.58, 0.41666666666667
105737, 1.325, 1.62, 0.41666666666667
105738, 1.325, 1.66, 0.41666666666667
105739, 1.3666666666667, 1.54, 0.41666666666667
105740, 1.3666666666667, 1.58, 0.41666666666667
105741, 1.3666666666667, 1.62, 0.41666666666667
105742, 1.3666666666667, 1.66, 0.41666666666667
105743, 1.4083333333333, 1.54, 0.41666666666667
105744, 1.4083333333333, 1.58, 0.41666666666667
105745, 1.4083333333333, 1.62, 0.41666666666667
105746, 1.4083333333333, 1.66, 0.41666666666667
105747, 1.45, 1.54, 0.41666666666667
105748, 1.45, 1.58, 0.41666666666667
105749, 1.45, 1.62, 0.41666666666667
105750, 1.45, 1.66, 0.41666666666667
105751, 1.4916666666667, 1.54, 0.41666666666667
105752, 1.4916666666667, 1.58, 0.41666666666667
105753, 1.4916666666667, 1.62, 0.41666666666667
105754, 1.4916666666667, 1.66, 0.41666666666667
105755, 1.5333333333333, 1.54, 0.41666666666667
105756, 1.5333333333333, 1.58, 0.41666666666667
105757, 1.5333333333333, 1.62, 0.41666666666667
105758, 1.5333333333333, 1.66, 0.41666666666667
105759, 1.575, 1.54, 0.41666666666667
105760, 1.575, 1.58, 0.41666666666667
105761, 1.575, 1.62, 0.41666666666667
105762, 1.575, 1.66, 0.41666666666667
105763, 1.6166666666667, 1.54, 0.41666666666667
105764, 1.6166666666667, 1.58, 0.41666666666667
105765, 1.6166666666667, 1.62, 0.41666666666667
105766, 1.6166666666667, 1.66, 0.41666666666667
105767, 1.6583333333333, 1.54, 0.41666666666667
105768, 1.6583333333333, 1.58, 0.41666666666667
105769, 1.6583333333333, 1.62, 0.41666666666667
105770, 1.6583333333333, 1.66, 0.41666666666667
105771, 1.7, 1.54, 0.41666666666667
105772, 1.7, 1.58, 0.41666666666667
105773, 1.7, 1.62, 0.41666666666667
105774, 1.7, 1.66, 0.41666666666667
105775, 1.7416666666667, 1.54, 0.41666666666667
105776, 1.7416666666667, 1.58, 0.41666666666667
105777, 1.7416666666667, 1.62, 0.41666666666667
105778, 1.7416666666667, 1.66, 0.41666666666667
105779, 1.7833333333333, 1.54, 0.41666666666667
105780, 1.7833333333333, 1.58, 0.41666666666667
105781, 1.7833333333333, 1.62, 0.41666666666667
105782, 1.7833333333333, 1.66, 0.41666666666667
105783, 1.825, 1.54, 0.41666666666667
105784, 1.825, 1.58, 0.41666666666667
105785, 1.825, 1.62, 0.41666666666667
105786, 1.825, 1.66, 0.41666666666667
105787, 1.8666666666667, 1.54, 0.41666666666667
105788, 1.8666666666667, 1.58, 0.41666666666667
105789, 1.8666666666667, 1.62, 0.41666666666667
105790, 1.8666666666667, 1.66, 0.41666666666667
105791, 1.9083333333333, 1.54, 0.41666666666667
105792, 1.9083333333333, 1.58, 0.41666666666667
105793, 1.9083333333333, 1.62, 0.41666666666667
105794, 1.9083333333333, 1.66, 0.41666666666667
105795, 1.95, 1.54, 0.41666666666667
105796, 1.95, 1.58, 0.41666666666667
105797, 1.95, 1.62, 0.41666666666667
105798, 1.95, 1.66, 0.41666666666667
105799, 1.9916666666667, 1.54, 0.41666666666667
105800, 1.9916666666667, 1.58, 0.41666666666667
105801, 1.9916666666667, 1.62, 0.41666666666667
105802, 1.9916666666667, 1.66, 0.41666666666667
105803, 2.0333333333333, 1.54, 0.41666666666667
105804, 2.0333333333333, 1.58, 0.41666666666667
105805, 2.0333333333333, 1.62, 0.41666666666667
105806, 2.0333333333333, 1.66, 0.41666666666667
105807, 2.075, 1.54, 0.41666666666667
105808, 2.075, 1.58, 0.41666666666667
105809, 2.075, 1.62, 0.41666666666667
105810, 2.075, 1.66, 0.41666666666667
105811, 2.1166666666667, 1.54, 0.41666666666667
105812, 2.1166666666667, 1.58, 0.41666666666667
105813, 2.1166666666667, 1.62, 0.41666666666667
105814, 2.1166666666667, 1.66, 0.41666666666667
105815, 2.1583333333333, 1.54, 0.41666666666667
105816, 2.1583333333333, 1.58, 0.41666666666667
105817, 2.1583333333333, 1.62, 0.41666666666667
105818, 2.1583333333333, 1.66, 0.41666666666667
105819, 1.2416666666667, 1.54, 0.45833333333333
105820, 1.2416666666667, 1.58, 0.45833333333333
105821, 1.2416666666667, 1.62, 0.45833333333333
105822, 1.2416666666667, 1.66, 0.45833333333333
105823, 1.2833333333333, 1.54, 0.45833333333333
105824, 1.2833333333333, 1.58, 0.45833333333333
105825, 1.2833333333333, 1.62, 0.45833333333333
105826, 1.2833333333333, 1.66, 0.45833333333333
105827, 1.325, 1.54, 0.45833333333333
105828, 1.325, 1.58, 0.45833333333333
105829, 1.325, 1.62, 0.45833333333333
105830, 1.325, 1.66, 0.45833333333333
105831, 1.3666666666667, 1.54, 0.45833333333333
105832, 1.3666666666667, 1.58, 0.45833333333333
105833, 1.3666666666667, 1.62, 0.45833333333333
105834, 1.3666666666667, 1.66, 0.45833333333333
105835, 1.4083333333333, 1.54, 0.45833333333333
105836, 1.4083333333333, 1.58, 0.45833333333333
105837, 1.4083333333333, 1.62, 0.45833333333333
105838, 1.4083333333333, 1.66, 0.45833333333333
105839, 1.45, 1.54, 0.45833333333333
105840, 1.45, 1.58, 0.45833333333333
105841, 1.45, 1.62, 0.45833333333333
105842, 1.45, 1.66, 0.45833333333333
105843, 1.4916666666667, 1.54, 0.45833333333333
105844, 1.4916666666667, 1.58, 0.45833333333333
105845, 1.4916666666667, 1.62, 0.45833333333333
105846, 1.4916666666667, 1.66, 0.45833333333333
105847, 1.5333333333333, 1.54, 0.45833333333333
105848, 1.5333333333333, 1.58, 0.45833333333333
105849, 1.5333333333333, 1.62, 0.45833333333333
105850, 1.5333333333333, 1.66, 0.45833333333333
105851, 1.575, 1.54, 0.45833333333333
105852, 1.575, 1.58, 0.45833333333333
105853, 1.575, 1.62, 0.45833333333333
105854, 1.575, 1.66, 0.45833333333333
105855, 1.6166666666667, 1.54, 0.45833333333333
105856, 1.6166666666667, 1.58, 0.45833333333333
105857, 1.6166666666667, 1.62, 0.45833333333333
105858, 1.6166666666667, 1.66, 0.45833333333333
105859, 1.6583333333333, 1.54, 0.45833333333333
105860, 1.6583333333333, 1.58, 0.45833333333333
105861, 1.6583333333333, 1.62, 0.45833333333333
105862, 1.6583333333333, 1.66, 0.45833333333333
105863, 1.7, 1.54, 0.45833333333333
105864, 1.7, 1.58, 0.45833333333333
105865, 1.7, 1.62, 0.45833333333333
105866, 1.7, 1.66, 0.45833333333333
105867, 1.7416666666667, 1.54, 0.45833333333333
105868, 1.7416666666667, 1.58, 0.45833333333333
105869, 1.7416666666667, 1.62, 0.45833333333333
105870, 1.7416666666667, 1.66, 0.45833333333333
105871, 1.7833333333333, 1.54, 0.45833333333333
105872, 1.7833333333333, 1.58, 0.45833333333333
105873, 1.7833333333333, 1.62, 0.45833333333333
105874, 1.7833333333333, 1.66, 0.45833333333333
105875, 1.825, 1.54, 0.45833333333333
105876, 1.825, 1.58, 0.45833333333333
105877, 1.825, 1.62, 0.45833333333333
105878, 1.825, 1.66, 0.45833333333333
105879, 1.8666666666667, 1.54, 0.45833333333333
105880, 1.8666666666667, 1.58, 0.45833333333333
105881, 1.8666666666667, 1.62, 0.45833333333333
105882, 1.8666666666667, 1.66, 0.45833333333333
105883, 1.9083333333333, 1.54, 0.45833333333333
105884, 1.9083333333333, 1.58, 0.45833333333333
105885, 1.9083333333333, 1.62, 0.45833333333333
105886, 1.9083333333333, 1.66, 0.45833333333333
105887, 1.95, 1.54, 0.45833333333333
105888, 1.95, 1.58, 0.45833333333333
105889, 1.95, 1.62, 0.45833333333333
105890, 1.95, 1.66, 0.45833333333333
105891, 1.9916666666667, 1.54, 0.45833333333333
105892, 1.9916666666667, 1.58, 0.45833333333333
105893, 1.9916666666667, 1.62, 0.45833333333333
105894, 1.9916666666667, 1.66, 0.45833333333333
105895, 2.0333333333333, 1.54, 0.45833333333333
105896, 2.0333333333333, 1.58, 0.45833333333333
105897, 2.0333333333333, 1.62, 0.45833333333333
105898, 2.0333333333333, 1.66, 0.45833333333333
105899, 2.075, 1.54, 0.45833333333333
105900, 2.075, 1.58, 0.45833333333333
105901, 2.075, 1.62, 0.45833333333333
105902, 2.075, 1.66, 0.45833333333333
105903, 2.1166666666667, 1.54, 0.45833333333333
105904, 2.1166666666667, 1.58, 0.45833333333333
105905, 2.1166666666667, 1.62, 0.45833333333333
105906, 2.1166666666667, 1.66, 0.45833333333333
105907, 2.1583333333333, 1.54, 0.45833333333333
105908, 2.1583333333333, 1.58, 0.45833333333333
105909, 2.1583333333333, 1.62, 0.45833333333333
105910, 2.1583333333333, 1.66, 0.45833333333333
105911, 1.2416666666667, 1.52, 0.041666666666667
105912, 1.2208333333333, 1.54, 0.041666666666667
105913, 1.2416666666667, 1.54, 0.020833333333333
105914, 1.2416666666667, 1.56, 0.041666666666667
105915, 1.2208333333333, 1.58, 0.041666666666667
105916, 1.2416666666667, 1.58, 0.020833333333333
105917, 1.2416666666667, 1.6, 0.041666666666667
105918, 1.2208333333333, 1.62, 0.041666666666667
105919, 1.2416666666667, 1.62, 0.020833333333333
105920, 1.2416666666667, 1.64, 0.041666666666667
105921, 1.2208333333333, 1.66, 0.041666666666667
105922, 1.2416666666667, 1.66, 0.020833333333333
105923, 1.2416666666667, 1.68, 0.041666666666667
105924, 1.2833333333333, 1.52, 0.041666666666667
105925, 1.2625, 1.54, 0.041666666666667
105926, 1.2833333333333, 1.54, 0.020833333333333
105927, 1.2833333333333, 1.56, 0.041666666666667
105928, 1.2625, 1.58, 0.041666666666667
105929, 1.2833333333333, 1.58, 0.020833333333333
105930, 1.2833333333333, 1.6, 0.041666666666667
105931, 1.2625, 1.62, 0.041666666666667
105932, 1.2833333333333, 1.62, 0.020833333333333
105933, 1.2833333333333, 1.64, 0.041666666666667
105934, 1.2625, 1.66, 0.041666666666667
105935, 1.2833333333333, 1.66, 0.020833333333333
105936, 1.2833333333333, 1.68, 0.041666666666667
105937, 1.325, 1.52, 0.041666666666667
105938, 1.3041666666667, 1.54, 0.041666666666667
105939, 1.325, 1.54, 0.020833333333333
105940, 1.325, 1.56, 0.041666666666667
105941, 1.3041666666667, 1.58, 0.041666666666667
105942, 1.325, 1.58, 0.020833333333333
105943, 1.325, 1.6, 0.041666666666667
105944, 1.3041666666667, 1.62, 0.041666666666667
105945, 1.325, 1.62, 0.020833333333333
105946, 1.325, 1.64, 0.041666666666667
105947, 1.3041666666667, 1.66, 0.041666666666667
105948, 1.325, 1.66, 0.020833333333333
105949, 1.325, 1.68, 0.041666666666667
105950, 1.3666666666667, 1.52, 0.041666666666667
105951, 1.3458333333333, 1.54, 0.041666666666667
105952, 1.3666666666667, 1.54, 0.020833333333333
105953, 1.3666666666667, 1.56, 0.041666666666667
105954, 1.3458333333333, 1.58, 0.041666666666667
105955, 1.3666666666667, 1.58, 0.020833333333333
105956, 1.3666666666667, 1.6, 0.041666666666667
105957, 1.3458333333333, 1.62, 0.041666666666667
105958, 1.3666666666667, 1.62, 0.020833333333333
105959, 1.3666666666667, 1.64, 0.041666666666667
105960, 1.3458333333333, 1.66, 0.041666666666667
105961, 1.3666666666667, 1.66, 0.020833333333333
105962, 1.3666666666667, 1.68, 0.041666666666667
105963, 1.4083333333333, 1.52, 0.041666666666667
105964, 1.3875, 1.54, 0.041666666666667
105965, 1.4083333333333, 1.54, 0.020833333333333
105966, 1.4083333333333, 1.56, 0.041666666666667
105967, 1.3875, 1.58, 0.041666666666667
105968, 1.4083333333333, 1.58, 0.020833333333333
105969, 1.4083333333333, 1.6, 0.041666666666667
105970, 1.3875, 1.62, 0.041666666666667
105971, 1.4083333333333, 1.62, 0.020833333333333
105972, 1.4083333333333, 1.64, 0.041666666666667
105973, 1.3875, 1.66, 0.041666666666667
105974, 1.4083333333333, 1.66, 0.020833333333333
105975, 1.4083333333333, 1.68, 0.041666666666667
105976, 1.45, 1.52, 0.041666666666667
105977, 1.4291666666667, 1.54, 0.041666666666667
105978, 1.45, 1.54, 0.020833333333333
105979, 1.45, 1.56, 0.041666666666667
105980, 1.4291666666667, 1.58, 0.041666666666667
105981, 1.45, 1.58, 0.020833333333333
105982, 1.45, 1.6, 0.041666666666667
105983, 1.4291666666667, 1.62, 0.041666666666667
105984, 1.45, 1.62, 0.020833333333333
105985, 1.45, 1.64, 0.041666666666667
105986, 1.4291666666667, 1.66, 0.041666666666667
105987, 1.45, 1.66, 0.020833333333333
105988, 1.45, 1.68, 0.041666666666667
105989, 1.4916666666667, 1.52, 0.041666666666667
105990, 1.4708333333333, 1.54, 0.041666666666667
105991, 1.4916666666667, 1.54, 0.020833333333333
105992, 1.4916666666667, 1.56, 0.041666666666667
105993, 1.4708333333333, 1.58, 0.041666666666667
105994, 1.4916666666667, 1.58, 0.020833333333333
105995, 1.4916666666667, 1.6, 0.041666666666667
105996, 1.4708333333333, 1.62, 0.041666666666667
105997, 1.4916666666667, 1.62, 0.020833333333333
105998, 1.4916666666667, 1.64, 0.041666666666667
105999, 1.4708333333333, 1.66, 0.041666666666667
106000, 1.4916666666667, 1.66, 0.020833333333333
106001, 1.4916666666667, 1.68, 0.041666666666667
106002, 1.5333333333333, 1.52, 0.041666666666667
106003, 1.5125, 1.54, 0.041666666666667
106004, 1.5333333333333, 1.54, 0.020833333333333
106005, 1.5333333333333, 1.56, 0.041666666666667
106006, 1.5125, 1.58, 0.041666666666667
106007, 1.5333333333333, 1.58, 0.020833333333333
106008, 1.5333333333333, 1.6, 0.041666666666667
106009, 1.5125, 1.62, 0.041666666666667
106010, 1.5333333333333, 1.62, 0.020833333333333
106011, 1.5333333333333, 1.64, 0.041666666666667
106012, 1.5125, 1.66, 0.041666666666667
106013, 1.5333333333333, 1.66, 0.020833333333333
106014, 1.5333333333333, 1.68, 0.041666666666667
106015, 1.575, 1.52, 0.041666666666667
106016, 1.5541666666667, 1.54, 0.041666666666667
106017, 1.575, 1.54, 0.020833333333333
106018, 1.575, 1.56, 0.041666666666667
106019, 1.5541666666667, 1.58, 0.041666666666667
106020, 1.575, 1.58, 0.020833333333333
106021, 1.575, 1.6, 0.041666666666667
106022, 1.5541666666667, 1.62, 0.041666666666667
106023, 1.575, 1.62, 0.020833333333333
106024, 1.575, 1.64, 0.041666666666667
106025, 1.5541666666667, 1.66, 0.041666666666667
106026, 1.575, 1.66, 0.020833333333333
106027, 1.575, 1.68, 0.041666666666667
106028, 1.6166666666667, 1.52, 0.041666666666667
106029, 1.5958333333333, 1.54, 0.041666666666667
106030, 1.6166666666667, 1.54, 0.020833333333333
106031, 1.6166666666667, 1.56, 0.041666666666667
106032, 1.5958333333333, 1.58, 0.041666666666667
106033, 1.6166666666667, 1.58, 0.020833333333333
106034, 1.6166666666667, 1.6, 0.041666666666667
106035, 1.5958333333333, 1.62, 0.041666666666667
106036, 1.6166666666667, 1.62, 0.020833333333333
106037, 1.6166666666667, 1.64, 0.041666666666667
106038, 1.5958333333333, 1.66, 0.041666666666667
106039, 1.6166666666667, 1.66, 0.020833333333333
106040, 1.6166666666667, 1.68, 0.041666666666667
106041, 1.6583333333333, 1.52, 0.041666666666667
106042, 1.6375, 1.54, 0.041666666666667
106043, 1.6583333333333, 1.54, 0.020833333333333
106044, 1.6583333333333, 1.56, 0.041666666666667
106045, 1.6375, 1.58, 0.041666666666667
106046, 1.6583333333333, 1.58, 0.020833333333333
106047, 1.6583333333333, 1.6, 0.041666666666667
106048, 1.6375, 1.62, 0.041666666666667
106049, 1.6583333333333, 1.62, 0.020833333333333
106050, 1.6583333333333, 1.64, 0.041666666666667
106051, 1.6375, 1.66, 0.041666666666667
106052, 1.6583333333333, 1.66, 0.020833333333333
106053, 1.6583333333333, 1.68, 0.041666666666667
106054, 1.7, 1.52, 0.041666666666667
106055, 1.6791666666667, 1.54, 0.041666666666667
106056, 1.7, 1.54, 0.020833333333333
106057, 1.7, 1.56, 0.041666666666667
106058, 1.6791666666667, 1.58, 0.041666666666667
106059, 1.7, 1.58, 0.020833333333333
106060, 1.7, 1.6, 0.041666666666667
106061, 1.6791666666667, 1.62, 0.041666666666667
106062, 1.7, 1.62, 0.020833333333333
106063, 1.7, 1.64, 0.041666666666667
106064, 1.6791666666667, 1.66, 0.041666666666667
106065, 1.7, 1.66, 0.020833333333333
106066, 1.7, 1.68, 0.041666666666667
106067, 1.7416666666667, 1.52, 0.041666666666667
106068, 1.7208333333333, 1.54, 0.041666666666667
106069, 1.7416666666667, 1.54, 0.020833333333333
106070, 1.7416666666667, 1.56, 0.041666666666667
106071, 1.7208333333333, 1.58, 0.041666666666667
106072, 1.7416666666667, 1.58, 0.020833333333333
106073, 1.7416666666667, 1.6, 0.041666666666667
106074, 1.7208333333333, 1.62, 0.041666666666667
106075, 1.7416666666667, 1.62, 0.020833333333333
106076, 1.7416666666667, 1.64, 0.041666666666667
106077, 1.7208333333333, 1.66, 0.041666666666667
106078, 1.7416666666667, 1.66, 0.020833333333333
106079, 1.7416666666667, 1.68, 0.041666666666667
106080, 1.7833333333333, 1.52, 0.041666666666667
106081, 1.7625, 1.54, 0.041666666666667
106082, 1.7833333333333, 1.54, 0.020833333333333
106083, 1.7833333333333, 1.56, 0.041666666666667
106084, 1.7625, 1.58, 0.041666666666667
106085, 1.7833333333333, 1.58, 0.020833333333333
106086, 1.7833333333333, 1.6, 0.041666666666667
106087, 1.7625, 1.62, 0.041666666666667
106088, 1.7833333333333, 1.62, 0.020833333333333
106089, 1.7833333333333, 1.64, 0.041666666666667
106090, 1.7625, 1.66, 0.041666666666667
106091, 1.7833333333333, 1.66, 0.020833333333333
106092, 1.7833333333333, 1.68, 0.041666666666667
106093, 1.825, 1.52, 0.041666666666667
106094, 1.8041666666667, 1.54, 0.041666666666667
106095, 1.825, 1.54, 0.020833333333333
106096, 1.825, 1.56, 0.041666666666667
106097, 1.8041666666667, 1.58, 0.041666666666667
106098, 1.825, 1.58, 0.020833333333333
106099, 1.825, 1.6, 0.041666666666667
106100, 1.8041666666667, 1.62, 0.041666666666667
106101, 1.825, 1.62, 0.020833333333333
106102, 1.825, 1.64, 0.041666666666667
106103, 1.8041666666667, 1.66, 0.041666666666667
106104, 1.825, 1.66, 0.020833333333333
106105, 1.825, 1.68, 0.041666666666667
106106, 1.8666666666667, 1.52, 0.041666666666667
106107, 1.8458333333333, 1.54, 0.041666666666667
106108, 1.8666666666667, 1.54, 0.020833333333333
106109, 1.8666666666667, 1.56, 0.041666666666667
106110, 1.8458333333333, 1.58, 0.041666666666667
106111, 1.8666666666667, 1.58, 0.020833333333333
106112, 1.8666666666667, 1.6, 0.041666666666667
106113, 1.8458333333333, 1.62, 0.041666666666667
106114, 1.8666666666667, 1.62, 0.020833333333333
106115, 1.8666666666667, 1.64, 0.041666666666667
106116, 1.8458333333333, 1.66, 0.041666666666667
106117, 1.8666666666667, 1.66, 0.020833333333333
106118, 1.8666666666667, 1.68, 0.041666666666667
106119, 1.9083333333333, 1.52, 0.041666666666667
106120, 1.8875, 1.54, 0.041666666666667
106121, 1.9083333333333, 1.54, 0.020833333333333
106122, 1.9083333333333, 1.56, 0.041666666666667
106123, 1.8875, 1.58, 0.041666666666667
106124, 1.9083333333333, 1.58, 0.020833333333333
106125, 1.9083333333333, 1.6, 0.041666666666667
106126, 1.8875, 1.62, 0.041666666666667
106127, 1.9083333333333, 1.62, 0.020833333333333
106128, 1.9083333333333, 1.64, 0.041666666666667
106129, 1.8875, 1.66, 0.041666666666667
106130, 1.9083333333333, 1.66, 0.020833333333333
106131, 1.9083333333333, 1.68, 0.041666666666667
106132, 1.95, 1.52, 0.041666666666667
106133, 1.9291666666667, 1.54, 0.041666666666667
106134, 1.95, 1.54, 0.020833333333333
106135, 1.95, 1.56, 0.041666666666667
106136, 1.9291666666667, 1.58, 0.041666666666667
106137, 1.95, 1.58, 0.020833333333333
106138, 1.95, 1.6, 0.041666666666667
106139, 1.9291666666667, 1.62, 0.041666666666667
106140, 1.95, 1.62, 0.020833333333333
106141, 1.95, 1.64, 0.041666666666667
106142, 1.9291666666667, 1.66, 0.041666666666667
106143, 1.95, 1.66, 0.020833333333333
106144, 1.95, 1.68, 0.041666666666667
106145, 1.9916666666667, 1.52, 0.041666666666667
106146, 1.9708333333333, 1.54, 0.041666666666667
106147, 1.9916666666667, 1.54, 0.020833333333333
106148, 1.9916666666667, 1.56, 0.041666666666667
106149, 1.9708333333333, 1.58, 0.041666666666667
106150, 1.9916666666667, 1.58, 0.020833333333333
106151, 1.9916666666667, 1.6, 0.041666666666667
106152, 1.9708333333333, 1.62, 0.041666666666667
106153, 1.9916666666667, 1.62, 0.020833333333333
106154, 1.9916666666667, 1.64, 0.041666666666667
106155, 1.9708333333333, 1.66, 0.041666666666667
106156, 1.9916666666667, 1.66, 0.020833333333333
106157, 1.9916666666667, 1.68, 0.041666666666667
106158, 2.0333333333333, 1.52, 0.041666666666667
106159, 2.0125, 1.54, 0.041666666666667
106160, 2.0333333333333, 1.54, 0.020833333333333
106161, 2.0333333333333, 1.56, 0.041666666666667
106162, 2.0125, 1.58, 0.041666666666667
106163, 2.0333333333333, 1.58, 0.020833333333333
106164, 2.0333333333333, 1.6, 0.041666666666667
106165, 2.0125, 1.62, 0.041666666666667
106166, 2.0333333333333, 1.62, 0.020833333333333
106167, 2.0333333333333, 1.64, 0.041666666666667
106168, 2.0125, 1.66, 0.041666666666667
106169, 2.0333333333333, 1.66, 0.020833333333333
106170, 2.0333333333333, 1.68, 0.041666666666667
106171, 2.075, 1.52, 0.041666666666667
106172, 2.0541666666667, 1.54, 0.041666666666667
106173, 2.075, 1.54, 0.020833333333333
106174, 2.075, 1.56, 0.041666666666667
106175, 2.0541666666667, 1.58, 0.041666666666667
106176, 2.075, 1.58, 0.020833333333333
106177, 2.075, 1.6, 0.041666666666667
106178, 2.0541666666667, 1.62, 0.041666666666667
106179, 2.075, 1.62, 0.020833333333333
106180, 2.075, 1.64, 0.041666666666667
106181, 2.0541666666667, 1.66, 0.041666666666667
106182, 2.075, 1.66, 0.020833333333333
106183, 2.075, 1.68, 0.041666666666667
106184, 2.1166666666667, 1.52, 0.041666666666667
106185, 2.0958333333333, 1.54, 0.041666666666667
106186, 2.1166666666667, 1.54, 0.020833333333333
106187, 2.1166666666667, 1.56, 0.041666666666667
106188, 2.0958333333333, 1.58, 0.041666666666667
106189, 2.1166666666667, 1.58, 0.020833333333333
106190, 2.1166666666667, 1.6, 0.041666666666667
106191, 2.0958333333333, 1.62, 0.041666666666667
106192, 2.1166666666667, 1.62, 0.020833333333333
106193, 2.1166666666667, 1.64, 0.041666666666667
106194, 2.0958333333333, 1.66, 0.041666666666667
106195, 2.1166666666667, 1.66, 0.020833333333333
106196, 2.1166666666667, 1.68, 0.041666666666667
106197, 2.1583333333333, 1.52, 0.041666666666667
106198, 2.1375, 1.54, 0.041666666666667
106199, 2.1583333333333, 1.54, 0.020833333333333
106200, 2.1583333333333, 1.56, 0.041666666666667
106201, 2.1375, 1.58, 0.041666666666667
106202, 2.1583333333333, 1.58, 0.020833333333333
106203, 2.1583333333333, 1.6, 0.041666666666667
106204, 2.1375, 1.62, 0.041666666666667
106205, 2.1583333333333, 1.62, 0.020833333333333
106206, 2.1583333333333, 1.64, 0.041666666666667
106207, 2.1375, 1.66, 0.041666666666667
106208, 2.1583333333333, 1.66, 0.020833333333333
106209, 2.1583333333333, 1.68, 0.041666666666667
106210, 2.1791666666667, 1.54, 0.041666666666667
106211, 2.1791666666667, 1.58, 0.041666666666667
106212, 2.1791666666667, 1.62, 0.041666666666667
106213, 2.1791666666667, 1.66, 0.041666666666667
106214, 1.2416666666667, 1.52, 0.083333333333333
106215, 1.2208333333333, 1.54, 0.083333333333333
106216, 1.2416666666667, 1.54, 0.0625
106217, 1.2416666666667, 1.56, 0.083333333333333
106218, 1.2208333333333, 1.58, 0.083333333333333
106219, 1.2416666666667, 1.58, 0.0625
106220, 1.2416666666667, 1.6, 0.083333333333333
106221, 1.2208333333333, 1.62, 0.083333333333333
106222, 1.2416666666667, 1.62, 0.0625
106223, 1.2416666666667, 1.64, 0.083333333333333
106224, 1.2208333333333, 1.66, 0.083333333333333
106225, 1.2416666666667, 1.66, 0.0625
106226, 1.2416666666667, 1.68, 0.083333333333333
106227, 1.2833333333333, 1.52, 0.083333333333333
106228, 1.2625, 1.54, 0.083333333333333
106229, 1.2833333333333, 1.54, 0.0625
106230, 1.2833333333333, 1.56, 0.083333333333333
106231, 1.2625, 1.58, 0.083333333333333
106232, 1.2833333333333, 1.58, 0.0625
106233, 1.2833333333333, 1.6, 0.083333333333333
106234, 1.2625, 1.62, 0.083333333333333
106235, 1.2833333333333, 1.62, 0.0625
106236, 1.2833333333333, 1.64, 0.083333333333333
106237, 1.2625, 1.66, 0.083333333333333
106238, 1.2833333333333, 1.66, 0.0625
106239, 1.2833333333333, 1.68, 0.083333333333333
106240, 1.325, 1.52, 0.083333333333333
106241, 1.3041666666667, 1.54, 0.083333333333333
106242, 1.325, 1.54, 0.0625
106243, 1.325, 1.56, 0.083333333333333
106244, 1.3041666666667, 1.58, 0.083333333333333
106245, 1.325, 1.58, 0.0625
106246, 1.325, 1.6, 0.083333333333333
106247, 1.3041666666667, 1.62, 0.083333333333333
106248, 1.325, 1.62, 0.0625
106249, 1.325, 1.64, 0.083333333333333
106250, 1.3041666666667, 1.66, 0.083333333333333
106251, 1.325, 1.66, 0.0625
106252, 1.325, 1.68, 0.083333333333333
106253, 1.3666666666667, 1.52, 0.083333333333333
106254, 1.3458333333333, 1.54, 0.083333333333333
106255, 1.3666666666667, 1.54, 0.0625
106256, 1.3666666666667, 1.56, 0.083333333333333
106257, 1.3458333333333, 1.58, 0.083333333333333
106258, 1.3666666666667, 1.58, 0.0625
106259, 1.3666666666667, 1.6, 0.083333333333333
106260, 1.3458333333333, 1.62, 0.083333333333333
106261, 1.3666666666667, 1.62, 0.0625
106262, 1.3666666666667, 1.64, 0.083333333333333
106263, 1.3458333333333, 1.66, 0.083333333333333
106264, 1.3666666666667, 1.66, 0.0625
106265, 1.3666666666667, 1.68, 0.083333333333333
106266, 1.4083333333333, 1.52, 0.083333333333333
106267, 1.3875, 1.54, 0.083333333333333
106268, 1.4083333333333, 1.54, 0.0625
106269, 1.4083333333333, 1.56, 0.083333333333333
106270, 1.3875, 1.58, 0.083333333333333
106271, 1.4083333333333, 1.58, 0.0625
106272, 1.4083333333333, 1.6, 0.083333333333333
106273, 1.3875, 1.62, 0.083333333333333
106274, 1.4083333333333, 1.62, 0.0625
106275, 1.4083333333333, 1.64, 0.083333333333333
106276, 1.3875, 1.66, 0.083333333333333
106277, 1.4083333333333, 1.66, 0.0625
106278, 1.4083333333333, 1.68, 0.083333333333333
106279, 1.45, 1.52, 0.083333333333333
106280, 1.4291666666667, 1.54, 0.083333333333333
106281, 1.45, 1.54, 0.0625
106282, 1.45, 1.56, 0.083333333333333
106283, 1.4291666666667, 1.58, 0.083333333333333
106284, 1.45, 1.58, 0.0625
106285, 1.45, 1.6, 0.083333333333333
106286, 1.4291666666667, 1.62, 0.083333333333333
106287, 1.45, 1.62, 0.0625
106288, 1.45, 1.64, 0.083333333333333
106289, 1.4291666666667, 1.66, 0.083333333333333
106290, 1.45, 1.66, 0.0625
106291, 1.45, 1.68, 0.083333333333333
106292, 1.4916666666667, 1.52, 0.083333333333333
106293, 1.4708333333333, 1.54, 0.083333333333333
106294, 1.4916666666667, 1.54, 0.0625
106295, 1.4916666666667, 1.56, 0.083333333333333
106296, 1.4708333333333, 1.58, 0.083333333333333
106297, 1.4916666666667, 1.58, 0.0625
106298, 1.4916666666667, 1.6, 0.083333333333333
106299, 1.4708333333333, 1.62, 0.083333333333333
106300, 1.4916666666667, 1.62, 0.0625
106301, 1.4916666666667, 1.64, 0.083333333333333
106302, 1.4708333333333, 1.66, 0.083333333333333
106303, 1.4916666666667, 1.66, 0.0625
106304, 1.4916666666667, 1.68, 0.083333333333333
106305, 1.5333333333333, 1.52, 0.083333333333333
106306, 1.5125, 1.54, 0.083333333333333
106307, 1.5333333333333, 1.54, 0.0625
106308, 1.5333333333333, 1.56, 0.083333333333333
106309, 1.5125, 1.58, 0.083333333333333
106310, 1.5333333333333, 1.58, 0.0625
106311, 1.5333333333333, 1.6, 0.083333333333333
106312, 1.5125, 1.62, 0.083333333333333
106313, 1.5333333333333, 1.62, 0.0625
106314, 1.5333333333333, 1.64, 0.083333333333333
106315, 1.5125, 1.66, 0.083333333333333
106316, 1.5333333333333, 1.66, 0.0625
106317, 1.5333333333333, 1.68, 0.083333333333333
106318, 1.575, 1.52, 0.083333333333333
106319, 1.5541666666667, 1.54, 0.083333333333333
106320, 1.575, 1.54, 0.0625
106321, 1.575, 1.56, 0.083333333333333
106322, 1.5541666666667, 1.58, 0.083333333333333
106323, 1.575, 1.58, 0.0625
106324, 1.575, 1.6, 0.083333333333333
106325, 1.5541666666667, 1.62, 0.083333333333333
106326, 1.575, 1.62, 0.0625
106327, 1.575, 1.64, 0.083333333333333
106328, 1.5541666666667, 1.66, 0.083333333333333
106329, 1.575, 1.66, 0.0625
106330, 1.575, 1.68, 0.083333333333333
106331, 1.6166666666667, 1.52, 0.083333333333333
106332, 1.5958333333333, 1.54, 0.083333333333333
106333, 1.6166666666667, 1.54, 0.0625
106334, 1.6166666666667, 1.56, 0.083333333333333
106335, 1.5958333333333, 1.58, 0.083333333333333
106336, 1.6166666666667, 1.58, 0.0625
106337, 1.6166666666667, 1.6, 0.083333333333333
106338, 1.5958333333333, 1.62, 0.083333333333333
106339, 1.6166666666667, 1.62, 0.0625
106340, 1.6166666666667, 1.64, 0.083333333333333
106341, 1.5958333333333, 1.66, 0.083333333333333
106342, 1.6166666666667, 1.66, 0.0625
106343, 1.6166666666667, 1.68, 0.083333333333333
106344, 1.6583333333333, 1.52, 0.083333333333333
106345, 1.6375, 1.54, 0.083333333333333
106346, 1.6583333333333, 1.54, 0.0625
106347, 1.6583333333333, 1.56, 0.083333333333333
106348, 1.6375, 1.58, 0.083333333333333
106349, 1.6583333333333, 1.58, 0.0625
106350, 1.6583333333333, 1.6, 0.083333333333333
106351, 1.6375, 1.62, 0.083333333333333
106352, 1.6583333333333, 1.62, 0.0625
106353, 1.6583333333333, 1.64, 0.083333333333333
106354, 1.6375, 1.66, 0.083333333333333
106355, 1.6583333333333, 1.66, 0.0625
106356, 1.6583333333333, 1.68, 0.083333333333333
106357, 1.7, 1.52, 0.083333333333333
106358, 1.6791666666667, 1.54, 0.083333333333333
106359, 1.7, 1.54, 0.0625
106360, 1.7, 1.56, 0.083333333333333
106361, 1.6791666666667, 1.58, 0.083333333333333
106362, 1.7, 1.58, 0.0625
106363, 1.7, 1.6, 0.083333333333333
106364, 1.6791666666667, 1.62, 0.083333333333333
106365, 1.7, 1.62, 0.0625
106366, 1.7, 1.64, 0.083333333333333
106367, 1.6791666666667, 1.66, 0.083333333333333
106368, 1.7, 1.66, 0.0625
106369, 1.7, 1.68, 0.083333333333333
106370, 1.7416666666667, 1.52, 0.083333333333333
106371, 1.7208333333333, 1.54, 0.083333333333333
106372, 1.7416666666667, 1.54, 0.0625
106373, 1.7416666666667, 1.56, 0.083333333333333
106374, 1.7208333333333, 1.58, 0.083333333333333
106375, 1.7416666666667, 1.58, 0.0625
106376, 1.7416666666667, 1.6, 0.083333333333333
106377, 1.7208333333333, 1.62, 0.083333333333333
106378, 1.7416666666667, 1.62, 0.0625
106379, 1.7416666666667, 1.64, 0.083333333333333
106380, 1.7208333333333, 1.66, 0.083333333333333
106381, 1.7416666666667, 1.66, 0.0625
106382, 1.7416666666667, 1.68, 0.083333333333333
106383, 1.7833333333333, 1.52, 0.083333333333333
106384, 1.7625, 1.54, 0.083333333333333
106385, 1.7833333333333, 1.54, 0.0625
106386, 1.7833333333333, 1.56, 0.083333333333333
106387, 1.7625, 1.58, 0.083333333333333
106388, 1.7833333333333, 1.58, 0.0625
106389, 1.7833333333333, 1.6, 0.083333333333333
106390, 1.7625, 1.62, 0.083333333333333
106391, 1.7833333333333, 1.62, 0.0625
106392, 1.7833333333333, 1.64, 0.083333333333333
106393, 1.7625, 1.66, 0.083333333333333
106394, 1.7833333333333, 1.66, 0.0625
106395, 1.7833333333333, 1.68, 0.083333333333333
106396, 1.825, 1.52, 0.083333333333333
106397, 1.8041666666667, 1.54, 0.083333333333333
106398, 1.825, 1.54, 0.0625
106399, 1.825, 1.56, 0.083333333333333
106400, 1.8041666666667, 1.58, 0.083333333333333
106401, 1.825, 1.58, 0.0625
106402, 1.825, 1.6, 0.083333333333333
106403, 1.8041666666667, 1.62, 0.083333333333333
106404, 1.825, 1.62, 0.0625
106405, 1.825, 1.64, 0.083333333333333
106406, 1.8041666666667, 1.66, 0.083333333333333
106407, 1.825, 1.66, 0.0625
106408, 1.825, 1.68, 0.083333333333333
106409, 1.8666666666667, 1.52, 0.083333333333333
106410, 1.8458333333333, 1.54, 0.083333333333333
106411, 1.8666666666667, 1.54, 0.0625
106412, 1.8666666666667, 1.56, 0.083333333333333
106413, 1.8458333333333, 1.58, 0.083333333333333
106414, 1.8666666666667, 1.58, 0.0625
106415, 1.8666666666667, 1.6, 0.083333333333333
106416, 1.8458333333333, 1.62, 0.083333333333333
106417, 1.8666666666667, 1.62, 0.0625
106418, 1.8666666666667, 1.64, 0.083333333333333
106419, 1.8458333333333, 1.66, 0.083333333333333
106420, 1.8666666666667, 1.66, 0.0625
106421, 1.8666666666667, 1.68, 0.083333333333333
106422, 1.9083333333333, 1.52, 0.083333333333333
106423, 1.8875, 1.54, 0.083333333333333
106424, 1.9083333333333, 1.54, 0.0625
106425, 1.9083333333333, 1.56, 0.083333333333333
106426, 1.8875, 1.58, 0.083333333333333
106427, 1.9083333333333, 1.58, 0.0625
106428, 1.9083333333333, 1.6, 0.083333333333333
106429, 1.8875, 1.62, 0.083333333333333
106430, 1.9083333333333, 1.62, 0.0625
106431, 1.9083333333333, 1.64, 0.083333333333333
106432, 1.8875, 1.66, 0.083333333333333
106433, 1.9083333333333, 1.66, 0.0625
106434, 1.9083333333333, 1.68, 0.083333333333333
106435, 1.95, 1.52, 0.083333333333333
106436, 1.9291666666667, 1.54, 0.083333333333333
106437, 1.95, 1.54, 0.0625
106438, 1.95, 1.56, 0.083333333333333
106439, 1.9291666666667, 1.58, 0.083333333333333
106440, 1.95, 1.58, 0.0625
106441, 1.95, 1.6, 0.083333333333333
106442, 1.9291666666667, 1.62, 0.083333333333333
106443, 1.95, 1.62, 0.0625
106444, 1.95, 1.64, 0.083333333333333
106445, 1.9291666666667, 1.66, 0.083333333333333
106446, 1.95, 1.66, 0.0625
106447, 1.95, 1.68, 0.083333333333333
106448, 1.9916666666667, 1.52, 0.083333333333333
106449, 1.9708333333333, 1.54, 0.083333333333333
106450, 1.9916666666667, 1.54, 0.0625
106451, 1.9916666666667, 1.56, 0.083333333333333
106452, 1.9708333333333, 1.58, 0.083333333333333
106453, 1.9916666666667, 1.58, 0.0625
106454, 1.9916666666667, 1.6, 0.083333333333333
106455, 1.9708333333333, 1.62, 0.083333333333333
106456, 1.9916666666667, 1.62, 0.0625
106457, 1.9916666666667, 1.64, 0.083333333333333
106458, 1.9708333333333, 1.66, 0.083333333333333
106459, 1.9916666666667, 1.66, 0.0625
106460, 1.9916666666667, 1.68, 0.083333333333333
106461, 2.0333333333333, 1.52, 0.083333333333333
106462, 2.0125, 1.54, 0.083333333333333
106463, 2.0333333333333, 1.54, 0.0625
106464, 2.0333333333333, 1.56, 0.083333333333333
106465, 2.0125, 1.58, 0.083333333333333
106466, 2.0333333333333, 1.58, 0.0625
106467, 2.0333333333333, 1.6, 0.083333333333333
106468, 2.0125, 1.62, 0.083333333333333
106469, 2.0333333333333, 1.62, 0.0625
106470, 2.0333333333333, 1.64, 0.083333333333333
106471, 2.0125, 1.66, 0.083333333333333
106472, 2.0333333333333, 1.66, 0.0625
106473, 2.0333333333333, 1.68, 0.083333333333333
106474, 2.075, 1.52, 0.083333333333333
106475, 2.0541666666667, 1.54, 0.083333333333333
106476, 2.075, 1.54, 0.0625
106477, 2.075, 1.56, 0.083333333333333
106478, 2.0541666666667, 1.58, 0.083333333333333
106479, 2.075, 1.58, 0.0625
106480, 2.075, 1.6, 0.083333333333333
106481, 2.0541666666667, 1.62, 0.083333333333333
106482, 2.075, 1.62, 0.0625
106483, 2.075, 1.64, 0.083333333333333
106484, 2.0541666666667, 1.66, 0.083333333333333
106485, 2.075, 1.66, 0.0625
106486, 2.075, 1.68, 0.083333333333333
106487, 2.1166666666667, 1.52, 0.083333333333333
106488, 2.0958333333333, 1.54, 0.083333333333333
106489, 2.1166666666667, 1.54, 0.0625
106490, 2.1166666666667, 1.56, 0.083333333333333
106491, 2.0958333333333, 1.58, 0.083333333333333
106492, 2.1166666666667, 1.58, 0.0625
106493, 2.1166666666667, 1.6, 0.083333333333333
106494, 2.0958333333333, 1.62, 0.083333333333333
106495, 2.1166666666667, 1.62, 0.0625
106496, 2.1166666666667, 1.64, 0.083333333333333
106497, 2.0958333333333, 1.66, 0.083333333333333
106498, 2.1166666666667, 1.66, 0.0625
106499, 2.1166666666667, 1.68, 0.083333333333333
106500, 2.1583333333333, 1.52, 0.083333333333333
106501, 2.1375, 1.54, 0.083333333333333
106502, 2.1583333333333, 1.54, 0.0625
106503, 2.1583333333333, 1.56, 0.083333333333333
106504, 2.1375, 1.58, 0.083333333333333
106505, 2.1583333333333, 1.58, 0.0625
106506, 2.1583333333333, 1.6, 0.083333333333333
106507, 2.1375, 1.62, 0.083333333333333
106508, 2.1583333333333, 1.62, 0.0625
106509, 2.1583333333333, 1.64, 0.083333333333333
106510, 2.1375, 1.66, 0.083333333333333
106511, 2.1583333333333, 1.66, 0.0625
106512, 2.1583333333333, 1.68, 0.083333333333333
106513, 2.1791666666667, 1.54, 0.083333333333333
106514, 2.1791666666667, 1.58, 0.083333333333333
106515, 2.1791666666667, 1.62, 0.083333333333333
106516, 2.1791666666667, 1.66, 0.083333333333333
106517, 1.2416666666667, 1.52, 0.125
106518, 1.2208333333333, 1.54, 0.125
106519, 1.2416666666667, 1.54, 0.10416666666667
106520, 1.2416666666667, 1.56, 0.125
106521, 1.2208333333333, 1.58, 0.125
106522, 1.2416666666667, 1.58, 0.10416666666667
106523, 1.2416666666667, 1.6, 0.125
106524, 1.2208333333333, 1.62, 0.125
106525, 1.2416666666667, 1.62, 0.10416666666667
106526, 1.2416666666667, 1.64, 0.125
106527, 1.2208333333333, 1.66, 0.125
106528, 1.2416666666667, 1.66, 0.10416666666667
106529, 1.2416666666667, 1.68, 0.125
106530, 1.2833333333333, 1.52, 0.125
106531, 1.2625, 1.54, 0.125
106532, 1.2833333333333, 1.54, 0.10416666666667
106533, 1.2833333333333, 1.56, 0.125
106534, 1.2625, 1.58, 0.125
106535, 1.2833333333333, 1.58, 0.10416666666667
106536, 1.2833333333333, 1.6, 0.125
106537, 1.2625, 1.62, 0.125
106538, 1.2833333333333, 1.62, 0.10416666666667
106539, 1.2833333333333, 1.64, 0.125
106540, 1.2625, 1.66, 0.125
106541, 1.2833333333333, 1.66, 0.10416666666667
106542, 1.2833333333333, 1.68, 0.125
106543, 1.325, 1.52, 0.125
106544, 1.3041666666667, 1.54, 0.125
106545, 1.325, 1.54, 0.10416666666667
106546, 1.325, 1.56, 0.125
106547, 1.3041666666667, 1.58, 0.125
106548, 1.325, 1.58, 0.10416666666667
106549, 1.325, 1.6, 0.125
106550, 1.3041666666667, 1.62, 0.125
106551, 1.325, 1.62, 0.10416666666667
106552, 1.325, 1.64, 0.125
106553, 1.3041666666667, 1.66, 0.125
106554, 1.325, 1.66, 0.10416666666667
106555, 1.325, 1.68, 0.125
106556, 1.3666666666667, 1.52, 0.125
106557, 1.3458333333333, 1.54, 0.125
106558, 1.3666666666667, 1.54, 0.10416666666667
106559, 1.3666666666667, 1.56, 0.125
106560, 1.3458333333333, 1.58, 0.125
106561, 1.3666666666667, 1.58, 0.10416666666667
106562, 1.3666666666667, 1.6, 0.125
106563, 1.3458333333333, 1.62, 0.125
106564, 1.3666666666667, 1.62, 0.10416666666667
106565, 1.3666666666667, 1.64, 0.125
106566, 1.3458333333333, 1.66, 0.125
106567, 1.3666666666667, 1.66, 0.10416666666667
