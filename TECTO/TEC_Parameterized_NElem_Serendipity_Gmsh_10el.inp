106568, 1.3666666666667, 1.68, 0.125
106569, 1.4083333333333, 1.52, 0.125
106570, 1.3875, 1.54, 0.125
106571, 1.4083333333333, 1.54, 0.10416666666667
106572, 1.4083333333333, 1.56, 0.125
106573, 1.3875, 1.58, 0.125
106574, 1.4083333333333, 1.58, 0.10416666666667
106575, 1.4083333333333, 1.6, 0.125
106576, 1.3875, 1.62, 0.125
106577, 1.4083333333333, 1.62, 0.10416666666667
106578, 1.4083333333333, 1.64, 0.125
106579, 1.3875, 1.66, 0.125
106580, 1.4083333333333, 1.66, 0.10416666666667
106581, 1.4083333333333, 1.68, 0.125
106582, 1.45, 1.52, 0.125
106583, 1.4291666666667, 1.54, 0.125
106584, 1.45, 1.54, 0.10416666666667
106585, 1.45, 1.56, 0.125
106586, 1.4291666666667, 1.58, 0.125
106587, 1.45, 1.58, 0.10416666666667
106588, 1.45, 1.6, 0.125
106589, 1.4291666666667, 1.62, 0.125
106590, 1.45, 1.62, 0.10416666666667
106591, 1.45, 1.64, 0.125
106592, 1.4291666666667, 1.66, 0.125
106593, 1.45, 1.66, 0.10416666666667
106594, 1.45, 1.68, 0.125
106595, 1.4916666666667, 1.52, 0.125
106596, 1.4708333333333, 1.54, 0.125
106597, 1.4916666666667, 1.54, 0.10416666666667
106598, 1.4916666666667, 1.56, 0.125
106599, 1.4708333333333, 1.58, 0.125
106600, 1.4916666666667, 1.58, 0.10416666666667
106601, 1.4916666666667, 1.6, 0.125
106602, 1.4708333333333, 1.62, 0.125
106603, 1.4916666666667, 1.62, 0.10416666666667
106604, 1.4916666666667, 1.64, 0.125
106605, 1.4708333333333, 1.66, 0.125
106606, 1.4916666666667, 1.66, 0.10416666666667
106607, 1.4916666666667, 1.68, 0.125
106608, 1.5333333333333, 1.52, 0.125
106609, 1.5125, 1.54, 0.125
106610, 1.5333333333333, 1.54, 0.10416666666667
106611, 1.5333333333333, 1.56, 0.125
106612, 1.5125, 1.58, 0.125
106613, 1.5333333333333, 1.58, 0.10416666666667
106614, 1.5333333333333, 1.6, 0.125
106615, 1.5125, 1.62, 0.125
106616, 1.5333333333333, 1.62, 0.10416666666667
106617, 1.5333333333333, 1.64, 0.125
106618, 1.5125, 1.66, 0.125
106619, 1.5333333333333, 1.66, 0.10416666666667
106620, 1.5333333333333, 1.68, 0.125
106621, 1.575, 1.52, 0.125
106622, 1.5541666666667, 1.54, 0.125
106623, 1.575, 1.54, 0.10416666666667
106624, 1.575, 1.56, 0.125
106625, 1.5541666666667, 1.58, 0.125
106626, 1.575, 1.58, 0.10416666666667
106627, 1.575, 1.6, 0.125
106628, 1.5541666666667, 1.62, 0.125
106629, 1.575, 1.62, 0.10416666666667
106630, 1.575, 1.64, 0.125
106631, 1.5541666666667, 1.66, 0.125
106632, 1.575, 1.66, 0.10416666666667
106633, 1.575, 1.68, 0.125
106634, 1.6166666666667, 1.52, 0.125
106635, 1.5958333333333, 1.54, 0.125
106636, 1.6166666666667, 1.54, 0.10416666666667
106637, 1.6166666666667, 1.56, 0.125
106638, 1.5958333333333, 1.58, 0.125
106639, 1.6166666666667, 1.58, 0.10416666666667
106640, 1.6166666666667, 1.6, 0.125
106641, 1.5958333333333, 1.62, 0.125
106642, 1.6166666666667, 1.62, 0.10416666666667
106643, 1.6166666666667, 1.64, 0.125
106644, 1.5958333333333, 1.66, 0.125
106645, 1.6166666666667, 1.66, 0.10416666666667
106646, 1.6166666666667, 1.68, 0.125
106647, 1.6583333333333, 1.52, 0.125
106648, 1.6375, 1.54, 0.125
106649, 1.6583333333333, 1.54, 0.10416666666667
106650, 1.6583333333333, 1.56, 0.125
106651, 1.6375, 1.58, 0.125
106652, 1.6583333333333, 1.58, 0.10416666666667
106653, 1.6583333333333, 1.6, 0.125
106654, 1.6375, 1.62, 0.125
106655, 1.6583333333333, 1.62, 0.10416666666667
106656, 1.6583333333333, 1.64, 0.125
106657, 1.6375, 1.66, 0.125
106658, 1.6583333333333, 1.66, 0.10416666666667
106659, 1.6583333333333, 1.68, 0.125
106660, 1.7, 1.52, 0.125
106661, 1.6791666666667, 1.54, 0.125
106662, 1.7, 1.54, 0.10416666666667
106663, 1.7, 1.56, 0.125
106664, 1.6791666666667, 1.58, 0.125
106665, 1.7, 1.58, 0.10416666666667
106666, 1.7, 1.6, 0.125
106667, 1.6791666666667, 1.62, 0.125
106668, 1.7, 1.62, 0.10416666666667
106669, 1.7, 1.64, 0.125
106670, 1.6791666666667, 1.66, 0.125
106671, 1.7, 1.66, 0.10416666666667
106672, 1.7, 1.68, 0.125
106673, 1.7416666666667, 1.52, 0.125
106674, 1.7208333333333, 1.54, 0.125
106675, 1.7416666666667, 1.54, 0.10416666666667
106676, 1.7416666666667, 1.56, 0.125
106677, 1.7208333333333, 1.58, 0.125
106678, 1.7416666666667, 1.58, 0.10416666666667
106679, 1.7416666666667, 1.6, 0.125
106680, 1.7208333333333, 1.62, 0.125
106681, 1.7416666666667, 1.62, 0.10416666666667
106682, 1.7416666666667, 1.64, 0.125
106683, 1.7208333333333, 1.66, 0.125
106684, 1.7416666666667, 1.66, 0.10416666666667
106685, 1.7416666666667, 1.68, 0.125
106686, 1.7833333333333, 1.52, 0.125
106687, 1.7625, 1.54, 0.125
106688, 1.7833333333333, 1.54, 0.10416666666667
106689, 1.7833333333333, 1.56, 0.125
106690, 1.7625, 1.58, 0.125
106691, 1.7833333333333, 1.58, 0.10416666666667
106692, 1.7833333333333, 1.6, 0.125
106693, 1.7625, 1.62, 0.125
106694, 1.7833333333333, 1.62, 0.10416666666667
106695, 1.7833333333333, 1.64, 0.125
106696, 1.7625, 1.66, 0.125
106697, 1.7833333333333, 1.66, 0.10416666666667
106698, 1.7833333333333, 1.68, 0.125
106699, 1.825, 1.52, 0.125
106700, 1.8041666666667, 1.54, 0.125
106701, 1.825, 1.54, 0.10416666666667
106702, 1.825, 1.56, 0.125
106703, 1.8041666666667, 1.58, 0.125
106704, 1.825, 1.58, 0.10416666666667
106705, 1.825, 1.6, 0.125
106706, 1.8041666666667, 1.62, 0.125
106707, 1.825, 1.62, 0.10416666666667
106708, 1.825, 1.64, 0.125
106709, 1.8041666666667, 1.66, 0.125
106710, 1.825, 1.66, 0.10416666666667
106711, 1.825, 1.68, 0.125
106712, 1.8666666666667, 1.52, 0.125
106713, 1.8458333333333, 1.54, 0.125
106714, 1.8666666666667, 1.54, 0.10416666666667
106715, 1.8666666666667, 1.56, 0.125
106716, 1.8458333333333, 1.58, 0.125
106717, 1.8666666666667, 1.58, 0.10416666666667
106718, 1.8666666666667, 1.6, 0.125
106719, 1.8458333333333, 1.62, 0.125
106720, 1.8666666666667, 1.62, 0.10416666666667
106721, 1.8666666666667, 1.64, 0.125
106722, 1.8458333333333, 1.66, 0.125
106723, 1.8666666666667, 1.66, 0.10416666666667
106724, 1.8666666666667, 1.68, 0.125
106725, 1.9083333333333, 1.52, 0.125
106726, 1.8875, 1.54, 0.125
106727, 1.9083333333333, 1.54, 0.10416666666667
106728, 1.9083333333333, 1.56, 0.125
106729, 1.8875, 1.58, 0.125
106730, 1.9083333333333, 1.58, 0.10416666666667
106731, 1.9083333333333, 1.6, 0.125
106732, 1.8875, 1.62, 0.125
106733, 1.9083333333333, 1.62, 0.10416666666667
106734, 1.9083333333333, 1.64, 0.125
106735, 1.8875, 1.66, 0.125
106736, 1.9083333333333, 1.66, 0.10416666666667
106737, 1.9083333333333, 1.68, 0.125
106738, 1.95, 1.52, 0.125
106739, 1.9291666666667, 1.54, 0.125
106740, 1.95, 1.54, 0.10416666666667
106741, 1.95, 1.56, 0.125
106742, 1.9291666666667, 1.58, 0.125
106743, 1.95, 1.58, 0.10416666666667
106744, 1.95, 1.6, 0.125
106745, 1.9291666666667, 1.62, 0.125
106746, 1.95, 1.62, 0.10416666666667
106747, 1.95, 1.64, 0.125
106748, 1.9291666666667, 1.66, 0.125
106749, 1.95, 1.66, 0.10416666666667
106750, 1.95, 1.68, 0.125
106751, 1.9916666666667, 1.52, 0.125
106752, 1.9708333333333, 1.54, 0.125
106753, 1.9916666666667, 1.54, 0.10416666666667
106754, 1.9916666666667, 1.56, 0.125
106755, 1.9708333333333, 1.58, 0.125
106756, 1.9916666666667, 1.58, 0.10416666666667
106757, 1.9916666666667, 1.6, 0.125
106758, 1.9708333333333, 1.62, 0.125
106759, 1.9916666666667, 1.62, 0.10416666666667
106760, 1.9916666666667, 1.64, 0.125
106761, 1.9708333333333, 1.66, 0.125
106762, 1.9916666666667, 1.66, 0.10416666666667
106763, 1.9916666666667, 1.68, 0.125
106764, 2.0333333333333, 1.52, 0.125
106765, 2.0125, 1.54, 0.125
106766, 2.0333333333333, 1.54, 0.10416666666667
106767, 2.0333333333333, 1.56, 0.125
106768, 2.0125, 1.58, 0.125
106769, 2.0333333333333, 1.58, 0.10416666666667
106770, 2.0333333333333, 1.6, 0.125
106771, 2.0125, 1.62, 0.125
106772, 2.0333333333333, 1.62, 0.10416666666667
106773, 2.0333333333333, 1.64, 0.125
106774, 2.0125, 1.66, 0.125
106775, 2.0333333333333, 1.66, 0.10416666666667
106776, 2.0333333333333, 1.68, 0.125
106777, 2.075, 1.52, 0.125
106778, 2.0541666666667, 1.54, 0.125
106779, 2.075, 1.54, 0.10416666666667
106780, 2.075, 1.56, 0.125
106781, 2.0541666666667, 1.58, 0.125
106782, 2.075, 1.58, 0.10416666666667
106783, 2.075, 1.6, 0.125
106784, 2.0541666666667, 1.62, 0.125
106785, 2.075, 1.62, 0.10416666666667
106786, 2.075, 1.64, 0.125
106787, 2.0541666666667, 1.66, 0.125
106788, 2.075, 1.66, 0.10416666666667
106789, 2.075, 1.68, 0.125
106790, 2.1166666666667, 1.52, 0.125
106791, 2.0958333333333, 1.54, 0.125
106792, 2.1166666666667, 1.54, 0.10416666666667
106793, 2.1166666666667, 1.56, 0.125
106794, 2.0958333333333, 1.58, 0.125
106795, 2.1166666666667, 1.58, 0.10416666666667
106796, 2.1166666666667, 1.6, 0.125
106797, 2.0958333333333, 1.62, 0.125
106798, 2.1166666666667, 1.62, 0.10416666666667
106799, 2.1166666666667, 1.64, 0.125
106800, 2.0958333333333, 1.66, 0.125
106801, 2.1166666666667, 1.66, 0.10416666666667
106802, 2.1166666666667, 1.68, 0.125
106803, 2.1583333333333, 1.52, 0.125
106804, 2.1375, 1.54, 0.125
106805, 2.1583333333333, 1.54, 0.10416666666667
106806, 2.1583333333333, 1.56, 0.125
106807, 2.1375, 1.58, 0.125
106808, 2.1583333333333, 1.58, 0.10416666666667
106809, 2.1583333333333, 1.6, 0.125
106810, 2.1375, 1.62, 0.125
106811, 2.1583333333333, 1.62, 0.10416666666667
106812, 2.1583333333333, 1.64, 0.125
106813, 2.1375, 1.66, 0.125
106814, 2.1583333333333, 1.66, 0.10416666666667
106815, 2.1583333333333, 1.68, 0.125
106816, 2.1791666666667, 1.54, 0.125
106817, 2.1791666666667, 1.58, 0.125
106818, 2.1791666666667, 1.62, 0.125
106819, 2.1791666666667, 1.66, 0.125
106820, 1.2416666666667, 1.52, 0.16666666666667
106821, 1.2208333333333, 1.54, 0.16666666666667
106822, 1.2416666666667, 1.54, 0.14583333333333
106823, 1.2416666666667, 1.56, 0.16666666666667
106824, 1.2208333333333, 1.58, 0.16666666666667
106825, 1.2416666666667, 1.58, 0.14583333333333
106826, 1.2416666666667, 1.6, 0.16666666666667
106827, 1.2208333333333, 1.62, 0.16666666666667
106828, 1.2416666666667, 1.62, 0.14583333333333
106829, 1.2416666666667, 1.64, 0.16666666666667
106830, 1.2208333333333, 1.66, 0.16666666666667
106831, 1.2416666666667, 1.66, 0.14583333333333
106832, 1.2416666666667, 1.68, 0.16666666666667
106833, 1.2833333333333, 1.52, 0.16666666666667
106834, 1.2625, 1.54, 0.16666666666667
106835, 1.2833333333333, 1.54, 0.14583333333333
106836, 1.2833333333333, 1.56, 0.16666666666667
106837, 1.2625, 1.58, 0.16666666666667
106838, 1.2833333333333, 1.58, 0.14583333333333
106839, 1.2833333333333, 1.6, 0.16666666666667
106840, 1.2625, 1.62, 0.16666666666667
106841, 1.2833333333333, 1.62, 0.14583333333333
106842, 1.2833333333333, 1.64, 0.16666666666667
106843, 1.2625, 1.66, 0.16666666666667
106844, 1.2833333333333, 1.66, 0.14583333333333
106845, 1.2833333333333, 1.68, 0.16666666666667
106846, 1.325, 1.52, 0.16666666666667
106847, 1.3041666666667, 1.54, 0.16666666666667
106848, 1.325, 1.54, 0.14583333333333
106849, 1.325, 1.56, 0.16666666666667
106850, 1.3041666666667, 1.58, 0.16666666666667
106851, 1.325, 1.58, 0.14583333333333
106852, 1.325, 1.6, 0.16666666666667
106853, 1.3041666666667, 1.62, 0.16666666666667
106854, 1.325, 1.62, 0.14583333333333
106855, 1.325, 1.64, 0.16666666666667
106856, 1.3041666666667, 1.66, 0.16666666666667
106857, 1.325, 1.66, 0.14583333333333
106858, 1.325, 1.68, 0.16666666666667
106859, 1.3666666666667, 1.52, 0.16666666666667
106860, 1.3458333333333, 1.54, 0.16666666666667
106861, 1.3666666666667, 1.54, 0.14583333333333
106862, 1.3666666666667, 1.56, 0.16666666666667
106863, 1.3458333333333, 1.58, 0.16666666666667
106864, 1.3666666666667, 1.58, 0.14583333333333
106865, 1.3666666666667, 1.6, 0.16666666666667
106866, 1.3458333333333, 1.62, 0.16666666666667
106867, 1.3666666666667, 1.62, 0.14583333333333
106868, 1.3666666666667, 1.64, 0.16666666666667
106869, 1.3458333333333, 1.66, 0.16666666666667
106870, 1.3666666666667, 1.66, 0.14583333333333
106871, 1.3666666666667, 1.68, 0.16666666666667
106872, 1.4083333333333, 1.52, 0.16666666666667
106873, 1.3875, 1.54, 0.16666666666667
106874, 1.4083333333333, 1.54, 0.14583333333333
106875, 1.4083333333333, 1.56, 0.16666666666667
106876, 1.3875, 1.58, 0.16666666666667
106877, 1.4083333333333, 1.58, 0.14583333333333
106878, 1.4083333333333, 1.6, 0.16666666666667
106879, 1.3875, 1.62, 0.16666666666667
106880, 1.4083333333333, 1.62, 0.14583333333333
106881, 1.4083333333333, 1.64, 0.16666666666667
106882, 1.3875, 1.66, 0.16666666666667
106883, 1.4083333333333, 1.66, 0.14583333333333
106884, 1.4083333333333, 1.68, 0.16666666666667
106885, 1.45, 1.52, 0.16666666666667
106886, 1.4291666666667, 1.54, 0.16666666666667
106887, 1.45, 1.54, 0.14583333333333
106888, 1.45, 1.56, 0.16666666666667
106889, 1.4291666666667, 1.58, 0.16666666666667
106890, 1.45, 1.58, 0.14583333333333
106891, 1.45, 1.6, 0.16666666666667
106892, 1.4291666666667, 1.62, 0.16666666666667
106893, 1.45, 1.62, 0.14583333333333
106894, 1.45, 1.64, 0.16666666666667
106895, 1.4291666666667, 1.66, 0.16666666666667
106896, 1.45, 1.66, 0.14583333333333
106897, 1.45, 1.68, 0.16666666666667
106898, 1.4916666666667, 1.52, 0.16666666666667
106899, 1.4708333333333, 1.54, 0.16666666666667
106900, 1.4916666666667, 1.54, 0.14583333333333
106901, 1.4916666666667, 1.56, 0.16666666666667
106902, 1.4708333333333, 1.58, 0.16666666666667
106903, 1.4916666666667, 1.58, 0.14583333333333
106904, 1.4916666666667, 1.6, 0.16666666666667
106905, 1.4708333333333, 1.62, 0.16666666666667
106906, 1.4916666666667, 1.62, 0.14583333333333
106907, 1.4916666666667, 1.64, 0.16666666666667
106908, 1.4708333333333, 1.66, 0.16666666666667
106909, 1.4916666666667, 1.66, 0.14583333333333
106910, 1.4916666666667, 1.68, 0.16666666666667
106911, 1.5333333333333, 1.52, 0.16666666666667
106912, 1.5125, 1.54, 0.16666666666667
106913, 1.5333333333333, 1.54, 0.14583333333333
106914, 1.5333333333333, 1.56, 0.16666666666667
106915, 1.5125, 1.58, 0.16666666666667
106916, 1.5333333333333, 1.58, 0.14583333333333
106917, 1.5333333333333, 1.6, 0.16666666666667
106918, 1.5125, 1.62, 0.16666666666667
106919, 1.5333333333333, 1.62, 0.14583333333333
106920, 1.5333333333333, 1.64, 0.16666666666667
106921, 1.5125, 1.66, 0.16666666666667
106922, 1.5333333333333, 1.66, 0.14583333333333
106923, 1.5333333333333, 1.68, 0.16666666666667
106924, 1.575, 1.52, 0.16666666666667
106925, 1.5541666666667, 1.54, 0.16666666666667
106926, 1.575, 1.54, 0.14583333333333
106927, 1.575, 1.56, 0.16666666666667
106928, 1.5541666666667, 1.58, 0.16666666666667
106929, 1.575, 1.58, 0.14583333333333
106930, 1.575, 1.6, 0.16666666666667
106931, 1.5541666666667, 1.62, 0.16666666666667
106932, 1.575, 1.62, 0.14583333333333
106933, 1.575, 1.64, 0.16666666666667
106934, 1.5541666666667, 1.66, 0.16666666666667
106935, 1.575, 1.66, 0.14583333333333
106936, 1.575, 1.68, 0.16666666666667
106937, 1.6166666666667, 1.52, 0.16666666666667
106938, 1.5958333333333, 1.54, 0.16666666666667
106939, 1.6166666666667, 1.54, 0.14583333333333
106940, 1.6166666666667, 1.56, 0.16666666666667
106941, 1.5958333333333, 1.58, 0.16666666666667
106942, 1.6166666666667, 1.58, 0.14583333333333
106943, 1.6166666666667, 1.6, 0.16666666666667
106944, 1.5958333333333, 1.62, 0.16666666666667
106945, 1.6166666666667, 1.62, 0.14583333333333
106946, 1.6166666666667, 1.64, 0.16666666666667
106947, 1.5958333333333, 1.66, 0.16666666666667
106948, 1.6166666666667, 1.66, 0.14583333333333
106949, 1.6166666666667, 1.68, 0.16666666666667
106950, 1.6583333333333, 1.52, 0.16666666666667
106951, 1.6375, 1.54, 0.16666666666667
106952, 1.6583333333333, 1.54, 0.14583333333333
106953, 1.6583333333333, 1.56, 0.16666666666667
106954, 1.6375, 1.58, 0.16666666666667
106955, 1.6583333333333, 1.58, 0.14583333333333
106956, 1.6583333333333, 1.6, 0.16666666666667
106957, 1.6375, 1.62, 0.16666666666667
106958, 1.6583333333333, 1.62, 0.14583333333333
106959, 1.6583333333333, 1.64, 0.16666666666667
106960, 1.6375, 1.66, 0.16666666666667
106961, 1.6583333333333, 1.66, 0.14583333333333
106962, 1.6583333333333, 1.68, 0.16666666666667
106963, 1.7, 1.52, 0.16666666666667
106964, 1.6791666666667, 1.54, 0.16666666666667
106965, 1.7, 1.54, 0.14583333333333
106966, 1.7, 1.56, 0.16666666666667
106967, 1.6791666666667, 1.58, 0.16666666666667
106968, 1.7, 1.58, 0.14583333333333
106969, 1.7, 1.6, 0.16666666666667
106970, 1.6791666666667, 1.62, 0.16666666666667
106971, 1.7, 1.62, 0.14583333333333
106972, 1.7, 1.64, 0.16666666666667
106973, 1.6791666666667, 1.66, 0.16666666666667
106974, 1.7, 1.66, 0.14583333333333
106975, 1.7, 1.68, 0.16666666666667
106976, 1.7416666666667, 1.52, 0.16666666666667
106977, 1.7208333333333, 1.54, 0.16666666666667
106978, 1.7416666666667, 1.54, 0.14583333333333
106979, 1.7416666666667, 1.56, 0.16666666666667
106980, 1.7208333333333, 1.58, 0.16666666666667
106981, 1.7416666666667, 1.58, 0.14583333333333
106982, 1.7416666666667, 1.6, 0.16666666666667
106983, 1.7208333333333, 1.62, 0.16666666666667
106984, 1.7416666666667, 1.62, 0.14583333333333
106985, 1.7416666666667, 1.64, 0.16666666666667
106986, 1.7208333333333, 1.66, 0.16666666666667
106987, 1.7416666666667, 1.66, 0.14583333333333
106988, 1.7416666666667, 1.68, 0.16666666666667
106989, 1.7833333333333, 1.52, 0.16666666666667
106990, 1.7625, 1.54, 0.16666666666667
106991, 1.7833333333333, 1.54, 0.14583333333333
106992, 1.7833333333333, 1.56, 0.16666666666667
106993, 1.7625, 1.58, 0.16666666666667
106994, 1.7833333333333, 1.58, 0.14583333333333
106995, 1.7833333333333, 1.6, 0.16666666666667
106996, 1.7625, 1.62, 0.16666666666667
106997, 1.7833333333333, 1.62, 0.14583333333333
106998, 1.7833333333333, 1.64, 0.16666666666667
106999, 1.7625, 1.66, 0.16666666666667
107000, 1.7833333333333, 1.66, 0.14583333333333
107001, 1.7833333333333, 1.68, 0.16666666666667
107002, 1.825, 1.52, 0.16666666666667
107003, 1.8041666666667, 1.54, 0.16666666666667
107004, 1.825, 1.54, 0.14583333333333
107005, 1.825, 1.56, 0.16666666666667
107006, 1.8041666666667, 1.58, 0.16666666666667
107007, 1.825, 1.58, 0.14583333333333
107008, 1.825, 1.6, 0.16666666666667
107009, 1.8041666666667, 1.62, 0.16666666666667
107010, 1.825, 1.62, 0.14583333333333
107011, 1.825, 1.64, 0.16666666666667
107012, 1.8041666666667, 1.66, 0.16666666666667
107013, 1.825, 1.66, 0.14583333333333
107014, 1.825, 1.68, 0.16666666666667
107015, 1.8666666666667, 1.52, 0.16666666666667
107016, 1.8458333333333, 1.54, 0.16666666666667
107017, 1.8666666666667, 1.54, 0.14583333333333
107018, 1.8666666666667, 1.56, 0.16666666666667
107019, 1.8458333333333, 1.58, 0.16666666666667
107020, 1.8666666666667, 1.58, 0.14583333333333
107021, 1.8666666666667, 1.6, 0.16666666666667
107022, 1.8458333333333, 1.62, 0.16666666666667
107023, 1.8666666666667, 1.62, 0.14583333333333
107024, 1.8666666666667, 1.64, 0.16666666666667
107025, 1.8458333333333, 1.66, 0.16666666666667
107026, 1.8666666666667, 1.66, 0.14583333333333
107027, 1.8666666666667, 1.68, 0.16666666666667
107028, 1.9083333333333, 1.52, 0.16666666666667
107029, 1.8875, 1.54, 0.16666666666667
107030, 1.9083333333333, 1.54, 0.14583333333333
107031, 1.9083333333333, 1.56, 0.16666666666667
107032, 1.8875, 1.58, 0.16666666666667
107033, 1.9083333333333, 1.58, 0.14583333333333
107034, 1.9083333333333, 1.6, 0.16666666666667
107035, 1.8875, 1.62, 0.16666666666667
107036, 1.9083333333333, 1.62, 0.14583333333333
107037, 1.9083333333333, 1.64, 0.16666666666667
107038, 1.8875, 1.66, 0.16666666666667
107039, 1.9083333333333, 1.66, 0.14583333333333
107040, 1.9083333333333, 1.68, 0.16666666666667
107041, 1.95, 1.52, 0.16666666666667
107042, 1.9291666666667, 1.54, 0.16666666666667
107043, 1.95, 1.54, 0.14583333333333
107044, 1.95, 1.56, 0.16666666666667
107045, 1.9291666666667, 1.58, 0.16666666666667
107046, 1.95, 1.58, 0.14583333333333
107047, 1.95, 1.6, 0.16666666666667
107048, 1.9291666666667, 1.62, 0.16666666666667
107049, 1.95, 1.62, 0.14583333333333
107050, 1.95, 1.64, 0.16666666666667
107051, 1.9291666666667, 1.66, 0.16666666666667
107052, 1.95, 1.66, 0.14583333333333
107053, 1.95, 1.68, 0.16666666666667
107054, 1.9916666666667, 1.52, 0.16666666666667
107055, 1.9708333333333, 1.54, 0.16666666666667
107056, 1.9916666666667, 1.54, 0.14583333333333
107057, 1.9916666666667, 1.56, 0.16666666666667
107058, 1.9708333333333, 1.58, 0.16666666666667
107059, 1.9916666666667, 1.58, 0.14583333333333
107060, 1.9916666666667, 1.6, 0.16666666666667
107061, 1.9708333333333, 1.62, 0.16666666666667
107062, 1.9916666666667, 1.62, 0.14583333333333
107063, 1.9916666666667, 1.64, 0.16666666666667
107064, 1.9708333333333, 1.66, 0.16666666666667
107065, 1.9916666666667, 1.66, 0.14583333333333
107066, 1.9916666666667, 1.68, 0.16666666666667
107067, 2.0333333333333, 1.52, 0.16666666666667
107068, 2.0125, 1.54, 0.16666666666667
107069, 2.0333333333333, 1.54, 0.14583333333333
107070, 2.0333333333333, 1.56, 0.16666666666667
107071, 2.0125, 1.58, 0.16666666666667
107072, 2.0333333333333, 1.58, 0.14583333333333
107073, 2.0333333333333, 1.6, 0.16666666666667
107074, 2.0125, 1.62, 0.16666666666667
107075, 2.0333333333333, 1.62, 0.14583333333333
107076, 2.0333333333333, 1.64, 0.16666666666667
107077, 2.0125, 1.66, 0.16666666666667
107078, 2.0333333333333, 1.66, 0.14583333333333
107079, 2.0333333333333, 1.68, 0.16666666666667
107080, 2.075, 1.52, 0.16666666666667
107081, 2.0541666666667, 1.54, 0.16666666666667
107082, 2.075, 1.54, 0.14583333333333
107083, 2.075, 1.56, 0.16666666666667
107084, 2.0541666666667, 1.58, 0.16666666666667
107085, 2.075, 1.58, 0.14583333333333
107086, 2.075, 1.6, 0.16666666666667
107087, 2.0541666666667, 1.62, 0.16666666666667
107088, 2.075, 1.62, 0.14583333333333
107089, 2.075, 1.64, 0.16666666666667
107090, 2.0541666666667, 1.66, 0.16666666666667
107091, 2.075, 1.66, 0.14583333333333
107092, 2.075, 1.68, 0.16666666666667
107093, 2.1166666666667, 1.52, 0.16666666666667
107094, 2.0958333333333, 1.54, 0.16666666666667
107095, 2.1166666666667, 1.54, 0.14583333333333
107096, 2.1166666666667, 1.56, 0.16666666666667
107097, 2.0958333333333, 1.58, 0.16666666666667
107098, 2.1166666666667, 1.58, 0.14583333333333
107099, 2.1166666666667, 1.6, 0.16666666666667
107100, 2.0958333333333, 1.62, 0.16666666666667
107101, 2.1166666666667, 1.62, 0.14583333333333
107102, 2.1166666666667, 1.64, 0.16666666666667
107103, 2.0958333333333, 1.66, 0.16666666666667
107104, 2.1166666666667, 1.66, 0.14583333333333
107105, 2.1166666666667, 1.68, 0.16666666666667
107106, 2.1583333333333, 1.52, 0.16666666666667
107107, 2.1375, 1.54, 0.16666666666667
107108, 2.1583333333333, 1.54, 0.14583333333333
107109, 2.1583333333333, 1.56, 0.16666666666667
107110, 2.1375, 1.58, 0.16666666666667
107111, 2.1583333333333, 1.58, 0.14583333333333
107112, 2.1583333333333, 1.6, 0.16666666666667
107113, 2.1375, 1.62, 0.16666666666667
107114, 2.1583333333333, 1.62, 0.14583333333333
107115, 2.1583333333333, 1.64, 0.16666666666667
107116, 2.1375, 1.66, 0.16666666666667
107117, 2.1583333333333, 1.66, 0.14583333333333
107118, 2.1583333333333, 1.68, 0.16666666666667
107119, 2.1791666666667, 1.54, 0.16666666666667
107120, 2.1791666666667, 1.58, 0.16666666666667
107121, 2.1791666666667, 1.62, 0.16666666666667
107122, 2.1791666666667, 1.66, 0.16666666666667
107123, 1.2416666666667, 1.52, 0.20833333333333
107124, 1.2208333333333, 1.54, 0.20833333333333
107125, 1.2416666666667, 1.54, 0.1875
107126, 1.2416666666667, 1.56, 0.20833333333333
107127, 1.2208333333333, 1.58, 0.20833333333333
107128, 1.2416666666667, 1.58, 0.1875
107129, 1.2416666666667, 1.6, 0.20833333333333
107130, 1.2208333333333, 1.62, 0.20833333333333
107131, 1.2416666666667, 1.62, 0.1875
107132, 1.2416666666667, 1.64, 0.20833333333333
107133, 1.2208333333333, 1.66, 0.20833333333333
107134, 1.2416666666667, 1.66, 0.1875
107135, 1.2416666666667, 1.68, 0.20833333333333
107136, 1.2833333333333, 1.52, 0.20833333333333
107137, 1.2625, 1.54, 0.20833333333333
107138, 1.2833333333333, 1.54, 0.1875
107139, 1.2833333333333, 1.56, 0.20833333333333
107140, 1.2625, 1.58, 0.20833333333333
107141, 1.2833333333333, 1.58, 0.1875
107142, 1.2833333333333, 1.6, 0.20833333333333
107143, 1.2625, 1.62, 0.20833333333333
107144, 1.2833333333333, 1.62, 0.1875
107145, 1.2833333333333, 1.64, 0.20833333333333
107146, 1.2625, 1.66, 0.20833333333333
107147, 1.2833333333333, 1.66, 0.1875
107148, 1.2833333333333, 1.68, 0.20833333333333
107149, 1.325, 1.52, 0.20833333333333
107150, 1.3041666666667, 1.54, 0.20833333333333
107151, 1.325, 1.54, 0.1875
107152, 1.325, 1.56, 0.20833333333333
107153, 1.3041666666667, 1.58, 0.20833333333333
107154, 1.325, 1.58, 0.1875
107155, 1.325, 1.6, 0.20833333333333
107156, 1.3041666666667, 1.62, 0.20833333333333
107157, 1.325, 1.62, 0.1875
107158, 1.325, 1.64, 0.20833333333333
107159, 1.3041666666667, 1.66, 0.20833333333333
107160, 1.325, 1.66, 0.1875
107161, 1.325, 1.68, 0.20833333333333
107162, 1.3666666666667, 1.52, 0.20833333333333
107163, 1.3458333333333, 1.54, 0.20833333333333
107164, 1.3666666666667, 1.54, 0.1875
107165, 1.3666666666667, 1.56, 0.20833333333333
107166, 1.3458333333333, 1.58, 0.20833333333333
107167, 1.3666666666667, 1.58, 0.1875
107168, 1.3666666666667, 1.6, 0.20833333333333
107169, 1.3458333333333, 1.62, 0.20833333333333
107170, 1.3666666666667, 1.62, 0.1875
107171, 1.3666666666667, 1.64, 0.20833333333333
107172, 1.3458333333333, 1.66, 0.20833333333333
107173, 1.3666666666667, 1.66, 0.1875
107174, 1.3666666666667, 1.68, 0.20833333333333
107175, 1.4083333333333, 1.52, 0.20833333333333
107176, 1.3875, 1.54, 0.20833333333333
107177, 1.4083333333333, 1.54, 0.1875
107178, 1.4083333333333, 1.56, 0.20833333333333
107179, 1.3875, 1.58, 0.20833333333333
107180, 1.4083333333333, 1.58, 0.1875
107181, 1.4083333333333, 1.6, 0.20833333333333
107182, 1.3875, 1.62, 0.20833333333333
107183, 1.4083333333333, 1.62, 0.1875
107184, 1.4083333333333, 1.64, 0.20833333333333
107185, 1.3875, 1.66, 0.20833333333333
107186, 1.4083333333333, 1.66, 0.1875
107187, 1.4083333333333, 1.68, 0.20833333333333
107188, 1.45, 1.52, 0.20833333333333
107189, 1.4291666666667, 1.54, 0.20833333333333
107190, 1.45, 1.54, 0.1875
107191, 1.45, 1.56, 0.20833333333333
107192, 1.4291666666667, 1.58, 0.20833333333333
107193, 1.45, 1.58, 0.1875
107194, 1.45, 1.6, 0.20833333333333
107195, 1.4291666666667, 1.62, 0.20833333333333
107196, 1.45, 1.62, 0.1875
107197, 1.45, 1.64, 0.20833333333333
107198, 1.4291666666667, 1.66, 0.20833333333333
107199, 1.45, 1.66, 0.1875
107200, 1.45, 1.68, 0.20833333333333
107201, 1.4916666666667, 1.52, 0.20833333333333
107202, 1.4708333333333, 1.54, 0.20833333333333
107203, 1.4916666666667, 1.54, 0.1875
107204, 1.4916666666667, 1.56, 0.20833333333333
107205, 1.4708333333333, 1.58, 0.20833333333333
107206, 1.4916666666667, 1.58, 0.1875
107207, 1.4916666666667, 1.6, 0.20833333333333
107208, 1.4708333333333, 1.62, 0.20833333333333
107209, 1.4916666666667, 1.62, 0.1875
107210, 1.4916666666667, 1.64, 0.20833333333333
107211, 1.4708333333333, 1.66, 0.20833333333333
107212, 1.4916666666667, 1.66, 0.1875
107213, 1.4916666666667, 1.68, 0.20833333333333
107214, 1.5333333333333, 1.52, 0.20833333333333
107215, 1.5125, 1.54, 0.20833333333333
107216, 1.5333333333333, 1.54, 0.1875
107217, 1.5333333333333, 1.56, 0.20833333333333
107218, 1.5125, 1.58, 0.20833333333333
107219, 1.5333333333333, 1.58, 0.1875
107220, 1.5333333333333, 1.6, 0.20833333333333
107221, 1.5125, 1.62, 0.20833333333333
107222, 1.5333333333333, 1.62, 0.1875
107223, 1.5333333333333, 1.64, 0.20833333333333
107224, 1.5125, 1.66, 0.20833333333333
107225, 1.5333333333333, 1.66, 0.1875
107226, 1.5333333333333, 1.68, 0.20833333333333
107227, 1.575, 1.52, 0.20833333333333
107228, 1.5541666666667, 1.54, 0.20833333333333
107229, 1.575, 1.54, 0.1875
107230, 1.575, 1.56, 0.20833333333333
107231, 1.5541666666667, 1.58, 0.20833333333333
107232, 1.575, 1.58, 0.1875
107233, 1.575, 1.6, 0.20833333333333
107234, 1.5541666666667, 1.62, 0.20833333333333
107235, 1.575, 1.62, 0.1875
107236, 1.575, 1.64, 0.20833333333333
107237, 1.5541666666667, 1.66, 0.20833333333333
107238, 1.575, 1.66, 0.1875
107239, 1.575, 1.68, 0.20833333333333
107240, 1.6166666666667, 1.52, 0.20833333333333
107241, 1.5958333333333, 1.54, 0.20833333333333
107242, 1.6166666666667, 1.54, 0.1875
107243, 1.6166666666667, 1.56, 0.20833333333333
107244, 1.5958333333333, 1.58, 0.20833333333333
107245, 1.6166666666667, 1.58, 0.1875
107246, 1.6166666666667, 1.6, 0.20833333333333
107247, 1.5958333333333, 1.62, 0.20833333333333
107248, 1.6166666666667, 1.62, 0.1875
107249, 1.6166666666667, 1.64, 0.20833333333333
107250, 1.5958333333333, 1.66, 0.20833333333333
107251, 1.6166666666667, 1.66, 0.1875
107252, 1.6166666666667, 1.68, 0.20833333333333
107253, 1.6583333333333, 1.52, 0.20833333333333
107254, 1.6375, 1.54, 0.20833333333333
107255, 1.6583333333333, 1.54, 0.1875
107256, 1.6583333333333, 1.56, 0.20833333333333
107257, 1.6375, 1.58, 0.20833333333333
107258, 1.6583333333333, 1.58, 0.1875
107259, 1.6583333333333, 1.6, 0.20833333333333
107260, 1.6375, 1.62, 0.20833333333333
107261, 1.6583333333333, 1.62, 0.1875
107262, 1.6583333333333, 1.64, 0.20833333333333
107263, 1.6375, 1.66, 0.20833333333333
107264, 1.6583333333333, 1.66, 0.1875
107265, 1.6583333333333, 1.68, 0.20833333333333
107266, 1.7, 1.52, 0.20833333333333
107267, 1.6791666666667, 1.54, 0.20833333333333
107268, 1.7, 1.54, 0.1875
107269, 1.7, 1.56, 0.20833333333333
107270, 1.6791666666667, 1.58, 0.20833333333333
107271, 1.7, 1.58, 0.1875
107272, 1.7, 1.6, 0.20833333333333
107273, 1.6791666666667, 1.62, 0.20833333333333
107274, 1.7, 1.62, 0.1875
107275, 1.7, 1.64, 0.20833333333333
107276, 1.6791666666667, 1.66, 0.20833333333333
107277, 1.7, 1.66, 0.1875
107278, 1.7, 1.68, 0.20833333333333
107279, 1.7416666666667, 1.52, 0.20833333333333
107280, 1.7208333333333, 1.54, 0.20833333333333
107281, 1.7416666666667, 1.54, 0.1875
107282, 1.7416666666667, 1.56, 0.20833333333333
107283, 1.7208333333333, 1.58, 0.20833333333333
107284, 1.7416666666667, 1.58, 0.1875
107285, 1.7416666666667, 1.6, 0.20833333333333
107286, 1.7208333333333, 1.62, 0.20833333333333
107287, 1.7416666666667, 1.62, 0.1875
107288, 1.7416666666667, 1.64, 0.20833333333333
107289, 1.7208333333333, 1.66, 0.20833333333333
107290, 1.7416666666667, 1.66, 0.1875
107291, 1.7416666666667, 1.68, 0.20833333333333
107292, 1.7833333333333, 1.52, 0.20833333333333
107293, 1.7625, 1.54, 0.20833333333333
107294, 1.7833333333333, 1.54, 0.1875
107295, 1.7833333333333, 1.56, 0.20833333333333
107296, 1.7625, 1.58, 0.20833333333333
107297, 1.7833333333333, 1.58, 0.1875
107298, 1.7833333333333, 1.6, 0.20833333333333
107299, 1.7625, 1.62, 0.20833333333333
107300, 1.7833333333333, 1.62, 0.1875
107301, 1.7833333333333, 1.64, 0.20833333333333
107302, 1.7625, 1.66, 0.20833333333333
107303, 1.7833333333333, 1.66, 0.1875
107304, 1.7833333333333, 1.68, 0.20833333333333
107305, 1.825, 1.52, 0.20833333333333
107306, 1.8041666666667, 1.54, 0.20833333333333
107307, 1.825, 1.54, 0.1875
107308, 1.825, 1.56, 0.20833333333333
107309, 1.8041666666667, 1.58, 0.20833333333333
107310, 1.825, 1.58, 0.1875
107311, 1.825, 1.6, 0.20833333333333
107312, 1.8041666666667, 1.62, 0.20833333333333
107313, 1.825, 1.62, 0.1875
107314, 1.825, 1.64, 0.20833333333333
107315, 1.8041666666667, 1.66, 0.20833333333333
107316, 1.825, 1.66, 0.1875
107317, 1.825, 1.68, 0.20833333333333
107318, 1.8666666666667, 1.52, 0.20833333333333
107319, 1.8458333333333, 1.54, 0.20833333333333
107320, 1.8666666666667, 1.54, 0.1875
107321, 1.8666666666667, 1.56, 0.20833333333333
107322, 1.8458333333333, 1.58, 0.20833333333333
107323, 1.8666666666667, 1.58, 0.1875
107324, 1.8666666666667, 1.6, 0.20833333333333
107325, 1.8458333333333, 1.62, 0.20833333333333
107326, 1.8666666666667, 1.62, 0.1875
107327, 1.8666666666667, 1.64, 0.20833333333333
107328, 1.8458333333333, 1.66, 0.20833333333333
107329, 1.8666666666667, 1.66, 0.1875
107330, 1.8666666666667, 1.68, 0.20833333333333
107331, 1.9083333333333, 1.52, 0.20833333333333
107332, 1.8875, 1.54, 0.20833333333333
107333, 1.9083333333333, 1.54, 0.1875
107334, 1.9083333333333, 1.56, 0.20833333333333
107335, 1.8875, 1.58, 0.20833333333333
107336, 1.9083333333333, 1.58, 0.1875
107337, 1.9083333333333, 1.6, 0.20833333333333
107338, 1.8875, 1.62, 0.20833333333333
107339, 1.9083333333333, 1.62, 0.1875
107340, 1.9083333333333, 1.64, 0.20833333333333
107341, 1.8875, 1.66, 0.20833333333333
107342, 1.9083333333333, 1.66, 0.1875
107343, 1.9083333333333, 1.68, 0.20833333333333
107344, 1.95, 1.52, 0.20833333333333
107345, 1.9291666666667, 1.54, 0.20833333333333
107346, 1.95, 1.54, 0.1875
107347, 1.95, 1.56, 0.20833333333333
107348, 1.9291666666667, 1.58, 0.20833333333333
107349, 1.95, 1.58, 0.1875
107350, 1.95, 1.6, 0.20833333333333
107351, 1.9291666666667, 1.62, 0.20833333333333
107352, 1.95, 1.62, 0.1875
107353, 1.95, 1.64, 0.20833333333333
107354, 1.9291666666667, 1.66, 0.20833333333333
107355, 1.95, 1.66, 0.1875
107356, 1.95, 1.68, 0.20833333333333
107357, 1.9916666666667, 1.52, 0.20833333333333
107358, 1.9708333333333, 1.54, 0.20833333333333
107359, 1.9916666666667, 1.54, 0.1875
107360, 1.9916666666667, 1.56, 0.20833333333333
107361, 1.9708333333333, 1.58, 0.20833333333333
107362, 1.9916666666667, 1.58, 0.1875
107363, 1.9916666666667, 1.6, 0.20833333333333
107364, 1.9708333333333, 1.62, 0.20833333333333
107365, 1.9916666666667, 1.62, 0.1875
107366, 1.9916666666667, 1.64, 0.20833333333333
107367, 1.9708333333333, 1.66, 0.20833333333333
107368, 1.9916666666667, 1.66, 0.1875
107369, 1.9916666666667, 1.68, 0.20833333333333
107370, 2.0333333333333, 1.52, 0.20833333333333
107371, 2.0125, 1.54, 0.20833333333333
107372, 2.0333333333333, 1.54, 0.1875
107373, 2.0333333333333, 1.56, 0.20833333333333
107374, 2.0125, 1.58, 0.20833333333333
107375, 2.0333333333333, 1.58, 0.1875
107376, 2.0333333333333, 1.6, 0.20833333333333
107377, 2.0125, 1.62, 0.20833333333333
107378, 2.0333333333333, 1.62, 0.1875
107379, 2.0333333333333, 1.64, 0.20833333333333
107380, 2.0125, 1.66, 0.20833333333333
107381, 2.0333333333333, 1.66, 0.1875
107382, 2.0333333333333, 1.68, 0.20833333333333
107383, 2.075, 1.52, 0.20833333333333
107384, 2.0541666666667, 1.54, 0.20833333333333
107385, 2.075, 1.54, 0.1875
107386, 2.075, 1.56, 0.20833333333333
107387, 2.0541666666667, 1.58, 0.20833333333333
107388, 2.075, 1.58, 0.1875
107389, 2.075, 1.6, 0.20833333333333
107390, 2.0541666666667, 1.62, 0.20833333333333
107391, 2.075, 1.62, 0.1875
107392, 2.075, 1.64, 0.20833333333333
107393, 2.0541666666667, 1.66, 0.20833333333333
107394, 2.075, 1.66, 0.1875
107395, 2.075, 1.68, 0.20833333333333
107396, 2.1166666666667, 1.52, 0.20833333333333
107397, 2.0958333333333, 1.54, 0.20833333333333
107398, 2.1166666666667, 1.54, 0.1875
107399, 2.1166666666667, 1.56, 0.20833333333333
107400, 2.0958333333333, 1.58, 0.20833333333333
107401, 2.1166666666667, 1.58, 0.1875
107402, 2.1166666666667, 1.6, 0.20833333333333
107403, 2.0958333333333, 1.62, 0.20833333333333
107404, 2.1166666666667, 1.62, 0.1875
107405, 2.1166666666667, 1.64, 0.20833333333333
107406, 2.0958333333333, 1.66, 0.20833333333333
107407, 2.1166666666667, 1.66, 0.1875
107408, 2.1166666666667, 1.68, 0.20833333333333
107409, 2.1583333333333, 1.52, 0.20833333333333
107410, 2.1375, 1.54, 0.20833333333333
107411, 2.1583333333333, 1.54, 0.1875
107412, 2.1583333333333, 1.56, 0.20833333333333
107413, 2.1375, 1.58, 0.20833333333333
107414, 2.1583333333333, 1.58, 0.1875
107415, 2.1583333333333, 1.6, 0.20833333333333
107416, 2.1375, 1.62, 0.20833333333333
107417, 2.1583333333333, 1.62, 0.1875
107418, 2.1583333333333, 1.64, 0.20833333333333
107419, 2.1375, 1.66, 0.20833333333333
107420, 2.1583333333333, 1.66, 0.1875
107421, 2.1583333333333, 1.68, 0.20833333333333
107422, 2.1791666666667, 1.54, 0.20833333333333
107423, 2.1791666666667, 1.58, 0.20833333333333
107424, 2.1791666666667, 1.62, 0.20833333333333
107425, 2.1791666666667, 1.66, 0.20833333333333
107426, 1.2416666666667, 1.52, 0.25
107427, 1.2208333333333, 1.54, 0.25
107428, 1.2416666666667, 1.54, 0.22916666666667
107429, 1.2416666666667, 1.56, 0.25
107430, 1.2208333333333, 1.58, 0.25
107431, 1.2416666666667, 1.58, 0.22916666666667
107432, 1.2416666666667, 1.6, 0.25
107433, 1.2208333333333, 1.62, 0.25
107434, 1.2416666666667, 1.62, 0.22916666666667
107435, 1.2416666666667, 1.64, 0.25
107436, 1.2208333333333, 1.66, 0.25
107437, 1.2416666666667, 1.66, 0.22916666666667
107438, 1.2416666666667, 1.68, 0.25
107439, 1.2833333333333, 1.52, 0.25
107440, 1.2625, 1.54, 0.25
107441, 1.2833333333333, 1.54, 0.22916666666667
107442, 1.2833333333333, 1.56, 0.25
107443, 1.2625, 1.58, 0.25
107444, 1.2833333333333, 1.58, 0.22916666666667
107445, 1.2833333333333, 1.6, 0.25
107446, 1.2625, 1.62, 0.25
107447, 1.2833333333333, 1.62, 0.22916666666667
107448, 1.2833333333333, 1.64, 0.25
107449, 1.2625, 1.66, 0.25
107450, 1.2833333333333, 1.66, 0.22916666666667
107451, 1.2833333333333, 1.68, 0.25
107452, 1.325, 1.52, 0.25
107453, 1.3041666666667, 1.54, 0.25
107454, 1.325, 1.54, 0.22916666666667
107455, 1.325, 1.56, 0.25
107456, 1.3041666666667, 1.58, 0.25
107457, 1.325, 1.58, 0.22916666666667
107458, 1.325, 1.6, 0.25
107459, 1.3041666666667, 1.62, 0.25
107460, 1.325, 1.62, 0.22916666666667
107461, 1.325, 1.64, 0.25
107462, 1.3041666666667, 1.66, 0.25
107463, 1.325, 1.66, 0.22916666666667
107464, 1.325, 1.68, 0.25
107465, 1.3666666666667, 1.52, 0.25
107466, 1.3458333333333, 1.54, 0.25
107467, 1.3666666666667, 1.54, 0.22916666666667
107468, 1.3666666666667, 1.56, 0.25
107469, 1.3458333333333, 1.58, 0.25
107470, 1.3666666666667, 1.58, 0.22916666666667
107471, 1.3666666666667, 1.6, 0.25
107472, 1.3458333333333, 1.62, 0.25
107473, 1.3666666666667, 1.62, 0.22916666666667
107474, 1.3666666666667, 1.64, 0.25
107475, 1.3458333333333, 1.66, 0.25
107476, 1.3666666666667, 1.66, 0.22916666666667
107477, 1.3666666666667, 1.68, 0.25
107478, 1.4083333333333, 1.52, 0.25
107479, 1.3875, 1.54, 0.25
107480, 1.4083333333333, 1.54, 0.22916666666667
107481, 1.4083333333333, 1.56, 0.25
107482, 1.3875, 1.58, 0.25
107483, 1.4083333333333, 1.58, 0.22916666666667
107484, 1.4083333333333, 1.6, 0.25
107485, 1.3875, 1.62, 0.25
107486, 1.4083333333333, 1.62, 0.22916666666667
107487, 1.4083333333333, 1.64, 0.25
107488, 1.3875, 1.66, 0.25
107489, 1.4083333333333, 1.66, 0.22916666666667
107490, 1.4083333333333, 1.68, 0.25
107491, 1.45, 1.52, 0.25
107492, 1.4291666666667, 1.54, 0.25
107493, 1.45, 1.54, 0.22916666666667
107494, 1.45, 1.56, 0.25
107495, 1.4291666666667, 1.58, 0.25
107496, 1.45, 1.58, 0.22916666666667
107497, 1.45, 1.6, 0.25
107498, 1.4291666666667, 1.62, 0.25
107499, 1.45, 1.62, 0.22916666666667
107500, 1.45, 1.64, 0.25
107501, 1.4291666666667, 1.66, 0.25
107502, 1.45, 1.66, 0.22916666666667
107503, 1.45, 1.68, 0.25
107504, 1.4916666666667, 1.52, 0.25
107505, 1.4708333333333, 1.54, 0.25
107506, 1.4916666666667, 1.54, 0.22916666666667
107507, 1.4916666666667, 1.56, 0.25
107508, 1.4708333333333, 1.58, 0.25
107509, 1.4916666666667, 1.58, 0.22916666666667
107510, 1.4916666666667, 1.6, 0.25
107511, 1.4708333333333, 1.62, 0.25
107512, 1.4916666666667, 1.62, 0.22916666666667
107513, 1.4916666666667, 1.64, 0.25
107514, 1.4708333333333, 1.66, 0.25
107515, 1.4916666666667, 1.66, 0.22916666666667
107516, 1.4916666666667, 1.68, 0.25
107517, 1.5333333333333, 1.52, 0.25
107518, 1.5125, 1.54, 0.25
107519, 1.5333333333333, 1.54, 0.22916666666667
107520, 1.5333333333333, 1.56, 0.25
107521, 1.5125, 1.58, 0.25
107522, 1.5333333333333, 1.58, 0.22916666666667
107523, 1.5333333333333, 1.6, 0.25
107524, 1.5125, 1.62, 0.25
107525, 1.5333333333333, 1.62, 0.22916666666667
107526, 1.5333333333333, 1.64, 0.25
107527, 1.5125, 1.66, 0.25
107528, 1.5333333333333, 1.66, 0.22916666666667
107529, 1.5333333333333, 1.68, 0.25
107530, 1.575, 1.52, 0.25
107531, 1.5541666666667, 1.54, 0.25
107532, 1.575, 1.54, 0.22916666666667
107533, 1.575, 1.56, 0.25
107534, 1.5541666666667, 1.58, 0.25
107535, 1.575, 1.58, 0.22916666666667
107536, 1.575, 1.6, 0.25
107537, 1.5541666666667, 1.62, 0.25
107538, 1.575, 1.62, 0.22916666666667
107539, 1.575, 1.64, 0.25
107540, 1.5541666666667, 1.66, 0.25
107541, 1.575, 1.66, 0.22916666666667
107542, 1.575, 1.68, 0.25
107543, 1.6166666666667, 1.52, 0.25
107544, 1.5958333333333, 1.54, 0.25
107545, 1.6166666666667, 1.54, 0.22916666666667
107546, 1.6166666666667, 1.56, 0.25
107547, 1.5958333333333, 1.58, 0.25
107548, 1.6166666666667, 1.58, 0.22916666666667
107549, 1.6166666666667, 1.6, 0.25
107550, 1.5958333333333, 1.62, 0.25
107551, 1.6166666666667, 1.62, 0.22916666666667
107552, 1.6166666666667, 1.64, 0.25
107553, 1.5958333333333, 1.66, 0.25
107554, 1.6166666666667, 1.66, 0.22916666666667
107555, 1.6166666666667, 1.68, 0.25
107556, 1.6583333333333, 1.52, 0.25
107557, 1.6375, 1.54, 0.25
107558, 1.6583333333333, 1.54, 0.22916666666667
107559, 1.6583333333333, 1.56, 0.25
107560, 1.6375, 1.58, 0.25
107561, 1.6583333333333, 1.58, 0.22916666666667
107562, 1.6583333333333, 1.6, 0.25
107563, 1.6375, 1.62, 0.25
107564, 1.6583333333333, 1.62, 0.22916666666667
107565, 1.6583333333333, 1.64, 0.25
107566, 1.6375, 1.66, 0.25
107567, 1.6583333333333, 1.66, 0.22916666666667
107568, 1.6583333333333, 1.68, 0.25
107569, 1.7, 1.52, 0.25
107570, 1.6791666666667, 1.54, 0.25
107571, 1.7, 1.54, 0.22916666666667
107572, 1.7, 1.56, 0.25
107573, 1.6791666666667, 1.58, 0.25
107574, 1.7, 1.58, 0.22916666666667
107575, 1.7, 1.6, 0.25
107576, 1.6791666666667, 1.62, 0.25
107577, 1.7, 1.62, 0.22916666666667
107578, 1.7, 1.64, 0.25
107579, 1.6791666666667, 1.66, 0.25
107580, 1.7, 1.66, 0.22916666666667
107581, 1.7, 1.68, 0.25
107582, 1.7416666666667, 1.52, 0.25
107583, 1.7208333333333, 1.54, 0.25
107584, 1.7416666666667, 1.54, 0.22916666666667
107585, 1.7416666666667, 1.56, 0.25
107586, 1.7208333333333, 1.58, 0.25
107587, 1.7416666666667, 1.58, 0.22916666666667
107588, 1.7416666666667, 1.6, 0.25
107589, 1.7208333333333, 1.62, 0.25
107590, 1.7416666666667, 1.62, 0.22916666666667
107591, 1.7416666666667, 1.64, 0.25
107592, 1.7208333333333, 1.66, 0.25
107593, 1.7416666666667, 1.66, 0.22916666666667
107594, 1.7416666666667, 1.68, 0.25
107595, 1.7833333333333, 1.52, 0.25
107596, 1.7625, 1.54, 0.25
107597, 1.7833333333333, 1.54, 0.22916666666667
107598, 1.7833333333333, 1.56, 0.25
107599, 1.7625, 1.58, 0.25
107600, 1.7833333333333, 1.58, 0.22916666666667
107601, 1.7833333333333, 1.6, 0.25
107602, 1.7625, 1.62, 0.25
107603, 1.7833333333333, 1.62, 0.22916666666667
107604, 1.7833333333333, 1.64, 0.25
107605, 1.7625, 1.66, 0.25
107606, 1.7833333333333, 1.66, 0.22916666666667
107607, 1.7833333333333, 1.68, 0.25
107608, 1.825, 1.52, 0.25
107609, 1.8041666666667, 1.54, 0.25
107610, 1.825, 1.54, 0.22916666666667
107611, 1.825, 1.56, 0.25
107612, 1.8041666666667, 1.58, 0.25
107613, 1.825, 1.58, 0.22916666666667
107614, 1.825, 1.6, 0.25
107615, 1.8041666666667, 1.62, 0.25
107616, 1.825, 1.62, 0.22916666666667
107617, 1.825, 1.64, 0.25
107618, 1.8041666666667, 1.66, 0.25
107619, 1.825, 1.66, 0.22916666666667
107620, 1.825, 1.68, 0.25
107621, 1.8666666666667, 1.52, 0.25
107622, 1.8458333333333, 1.54, 0.25
107623, 1.8666666666667, 1.54, 0.22916666666667
107624, 1.8666666666667, 1.56, 0.25
107625, 1.8458333333333, 1.58, 0.25
107626, 1.8666666666667, 1.58, 0.22916666666667
107627, 1.8666666666667, 1.6, 0.25
107628, 1.8458333333333, 1.62, 0.25
107629, 1.8666666666667, 1.62, 0.22916666666667
107630, 1.8666666666667, 1.64, 0.25
107631, 1.8458333333333, 1.66, 0.25
107632, 1.8666666666667, 1.66, 0.22916666666667
107633, 1.8666666666667, 1.68, 0.25
107634, 1.9083333333333, 1.52, 0.25
107635, 1.8875, 1.54, 0.25
107636, 1.9083333333333, 1.54, 0.22916666666667
107637, 1.9083333333333, 1.56, 0.25
107638, 1.8875, 1.58, 0.25
107639, 1.9083333333333, 1.58, 0.22916666666667
107640, 1.9083333333333, 1.6, 0.25
107641, 1.8875, 1.62, 0.25
107642, 1.9083333333333, 1.62, 0.22916666666667
107643, 1.9083333333333, 1.64, 0.25
107644, 1.8875, 1.66, 0.25
107645, 1.9083333333333, 1.66, 0.22916666666667
107646, 1.9083333333333, 1.68, 0.25
107647, 1.95, 1.52, 0.25
107648, 1.9291666666667, 1.54, 0.25
107649, 1.95, 1.54, 0.22916666666667
107650, 1.95, 1.56, 0.25
107651, 1.9291666666667, 1.58, 0.25
107652, 1.95, 1.58, 0.22916666666667
107653, 1.95, 1.6, 0.25
107654, 1.9291666666667, 1.62, 0.25
107655, 1.95, 1.62, 0.22916666666667
107656, 1.95, 1.64, 0.25
107657, 1.9291666666667, 1.66, 0.25
107658, 1.95, 1.66, 0.22916666666667
107659, 1.95, 1.68, 0.25
107660, 1.9916666666667, 1.52, 0.25
107661, 1.9708333333333, 1.54, 0.25
107662, 1.9916666666667, 1.54, 0.22916666666667
107663, 1.9916666666667, 1.56, 0.25
107664, 1.9708333333333, 1.58, 0.25
107665, 1.9916666666667, 1.58, 0.22916666666667
107666, 1.9916666666667, 1.6, 0.25
107667, 1.9708333333333, 1.62, 0.25
107668, 1.9916666666667, 1.62, 0.22916666666667
107669, 1.9916666666667, 1.64, 0.25
107670, 1.9708333333333, 1.66, 0.25
107671, 1.9916666666667, 1.66, 0.22916666666667
107672, 1.9916666666667, 1.68, 0.25
107673, 2.0333333333333, 1.52, 0.25
107674, 2.0125, 1.54, 0.25
107675, 2.0333333333333, 1.54, 0.22916666666667
107676, 2.0333333333333, 1.56, 0.25
107677, 2.0125, 1.58, 0.25
107678, 2.0333333333333, 1.58, 0.22916666666667
107679, 2.0333333333333, 1.6, 0.25
107680, 2.0125, 1.62, 0.25
107681, 2.0333333333333, 1.62, 0.22916666666667
107682, 2.0333333333333, 1.64, 0.25
107683, 2.0125, 1.66, 0.25
107684, 2.0333333333333, 1.66, 0.22916666666667
107685, 2.0333333333333, 1.68, 0.25
107686, 2.075, 1.52, 0.25
107687, 2.0541666666667, 1.54, 0.25
107688, 2.075, 1.54, 0.22916666666667
107689, 2.075, 1.56, 0.25
107690, 2.0541666666667, 1.58, 0.25
107691, 2.075, 1.58, 0.22916666666667
107692, 2.075, 1.6, 0.25
107693, 2.0541666666667, 1.62, 0.25
107694, 2.075, 1.62, 0.22916666666667
107695, 2.075, 1.64, 0.25
107696, 2.0541666666667, 1.66, 0.25
107697, 2.075, 1.66, 0.22916666666667
107698, 2.075, 1.68, 0.25
107699, 2.1166666666667, 1.52, 0.25
107700, 2.0958333333333, 1.54, 0.25
107701, 2.1166666666667, 1.54, 0.22916666666667
107702, 2.1166666666667, 1.56, 0.25
107703, 2.0958333333333, 1.58, 0.25
107704, 2.1166666666667, 1.58, 0.22916666666667
107705, 2.1166666666667, 1.6, 0.25
107706, 2.0958333333333, 1.62, 0.25
107707, 2.1166666666667, 1.62, 0.22916666666667
107708, 2.1166666666667, 1.64, 0.25
107709, 2.0958333333333, 1.66, 0.25
107710, 2.1166666666667, 1.66, 0.22916666666667
107711, 2.1166666666667, 1.68, 0.25
107712, 2.1583333333333, 1.52, 0.25
107713, 2.1375, 1.54, 0.25
107714, 2.1583333333333, 1.54, 0.22916666666667
107715, 2.1583333333333, 1.56, 0.25
107716, 2.1375, 1.58, 0.25
107717, 2.1583333333333, 1.58, 0.22916666666667
107718, 2.1583333333333, 1.6, 0.25
107719, 2.1375, 1.62, 0.25
107720, 2.1583333333333, 1.62, 0.22916666666667
107721, 2.1583333333333, 1.64, 0.25
107722, 2.1375, 1.66, 0.25
107723, 2.1583333333333, 1.66, 0.22916666666667
107724, 2.1583333333333, 1.68, 0.25
107725, 2.1791666666667, 1.54, 0.25
107726, 2.1791666666667, 1.58, 0.25
107727, 2.1791666666667, 1.62, 0.25
107728, 2.1791666666667, 1.66, 0.25
107729, 1.2416666666667, 1.52, 0.29166666666667
107730, 1.2208333333333, 1.54, 0.29166666666667
107731, 1.2416666666667, 1.54, 0.27083333333333
107732, 1.2416666666667, 1.56, 0.29166666666667
107733, 1.2208333333333, 1.58, 0.29166666666667
107734, 1.2416666666667, 1.58, 0.27083333333333
107735, 1.2416666666667, 1.6, 0.29166666666667
107736, 1.2208333333333, 1.62, 0.29166666666667
107737, 1.2416666666667, 1.62, 0.27083333333333
107738, 1.2416666666667, 1.64, 0.29166666666667
107739, 1.2208333333333, 1.66, 0.29166666666667
107740, 1.2416666666667, 1.66, 0.27083333333333
107741, 1.2416666666667, 1.68, 0.29166666666667
107742, 1.2833333333333, 1.52, 0.29166666666667
107743, 1.2625, 1.54, 0.29166666666667
107744, 1.2833333333333, 1.54, 0.27083333333333
107745, 1.2833333333333, 1.56, 0.29166666666667
107746, 1.2625, 1.58, 0.29166666666667
107747, 1.2833333333333, 1.58, 0.27083333333333
107748, 1.2833333333333, 1.6, 0.29166666666667
107749, 1.2625, 1.62, 0.29166666666667
107750, 1.2833333333333, 1.62, 0.27083333333333
107751, 1.2833333333333, 1.64, 0.29166666666667
107752, 1.2625, 1.66, 0.29166666666667
107753, 1.2833333333333, 1.66, 0.27083333333333
107754, 1.2833333333333, 1.68, 0.29166666666667
107755, 1.325, 1.52, 0.29166666666667
107756, 1.3041666666667, 1.54, 0.29166666666667
107757, 1.325, 1.54, 0.27083333333333
107758, 1.325, 1.56, 0.29166666666667
107759, 1.3041666666667, 1.58, 0.29166666666667
107760, 1.325, 1.58, 0.27083333333333
107761, 1.325, 1.6, 0.29166666666667
107762, 1.3041666666667, 1.62, 0.29166666666667
107763, 1.325, 1.62, 0.27083333333333
107764, 1.325, 1.64, 0.29166666666667
107765, 1.3041666666667, 1.66, 0.29166666666667
107766, 1.325, 1.66, 0.27083333333333
107767, 1.325, 1.68, 0.29166666666667
107768, 1.3666666666667, 1.52, 0.29166666666667
107769, 1.3458333333333, 1.54, 0.29166666666667
107770, 1.3666666666667, 1.54, 0.27083333333333
107771, 1.3666666666667, 1.56, 0.29166666666667
107772, 1.3458333333333, 1.58, 0.29166666666667
107773, 1.3666666666667, 1.58, 0.27083333333333
107774, 1.3666666666667, 1.6, 0.29166666666667
107775, 1.3458333333333, 1.62, 0.29166666666667
107776, 1.3666666666667, 1.62, 0.27083333333333
107777, 1.3666666666667, 1.64, 0.29166666666667
107778, 1.3458333333333, 1.66, 0.29166666666667
107779, 1.3666666666667, 1.66, 0.27083333333333
107780, 1.3666666666667, 1.68, 0.29166666666667
107781, 1.4083333333333, 1.52, 0.29166666666667
107782, 1.3875, 1.54, 0.29166666666667
107783, 1.4083333333333, 1.54, 0.27083333333333
107784, 1.4083333333333, 1.56, 0.29166666666667
107785, 1.3875, 1.58, 0.29166666666667
107786, 1.4083333333333, 1.58, 0.27083333333333
107787, 1.4083333333333, 1.6, 0.29166666666667
107788, 1.3875, 1.62, 0.29166666666667
107789, 1.4083333333333, 1.62, 0.27083333333333
107790, 1.4083333333333, 1.64, 0.29166666666667
107791, 1.3875, 1.66, 0.29166666666667
107792, 1.4083333333333, 1.66, 0.27083333333333
107793, 1.4083333333333, 1.68, 0.29166666666667
107794, 1.45, 1.52, 0.29166666666667
107795, 1.4291666666667, 1.54, 0.29166666666667
107796, 1.45, 1.54, 0.27083333333333
107797, 1.45, 1.56, 0.29166666666667
107798, 1.4291666666667, 1.58, 0.29166666666667
107799, 1.45, 1.58, 0.27083333333333
107800, 1.45, 1.6, 0.29166666666667
107801, 1.4291666666667, 1.62, 0.29166666666667
107802, 1.45, 1.62, 0.27083333333333
107803, 1.45, 1.64, 0.29166666666667
107804, 1.4291666666667, 1.66, 0.29166666666667
107805, 1.45, 1.66, 0.27083333333333
107806, 1.45, 1.68, 0.29166666666667
107807, 1.4916666666667, 1.52, 0.29166666666667
107808, 1.4708333333333, 1.54, 0.29166666666667
107809, 1.4916666666667, 1.54, 0.27083333333333
107810, 1.4916666666667, 1.56, 0.29166666666667
107811, 1.4708333333333, 1.58, 0.29166666666667
107812, 1.4916666666667, 1.58, 0.27083333333333
107813, 1.4916666666667, 1.6, 0.29166666666667
107814, 1.4708333333333, 1.62, 0.29166666666667
107815, 1.4916666666667, 1.62, 0.27083333333333
107816, 1.4916666666667, 1.64, 0.29166666666667
107817, 1.4708333333333, 1.66, 0.29166666666667
107818, 1.4916666666667, 1.66, 0.27083333333333
107819, 1.4916666666667, 1.68, 0.29166666666667
107820, 1.5333333333333, 1.52, 0.29166666666667
107821, 1.5125, 1.54, 0.29166666666667
107822, 1.5333333333333, 1.54, 0.27083333333333
107823, 1.5333333333333, 1.56, 0.29166666666667
107824, 1.5125, 1.58, 0.29166666666667
107825, 1.5333333333333, 1.58, 0.27083333333333
107826, 1.5333333333333, 1.6, 0.29166666666667
107827, 1.5125, 1.62, 0.29166666666667
107828, 1.5333333333333, 1.62, 0.27083333333333
107829, 1.5333333333333, 1.64, 0.29166666666667
107830, 1.5125, 1.66, 0.29166666666667
107831, 1.5333333333333, 1.66, 0.27083333333333
107832, 1.5333333333333, 1.68, 0.29166666666667
107833, 1.575, 1.52, 0.29166666666667
107834, 1.5541666666667, 1.54, 0.29166666666667
107835, 1.575, 1.54, 0.27083333333333
107836, 1.575, 1.56, 0.29166666666667
107837, 1.5541666666667, 1.58, 0.29166666666667
107838, 1.575, 1.58, 0.27083333333333
107839, 1.575, 1.6, 0.29166666666667
107840, 1.5541666666667, 1.62, 0.29166666666667
107841, 1.575, 1.62, 0.27083333333333
107842, 1.575, 1.64, 0.29166666666667
107843, 1.5541666666667, 1.66, 0.29166666666667
107844, 1.575, 1.66, 0.27083333333333
107845, 1.575, 1.68, 0.29166666666667
107846, 1.6166666666667, 1.52, 0.29166666666667
107847, 1.5958333333333, 1.54, 0.29166666666667
107848, 1.6166666666667, 1.54, 0.27083333333333
107849, 1.6166666666667, 1.56, 0.29166666666667
107850, 1.5958333333333, 1.58, 0.29166666666667
107851, 1.6166666666667, 1.58, 0.27083333333333
107852, 1.6166666666667, 1.6, 0.29166666666667
107853, 1.5958333333333, 1.62, 0.29166666666667
107854, 1.6166666666667, 1.62, 0.27083333333333
107855, 1.6166666666667, 1.64, 0.29166666666667
107856, 1.5958333333333, 1.66, 0.29166666666667
107857, 1.6166666666667, 1.66, 0.27083333333333
107858, 1.6166666666667, 1.68, 0.29166666666667
107859, 1.6583333333333, 1.52, 0.29166666666667
107860, 1.6375, 1.54, 0.29166666666667
107861, 1.6583333333333, 1.54, 0.27083333333333
107862, 1.6583333333333, 1.56, 0.29166666666667
107863, 1.6375, 1.58, 0.29166666666667
107864, 1.6583333333333, 1.58, 0.27083333333333
107865, 1.6583333333333, 1.6, 0.29166666666667
107866, 1.6375, 1.62, 0.29166666666667
107867, 1.6583333333333, 1.62, 0.27083333333333
107868, 1.6583333333333, 1.64, 0.29166666666667
107869, 1.6375, 1.66, 0.29166666666667
107870, 1.6583333333333, 1.66, 0.27083333333333
107871, 1.6583333333333, 1.68, 0.29166666666667
107872, 1.7, 1.52, 0.29166666666667
107873, 1.6791666666667, 1.54, 0.29166666666667
107874, 1.7, 1.54, 0.27083333333333
107875, 1.7, 1.56, 0.29166666666667
107876, 1.6791666666667, 1.58, 0.29166666666667
107877, 1.7, 1.58, 0.27083333333333
107878, 1.7, 1.6, 0.29166666666667
107879, 1.6791666666667, 1.62, 0.29166666666667
107880, 1.7, 1.62, 0.27083333333333
107881, 1.7, 1.64, 0.29166666666667
107882, 1.6791666666667, 1.66, 0.29166666666667
107883, 1.7, 1.66, 0.27083333333333
107884, 1.7, 1.68, 0.29166666666667
107885, 1.7416666666667, 1.52, 0.29166666666667
107886, 1.7208333333333, 1.54, 0.29166666666667
107887, 1.7416666666667, 1.54, 0.27083333333333
107888, 1.7416666666667, 1.56, 0.29166666666667
107889, 1.7208333333333, 1.58, 0.29166666666667
107890, 1.7416666666667, 1.58, 0.27083333333333
107891, 1.7416666666667, 1.6, 0.29166666666667
107892, 1.7208333333333, 1.62, 0.29166666666667
107893, 1.7416666666667, 1.62, 0.27083333333333
107894, 1.7416666666667, 1.64, 0.29166666666667
107895, 1.7208333333333, 1.66, 0.29166666666667
107896, 1.7416666666667, 1.66, 0.27083333333333
107897, 1.7416666666667, 1.68, 0.29166666666667
107898, 1.7833333333333, 1.52, 0.29166666666667
107899, 1.7625, 1.54, 0.29166666666667
107900, 1.7833333333333, 1.54, 0.27083333333333
107901, 1.7833333333333, 1.56, 0.29166666666667
107902, 1.7625, 1.58, 0.29166666666667
107903, 1.7833333333333, 1.58, 0.27083333333333
107904, 1.7833333333333, 1.6, 0.29166666666667
107905, 1.7625, 1.62, 0.29166666666667
107906, 1.7833333333333, 1.62, 0.27083333333333
107907, 1.7833333333333, 1.64, 0.29166666666667
107908, 1.7625, 1.66, 0.29166666666667
107909, 1.7833333333333, 1.66, 0.27083333333333
107910, 1.7833333333333, 1.68, 0.29166666666667
107911, 1.825, 1.52, 0.29166666666667
107912, 1.8041666666667, 1.54, 0.29166666666667
107913, 1.825, 1.54, 0.27083333333333
107914, 1.825, 1.56, 0.29166666666667
107915, 1.8041666666667, 1.58, 0.29166666666667
107916, 1.825, 1.58, 0.27083333333333
107917, 1.825, 1.6, 0.29166666666667
107918, 1.8041666666667, 1.62, 0.29166666666667
107919, 1.825, 1.62, 0.27083333333333
107920, 1.825, 1.64, 0.29166666666667
107921, 1.8041666666667, 1.66, 0.29166666666667
107922, 1.825, 1.66, 0.27083333333333
107923, 1.825, 1.68, 0.29166666666667
107924, 1.8666666666667, 1.52, 0.29166666666667
107925, 1.8458333333333, 1.54, 0.29166666666667
107926, 1.8666666666667, 1.54, 0.27083333333333
107927, 1.8666666666667, 1.56, 0.29166666666667
107928, 1.8458333333333, 1.58, 0.29166666666667
107929, 1.8666666666667, 1.58, 0.27083333333333
107930, 1.8666666666667, 1.6, 0.29166666666667
107931, 1.8458333333333, 1.62, 0.29166666666667
107932, 1.8666666666667, 1.62, 0.27083333333333
107933, 1.8666666666667, 1.64, 0.29166666666667
107934, 1.8458333333333, 1.66, 0.29166666666667
107935, 1.8666666666667, 1.66, 0.27083333333333
107936, 1.8666666666667, 1.68, 0.29166666666667
107937, 1.9083333333333, 1.52, 0.29166666666667
107938, 1.8875, 1.54, 0.29166666666667
107939, 1.9083333333333, 1.54, 0.27083333333333
107940, 1.9083333333333, 1.56, 0.29166666666667
107941, 1.8875, 1.58, 0.29166666666667
107942, 1.9083333333333, 1.58, 0.27083333333333
107943, 1.9083333333333, 1.6, 0.29166666666667
107944, 1.8875, 1.62, 0.29166666666667
107945, 1.9083333333333, 1.62, 0.27083333333333
107946, 1.9083333333333, 1.64, 0.29166666666667
107947, 1.8875, 1.66, 0.29166666666667
107948, 1.9083333333333, 1.66, 0.27083333333333
107949, 1.9083333333333, 1.68, 0.29166666666667
107950, 1.95, 1.52, 0.29166666666667
107951, 1.9291666666667, 1.54, 0.29166666666667
107952, 1.95, 1.54, 0.27083333333333
107953, 1.95, 1.56, 0.29166666666667
107954, 1.9291666666667, 1.58, 0.29166666666667
107955, 1.95, 1.58, 0.27083333333333
107956, 1.95, 1.6, 0.29166666666667
107957, 1.9291666666667, 1.62, 0.29166666666667
107958, 1.95, 1.62, 0.27083333333333
107959, 1.95, 1.64, 0.29166666666667
107960, 1.9291666666667, 1.66, 0.29166666666667
107961, 1.95, 1.66, 0.27083333333333
107962, 1.95, 1.68, 0.29166666666667
107963, 1.9916666666667, 1.52, 0.29166666666667
107964, 1.9708333333333, 1.54, 0.29166666666667
107965, 1.9916666666667, 1.54, 0.27083333333333
107966, 1.9916666666667, 1.56, 0.29166666666667
107967, 1.9708333333333, 1.58, 0.29166666666667
107968, 1.9916666666667, 1.58, 0.27083333333333
107969, 1.9916666666667, 1.6, 0.29166666666667
107970, 1.9708333333333, 1.62, 0.29166666666667
107971, 1.9916666666667, 1.62, 0.27083333333333
107972, 1.9916666666667, 1.64, 0.29166666666667
107973, 1.9708333333333, 1.66, 0.29166666666667
107974, 1.9916666666667, 1.66, 0.27083333333333
107975, 1.9916666666667, 1.68, 0.29166666666667
107976, 2.0333333333333, 1.52, 0.29166666666667
107977, 2.0125, 1.54, 0.29166666666667
107978, 2.0333333333333, 1.54, 0.27083333333333
107979, 2.0333333333333, 1.56, 0.29166666666667
107980, 2.0125, 1.58, 0.29166666666667
107981, 2.0333333333333, 1.58, 0.27083333333333
107982, 2.0333333333333, 1.6, 0.29166666666667
107983, 2.0125, 1.62, 0.29166666666667
107984, 2.0333333333333, 1.62, 0.27083333333333
107985, 2.0333333333333, 1.64, 0.29166666666667
107986, 2.0125, 1.66, 0.29166666666667
107987, 2.0333333333333, 1.66, 0.27083333333333
107988, 2.0333333333333, 1.68, 0.29166666666667
107989, 2.075, 1.52, 0.29166666666667
107990, 2.0541666666667, 1.54, 0.29166666666667
107991, 2.075, 1.54, 0.27083333333333
107992, 2.075, 1.56, 0.29166666666667
107993, 2.0541666666667, 1.58, 0.29166666666667
107994, 2.075, 1.58, 0.27083333333333
107995, 2.075, 1.6, 0.29166666666667
107996, 2.0541666666667, 1.62, 0.29166666666667
107997, 2.075, 1.62, 0.27083333333333
107998, 2.075, 1.64, 0.29166666666667
107999, 2.0541666666667, 1.66, 0.29166666666667
108000, 2.075, 1.66, 0.27083333333333
108001, 2.075, 1.68, 0.29166666666667
108002, 2.1166666666667, 1.52, 0.29166666666667
108003, 2.0958333333333, 1.54, 0.29166666666667
108004, 2.1166666666667, 1.54, 0.27083333333333
108005, 2.1166666666667, 1.56, 0.29166666666667
108006, 2.0958333333333, 1.58, 0.29166666666667
108007, 2.1166666666667, 1.58, 0.27083333333333
108008, 2.1166666666667, 1.6, 0.29166666666667
108009, 2.0958333333333, 1.62, 0.29166666666667
108010, 2.1166666666667, 1.62, 0.27083333333333
108011, 2.1166666666667, 1.64, 0.29166666666667
108012, 2.0958333333333, 1.66, 0.29166666666667
108013, 2.1166666666667, 1.66, 0.27083333333333
108014, 2.1166666666667, 1.68, 0.29166666666667
108015, 2.1583333333333, 1.52, 0.29166666666667
108016, 2.1375, 1.54, 0.29166666666667
108017, 2.1583333333333, 1.54, 0.27083333333333
108018, 2.1583333333333, 1.56, 0.29166666666667
108019, 2.1375, 1.58, 0.29166666666667
108020, 2.1583333333333, 1.58, 0.27083333333333
108021, 2.1583333333333, 1.6, 0.29166666666667
108022, 2.1375, 1.62, 0.29166666666667
108023, 2.1583333333333, 1.62, 0.27083333333333
108024, 2.1583333333333, 1.64, 0.29166666666667
108025, 2.1375, 1.66, 0.29166666666667
108026, 2.1583333333333, 1.66, 0.27083333333333
108027, 2.1583333333333, 1.68, 0.29166666666667
108028, 2.1791666666667, 1.54, 0.29166666666667
108029, 2.1791666666667, 1.58, 0.29166666666667
108030, 2.1791666666667, 1.62, 0.29166666666667
108031, 2.1791666666667, 1.66, 0.29166666666667
108032, 1.2416666666667, 1.52, 0.33333333333333
108033, 1.2208333333333, 1.54, 0.33333333333333
108034, 1.2416666666667, 1.54, 0.3125
108035, 1.2416666666667, 1.56, 0.33333333333333
108036, 1.2208333333333, 1.58, 0.33333333333333
108037, 1.2416666666667, 1.58, 0.3125
108038, 1.2416666666667, 1.6, 0.33333333333333
108039, 1.2208333333333, 1.62, 0.33333333333333
108040, 1.2416666666667, 1.62, 0.3125
108041, 1.2416666666667, 1.64, 0.33333333333333
108042, 1.2208333333333, 1.66, 0.33333333333333
108043, 1.2416666666667, 1.66, 0.3125
108044, 1.2416666666667, 1.68, 0.33333333333333
108045, 1.2833333333333, 1.52, 0.33333333333333
108046, 1.2625, 1.54, 0.33333333333333
108047, 1.2833333333333, 1.54, 0.3125
108048, 1.2833333333333, 1.56, 0.33333333333333
108049, 1.2625, 1.58, 0.33333333333333
108050, 1.2833333333333, 1.58, 0.3125
108051, 1.2833333333333, 1.6, 0.33333333333333
108052, 1.2625, 1.62, 0.33333333333333
108053, 1.2833333333333, 1.62, 0.3125
108054, 1.2833333333333, 1.64, 0.33333333333333
108055, 1.2625, 1.66, 0.33333333333333
108056, 1.2833333333333, 1.66, 0.3125
108057, 1.2833333333333, 1.68, 0.33333333333333
108058, 1.325, 1.52, 0.33333333333333
108059, 1.3041666666667, 1.54, 0.33333333333333
108060, 1.325, 1.54, 0.3125
108061, 1.325, 1.56, 0.33333333333333
108062, 1.3041666666667, 1.58, 0.33333333333333
108063, 1.325, 1.58, 0.3125
108064, 1.325, 1.6, 0.33333333333333
108065, 1.3041666666667, 1.62, 0.33333333333333
108066, 1.325, 1.62, 0.3125
108067, 1.325, 1.64, 0.33333333333333
108068, 1.3041666666667, 1.66, 0.33333333333333
108069, 1.325, 1.66, 0.3125
108070, 1.325, 1.68, 0.33333333333333
108071, 1.3666666666667, 1.52, 0.33333333333333
108072, 1.3458333333333, 1.54, 0.33333333333333
108073, 1.3666666666667, 1.54, 0.3125
108074, 1.3666666666667, 1.56, 0.33333333333333
108075, 1.3458333333333, 1.58, 0.33333333333333
108076, 1.3666666666667, 1.58, 0.3125
108077, 1.3666666666667, 1.6, 0.33333333333333
108078, 1.3458333333333, 1.62, 0.33333333333333
108079, 1.3666666666667, 1.62, 0.3125
108080, 1.3666666666667, 1.64, 0.33333333333333
108081, 1.3458333333333, 1.66, 0.33333333333333
108082, 1.3666666666667, 1.66, 0.3125
108083, 1.3666666666667, 1.68, 0.33333333333333
108084, 1.4083333333333, 1.52, 0.33333333333333
108085, 1.3875, 1.54, 0.33333333333333
108086, 1.4083333333333, 1.54, 0.3125
108087, 1.4083333333333, 1.56, 0.33333333333333
108088, 1.3875, 1.58, 0.33333333333333
108089, 1.4083333333333, 1.58, 0.3125
108090, 1.4083333333333, 1.6, 0.33333333333333
108091, 1.3875, 1.62, 0.33333333333333
108092, 1.4083333333333, 1.62, 0.3125
108093, 1.4083333333333, 1.64, 0.33333333333333
108094, 1.3875, 1.66, 0.33333333333333
108095, 1.4083333333333, 1.66, 0.3125
108096, 1.4083333333333, 1.68, 0.33333333333333
108097, 1.45, 1.52, 0.33333333333333
108098, 1.4291666666667, 1.54, 0.33333333333333
108099, 1.45, 1.54, 0.3125
108100, 1.45, 1.56, 0.33333333333333
108101, 1.4291666666667, 1.58, 0.33333333333333
108102, 1.45, 1.58, 0.3125
108103, 1.45, 1.6, 0.33333333333333
108104, 1.4291666666667, 1.62, 0.33333333333333
108105, 1.45, 1.62, 0.3125
108106, 1.45, 1.64, 0.33333333333333
108107, 1.4291666666667, 1.66, 0.33333333333333
108108, 1.45, 1.66, 0.3125
108109, 1.45, 1.68, 0.33333333333333
108110, 1.4916666666667, 1.52, 0.33333333333333
108111, 1.4708333333333, 1.54, 0.33333333333333
108112, 1.4916666666667, 1.54, 0.3125
108113, 1.4916666666667, 1.56, 0.33333333333333
108114, 1.4708333333333, 1.58, 0.33333333333333
108115, 1.4916666666667, 1.58, 0.3125
108116, 1.4916666666667, 1.6, 0.33333333333333
108117, 1.4708333333333, 1.62, 0.33333333333333
108118, 1.4916666666667, 1.62, 0.3125
108119, 1.4916666666667, 1.64, 0.33333333333333
108120, 1.4708333333333, 1.66, 0.33333333333333
108121, 1.4916666666667, 1.66, 0.3125
108122, 1.4916666666667, 1.68, 0.33333333333333
108123, 1.5333333333333, 1.52, 0.33333333333333
108124, 1.5125, 1.54, 0.33333333333333
108125, 1.5333333333333, 1.54, 0.3125
108126, 1.5333333333333, 1.56, 0.33333333333333
108127, 1.5125, 1.58, 0.33333333333333
108128, 1.5333333333333, 1.58, 0.3125
108129, 1.5333333333333, 1.6, 0.33333333333333
108130, 1.5125, 1.62, 0.33333333333333
108131, 1.5333333333333, 1.62, 0.3125
108132, 1.5333333333333, 1.64, 0.33333333333333
108133, 1.5125, 1.66, 0.33333333333333
108134, 1.5333333333333, 1.66, 0.3125
108135, 1.5333333333333, 1.68, 0.33333333333333
108136, 1.575, 1.52, 0.33333333333333
108137, 1.5541666666667, 1.54, 0.33333333333333
108138, 1.575, 1.54, 0.3125
108139, 1.575, 1.56, 0.33333333333333
108140, 1.5541666666667, 1.58, 0.33333333333333
108141, 1.575, 1.58, 0.3125
108142, 1.575, 1.6, 0.33333333333333
108143, 1.5541666666667, 1.62, 0.33333333333333
108144, 1.575, 1.62, 0.3125
108145, 1.575, 1.64, 0.33333333333333
108146, 1.5541666666667, 1.66, 0.33333333333333
108147, 1.575, 1.66, 0.3125
108148, 1.575, 1.68, 0.33333333333333
108149, 1.6166666666667, 1.52, 0.33333333333333
108150, 1.5958333333333, 1.54, 0.33333333333333
108151, 1.6166666666667, 1.54, 0.3125
108152, 1.6166666666667, 1.56, 0.33333333333333
108153, 1.5958333333333, 1.58, 0.33333333333333
108154, 1.6166666666667, 1.58, 0.3125
108155, 1.6166666666667, 1.6, 0.33333333333333
108156, 1.5958333333333, 1.62, 0.33333333333333
108157, 1.6166666666667, 1.62, 0.3125
108158, 1.6166666666667, 1.64, 0.33333333333333
108159, 1.5958333333333, 1.66, 0.33333333333333
108160, 1.6166666666667, 1.66, 0.3125
108161, 1.6166666666667, 1.68, 0.33333333333333
108162, 1.6583333333333, 1.52, 0.33333333333333
108163, 1.6375, 1.54, 0.33333333333333
108164, 1.6583333333333, 1.54, 0.3125
108165, 1.6583333333333, 1.56, 0.33333333333333
108166, 1.6375, 1.58, 0.33333333333333
108167, 1.6583333333333, 1.58, 0.3125
108168, 1.6583333333333, 1.6, 0.33333333333333
108169, 1.6375, 1.62, 0.33333333333333
108170, 1.6583333333333, 1.62, 0.3125
108171, 1.6583333333333, 1.64, 0.33333333333333
108172, 1.6375, 1.66, 0.33333333333333
108173, 1.6583333333333, 1.66, 0.3125
108174, 1.6583333333333, 1.68, 0.33333333333333
108175, 1.7, 1.52, 0.33333333333333
108176, 1.6791666666667, 1.54, 0.33333333333333
108177, 1.7, 1.54, 0.3125
108178, 1.7, 1.56, 0.33333333333333
108179, 1.6791666666667, 1.58, 0.33333333333333
108180, 1.7, 1.58, 0.3125
108181, 1.7, 1.6, 0.33333333333333
108182, 1.6791666666667, 1.62, 0.33333333333333
108183, 1.7, 1.62, 0.3125
108184, 1.7, 1.64, 0.33333333333333
108185, 1.6791666666667, 1.66, 0.33333333333333
108186, 1.7, 1.66, 0.3125
108187, 1.7, 1.68, 0.33333333333333
108188, 1.7416666666667, 1.52, 0.33333333333333
108189, 1.7208333333333, 1.54, 0.33333333333333
108190, 1.7416666666667, 1.54, 0.3125
108191, 1.7416666666667, 1.56, 0.33333333333333
108192, 1.7208333333333, 1.58, 0.33333333333333
108193, 1.7416666666667, 1.58, 0.3125
108194, 1.7416666666667, 1.6, 0.33333333333333
108195, 1.7208333333333, 1.62, 0.33333333333333
108196, 1.7416666666667, 1.62, 0.3125
108197, 1.7416666666667, 1.64, 0.33333333333333
108198, 1.7208333333333, 1.66, 0.33333333333333
108199, 1.7416666666667, 1.66, 0.3125
108200, 1.7416666666667, 1.68, 0.33333333333333
108201, 1.7833333333333, 1.52, 0.33333333333333
108202, 1.7625, 1.54, 0.33333333333333
108203, 1.7833333333333, 1.54, 0.3125
108204, 1.7833333333333, 1.56, 0.33333333333333
108205, 1.7625, 1.58, 0.33333333333333
108206, 1.7833333333333, 1.58, 0.3125
108207, 1.7833333333333, 1.6, 0.33333333333333
108208, 1.7625, 1.62, 0.33333333333333
108209, 1.7833333333333, 1.62, 0.3125
108210, 1.7833333333333, 1.64, 0.33333333333333
108211, 1.7625, 1.66, 0.33333333333333
108212, 1.7833333333333, 1.66, 0.3125
108213, 1.7833333333333, 1.68, 0.33333333333333
108214, 1.825, 1.52, 0.33333333333333
108215, 1.8041666666667, 1.54, 0.33333333333333
108216, 1.825, 1.54, 0.3125
108217, 1.825, 1.56, 0.33333333333333
108218, 1.8041666666667, 1.58, 0.33333333333333
108219, 1.825, 1.58, 0.3125
108220, 1.825, 1.6, 0.33333333333333
108221, 1.8041666666667, 1.62, 0.33333333333333
108222, 1.825, 1.62, 0.3125
108223, 1.825, 1.64, 0.33333333333333
108224, 1.8041666666667, 1.66, 0.33333333333333
108225, 1.825, 1.66, 0.3125
108226, 1.825, 1.68, 0.33333333333333
108227, 1.8666666666667, 1.52, 0.33333333333333
108228, 1.8458333333333, 1.54, 0.33333333333333
108229, 1.8666666666667, 1.54, 0.3125
108230, 1.8666666666667, 1.56, 0.33333333333333
108231, 1.8458333333333, 1.58, 0.33333333333333
108232, 1.8666666666667, 1.58, 0.3125
108233, 1.8666666666667, 1.6, 0.33333333333333
108234, 1.8458333333333, 1.62, 0.33333333333333
108235, 1.8666666666667, 1.62, 0.3125
108236, 1.8666666666667, 1.64, 0.33333333333333
108237, 1.8458333333333, 1.66, 0.33333333333333
108238, 1.8666666666667, 1.66, 0.3125
108239, 1.8666666666667, 1.68, 0.33333333333333
108240, 1.9083333333333, 1.52, 0.33333333333333
108241, 1.8875, 1.54, 0.33333333333333
108242, 1.9083333333333, 1.54, 0.3125
108243, 1.9083333333333, 1.56, 0.33333333333333
108244, 1.8875, 1.58, 0.33333333333333
108245, 1.9083333333333, 1.58, 0.3125
108246, 1.9083333333333, 1.6, 0.33333333333333
108247, 1.8875, 1.62, 0.33333333333333
108248, 1.9083333333333, 1.62, 0.3125
108249, 1.9083333333333, 1.64, 0.33333333333333
108250, 1.8875, 1.66, 0.33333333333333
108251, 1.9083333333333, 1.66, 0.3125
108252, 1.9083333333333, 1.68, 0.33333333333333
108253, 1.95, 1.52, 0.33333333333333
108254, 1.9291666666667, 1.54, 0.33333333333333
108255, 1.95, 1.54, 0.3125
108256, 1.95, 1.56, 0.33333333333333
108257, 1.9291666666667, 1.58, 0.33333333333333
108258, 1.95, 1.58, 0.3125
108259, 1.95, 1.6, 0.33333333333333
108260, 1.9291666666667, 1.62, 0.33333333333333
108261, 1.95, 1.62, 0.3125
108262, 1.95, 1.64, 0.33333333333333
108263, 1.9291666666667, 1.66, 0.33333333333333
108264, 1.95, 1.66, 0.3125
108265, 1.95, 1.68, 0.33333333333333
108266, 1.9916666666667, 1.52, 0.33333333333333
108267, 1.9708333333333, 1.54, 0.33333333333333
108268, 1.9916666666667, 1.54, 0.3125
108269, 1.9916666666667, 1.56, 0.33333333333333
108270, 1.9708333333333, 1.58, 0.33333333333333
108271, 1.9916666666667, 1.58, 0.3125
108272, 1.9916666666667, 1.6, 0.33333333333333
108273, 1.9708333333333, 1.62, 0.33333333333333
108274, 1.9916666666667, 1.62, 0.3125
108275, 1.9916666666667, 1.64, 0.33333333333333
108276, 1.9708333333333, 1.66, 0.33333333333333
108277, 1.9916666666667, 1.66, 0.3125
108278, 1.9916666666667, 1.68, 0.33333333333333
108279, 2.0333333333333, 1.52, 0.33333333333333
108280, 2.0125, 1.54, 0.33333333333333
108281, 2.0333333333333, 1.54, 0.3125
108282, 2.0333333333333, 1.56, 0.33333333333333
108283, 2.0125, 1.58, 0.33333333333333
108284, 2.0333333333333, 1.58, 0.3125
108285, 2.0333333333333, 1.6, 0.33333333333333
108286, 2.0125, 1.62, 0.33333333333333
108287, 2.0333333333333, 1.62, 0.3125
108288, 2.0333333333333, 1.64, 0.33333333333333
108289, 2.0125, 1.66, 0.33333333333333
108290, 2.0333333333333, 1.66, 0.3125
108291, 2.0333333333333, 1.68, 0.33333333333333
108292, 2.075, 1.52, 0.33333333333333
108293, 2.0541666666667, 1.54, 0.33333333333333
108294, 2.075, 1.54, 0.3125
108295, 2.075, 1.56, 0.33333333333333
108296, 2.0541666666667, 1.58, 0.33333333333333
108297, 2.075, 1.58, 0.3125
108298, 2.075, 1.6, 0.33333333333333
108299, 2.0541666666667, 1.62, 0.33333333333333
108300, 2.075, 1.62, 0.3125
108301, 2.075, 1.64, 0.33333333333333
108302, 2.0541666666667, 1.66, 0.33333333333333
108303, 2.075, 1.66, 0.3125
108304, 2.075, 1.68, 0.33333333333333
108305, 2.1166666666667, 1.52, 0.33333333333333
108306, 2.0958333333333, 1.54, 0.33333333333333
108307, 2.1166666666667, 1.54, 0.3125
108308, 2.1166666666667, 1.56, 0.33333333333333
108309, 2.0958333333333, 1.58, 0.33333333333333
108310, 2.1166666666667, 1.58, 0.3125
108311, 2.1166666666667, 1.6, 0.33333333333333
108312, 2.0958333333333, 1.62, 0.33333333333333
108313, 2.1166666666667, 1.62, 0.3125
108314, 2.1166666666667, 1.64, 0.33333333333333
108315, 2.0958333333333, 1.66, 0.33333333333333
108316, 2.1166666666667, 1.66, 0.3125
108317, 2.1166666666667, 1.68, 0.33333333333333
108318, 2.1583333333333, 1.52, 0.33333333333333
108319, 2.1375, 1.54, 0.33333333333333
108320, 2.1583333333333, 1.54, 0.3125
108321, 2.1583333333333, 1.56, 0.33333333333333
108322, 2.1375, 1.58, 0.33333333333333
108323, 2.1583333333333, 1.58, 0.3125
108324, 2.1583333333333, 1.6, 0.33333333333333
108325, 2.1375, 1.62, 0.33333333333333
108326, 2.1583333333333, 1.62, 0.3125
108327, 2.1583333333333, 1.64, 0.33333333333333
108328, 2.1375, 1.66, 0.33333333333333
108329, 2.1583333333333, 1.66, 0.3125
108330, 2.1583333333333, 1.68, 0.33333333333333
108331, 2.1791666666667, 1.54, 0.33333333333333
108332, 2.1791666666667, 1.58, 0.33333333333333
108333, 2.1791666666667, 1.62, 0.33333333333333
108334, 2.1791666666667, 1.66, 0.33333333333333
108335, 1.2416666666667, 1.52, 0.375
108336, 1.2208333333333, 1.54, 0.375
108337, 1.2416666666667, 1.54, 0.35416666666667
108338, 1.2416666666667, 1.56, 0.375
108339, 1.2208333333333, 1.58, 0.375
108340, 1.2416666666667, 1.58, 0.35416666666667
108341, 1.2416666666667, 1.6, 0.375
108342, 1.2208333333333, 1.62, 0.375
108343, 1.2416666666667, 1.62, 0.35416666666667
108344, 1.2416666666667, 1.64, 0.375
108345, 1.2208333333333, 1.66, 0.375
108346, 1.2416666666667, 1.66, 0.35416666666667
108347, 1.2416666666667, 1.68, 0.375
108348, 1.2833333333333, 1.52, 0.375
108349, 1.2625, 1.54, 0.375
108350, 1.2833333333333, 1.54, 0.35416666666667
108351, 1.2833333333333, 1.56, 0.375
108352, 1.2625, 1.58, 0.375
108353, 1.2833333333333, 1.58, 0.35416666666667
108354, 1.2833333333333, 1.6, 0.375
108355, 1.2625, 1.62, 0.375
108356, 1.2833333333333, 1.62, 0.35416666666667
108357, 1.2833333333333, 1.64, 0.375
108358, 1.2625, 1.66, 0.375
108359, 1.2833333333333, 1.66, 0.35416666666667
108360, 1.2833333333333, 1.68, 0.375
108361, 1.325, 1.52, 0.375
108362, 1.3041666666667, 1.54, 0.375
108363, 1.325, 1.54, 0.35416666666667
108364, 1.325, 1.56, 0.375
108365, 1.3041666666667, 1.58, 0.375
108366, 1.325, 1.58, 0.35416666666667
108367, 1.325, 1.6, 0.375
108368, 1.3041666666667, 1.62, 0.375
108369, 1.325, 1.62, 0.35416666666667
108370, 1.325, 1.64, 0.375
108371, 1.3041666666667, 1.66, 0.375
108372, 1.325, 1.66, 0.35416666666667
108373, 1.325, 1.68, 0.375
108374, 1.3666666666667, 1.52, 0.375
108375, 1.3458333333333, 1.54, 0.375
108376, 1.3666666666667, 1.54, 0.35416666666667
108377, 1.3666666666667, 1.56, 0.375
108378, 1.3458333333333, 1.58, 0.375
108379, 1.3666666666667, 1.58, 0.35416666666667
108380, 1.3666666666667, 1.6, 0.375
108381, 1.3458333333333, 1.62, 0.375
108382, 1.3666666666667, 1.62, 0.35416666666667
108383, 1.3666666666667, 1.64, 0.375
108384, 1.3458333333333, 1.66, 0.375
108385, 1.3666666666667, 1.66, 0.35416666666667
108386, 1.3666666666667, 1.68, 0.375
108387, 1.4083333333333, 1.52, 0.375
108388, 1.3875, 1.54, 0.375
108389, 1.4083333333333, 1.54, 0.35416666666667
108390, 1.4083333333333, 1.56, 0.375
108391, 1.3875, 1.58, 0.375
108392, 1.4083333333333, 1.58, 0.35416666666667
108393, 1.4083333333333, 1.6, 0.375
108394, 1.3875, 1.62, 0.375
108395, 1.4083333333333, 1.62, 0.35416666666667
108396, 1.4083333333333, 1.64, 0.375
108397, 1.3875, 1.66, 0.375
108398, 1.4083333333333, 1.66, 0.35416666666667
108399, 1.4083333333333, 1.68, 0.375
108400, 1.45, 1.52, 0.375
108401, 1.4291666666667, 1.54, 0.375
108402, 1.45, 1.54, 0.35416666666667
108403, 1.45, 1.56, 0.375
108404, 1.4291666666667, 1.58, 0.375
108405, 1.45, 1.58, 0.35416666666667
108406, 1.45, 1.6, 0.375
108407, 1.4291666666667, 1.62, 0.375
108408, 1.45, 1.62, 0.35416666666667
108409, 1.45, 1.64, 0.375
108410, 1.4291666666667, 1.66, 0.375
108411, 1.45, 1.66, 0.35416666666667
108412, 1.45, 1.68, 0.375
108413, 1.4916666666667, 1.52, 0.375
108414, 1.4708333333333, 1.54, 0.375
108415, 1.4916666666667, 1.54, 0.35416666666667
108416, 1.4916666666667, 1.56, 0.375
108417, 1.4708333333333, 1.58, 0.375
108418, 1.4916666666667, 1.58, 0.35416666666667
108419, 1.4916666666667, 1.6, 0.375
108420, 1.4708333333333, 1.62, 0.375
108421, 1.4916666666667, 1.62, 0.35416666666667
108422, 1.4916666666667, 1.64, 0.375
108423, 1.4708333333333, 1.66, 0.375
108424, 1.4916666666667, 1.66, 0.35416666666667
108425, 1.4916666666667, 1.68, 0.375
108426, 1.5333333333333, 1.52, 0.375
108427, 1.5125, 1.54, 0.375
108428, 1.5333333333333, 1.54, 0.35416666666667
108429, 1.5333333333333, 1.56, 0.375
108430, 1.5125, 1.58, 0.375
108431, 1.5333333333333, 1.58, 0.35416666666667
108432, 1.5333333333333, 1.6, 0.375
108433, 1.5125, 1.62, 0.375
108434, 1.5333333333333, 1.62, 0.35416666666667
108435, 1.5333333333333, 1.64, 0.375
108436, 1.5125, 1.66, 0.375
108437, 1.5333333333333, 1.66, 0.35416666666667
108438, 1.5333333333333, 1.68, 0.375
108439, 1.575, 1.52, 0.375
108440, 1.5541666666667, 1.54, 0.375
108441, 1.575, 1.54, 0.35416666666667
108442, 1.575, 1.56, 0.375
108443, 1.5541666666667, 1.58, 0.375
108444, 1.575, 1.58, 0.35416666666667
108445, 1.575, 1.6, 0.375
108446, 1.5541666666667, 1.62, 0.375
108447, 1.575, 1.62, 0.35416666666667
108448, 1.575, 1.64, 0.375
108449, 1.5541666666667, 1.66, 0.375
108450, 1.575, 1.66, 0.35416666666667
108451, 1.575, 1.68, 0.375
108452, 1.6166666666667, 1.52, 0.375
108453, 1.5958333333333, 1.54, 0.375
108454, 1.6166666666667, 1.54, 0.35416666666667
108455, 1.6166666666667, 1.56, 0.375
108456, 1.5958333333333, 1.58, 0.375
108457, 1.6166666666667, 1.58, 0.35416666666667
108458, 1.6166666666667, 1.6, 0.375
108459, 1.5958333333333, 1.62, 0.375
108460, 1.6166666666667, 1.62, 0.35416666666667
108461, 1.6166666666667, 1.64, 0.375
108462, 1.5958333333333, 1.66, 0.375
108463, 1.6166666666667, 1.66, 0.35416666666667
108464, 1.6166666666667, 1.68, 0.375
108465, 1.6583333333333, 1.52, 0.375
108466, 1.6375, 1.54, 0.375
108467, 1.6583333333333, 1.54, 0.35416666666667
108468, 1.6583333333333, 1.56, 0.375
108469, 1.6375, 1.58, 0.375
108470, 1.6583333333333, 1.58, 0.35416666666667
108471, 1.6583333333333, 1.6, 0.375
108472, 1.6375, 1.62, 0.375
108473, 1.6583333333333, 1.62, 0.35416666666667
108474, 1.6583333333333, 1.64, 0.375
108475, 1.6375, 1.66, 0.375
108476, 1.6583333333333, 1.66, 0.35416666666667
108477, 1.6583333333333, 1.68, 0.375
108478, 1.7, 1.52, 0.375
108479, 1.6791666666667, 1.54, 0.375
108480, 1.7, 1.54, 0.35416666666667
108481, 1.7, 1.56, 0.375
108482, 1.6791666666667, 1.58, 0.375
108483, 1.7, 1.58, 0.35416666666667
108484, 1.7, 1.6, 0.375
108485, 1.6791666666667, 1.62, 0.375
108486, 1.7, 1.62, 0.35416666666667
108487, 1.7, 1.64, 0.375
108488, 1.6791666666667, 1.66, 0.375
108489, 1.7, 1.66, 0.35416666666667
108490, 1.7, 1.68, 0.375
108491, 1.7416666666667, 1.52, 0.375
108492, 1.7208333333333, 1.54, 0.375
108493, 1.7416666666667, 1.54, 0.35416666666667
108494, 1.7416666666667, 1.56, 0.375
108495, 1.7208333333333, 1.58, 0.375
108496, 1.7416666666667, 1.58, 0.35416666666667
108497, 1.7416666666667, 1.6, 0.375
108498, 1.7208333333333, 1.62, 0.375
108499, 1.7416666666667, 1.62, 0.35416666666667
108500, 1.7416666666667, 1.64, 0.375
108501, 1.7208333333333, 1.66, 0.375
108502, 1.7416666666667, 1.66, 0.35416666666667
108503, 1.7416666666667, 1.68, 0.375
108504, 1.7833333333333, 1.52, 0.375
108505, 1.7625, 1.54, 0.375
108506, 1.7833333333333, 1.54, 0.35416666666667
108507, 1.7833333333333, 1.56, 0.375
108508, 1.7625, 1.58, 0.375
108509, 1.7833333333333, 1.58, 0.35416666666667
108510, 1.7833333333333, 1.6, 0.375
108511, 1.7625, 1.62, 0.375
108512, 1.7833333333333, 1.62, 0.35416666666667
108513, 1.7833333333333, 1.64, 0.375
108514, 1.7625, 1.66, 0.375
108515, 1.7833333333333, 1.66, 0.35416666666667
108516, 1.7833333333333, 1.68, 0.375
108517, 1.825, 1.52, 0.375
108518, 1.8041666666667, 1.54, 0.375
108519, 1.825, 1.54, 0.35416666666667
108520, 1.825, 1.56, 0.375
108521, 1.8041666666667, 1.58, 0.375
108522, 1.825, 1.58, 0.35416666666667
108523, 1.825, 1.6, 0.375
108524, 1.8041666666667, 1.62, 0.375
108525, 1.825, 1.62, 0.35416666666667
108526, 1.825, 1.64, 0.375
108527, 1.8041666666667, 1.66, 0.375
108528, 1.825, 1.66, 0.35416666666667
108529, 1.825, 1.68, 0.375
108530, 1.8666666666667, 1.52, 0.375
108531, 1.8458333333333, 1.54, 0.375
108532, 1.8666666666667, 1.54, 0.35416666666667
108533, 1.8666666666667, 1.56, 0.375
108534, 1.8458333333333, 1.58, 0.375
108535, 1.8666666666667, 1.58, 0.35416666666667
108536, 1.8666666666667, 1.6, 0.375
108537, 1.8458333333333, 1.62, 0.375
108538, 1.8666666666667, 1.62, 0.35416666666667
108539, 1.8666666666667, 1.64, 0.375
108540, 1.8458333333333, 1.66, 0.375
108541, 1.8666666666667, 1.66, 0.35416666666667
108542, 1.8666666666667, 1.68, 0.375
108543, 1.9083333333333, 1.52, 0.375
108544, 1.8875, 1.54, 0.375
108545, 1.9083333333333, 1.54, 0.35416666666667
108546, 1.9083333333333, 1.56, 0.375
108547, 1.8875, 1.58, 0.375
108548, 1.9083333333333, 1.58, 0.35416666666667
108549, 1.9083333333333, 1.6, 0.375
108550, 1.8875, 1.62, 0.375
108551, 1.9083333333333, 1.62, 0.35416666666667
108552, 1.9083333333333, 1.64, 0.375
108553, 1.8875, 1.66, 0.375
108554, 1.9083333333333, 1.66, 0.35416666666667
108555, 1.9083333333333, 1.68, 0.375
108556, 1.95, 1.52, 0.375
108557, 1.9291666666667, 1.54, 0.375
108558, 1.95, 1.54, 0.35416666666667
108559, 1.95, 1.56, 0.375
108560, 1.9291666666667, 1.58, 0.375
108561, 1.95, 1.58, 0.35416666666667
108562, 1.95, 1.6, 0.375
108563, 1.9291666666667, 1.62, 0.375
108564, 1.95, 1.62, 0.35416666666667
108565, 1.95, 1.64, 0.375
108566, 1.9291666666667, 1.66, 0.375
108567, 1.95, 1.66, 0.35416666666667
108568, 1.95, 1.68, 0.375
108569, 1.9916666666667, 1.52, 0.375
108570, 1.9708333333333, 1.54, 0.375
108571, 1.9916666666667, 1.54, 0.35416666666667
108572, 1.9916666666667, 1.56, 0.375
108573, 1.9708333333333, 1.58, 0.375
108574, 1.9916666666667, 1.58, 0.35416666666667
108575, 1.9916666666667, 1.6, 0.375
108576, 1.9708333333333, 1.62, 0.375
108577, 1.9916666666667, 1.62, 0.35416666666667
108578, 1.9916666666667, 1.64, 0.375
108579, 1.9708333333333, 1.66, 0.375
108580, 1.9916666666667, 1.66, 0.35416666666667
108581, 1.9916666666667, 1.68, 0.375
108582, 2.0333333333333, 1.52, 0.375
108583, 2.0125, 1.54, 0.375
108584, 2.0333333333333, 1.54, 0.35416666666667
108585, 2.0333333333333, 1.56, 0.375
108586, 2.0125, 1.58, 0.375
108587, 2.0333333333333, 1.58, 0.35416666666667
108588, 2.0333333333333, 1.6, 0.375
108589, 2.0125, 1.62, 0.375
108590, 2.0333333333333, 1.62, 0.35416666666667
108591, 2.0333333333333, 1.64, 0.375
108592, 2.0125, 1.66, 0.375
108593, 2.0333333333333, 1.66, 0.35416666666667
108594, 2.0333333333333, 1.68, 0.375
108595, 2.075, 1.52, 0.375
108596, 2.0541666666667, 1.54, 0.375
108597, 2.075, 1.54, 0.35416666666667
108598, 2.075, 1.56, 0.375
108599, 2.0541666666667, 1.58, 0.375
108600, 2.075, 1.58, 0.35416666666667
108601, 2.075, 1.6, 0.375
108602, 2.0541666666667, 1.62, 0.375
108603, 2.075, 1.62, 0.35416666666667
108604, 2.075, 1.64, 0.375
108605, 2.0541666666667, 1.66, 0.375
108606, 2.075, 1.66, 0.35416666666667
108607, 2.075, 1.68, 0.375
108608, 2.1166666666667, 1.52, 0.375
108609, 2.0958333333333, 1.54, 0.375
108610, 2.1166666666667, 1.54, 0.35416666666667
108611, 2.1166666666667, 1.56, 0.375
108612, 2.0958333333333, 1.58, 0.375
108613, 2.1166666666667, 1.58, 0.35416666666667
108614, 2.1166666666667, 1.6, 0.375
108615, 2.0958333333333, 1.62, 0.375
108616, 2.1166666666667, 1.62, 0.35416666666667
108617, 2.1166666666667, 1.64, 0.375
108618, 2.0958333333333, 1.66, 0.375
108619, 2.1166666666667, 1.66, 0.35416666666667
108620, 2.1166666666667, 1.68, 0.375
108621, 2.1583333333333, 1.52, 0.375
108622, 2.1375, 1.54, 0.375
108623, 2.1583333333333, 1.54, 0.35416666666667
108624, 2.1583333333333, 1.56, 0.375
108625, 2.1375, 1.58, 0.375
108626, 2.1583333333333, 1.58, 0.35416666666667
108627, 2.1583333333333, 1.6, 0.375
108628, 2.1375, 1.62, 0.375
108629, 2.1583333333333, 1.62, 0.35416666666667
108630, 2.1583333333333, 1.64, 0.375
108631, 2.1375, 1.66, 0.375
108632, 2.1583333333333, 1.66, 0.35416666666667
108633, 2.1583333333333, 1.68, 0.375
108634, 2.1791666666667, 1.54, 0.375
108635, 2.1791666666667, 1.58, 0.375
108636, 2.1791666666667, 1.62, 0.375
108637, 2.1791666666667, 1.66, 0.375
108638, 1.2416666666667, 1.52, 0.41666666666667
108639, 1.2208333333333, 1.54, 0.41666666666667
108640, 1.2416666666667, 1.54, 0.39583333333333
108641, 1.2416666666667, 1.56, 0.41666666666667
108642, 1.2208333333333, 1.58, 0.41666666666667
108643, 1.2416666666667, 1.58, 0.39583333333333
108644, 1.2416666666667, 1.6, 0.41666666666667
108645, 1.2208333333333, 1.62, 0.41666666666667
108646, 1.2416666666667, 1.62, 0.39583333333333
108647, 1.2416666666667, 1.64, 0.41666666666667
108648, 1.2208333333333, 1.66, 0.41666666666667
108649, 1.2416666666667, 1.66, 0.39583333333333
108650, 1.2416666666667, 1.68, 0.41666666666667
108651, 1.2833333333333, 1.52, 0.41666666666667
108652, 1.2625, 1.54, 0.41666666666667
108653, 1.2833333333333, 1.54, 0.39583333333333
108654, 1.2833333333333, 1.56, 0.41666666666667
108655, 1.2625, 1.58, 0.41666666666667
108656, 1.2833333333333, 1.58, 0.39583333333333
108657, 1.2833333333333, 1.6, 0.41666666666667
108658, 1.2625, 1.62, 0.41666666666667
108659, 1.2833333333333, 1.62, 0.39583333333333
108660, 1.2833333333333, 1.64, 0.41666666666667
108661, 1.2625, 1.66, 0.41666666666667
108662, 1.2833333333333, 1.66, 0.39583333333333
108663, 1.2833333333333, 1.68, 0.41666666666667
108664, 1.325, 1.52, 0.41666666666667
108665, 1.3041666666667, 1.54, 0.41666666666667
108666, 1.325, 1.54, 0.39583333333333
108667, 1.325, 1.56, 0.41666666666667
108668, 1.3041666666667, 1.58, 0.41666666666667
108669, 1.325, 1.58, 0.39583333333333
108670, 1.325, 1.6, 0.41666666666667
108671, 1.3041666666667, 1.62, 0.41666666666667
108672, 1.325, 1.62, 0.39583333333333
108673, 1.325, 1.64, 0.41666666666667
108674, 1.3041666666667, 1.66, 0.41666666666667
108675, 1.325, 1.66, 0.39583333333333
108676, 1.325, 1.68, 0.41666666666667
108677, 1.3666666666667, 1.52, 0.41666666666667
108678, 1.3458333333333, 1.54, 0.41666666666667
108679, 1.3666666666667, 1.54, 0.39583333333333
108680, 1.3666666666667, 1.56, 0.41666666666667
108681, 1.3458333333333, 1.58, 0.41666666666667
108682, 1.3666666666667, 1.58, 0.39583333333333
108683, 1.3666666666667, 1.6, 0.41666666666667
108684, 1.3458333333333, 1.62, 0.41666666666667
108685, 1.3666666666667, 1.62, 0.39583333333333
108686, 1.3666666666667, 1.64, 0.41666666666667
108687, 1.3458333333333, 1.66, 0.41666666666667
108688, 1.3666666666667, 1.66, 0.39583333333333
108689, 1.3666666666667, 1.68, 0.41666666666667
108690, 1.4083333333333, 1.52, 0.41666666666667
108691, 1.3875, 1.54, 0.41666666666667
108692, 1.4083333333333, 1.54, 0.39583333333333
108693, 1.4083333333333, 1.56, 0.41666666666667
108694, 1.3875, 1.58, 0.41666666666667
108695, 1.4083333333333, 1.58, 0.39583333333333
108696, 1.4083333333333, 1.6, 0.41666666666667
108697, 1.3875, 1.62, 0.41666666666667
108698, 1.4083333333333, 1.62, 0.39583333333333
108699, 1.4083333333333, 1.64, 0.41666666666667
108700, 1.3875, 1.66, 0.41666666666667
108701, 1.4083333333333, 1.66, 0.39583333333333
108702, 1.4083333333333, 1.68, 0.41666666666667
108703, 1.45, 1.52, 0.41666666666667
108704, 1.4291666666667, 1.54, 0.41666666666667
108705, 1.45, 1.54, 0.39583333333333
108706, 1.45, 1.56, 0.41666666666667
108707, 1.4291666666667, 1.58, 0.41666666666667
108708, 1.45, 1.58, 0.39583333333333
108709, 1.45, 1.6, 0.41666666666667
108710, 1.4291666666667, 1.62, 0.41666666666667
108711, 1.45, 1.62, 0.39583333333333
108712, 1.45, 1.64, 0.41666666666667
108713, 1.4291666666667, 1.66, 0.41666666666667
108714, 1.45, 1.66, 0.39583333333333
108715, 1.45, 1.68, 0.41666666666667
108716, 1.4916666666667, 1.52, 0.41666666666667
108717, 1.4708333333333, 1.54, 0.41666666666667
108718, 1.4916666666667, 1.54, 0.39583333333333
108719, 1.4916666666667, 1.56, 0.41666666666667
108720, 1.4708333333333, 1.58, 0.41666666666667
108721, 1.4916666666667, 1.58, 0.39583333333333
108722, 1.4916666666667, 1.6, 0.41666666666667
108723, 1.4708333333333, 1.62, 0.41666666666667
108724, 1.4916666666667, 1.62, 0.39583333333333
108725, 1.4916666666667, 1.64, 0.41666666666667
108726, 1.4708333333333, 1.66, 0.41666666666667
108727, 1.4916666666667, 1.66, 0.39583333333333
108728, 1.4916666666667, 1.68, 0.41666666666667
108729, 1.5333333333333, 1.52, 0.41666666666667
108730, 1.5125, 1.54, 0.41666666666667
108731, 1.5333333333333, 1.54, 0.39583333333333
108732, 1.5333333333333, 1.56, 0.41666666666667
108733, 1.5125, 1.58, 0.41666666666667
108734, 1.5333333333333, 1.58, 0.39583333333333
108735, 1.5333333333333, 1.6, 0.41666666666667
108736, 1.5125, 1.62, 0.41666666666667
108737, 1.5333333333333, 1.62, 0.39583333333333
108738, 1.5333333333333, 1.64, 0.41666666666667
108739, 1.5125, 1.66, 0.41666666666667
108740, 1.5333333333333, 1.66, 0.39583333333333
108741, 1.5333333333333, 1.68, 0.41666666666667
108742, 1.575, 1.52, 0.41666666666667
108743, 1.5541666666667, 1.54, 0.41666666666667
108744, 1.575, 1.54, 0.39583333333333
108745, 1.575, 1.56, 0.41666666666667
108746, 1.5541666666667, 1.58, 0.41666666666667
108747, 1.575, 1.58, 0.39583333333333
108748, 1.575, 1.6, 0.41666666666667
108749, 1.5541666666667, 1.62, 0.41666666666667
108750, 1.575, 1.62, 0.39583333333333
108751, 1.575, 1.64, 0.41666666666667
108752, 1.5541666666667, 1.66, 0.41666666666667
108753, 1.575, 1.66, 0.39583333333333
108754, 1.575, 1.68, 0.41666666666667
108755, 1.6166666666667, 1.52, 0.41666666666667
108756, 1.5958333333333, 1.54, 0.41666666666667
108757, 1.6166666666667, 1.54, 0.39583333333333
108758, 1.6166666666667, 1.56, 0.41666666666667
108759, 1.5958333333333, 1.58, 0.41666666666667
108760, 1.6166666666667, 1.58, 0.39583333333333
108761, 1.6166666666667, 1.6, 0.41666666666667
108762, 1.5958333333333, 1.62, 0.41666666666667
108763, 1.6166666666667, 1.62, 0.39583333333333
108764, 1.6166666666667, 1.64, 0.41666666666667
108765, 1.5958333333333, 1.66, 0.41666666666667
108766, 1.6166666666667, 1.66, 0.39583333333333
108767, 1.6166666666667, 1.68, 0.41666666666667
108768, 1.6583333333333, 1.52, 0.41666666666667
108769, 1.6375, 1.54, 0.41666666666667
108770, 1.6583333333333, 1.54, 0.39583333333333
108771, 1.6583333333333, 1.56, 0.41666666666667
108772, 1.6375, 1.58, 0.41666666666667
108773, 1.6583333333333, 1.58, 0.39583333333333
108774, 1.6583333333333, 1.6, 0.41666666666667
108775, 1.6375, 1.62, 0.41666666666667
108776, 1.6583333333333, 1.62, 0.39583333333333
108777, 1.6583333333333, 1.64, 0.41666666666667
108778, 1.6375, 1.66, 0.41666666666667
108779, 1.6583333333333, 1.66, 0.39583333333333
108780, 1.6583333333333, 1.68, 0.41666666666667
108781, 1.7, 1.52, 0.41666666666667
108782, 1.6791666666667, 1.54, 0.41666666666667
108783, 1.7, 1.54, 0.39583333333333
108784, 1.7, 1.56, 0.41666666666667
108785, 1.6791666666667, 1.58, 0.41666666666667
108786, 1.7, 1.58, 0.39583333333333
108787, 1.7, 1.6, 0.41666666666667
108788, 1.6791666666667, 1.62, 0.41666666666667
108789, 1.7, 1.62, 0.39583333333333
108790, 1.7, 1.64, 0.41666666666667
108791, 1.6791666666667, 1.66, 0.41666666666667
108792, 1.7, 1.66, 0.39583333333333
108793, 1.7, 1.68, 0.41666666666667
108794, 1.7416666666667, 1.52, 0.41666666666667
108795, 1.7208333333333, 1.54, 0.41666666666667
108796, 1.7416666666667, 1.54, 0.39583333333333
108797, 1.7416666666667, 1.56, 0.41666666666667
108798, 1.7208333333333, 1.58, 0.41666666666667
108799, 1.7416666666667, 1.58, 0.39583333333333
108800, 1.7416666666667, 1.6, 0.41666666666667
108801, 1.7208333333333, 1.62, 0.41666666666667
108802, 1.7416666666667, 1.62, 0.39583333333333
108803, 1.7416666666667, 1.64, 0.41666666666667
108804, 1.7208333333333, 1.66, 0.41666666666667
108805, 1.7416666666667, 1.66, 0.39583333333333
108806, 1.7416666666667, 1.68, 0.41666666666667
108807, 1.7833333333333, 1.52, 0.41666666666667
108808, 1.7625, 1.54, 0.41666666666667
108809, 1.7833333333333, 1.54, 0.39583333333333
108810, 1.7833333333333, 1.56, 0.41666666666667
108811, 1.7625, 1.58, 0.41666666666667
108812, 1.7833333333333, 1.58, 0.39583333333333
108813, 1.7833333333333, 1.6, 0.41666666666667
108814, 1.7625, 1.62, 0.41666666666667
108815, 1.7833333333333, 1.62, 0.39583333333333
108816, 1.7833333333333, 1.64, 0.41666666666667
108817, 1.7625, 1.66, 0.41666666666667
108818, 1.7833333333333, 1.66, 0.39583333333333
108819, 1.7833333333333, 1.68, 0.41666666666667
108820, 1.825, 1.52, 0.41666666666667
108821, 1.8041666666667, 1.54, 0.41666666666667
108822, 1.825, 1.54, 0.39583333333333
108823, 1.825, 1.56, 0.41666666666667
108824, 1.8041666666667, 1.58, 0.41666666666667
108825, 1.825, 1.58, 0.39583333333333
108826, 1.825, 1.6, 0.41666666666667
108827, 1.8041666666667, 1.62, 0.41666666666667
108828, 1.825, 1.62, 0.39583333333333
108829, 1.825, 1.64, 0.41666666666667
108830, 1.8041666666667, 1.66, 0.41666666666667
108831, 1.825, 1.66, 0.39583333333333
108832, 1.825, 1.68, 0.41666666666667
108833, 1.8666666666667, 1.52, 0.41666666666667
108834, 1.8458333333333, 1.54, 0.41666666666667
108835, 1.8666666666667, 1.54, 0.39583333333333
108836, 1.8666666666667, 1.56, 0.41666666666667
108837, 1.8458333333333, 1.58, 0.41666666666667
108838, 1.8666666666667, 1.58, 0.39583333333333
108839, 1.8666666666667, 1.6, 0.41666666666667
108840, 1.8458333333333, 1.62, 0.41666666666667
108841, 1.8666666666667, 1.62, 0.39583333333333
108842, 1.8666666666667, 1.64, 0.41666666666667
108843, 1.8458333333333, 1.66, 0.41666666666667
108844, 1.8666666666667, 1.66, 0.39583333333333
108845, 1.8666666666667, 1.68, 0.41666666666667
108846, 1.9083333333333, 1.52, 0.41666666666667
108847, 1.8875, 1.54, 0.41666666666667
108848, 1.9083333333333, 1.54, 0.39583333333333
108849, 1.9083333333333, 1.56, 0.41666666666667
108850, 1.8875, 1.58, 0.41666666666667
108851, 1.9083333333333, 1.58, 0.39583333333333
108852, 1.9083333333333, 1.6, 0.41666666666667
108853, 1.8875, 1.62, 0.41666666666667
108854, 1.9083333333333, 1.62, 0.39583333333333
108855, 1.9083333333333, 1.64, 0.41666666666667
108856, 1.8875, 1.66, 0.41666666666667
108857, 1.9083333333333, 1.66, 0.39583333333333
108858, 1.9083333333333, 1.68, 0.41666666666667
108859, 1.95, 1.52, 0.41666666666667
108860, 1.9291666666667, 1.54, 0.41666666666667
108861, 1.95, 1.54, 0.39583333333333
108862, 1.95, 1.56, 0.41666666666667
108863, 1.9291666666667, 1.58, 0.41666666666667
108864, 1.95, 1.58, 0.39583333333333
108865, 1.95, 1.6, 0.41666666666667
108866, 1.9291666666667, 1.62, 0.41666666666667
108867, 1.95, 1.62, 0.39583333333333
108868, 1.95, 1.64, 0.41666666666667
108869, 1.9291666666667, 1.66, 0.41666666666667
108870, 1.95, 1.66, 0.39583333333333
108871, 1.95, 1.68, 0.41666666666667
108872, 1.9916666666667, 1.52, 0.41666666666667
108873, 1.9708333333333, 1.54, 0.41666666666667
108874, 1.9916666666667, 1.54, 0.39583333333333
108875, 1.9916666666667, 1.56, 0.41666666666667
108876, 1.9708333333333, 1.58, 0.41666666666667
108877, 1.9916666666667, 1.58, 0.39583333333333
108878, 1.9916666666667, 1.6, 0.41666666666667
108879, 1.9708333333333, 1.62, 0.41666666666667
108880, 1.9916666666667, 1.62, 0.39583333333333
108881, 1.9916666666667, 1.64, 0.41666666666667
108882, 1.9708333333333, 1.66, 0.41666666666667
108883, 1.9916666666667, 1.66, 0.39583333333333
108884, 1.9916666666667, 1.68, 0.41666666666667
108885, 2.0333333333333, 1.52, 0.41666666666667
108886, 2.0125, 1.54, 0.41666666666667
108887, 2.0333333333333, 1.54, 0.39583333333333
108888, 2.0333333333333, 1.56, 0.41666666666667
108889, 2.0125, 1.58, 0.41666666666667
108890, 2.0333333333333, 1.58, 0.39583333333333
108891, 2.0333333333333, 1.6, 0.41666666666667
108892, 2.0125, 1.62, 0.41666666666667
108893, 2.0333333333333, 1.62, 0.39583333333333
108894, 2.0333333333333, 1.64, 0.41666666666667
108895, 2.0125, 1.66, 0.41666666666667
108896, 2.0333333333333, 1.66, 0.39583333333333
108897, 2.0333333333333, 1.68, 0.41666666666667
108898, 2.075, 1.52, 0.41666666666667
108899, 2.0541666666667, 1.54, 0.41666666666667
108900, 2.075, 1.54, 0.39583333333333
108901, 2.075, 1.56, 0.41666666666667
108902, 2.0541666666667, 1.58, 0.41666666666667
108903, 2.075, 1.58, 0.39583333333333
108904, 2.075, 1.6, 0.41666666666667
108905, 2.0541666666667, 1.62, 0.41666666666667
108906, 2.075, 1.62, 0.39583333333333
108907, 2.075, 1.64, 0.41666666666667
108908, 2.0541666666667, 1.66, 0.41666666666667
108909, 2.075, 1.66, 0.39583333333333
108910, 2.075, 1.68, 0.41666666666667
108911, 2.1166666666667, 1.52, 0.41666666666667
108912, 2.0958333333333, 1.54, 0.41666666666667
108913, 2.1166666666667, 1.54, 0.39583333333333
108914, 2.1166666666667, 1.56, 0.41666666666667
108915, 2.0958333333333, 1.58, 0.41666666666667
108916, 2.1166666666667, 1.58, 0.39583333333333
108917, 2.1166666666667, 1.6, 0.41666666666667
108918, 2.0958333333333, 1.62, 0.41666666666667
108919, 2.1166666666667, 1.62, 0.39583333333333
108920, 2.1166666666667, 1.64, 0.41666666666667
108921, 2.0958333333333, 1.66, 0.41666666666667
108922, 2.1166666666667, 1.66, 0.39583333333333
108923, 2.1166666666667, 1.68, 0.41666666666667
108924, 2.1583333333333, 1.52, 0.41666666666667
108925, 2.1375, 1.54, 0.41666666666667
108926, 2.1583333333333, 1.54, 0.39583333333333
108927, 2.1583333333333, 1.56, 0.41666666666667
108928, 2.1375, 1.58, 0.41666666666667
108929, 2.1583333333333, 1.58, 0.39583333333333
108930, 2.1583333333333, 1.6, 0.41666666666667
108931, 2.1375, 1.62, 0.41666666666667
108932, 2.1583333333333, 1.62, 0.39583333333333
108933, 2.1583333333333, 1.64, 0.41666666666667
108934, 2.1375, 1.66, 0.41666666666667
108935, 2.1583333333333, 1.66, 0.39583333333333
108936, 2.1583333333333, 1.68, 0.41666666666667
108937, 2.1791666666667, 1.54, 0.41666666666667
108938, 2.1791666666667, 1.58, 0.41666666666667
108939, 2.1791666666667, 1.62, 0.41666666666667
108940, 2.1791666666667, 1.66, 0.41666666666667
108941, 1.2416666666667, 1.52, 0.45833333333333
108942, 1.2208333333333, 1.54, 0.45833333333333
108943, 1.2416666666667, 1.54, 0.4375
108944, 1.2416666666667, 1.56, 0.45833333333333
108945, 1.2208333333333, 1.58, 0.45833333333333
108946, 1.2416666666667, 1.58, 0.4375
108947, 1.2416666666667, 1.6, 0.45833333333333
108948, 1.2208333333333, 1.62, 0.45833333333333
108949, 1.2416666666667, 1.62, 0.4375
108950, 1.2416666666667, 1.64, 0.45833333333333
108951, 1.2208333333333, 1.66, 0.45833333333333
108952, 1.2416666666667, 1.66, 0.4375
108953, 1.2416666666667, 1.68, 0.45833333333333
108954, 1.2833333333333, 1.52, 0.45833333333333
108955, 1.2625, 1.54, 0.45833333333333
108956, 1.2833333333333, 1.54, 0.4375
108957, 1.2833333333333, 1.56, 0.45833333333333
108958, 1.2625, 1.58, 0.45833333333333
108959, 1.2833333333333, 1.58, 0.4375
108960, 1.2833333333333, 1.6, 0.45833333333333
108961, 1.2625, 1.62, 0.45833333333333
108962, 1.2833333333333, 1.62, 0.4375
108963, 1.2833333333333, 1.64, 0.45833333333333
108964, 1.2625, 1.66, 0.45833333333333
108965, 1.2833333333333, 1.66, 0.4375
108966, 1.2833333333333, 1.68, 0.45833333333333
108967, 1.325, 1.52, 0.45833333333333
108968, 1.3041666666667, 1.54, 0.45833333333333
108969, 1.325, 1.54, 0.4375
108970, 1.325, 1.56, 0.45833333333333
108971, 1.3041666666667, 1.58, 0.45833333333333
108972, 1.325, 1.58, 0.4375
108973, 1.325, 1.6, 0.45833333333333
108974, 1.3041666666667, 1.62, 0.45833333333333
108975, 1.325, 1.62, 0.4375
108976, 1.325, 1.64, 0.45833333333333
108977, 1.3041666666667, 1.66, 0.45833333333333
108978, 1.325, 1.66, 0.4375
108979, 1.325, 1.68, 0.45833333333333
108980, 1.3666666666667, 1.52, 0.45833333333333
108981, 1.3458333333333, 1.54, 0.45833333333333
108982, 1.3666666666667, 1.54, 0.4375
108983, 1.3666666666667, 1.56, 0.45833333333333
108984, 1.3458333333333, 1.58, 0.45833333333333
108985, 1.3666666666667, 1.58, 0.4375
108986, 1.3666666666667, 1.6, 0.45833333333333
108987, 1.3458333333333, 1.62, 0.45833333333333
108988, 1.3666666666667, 1.62, 0.4375
108989, 1.3666666666667, 1.64, 0.45833333333333
108990, 1.3458333333333, 1.66, 0.45833333333333
108991, 1.3666666666667, 1.66, 0.4375
108992, 1.3666666666667, 1.68, 0.45833333333333
108993, 1.4083333333333, 1.52, 0.45833333333333
108994, 1.3875, 1.54, 0.45833333333333
108995, 1.4083333333333, 1.54, 0.4375
108996, 1.4083333333333, 1.56, 0.45833333333333
