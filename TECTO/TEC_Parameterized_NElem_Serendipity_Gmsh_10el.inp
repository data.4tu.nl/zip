79913, 1.9916666666667, 0.25, 0.0625
79914, 1.9708333333333, 0.25, 0.083333333333333
79915, 1.9916666666667, 0.225, 0.083333333333333
79916, 1.9916666666667, 0.2, 0.0625
79917, 1.9708333333333, 0.2, 0.083333333333333
79918, 1.9916666666667, 0.175, 0.083333333333333
79919, 2.0333333333333, 1.325, 0.083333333333333
79920, 2.0333333333333, 1.3, 0.0625
79921, 2.0125, 1.3, 0.083333333333333
79922, 2.0333333333333, 1.275, 0.083333333333333
79923, 2.0333333333333, 1.25, 0.0625
79924, 2.0125, 1.25, 0.083333333333333
79925, 2.0333333333333, 1.225, 0.083333333333333
79926, 2.0333333333333, 1.2, 0.0625
79927, 2.0125, 1.2, 0.083333333333333
79928, 2.0333333333333, 1.175, 0.083333333333333
79929, 2.0333333333333, 1.15, 0.0625
79930, 2.0125, 1.15, 0.083333333333333
79931, 2.0333333333333, 1.125, 0.083333333333333
79932, 2.0333333333333, 1.1, 0.0625
79933, 2.0125, 1.1, 0.083333333333333
79934, 2.0333333333333, 1.075, 0.083333333333333
79935, 2.0333333333333, 1.05, 0.0625
79936, 2.0125, 1.05, 0.083333333333333
79937, 2.0333333333333, 1.025, 0.083333333333333
79938, 2.0333333333333, 1, 0.0625
79939, 2.0125, 1, 0.083333333333333
79940, 2.0333333333333, 0.975, 0.083333333333333
79941, 2.0333333333333, 0.95, 0.0625
79942, 2.0125, 0.95, 0.083333333333333
79943, 2.0333333333333, 0.925, 0.083333333333333
79944, 2.0333333333333, 0.9, 0.0625
79945, 2.0125, 0.9, 0.083333333333333
79946, 2.0333333333333, 0.875, 0.083333333333333
79947, 2.0333333333333, 0.85, 0.0625
79948, 2.0125, 0.85, 0.083333333333333
79949, 2.0333333333333, 0.825, 0.083333333333333
79950, 2.0333333333333, 0.8, 0.0625
79951, 2.0125, 0.8, 0.083333333333333
79952, 2.0333333333333, 0.775, 0.083333333333333
79953, 2.0333333333333, 0.75, 0.0625
79954, 2.0125, 0.75, 0.083333333333333
79955, 2.0333333333333, 0.725, 0.083333333333333
79956, 2.0333333333333, 0.7, 0.0625
79957, 2.0125, 0.7, 0.083333333333333
79958, 2.0333333333333, 0.675, 0.083333333333333
79959, 2.0333333333333, 0.65, 0.0625
79960, 2.0125, 0.65, 0.083333333333333
79961, 2.0333333333333, 0.625, 0.083333333333333
79962, 2.0333333333333, 0.6, 0.0625
79963, 2.0125, 0.6, 0.083333333333333
79964, 2.0333333333333, 0.575, 0.083333333333333
79965, 2.0333333333333, 0.55, 0.0625
79966, 2.0125, 0.55, 0.083333333333333
79967, 2.0333333333333, 0.525, 0.083333333333333
79968, 2.0333333333333, 0.5, 0.0625
79969, 2.0125, 0.5, 0.083333333333333
79970, 2.0333333333333, 0.475, 0.083333333333333
79971, 2.0333333333333, 0.45, 0.0625
79972, 2.0125, 0.45, 0.083333333333333
79973, 2.0333333333333, 0.425, 0.083333333333333
79974, 2.0333333333333, 0.4, 0.0625
79975, 2.0125, 0.4, 0.083333333333333
79976, 2.0333333333333, 0.375, 0.083333333333333
79977, 2.0333333333333, 0.35, 0.0625
79978, 2.0125, 0.35, 0.083333333333333
79979, 2.0333333333333, 0.325, 0.083333333333333
79980, 2.0333333333333, 0.3, 0.0625
79981, 2.0125, 0.3, 0.083333333333333
79982, 2.0333333333333, 0.275, 0.083333333333333
79983, 2.0333333333333, 0.25, 0.0625
79984, 2.0125, 0.25, 0.083333333333333
79985, 2.0333333333333, 0.225, 0.083333333333333
79986, 2.0333333333333, 0.2, 0.0625
79987, 2.0125, 0.2, 0.083333333333333
79988, 2.0333333333333, 0.175, 0.083333333333333
79989, 2.075, 1.325, 0.083333333333333
79990, 2.075, 1.3, 0.0625
79991, 2.0541666666667, 1.3, 0.083333333333333
79992, 2.075, 1.275, 0.083333333333333
79993, 2.075, 1.25, 0.0625
79994, 2.0541666666667, 1.25, 0.083333333333333
79995, 2.075, 1.225, 0.083333333333333
79996, 2.075, 1.2, 0.0625
79997, 2.0541666666667, 1.2, 0.083333333333333
79998, 2.075, 1.175, 0.083333333333333
79999, 2.075, 1.15, 0.0625
80000, 2.0541666666667, 1.15, 0.083333333333333
80001, 2.075, 1.125, 0.083333333333333
80002, 2.075, 1.1, 0.0625
80003, 2.0541666666667, 1.1, 0.083333333333333
80004, 2.075, 1.075, 0.083333333333333
80005, 2.075, 1.05, 0.0625
80006, 2.0541666666667, 1.05, 0.083333333333333
80007, 2.075, 1.025, 0.083333333333333
80008, 2.075, 1, 0.0625
80009, 2.0541666666667, 1, 0.083333333333333
80010, 2.075, 0.975, 0.083333333333333
80011, 2.075, 0.95, 0.0625
80012, 2.0541666666667, 0.95, 0.083333333333333
80013, 2.075, 0.925, 0.083333333333333
80014, 2.075, 0.9, 0.0625
80015, 2.0541666666667, 0.9, 0.083333333333333
80016, 2.075, 0.875, 0.083333333333333
80017, 2.075, 0.85, 0.0625
80018, 2.0541666666667, 0.85, 0.083333333333333
80019, 2.075, 0.825, 0.083333333333333
80020, 2.075, 0.8, 0.0625
80021, 2.0541666666667, 0.8, 0.083333333333333
80022, 2.075, 0.775, 0.083333333333333
80023, 2.075, 0.75, 0.0625
80024, 2.0541666666667, 0.75, 0.083333333333333
80025, 2.075, 0.725, 0.083333333333333
80026, 2.075, 0.7, 0.0625
80027, 2.0541666666667, 0.7, 0.083333333333333
80028, 2.075, 0.675, 0.083333333333333
80029, 2.075, 0.65, 0.0625
80030, 2.0541666666667, 0.65, 0.083333333333333
80031, 2.075, 0.625, 0.083333333333333
80032, 2.075, 0.6, 0.0625
80033, 2.0541666666667, 0.6, 0.083333333333333
80034, 2.075, 0.575, 0.083333333333333
80035, 2.075, 0.55, 0.0625
80036, 2.0541666666667, 0.55, 0.083333333333333
80037, 2.075, 0.525, 0.083333333333333
80038, 2.075, 0.5, 0.0625
80039, 2.0541666666667, 0.5, 0.083333333333333
80040, 2.075, 0.475, 0.083333333333333
80041, 2.075, 0.45, 0.0625
80042, 2.0541666666667, 0.45, 0.083333333333333
80043, 2.075, 0.425, 0.083333333333333
80044, 2.075, 0.4, 0.0625
80045, 2.0541666666667, 0.4, 0.083333333333333
80046, 2.075, 0.375, 0.083333333333333
80047, 2.075, 0.35, 0.0625
80048, 2.0541666666667, 0.35, 0.083333333333333
80049, 2.075, 0.325, 0.083333333333333
80050, 2.075, 0.3, 0.0625
80051, 2.0541666666667, 0.3, 0.083333333333333
80052, 2.075, 0.275, 0.083333333333333
80053, 2.075, 0.25, 0.0625
80054, 2.0541666666667, 0.25, 0.083333333333333
80055, 2.075, 0.225, 0.083333333333333
80056, 2.075, 0.2, 0.0625
80057, 2.0541666666667, 0.2, 0.083333333333333
80058, 2.075, 0.175, 0.083333333333333
80059, 2.1166666666667, 1.325, 0.083333333333333
80060, 2.1166666666667, 1.3, 0.0625
80061, 2.0958333333333, 1.3, 0.083333333333333
80062, 2.1166666666667, 1.275, 0.083333333333333
80063, 2.1166666666667, 1.25, 0.0625
80064, 2.0958333333333, 1.25, 0.083333333333333
80065, 2.1166666666667, 1.225, 0.083333333333333
80066, 2.1166666666667, 1.2, 0.0625
80067, 2.0958333333333, 1.2, 0.083333333333333
80068, 2.1166666666667, 1.175, 0.083333333333333
80069, 2.1166666666667, 1.15, 0.0625
80070, 2.0958333333333, 1.15, 0.083333333333333
80071, 2.1166666666667, 1.125, 0.083333333333333
80072, 2.1166666666667, 1.1, 0.0625
80073, 2.0958333333333, 1.1, 0.083333333333333
80074, 2.1166666666667, 1.075, 0.083333333333333
80075, 2.1166666666667, 1.05, 0.0625
80076, 2.0958333333333, 1.05, 0.083333333333333
80077, 2.1166666666667, 1.025, 0.083333333333333
80078, 2.1166666666667, 1, 0.0625
80079, 2.0958333333333, 1, 0.083333333333333
80080, 2.1166666666667, 0.975, 0.083333333333333
80081, 2.1166666666667, 0.95, 0.0625
80082, 2.0958333333333, 0.95, 0.083333333333333
80083, 2.1166666666667, 0.925, 0.083333333333333
80084, 2.1166666666667, 0.9, 0.0625
80085, 2.0958333333333, 0.9, 0.083333333333333
80086, 2.1166666666667, 0.875, 0.083333333333333
80087, 2.1166666666667, 0.85, 0.0625
80088, 2.0958333333333, 0.85, 0.083333333333333
80089, 2.1166666666667, 0.825, 0.083333333333333
80090, 2.1166666666667, 0.8, 0.0625
80091, 2.0958333333333, 0.8, 0.083333333333333
80092, 2.1166666666667, 0.775, 0.083333333333333
80093, 2.1166666666667, 0.75, 0.0625
80094, 2.0958333333333, 0.75, 0.083333333333333
80095, 2.1166666666667, 0.725, 0.083333333333333
80096, 2.1166666666667, 0.7, 0.0625
80097, 2.0958333333333, 0.7, 0.083333333333333
80098, 2.1166666666667, 0.675, 0.083333333333333
80099, 2.1166666666667, 0.65, 0.0625
80100, 2.0958333333333, 0.65, 0.083333333333333
80101, 2.1166666666667, 0.625, 0.083333333333333
80102, 2.1166666666667, 0.6, 0.0625
80103, 2.0958333333333, 0.6, 0.083333333333333
80104, 2.1166666666667, 0.575, 0.083333333333333
80105, 2.1166666666667, 0.55, 0.0625
80106, 2.0958333333333, 0.55, 0.083333333333333
80107, 2.1166666666667, 0.525, 0.083333333333333
80108, 2.1166666666667, 0.5, 0.0625
80109, 2.0958333333333, 0.5, 0.083333333333333
80110, 2.1166666666667, 0.475, 0.083333333333333
80111, 2.1166666666667, 0.45, 0.0625
80112, 2.0958333333333, 0.45, 0.083333333333333
80113, 2.1166666666667, 0.425, 0.083333333333333
80114, 2.1166666666667, 0.4, 0.0625
80115, 2.0958333333333, 0.4, 0.083333333333333
80116, 2.1166666666667, 0.375, 0.083333333333333
80117, 2.1166666666667, 0.35, 0.0625
80118, 2.0958333333333, 0.35, 0.083333333333333
80119, 2.1166666666667, 0.325, 0.083333333333333
80120, 2.1166666666667, 0.3, 0.0625
80121, 2.0958333333333, 0.3, 0.083333333333333
80122, 2.1166666666667, 0.275, 0.083333333333333
80123, 2.1166666666667, 0.25, 0.0625
80124, 2.0958333333333, 0.25, 0.083333333333333
80125, 2.1166666666667, 0.225, 0.083333333333333
80126, 2.1166666666667, 0.2, 0.0625
80127, 2.0958333333333, 0.2, 0.083333333333333
80128, 2.1166666666667, 0.175, 0.083333333333333
80129, 2.1583333333333, 1.325, 0.083333333333333
80130, 2.1583333333333, 1.3, 0.0625
80131, 2.1375, 1.3, 0.083333333333333
80132, 2.1583333333333, 1.275, 0.083333333333333
80133, 2.1583333333333, 1.25, 0.0625
80134, 2.1375, 1.25, 0.083333333333333
80135, 2.1583333333333, 1.225, 0.083333333333333
80136, 2.1583333333333, 1.2, 0.0625
80137, 2.1375, 1.2, 0.083333333333333
80138, 2.1583333333333, 1.175, 0.083333333333333
80139, 2.1583333333333, 1.15, 0.0625
80140, 2.1375, 1.15, 0.083333333333333
80141, 2.1583333333333, 1.125, 0.083333333333333
80142, 2.1583333333333, 1.1, 0.0625
80143, 2.1375, 1.1, 0.083333333333333
80144, 2.1583333333333, 1.075, 0.083333333333333
80145, 2.1583333333333, 1.05, 0.0625
80146, 2.1375, 1.05, 0.083333333333333
80147, 2.1583333333333, 1.025, 0.083333333333333
80148, 2.1583333333333, 1, 0.0625
80149, 2.1375, 1, 0.083333333333333
80150, 2.1583333333333, 0.975, 0.083333333333333
80151, 2.1583333333333, 0.95, 0.0625
80152, 2.1375, 0.95, 0.083333333333333
80153, 2.1583333333333, 0.925, 0.083333333333333
80154, 2.1583333333333, 0.9, 0.0625
80155, 2.1375, 0.9, 0.083333333333333
80156, 2.1583333333333, 0.875, 0.083333333333333
80157, 2.1583333333333, 0.85, 0.0625
80158, 2.1375, 0.85, 0.083333333333333
80159, 2.1583333333333, 0.825, 0.083333333333333
80160, 2.1583333333333, 0.8, 0.0625
80161, 2.1375, 0.8, 0.083333333333333
80162, 2.1583333333333, 0.775, 0.083333333333333
80163, 2.1583333333333, 0.75, 0.0625
80164, 2.1375, 0.75, 0.083333333333333
80165, 2.1583333333333, 0.725, 0.083333333333333
80166, 2.1583333333333, 0.7, 0.0625
80167, 2.1375, 0.7, 0.083333333333333
80168, 2.1583333333333, 0.675, 0.083333333333333
80169, 2.1583333333333, 0.65, 0.0625
80170, 2.1375, 0.65, 0.083333333333333
80171, 2.1583333333333, 0.625, 0.083333333333333
80172, 2.1583333333333, 0.6, 0.0625
80173, 2.1375, 0.6, 0.083333333333333
80174, 2.1583333333333, 0.575, 0.083333333333333
80175, 2.1583333333333, 0.55, 0.0625
80176, 2.1375, 0.55, 0.083333333333333
80177, 2.1583333333333, 0.525, 0.083333333333333
80178, 2.1583333333333, 0.5, 0.0625
80179, 2.1375, 0.5, 0.083333333333333
80180, 2.1583333333333, 0.475, 0.083333333333333
80181, 2.1583333333333, 0.45, 0.0625
80182, 2.1375, 0.45, 0.083333333333333
80183, 2.1583333333333, 0.425, 0.083333333333333
80184, 2.1583333333333, 0.4, 0.0625
80185, 2.1375, 0.4, 0.083333333333333
80186, 2.1583333333333, 0.375, 0.083333333333333
80187, 2.1583333333333, 0.35, 0.0625
80188, 2.1375, 0.35, 0.083333333333333
80189, 2.1583333333333, 0.325, 0.083333333333333
80190, 2.1583333333333, 0.3, 0.0625
80191, 2.1375, 0.3, 0.083333333333333
80192, 2.1583333333333, 0.275, 0.083333333333333
80193, 2.1583333333333, 0.25, 0.0625
80194, 2.1375, 0.25, 0.083333333333333
80195, 2.1583333333333, 0.225, 0.083333333333333
80196, 2.1583333333333, 0.2, 0.0625
80197, 2.1375, 0.2, 0.083333333333333
80198, 2.1583333333333, 0.175, 0.083333333333333
80199, 2.1791666666667, 1.3, 0.083333333333333
80200, 2.1791666666667, 1.25, 0.083333333333333
80201, 2.1791666666667, 1.2, 0.083333333333333
80202, 2.1791666666667, 1.15, 0.083333333333333
80203, 2.1791666666667, 1.1, 0.083333333333333
80204, 2.1791666666667, 1.05, 0.083333333333333
80205, 2.1791666666667, 1, 0.083333333333333
80206, 2.1791666666667, 0.95, 0.083333333333333
80207, 2.1791666666667, 0.9, 0.083333333333333
80208, 2.1791666666667, 0.85, 0.083333333333333
80209, 2.1791666666667, 0.8, 0.083333333333333
80210, 2.1791666666667, 0.75, 0.083333333333333
80211, 2.1791666666667, 0.7, 0.083333333333333
80212, 2.1791666666667, 0.65, 0.083333333333333
80213, 2.1791666666667, 0.6, 0.083333333333333
80214, 2.1791666666667, 0.55, 0.083333333333333
80215, 2.1791666666667, 0.5, 0.083333333333333
80216, 2.1791666666667, 0.45, 0.083333333333333
80217, 2.1791666666667, 0.4, 0.083333333333333
80218, 2.1791666666667, 0.35, 0.083333333333333
80219, 2.1791666666667, 0.3, 0.083333333333333
80220, 2.1791666666667, 0.25, 0.083333333333333
80221, 2.1791666666667, 0.2, 0.083333333333333
80222, 1.2416666666667, 1.325, 0.125
80223, 1.2416666666667, 1.3, 0.10416666666667
80224, 1.2208333333333, 1.3, 0.125
80225, 1.2416666666667, 1.275, 0.125
80226, 1.2416666666667, 1.25, 0.10416666666667
80227, 1.2208333333333, 1.25, 0.125
80228, 1.2416666666667, 1.225, 0.125
80229, 1.2416666666667, 1.2, 0.10416666666667
80230, 1.2208333333333, 1.2, 0.125
80231, 1.2416666666667, 1.175, 0.125
80232, 1.2416666666667, 1.15, 0.10416666666667
80233, 1.2208333333333, 1.15, 0.125
80234, 1.2416666666667, 1.125, 0.125
80235, 1.2416666666667, 1.1, 0.10416666666667
80236, 1.2208333333333, 1.1, 0.125
80237, 1.2416666666667, 1.075, 0.125
80238, 1.2416666666667, 1.05, 0.10416666666667
80239, 1.2208333333333, 1.05, 0.125
80240, 1.2416666666667, 1.025, 0.125
80241, 1.2416666666667, 1, 0.10416666666667
80242, 1.2208333333333, 1, 0.125
80243, 1.2416666666667, 0.975, 0.125
80244, 1.2416666666667, 0.95, 0.10416666666667
80245, 1.2208333333333, 0.95, 0.125
80246, 1.2416666666667, 0.925, 0.125
80247, 1.2416666666667, 0.9, 0.10416666666667
80248, 1.2208333333333, 0.9, 0.125
80249, 1.2416666666667, 0.875, 0.125
80250, 1.2416666666667, 0.85, 0.10416666666667
80251, 1.2208333333333, 0.85, 0.125
80252, 1.2416666666667, 0.825, 0.125
80253, 1.2416666666667, 0.8, 0.10416666666667
80254, 1.2208333333333, 0.8, 0.125
80255, 1.2416666666667, 0.775, 0.125
80256, 1.2416666666667, 0.75, 0.10416666666667
80257, 1.2208333333333, 0.75, 0.125
80258, 1.2416666666667, 0.725, 0.125
80259, 1.2416666666667, 0.7, 0.10416666666667
80260, 1.2208333333333, 0.7, 0.125
80261, 1.2416666666667, 0.675, 0.125
80262, 1.2416666666667, 0.65, 0.10416666666667
80263, 1.2208333333333, 0.65, 0.125
80264, 1.2416666666667, 0.625, 0.125
80265, 1.2416666666667, 0.6, 0.10416666666667
80266, 1.2208333333333, 0.6, 0.125
80267, 1.2416666666667, 0.575, 0.125
80268, 1.2416666666667, 0.55, 0.10416666666667
80269, 1.2208333333333, 0.55, 0.125
80270, 1.2416666666667, 0.525, 0.125
80271, 1.2416666666667, 0.5, 0.10416666666667
80272, 1.2208333333333, 0.5, 0.125
80273, 1.2416666666667, 0.475, 0.125
80274, 1.2416666666667, 0.45, 0.10416666666667
80275, 1.2208333333333, 0.45, 0.125
80276, 1.2416666666667, 0.425, 0.125
80277, 1.2416666666667, 0.4, 0.10416666666667
80278, 1.2208333333333, 0.4, 0.125
80279, 1.2416666666667, 0.375, 0.125
80280, 1.2416666666667, 0.35, 0.10416666666667
80281, 1.2208333333333, 0.35, 0.125
80282, 1.2416666666667, 0.325, 0.125
80283, 1.2416666666667, 0.3, 0.10416666666667
80284, 1.2208333333333, 0.3, 0.125
80285, 1.2416666666667, 0.275, 0.125
80286, 1.2416666666667, 0.25, 0.10416666666667
80287, 1.2208333333333, 0.25, 0.125
80288, 1.2416666666667, 0.225, 0.125
80289, 1.2416666666667, 0.2, 0.10416666666667
80290, 1.2208333333333, 0.2, 0.125
80291, 1.2416666666667, 0.175, 0.125
80292, 1.2833333333333, 1.325, 0.125
80293, 1.2833333333333, 1.3, 0.10416666666667
80294, 1.2625, 1.3, 0.125
80295, 1.2833333333333, 1.275, 0.125
80296, 1.2833333333333, 1.25, 0.10416666666667
80297, 1.2625, 1.25, 0.125
80298, 1.2833333333333, 1.225, 0.125
80299, 1.2833333333333, 1.2, 0.10416666666667
80300, 1.2625, 1.2, 0.125
80301, 1.2833333333333, 1.175, 0.125
80302, 1.2833333333333, 1.15, 0.10416666666667
80303, 1.2625, 1.15, 0.125
80304, 1.2833333333333, 1.125, 0.125
80305, 1.2833333333333, 1.1, 0.10416666666667
80306, 1.2625, 1.1, 0.125
80307, 1.2833333333333, 1.075, 0.125
80308, 1.2833333333333, 1.05, 0.10416666666667
80309, 1.2625, 1.05, 0.125
80310, 1.2833333333333, 1.025, 0.125
80311, 1.2833333333333, 1, 0.10416666666667
80312, 1.2625, 1, 0.125
80313, 1.2833333333333, 0.975, 0.125
80314, 1.2833333333333, 0.95, 0.10416666666667
80315, 1.2625, 0.95, 0.125
80316, 1.2833333333333, 0.925, 0.125
80317, 1.2833333333333, 0.9, 0.10416666666667
80318, 1.2625, 0.9, 0.125
80319, 1.2833333333333, 0.875, 0.125
80320, 1.2833333333333, 0.85, 0.10416666666667
80321, 1.2625, 0.85, 0.125
80322, 1.2833333333333, 0.825, 0.125
80323, 1.2833333333333, 0.8, 0.10416666666667
80324, 1.2625, 0.8, 0.125
80325, 1.2833333333333, 0.775, 0.125
80326, 1.2833333333333, 0.75, 0.10416666666667
80327, 1.2625, 0.75, 0.125
80328, 1.2833333333333, 0.725, 0.125
80329, 1.2833333333333, 0.7, 0.10416666666667
80330, 1.2625, 0.7, 0.125
80331, 1.2833333333333, 0.675, 0.125
80332, 1.2833333333333, 0.65, 0.10416666666667
80333, 1.2625, 0.65, 0.125
80334, 1.2833333333333, 0.625, 0.125
80335, 1.2833333333333, 0.6, 0.10416666666667
80336, 1.2625, 0.6, 0.125
80337, 1.2833333333333, 0.575, 0.125
80338, 1.2833333333333, 0.55, 0.10416666666667
80339, 1.2625, 0.55, 0.125
80340, 1.2833333333333, 0.525, 0.125
80341, 1.2833333333333, 0.5, 0.10416666666667
80342, 1.2625, 0.5, 0.125
80343, 1.2833333333333, 0.475, 0.125
80344, 1.2833333333333, 0.45, 0.10416666666667
80345, 1.2625, 0.45, 0.125
80346, 1.2833333333333, 0.425, 0.125
80347, 1.2833333333333, 0.4, 0.10416666666667
80348, 1.2625, 0.4, 0.125
80349, 1.2833333333333, 0.375, 0.125
80350, 1.2833333333333, 0.35, 0.10416666666667
80351, 1.2625, 0.35, 0.125
80352, 1.2833333333333, 0.325, 0.125
80353, 1.2833333333333, 0.3, 0.10416666666667
80354, 1.2625, 0.3, 0.125
80355, 1.2833333333333, 0.275, 0.125
80356, 1.2833333333333, 0.25, 0.10416666666667
80357, 1.2625, 0.25, 0.125
80358, 1.2833333333333, 0.225, 0.125
80359, 1.2833333333333, 0.2, 0.10416666666667
80360, 1.2625, 0.2, 0.125
80361, 1.2833333333333, 0.175, 0.125
80362, 1.325, 1.325, 0.125
80363, 1.325, 1.3, 0.10416666666667
80364, 1.3041666666667, 1.3, 0.125
80365, 1.325, 1.275, 0.125
80366, 1.325, 1.25, 0.10416666666667
80367, 1.3041666666667, 1.25, 0.125
80368, 1.325, 1.225, 0.125
80369, 1.325, 1.2, 0.10416666666667
80370, 1.3041666666667, 1.2, 0.125
80371, 1.325, 1.175, 0.125
80372, 1.325, 1.15, 0.10416666666667
80373, 1.3041666666667, 1.15, 0.125
80374, 1.325, 1.125, 0.125
80375, 1.325, 1.1, 0.10416666666667
80376, 1.3041666666667, 1.1, 0.125
80377, 1.325, 1.075, 0.125
80378, 1.325, 1.05, 0.10416666666667
80379, 1.3041666666667, 1.05, 0.125
80380, 1.325, 1.025, 0.125
80381, 1.325, 1, 0.10416666666667
80382, 1.3041666666667, 1, 0.125
80383, 1.325, 0.975, 0.125
80384, 1.325, 0.95, 0.10416666666667
80385, 1.3041666666667, 0.95, 0.125
80386, 1.325, 0.925, 0.125
80387, 1.325, 0.9, 0.10416666666667
80388, 1.3041666666667, 0.9, 0.125
80389, 1.325, 0.875, 0.125
80390, 1.325, 0.85, 0.10416666666667
80391, 1.3041666666667, 0.85, 0.125
80392, 1.325, 0.825, 0.125
80393, 1.325, 0.8, 0.10416666666667
80394, 1.3041666666667, 0.8, 0.125
80395, 1.325, 0.775, 0.125
80396, 1.325, 0.75, 0.10416666666667
80397, 1.3041666666667, 0.75, 0.125
80398, 1.325, 0.725, 0.125
80399, 1.325, 0.7, 0.10416666666667
80400, 1.3041666666667, 0.7, 0.125
80401, 1.325, 0.675, 0.125
80402, 1.325, 0.65, 0.10416666666667
80403, 1.3041666666667, 0.65, 0.125
80404, 1.325, 0.625, 0.125
80405, 1.325, 0.6, 0.10416666666667
80406, 1.3041666666667, 0.6, 0.125
80407, 1.325, 0.575, 0.125
80408, 1.325, 0.55, 0.10416666666667
80409, 1.3041666666667, 0.55, 0.125
80410, 1.325, 0.525, 0.125
80411, 1.325, 0.5, 0.10416666666667
80412, 1.3041666666667, 0.5, 0.125
80413, 1.325, 0.475, 0.125
80414, 1.325, 0.45, 0.10416666666667
80415, 1.3041666666667, 0.45, 0.125
80416, 1.325, 0.425, 0.125
80417, 1.325, 0.4, 0.10416666666667
80418, 1.3041666666667, 0.4, 0.125
80419, 1.325, 0.375, 0.125
80420, 1.325, 0.35, 0.10416666666667
80421, 1.3041666666667, 0.35, 0.125
80422, 1.325, 0.325, 0.125
80423, 1.325, 0.3, 0.10416666666667
80424, 1.3041666666667, 0.3, 0.125
80425, 1.325, 0.275, 0.125
80426, 1.325, 0.25, 0.10416666666667
80427, 1.3041666666667, 0.25, 0.125
80428, 1.325, 0.225, 0.125
80429, 1.325, 0.2, 0.10416666666667
80430, 1.3041666666667, 0.2, 0.125
80431, 1.325, 0.175, 0.125
80432, 1.3666666666667, 1.325, 0.125
80433, 1.3666666666667, 1.3, 0.10416666666667
80434, 1.3458333333333, 1.3, 0.125
80435, 1.3666666666667, 1.275, 0.125
80436, 1.3666666666667, 1.25, 0.10416666666667
80437, 1.3458333333333, 1.25, 0.125
80438, 1.3666666666667, 1.225, 0.125
80439, 1.3666666666667, 1.2, 0.10416666666667
80440, 1.3458333333333, 1.2, 0.125
80441, 1.3666666666667, 1.175, 0.125
80442, 1.3666666666667, 1.15, 0.10416666666667
80443, 1.3458333333333, 1.15, 0.125
80444, 1.3666666666667, 1.125, 0.125
80445, 1.3666666666667, 1.1, 0.10416666666667
80446, 1.3458333333333, 1.1, 0.125
80447, 1.3666666666667, 1.075, 0.125
80448, 1.3666666666667, 1.05, 0.10416666666667
80449, 1.3458333333333, 1.05, 0.125
80450, 1.3666666666667, 1.025, 0.125
80451, 1.3666666666667, 1, 0.10416666666667
80452, 1.3458333333333, 1, 0.125
80453, 1.3666666666667, 0.975, 0.125
80454, 1.3666666666667, 0.95, 0.10416666666667
80455, 1.3458333333333, 0.95, 0.125
80456, 1.3666666666667, 0.925, 0.125
80457, 1.3666666666667, 0.9, 0.10416666666667
80458, 1.3458333333333, 0.9, 0.125
80459, 1.3666666666667, 0.875, 0.125
80460, 1.3666666666667, 0.85, 0.10416666666667
80461, 1.3458333333333, 0.85, 0.125
80462, 1.3666666666667, 0.825, 0.125
80463, 1.3666666666667, 0.8, 0.10416666666667
80464, 1.3458333333333, 0.8, 0.125
80465, 1.3666666666667, 0.775, 0.125
80466, 1.3666666666667, 0.75, 0.10416666666667
80467, 1.3458333333333, 0.75, 0.125
80468, 1.3666666666667, 0.725, 0.125
80469, 1.3666666666667, 0.7, 0.10416666666667
80470, 1.3458333333333, 0.7, 0.125
80471, 1.3666666666667, 0.675, 0.125
80472, 1.3666666666667, 0.65, 0.10416666666667
80473, 1.3458333333333, 0.65, 0.125
80474, 1.3666666666667, 0.625, 0.125
80475, 1.3666666666667, 0.6, 0.10416666666667
80476, 1.3458333333333, 0.6, 0.125
80477, 1.3666666666667, 0.575, 0.125
80478, 1.3666666666667, 0.55, 0.10416666666667
80479, 1.3458333333333, 0.55, 0.125
80480, 1.3666666666667, 0.525, 0.125
80481, 1.3666666666667, 0.5, 0.10416666666667
80482, 1.3458333333333, 0.5, 0.125
80483, 1.3666666666667, 0.475, 0.125
80484, 1.3666666666667, 0.45, 0.10416666666667
80485, 1.3458333333333, 0.45, 0.125
80486, 1.3666666666667, 0.425, 0.125
80487, 1.3666666666667, 0.4, 0.10416666666667
80488, 1.3458333333333, 0.4, 0.125
80489, 1.3666666666667, 0.375, 0.125
80490, 1.3666666666667, 0.35, 0.10416666666667
80491, 1.3458333333333, 0.35, 0.125
80492, 1.3666666666667, 0.325, 0.125
80493, 1.3666666666667, 0.3, 0.10416666666667
80494, 1.3458333333333, 0.3, 0.125
80495, 1.3666666666667, 0.275, 0.125
80496, 1.3666666666667, 0.25, 0.10416666666667
80497, 1.3458333333333, 0.25, 0.125
80498, 1.3666666666667, 0.225, 0.125
80499, 1.3666666666667, 0.2, 0.10416666666667
80500, 1.3458333333333, 0.2, 0.125
80501, 1.3666666666667, 0.175, 0.125
80502, 1.4083333333333, 1.325, 0.125
80503, 1.4083333333333, 1.3, 0.10416666666667
80504, 1.3875, 1.3, 0.125
80505, 1.4083333333333, 1.275, 0.125
80506, 1.4083333333333, 1.25, 0.10416666666667
80507, 1.3875, 1.25, 0.125
80508, 1.4083333333333, 1.225, 0.125
80509, 1.4083333333333, 1.2, 0.10416666666667
80510, 1.3875, 1.2, 0.125
80511, 1.4083333333333, 1.175, 0.125
80512, 1.4083333333333, 1.15, 0.10416666666667
80513, 1.3875, 1.15, 0.125
80514, 1.4083333333333, 1.125, 0.125
80515, 1.4083333333333, 1.1, 0.10416666666667
80516, 1.3875, 1.1, 0.125
80517, 1.4083333333333, 1.075, 0.125
80518, 1.4083333333333, 1.05, 0.10416666666667
80519, 1.3875, 1.05, 0.125
80520, 1.4083333333333, 1.025, 0.125
80521, 1.4083333333333, 1, 0.10416666666667
80522, 1.3875, 1, 0.125
80523, 1.4083333333333, 0.975, 0.125
80524, 1.4083333333333, 0.95, 0.10416666666667
80525, 1.3875, 0.95, 0.125
80526, 1.4083333333333, 0.925, 0.125
80527, 1.4083333333333, 0.9, 0.10416666666667
80528, 1.3875, 0.9, 0.125
80529, 1.4083333333333, 0.875, 0.125
80530, 1.4083333333333, 0.85, 0.10416666666667
80531, 1.3875, 0.85, 0.125
80532, 1.4083333333333, 0.825, 0.125
80533, 1.4083333333333, 0.8, 0.10416666666667
80534, 1.3875, 0.8, 0.125
80535, 1.4083333333333, 0.775, 0.125
80536, 1.4083333333333, 0.75, 0.10416666666667
80537, 1.3875, 0.75, 0.125
80538, 1.4083333333333, 0.725, 0.125
80539, 1.4083333333333, 0.7, 0.10416666666667
80540, 1.3875, 0.7, 0.125
80541, 1.4083333333333, 0.675, 0.125
80542, 1.4083333333333, 0.65, 0.10416666666667
80543, 1.3875, 0.65, 0.125
80544, 1.4083333333333, 0.625, 0.125
80545, 1.4083333333333, 0.6, 0.10416666666667
80546, 1.3875, 0.6, 0.125
80547, 1.4083333333333, 0.575, 0.125
80548, 1.4083333333333, 0.55, 0.10416666666667
80549, 1.3875, 0.55, 0.125
80550, 1.4083333333333, 0.525, 0.125
80551, 1.4083333333333, 0.5, 0.10416666666667
80552, 1.3875, 0.5, 0.125
80553, 1.4083333333333, 0.475, 0.125
80554, 1.4083333333333, 0.45, 0.10416666666667
80555, 1.3875, 0.45, 0.125
80556, 1.4083333333333, 0.425, 0.125
80557, 1.4083333333333, 0.4, 0.10416666666667
80558, 1.3875, 0.4, 0.125
80559, 1.4083333333333, 0.375, 0.125
80560, 1.4083333333333, 0.35, 0.10416666666667
80561, 1.3875, 0.35, 0.125
80562, 1.4083333333333, 0.325, 0.125
80563, 1.4083333333333, 0.3, 0.10416666666667
80564, 1.3875, 0.3, 0.125
80565, 1.4083333333333, 0.275, 0.125
80566, 1.4083333333333, 0.25, 0.10416666666667
80567, 1.3875, 0.25, 0.125
80568, 1.4083333333333, 0.225, 0.125
80569, 1.4083333333333, 0.2, 0.10416666666667
80570, 1.3875, 0.2, 0.125
80571, 1.4083333333333, 0.175, 0.125
80572, 1.45, 1.325, 0.125
80573, 1.45, 1.3, 0.10416666666667
80574, 1.4291666666667, 1.3, 0.125
80575, 1.45, 1.275, 0.125
80576, 1.45, 1.25, 0.10416666666667
80577, 1.4291666666667, 1.25, 0.125
80578, 1.45, 1.225, 0.125
80579, 1.45, 1.2, 0.10416666666667
80580, 1.4291666666667, 1.2, 0.125
80581, 1.45, 1.175, 0.125
80582, 1.45, 1.15, 0.10416666666667
80583, 1.4291666666667, 1.15, 0.125
80584, 1.45, 1.125, 0.125
80585, 1.45, 1.1, 0.10416666666667
80586, 1.4291666666667, 1.1, 0.125
80587, 1.45, 1.075, 0.125
80588, 1.45, 1.05, 0.10416666666667
80589, 1.4291666666667, 1.05, 0.125
80590, 1.45, 1.025, 0.125
80591, 1.45, 1, 0.10416666666667
80592, 1.4291666666667, 1, 0.125
80593, 1.45, 0.975, 0.125
80594, 1.45, 0.95, 0.10416666666667
80595, 1.4291666666667, 0.95, 0.125
80596, 1.45, 0.925, 0.125
80597, 1.45, 0.9, 0.10416666666667
80598, 1.4291666666667, 0.9, 0.125
80599, 1.45, 0.875, 0.125
80600, 1.45, 0.85, 0.10416666666667
80601, 1.4291666666667, 0.85, 0.125
80602, 1.45, 0.825, 0.125
80603, 1.45, 0.8, 0.10416666666667
80604, 1.4291666666667, 0.8, 0.125
80605, 1.45, 0.775, 0.125
80606, 1.45, 0.75, 0.10416666666667
80607, 1.4291666666667, 0.75, 0.125
80608, 1.45, 0.725, 0.125
80609, 1.45, 0.7, 0.10416666666667
80610, 1.4291666666667, 0.7, 0.125
80611, 1.45, 0.675, 0.125
80612, 1.45, 0.65, 0.10416666666667
80613, 1.4291666666667, 0.65, 0.125
80614, 1.45, 0.625, 0.125
80615, 1.45, 0.6, 0.10416666666667
80616, 1.4291666666667, 0.6, 0.125
80617, 1.45, 0.575, 0.125
80618, 1.45, 0.55, 0.10416666666667
80619, 1.4291666666667, 0.55, 0.125
80620, 1.45, 0.525, 0.125
80621, 1.45, 0.5, 0.10416666666667
80622, 1.4291666666667, 0.5, 0.125
80623, 1.45, 0.475, 0.125
80624, 1.45, 0.45, 0.10416666666667
80625, 1.4291666666667, 0.45, 0.125
80626, 1.45, 0.425, 0.125
80627, 1.45, 0.4, 0.10416666666667
80628, 1.4291666666667, 0.4, 0.125
80629, 1.45, 0.375, 0.125
80630, 1.45, 0.35, 0.10416666666667
80631, 1.4291666666667, 0.35, 0.125
80632, 1.45, 0.325, 0.125
80633, 1.45, 0.3, 0.10416666666667
80634, 1.4291666666667, 0.3, 0.125
80635, 1.45, 0.275, 0.125
80636, 1.45, 0.25, 0.10416666666667
80637, 1.4291666666667, 0.25, 0.125
80638, 1.45, 0.225, 0.125
80639, 1.45, 0.2, 0.10416666666667
80640, 1.4291666666667, 0.2, 0.125
80641, 1.45, 0.175, 0.125
80642, 1.4916666666667, 1.325, 0.125
80643, 1.4916666666667, 1.3, 0.10416666666667
80644, 1.4708333333333, 1.3, 0.125
80645, 1.4916666666667, 1.275, 0.125
80646, 1.4916666666667, 1.25, 0.10416666666667
80647, 1.4708333333333, 1.25, 0.125
80648, 1.4916666666667, 1.225, 0.125
80649, 1.4916666666667, 1.2, 0.10416666666667
80650, 1.4708333333333, 1.2, 0.125
80651, 1.4916666666667, 1.175, 0.125
80652, 1.4916666666667, 1.15, 0.10416666666667
80653, 1.4708333333333, 1.15, 0.125
80654, 1.4916666666667, 1.125, 0.125
80655, 1.4916666666667, 1.1, 0.10416666666667
80656, 1.4708333333333, 1.1, 0.125
80657, 1.4916666666667, 1.075, 0.125
80658, 1.4916666666667, 1.05, 0.10416666666667
80659, 1.4708333333333, 1.05, 0.125
80660, 1.4916666666667, 1.025, 0.125
80661, 1.4916666666667, 1, 0.10416666666667
80662, 1.4708333333333, 1, 0.125
80663, 1.4916666666667, 0.975, 0.125
80664, 1.4916666666667, 0.95, 0.10416666666667
80665, 1.4708333333333, 0.95, 0.125
80666, 1.4916666666667, 0.925, 0.125
80667, 1.4916666666667, 0.9, 0.10416666666667
80668, 1.4708333333333, 0.9, 0.125
80669, 1.4916666666667, 0.875, 0.125
80670, 1.4916666666667, 0.85, 0.10416666666667
80671, 1.4708333333333, 0.85, 0.125
80672, 1.4916666666667, 0.825, 0.125
80673, 1.4916666666667, 0.8, 0.10416666666667
80674, 1.4708333333333, 0.8, 0.125
80675, 1.4916666666667, 0.775, 0.125
80676, 1.4916666666667, 0.75, 0.10416666666667
80677, 1.4708333333333, 0.75, 0.125
80678, 1.4916666666667, 0.725, 0.125
80679, 1.4916666666667, 0.7, 0.10416666666667
80680, 1.4708333333333, 0.7, 0.125
80681, 1.4916666666667, 0.675, 0.125
80682, 1.4916666666667, 0.65, 0.10416666666667
80683, 1.4708333333333, 0.65, 0.125
80684, 1.4916666666667, 0.625, 0.125
80685, 1.4916666666667, 0.6, 0.10416666666667
80686, 1.4708333333333, 0.6, 0.125
80687, 1.4916666666667, 0.575, 0.125
80688, 1.4916666666667, 0.55, 0.10416666666667
80689, 1.4708333333333, 0.55, 0.125
80690, 1.4916666666667, 0.525, 0.125
80691, 1.4916666666667, 0.5, 0.10416666666667
80692, 1.4708333333333, 0.5, 0.125
80693, 1.4916666666667, 0.475, 0.125
80694, 1.4916666666667, 0.45, 0.10416666666667
80695, 1.4708333333333, 0.45, 0.125
80696, 1.4916666666667, 0.425, 0.125
80697, 1.4916666666667, 0.4, 0.10416666666667
80698, 1.4708333333333, 0.4, 0.125
80699, 1.4916666666667, 0.375, 0.125
80700, 1.4916666666667, 0.35, 0.10416666666667
80701, 1.4708333333333, 0.35, 0.125
80702, 1.4916666666667, 0.325, 0.125
80703, 1.4916666666667, 0.3, 0.10416666666667
80704, 1.4708333333333, 0.3, 0.125
80705, 1.4916666666667, 0.275, 0.125
80706, 1.4916666666667, 0.25, 0.10416666666667
80707, 1.4708333333333, 0.25, 0.125
80708, 1.4916666666667, 0.225, 0.125
80709, 1.4916666666667, 0.2, 0.10416666666667
80710, 1.4708333333333, 0.2, 0.125
80711, 1.4916666666667, 0.175, 0.125
80712, 1.5333333333333, 1.325, 0.125
80713, 1.5333333333333, 1.3, 0.10416666666667
80714, 1.5125, 1.3, 0.125
80715, 1.5333333333333, 1.275, 0.125
80716, 1.5333333333333, 1.25, 0.10416666666667
80717, 1.5125, 1.25, 0.125
80718, 1.5333333333333, 1.225, 0.125
80719, 1.5333333333333, 1.2, 0.10416666666667
80720, 1.5125, 1.2, 0.125
80721, 1.5333333333333, 1.175, 0.125
80722, 1.5333333333333, 1.15, 0.10416666666667
80723, 1.5125, 1.15, 0.125
80724, 1.5333333333333, 1.125, 0.125
80725, 1.5333333333333, 1.1, 0.10416666666667
80726, 1.5125, 1.1, 0.125
80727, 1.5333333333333, 1.075, 0.125
80728, 1.5333333333333, 1.05, 0.10416666666667
80729, 1.5125, 1.05, 0.125
80730, 1.5333333333333, 1.025, 0.125
80731, 1.5333333333333, 1, 0.10416666666667
80732, 1.5125, 1, 0.125
80733, 1.5333333333333, 0.975, 0.125
80734, 1.5333333333333, 0.95, 0.10416666666667
80735, 1.5125, 0.95, 0.125
80736, 1.5333333333333, 0.925, 0.125
80737, 1.5333333333333, 0.9, 0.10416666666667
80738, 1.5125, 0.9, 0.125
80739, 1.5333333333333, 0.875, 0.125
80740, 1.5333333333333, 0.85, 0.10416666666667
80741, 1.5125, 0.85, 0.125
80742, 1.5333333333333, 0.825, 0.125
80743, 1.5333333333333, 0.8, 0.10416666666667
80744, 1.5125, 0.8, 0.125
80745, 1.5333333333333, 0.775, 0.125
80746, 1.5333333333333, 0.75, 0.10416666666667
80747, 1.5125, 0.75, 0.125
80748, 1.5333333333333, 0.725, 0.125
80749, 1.5333333333333, 0.7, 0.10416666666667
80750, 1.5125, 0.7, 0.125
80751, 1.5333333333333, 0.675, 0.125
80752, 1.5333333333333, 0.65, 0.10416666666667
80753, 1.5125, 0.65, 0.125
80754, 1.5333333333333, 0.625, 0.125
80755, 1.5333333333333, 0.6, 0.10416666666667
80756, 1.5125, 0.6, 0.125
80757, 1.5333333333333, 0.575, 0.125
80758, 1.5333333333333, 0.55, 0.10416666666667
80759, 1.5125, 0.55, 0.125
80760, 1.5333333333333, 0.525, 0.125
80761, 1.5333333333333, 0.5, 0.10416666666667
80762, 1.5125, 0.5, 0.125
80763, 1.5333333333333, 0.475, 0.125
80764, 1.5333333333333, 0.45, 0.10416666666667
80765, 1.5125, 0.45, 0.125
80766, 1.5333333333333, 0.425, 0.125
80767, 1.5333333333333, 0.4, 0.10416666666667
80768, 1.5125, 0.4, 0.125
80769, 1.5333333333333, 0.375, 0.125
80770, 1.5333333333333, 0.35, 0.10416666666667
80771, 1.5125, 0.35, 0.125
80772, 1.5333333333333, 0.325, 0.125
80773, 1.5333333333333, 0.3, 0.10416666666667
80774, 1.5125, 0.3, 0.125
80775, 1.5333333333333, 0.275, 0.125
80776, 1.5333333333333, 0.25, 0.10416666666667
80777, 1.5125, 0.25, 0.125
80778, 1.5333333333333, 0.225, 0.125
80779, 1.5333333333333, 0.2, 0.10416666666667
80780, 1.5125, 0.2, 0.125
80781, 1.5333333333333, 0.175, 0.125
80782, 1.575, 1.325, 0.125
80783, 1.575, 1.3, 0.10416666666667
80784, 1.5541666666667, 1.3, 0.125
80785, 1.575, 1.275, 0.125
80786, 1.575, 1.25, 0.10416666666667
80787, 1.5541666666667, 1.25, 0.125
80788, 1.575, 1.225, 0.125
80789, 1.575, 1.2, 0.10416666666667
80790, 1.5541666666667, 1.2, 0.125
80791, 1.575, 1.175, 0.125
80792, 1.575, 1.15, 0.10416666666667
80793, 1.5541666666667, 1.15, 0.125
80794, 1.575, 1.125, 0.125
80795, 1.575, 1.1, 0.10416666666667
80796, 1.5541666666667, 1.1, 0.125
80797, 1.575, 1.075, 0.125
80798, 1.575, 1.05, 0.10416666666667
80799, 1.5541666666667, 1.05, 0.125
80800, 1.575, 1.025, 0.125
80801, 1.575, 1, 0.10416666666667
80802, 1.5541666666667, 1, 0.125
80803, 1.575, 0.975, 0.125
80804, 1.575, 0.95, 0.10416666666667
80805, 1.5541666666667, 0.95, 0.125
80806, 1.575, 0.925, 0.125
80807, 1.575, 0.9, 0.10416666666667
80808, 1.5541666666667, 0.9, 0.125
80809, 1.575, 0.875, 0.125
80810, 1.575, 0.85, 0.10416666666667
80811, 1.5541666666667, 0.85, 0.125
80812, 1.575, 0.825, 0.125
80813, 1.575, 0.8, 0.10416666666667
80814, 1.5541666666667, 0.8, 0.125
80815, 1.575, 0.775, 0.125
80816, 1.575, 0.75, 0.10416666666667
80817, 1.5541666666667, 0.75, 0.125
80818, 1.575, 0.725, 0.125
80819, 1.575, 0.7, 0.10416666666667
80820, 1.5541666666667, 0.7, 0.125
80821, 1.575, 0.675, 0.125
80822, 1.575, 0.65, 0.10416666666667
80823, 1.5541666666667, 0.65, 0.125
80824, 1.575, 0.625, 0.125
80825, 1.575, 0.6, 0.10416666666667
80826, 1.5541666666667, 0.6, 0.125
80827, 1.575, 0.575, 0.125
80828, 1.575, 0.55, 0.10416666666667
80829, 1.5541666666667, 0.55, 0.125
80830, 1.575, 0.525, 0.125
80831, 1.575, 0.5, 0.10416666666667
80832, 1.5541666666667, 0.5, 0.125
80833, 1.575, 0.475, 0.125
80834, 1.575, 0.45, 0.10416666666667
80835, 1.5541666666667, 0.45, 0.125
80836, 1.575, 0.425, 0.125
80837, 1.575, 0.4, 0.10416666666667
80838, 1.5541666666667, 0.4, 0.125
80839, 1.575, 0.375, 0.125
80840, 1.575, 0.35, 0.10416666666667
80841, 1.5541666666667, 0.35, 0.125
80842, 1.575, 0.325, 0.125
80843, 1.575, 0.3, 0.10416666666667
80844, 1.5541666666667, 0.3, 0.125
80845, 1.575, 0.275, 0.125
80846, 1.575, 0.25, 0.10416666666667
80847, 1.5541666666667, 0.25, 0.125
80848, 1.575, 0.225, 0.125
80849, 1.575, 0.2, 0.10416666666667
80850, 1.5541666666667, 0.2, 0.125
80851, 1.575, 0.175, 0.125
80852, 1.6166666666667, 1.325, 0.125
80853, 1.6166666666667, 1.3, 0.10416666666667
80854, 1.5958333333333, 1.3, 0.125
80855, 1.6166666666667, 1.275, 0.125
80856, 1.6166666666667, 1.25, 0.10416666666667
80857, 1.5958333333333, 1.25, 0.125
80858, 1.6166666666667, 1.225, 0.125
80859, 1.6166666666667, 1.2, 0.10416666666667
80860, 1.5958333333333, 1.2, 0.125
80861, 1.6166666666667, 1.175, 0.125
80862, 1.6166666666667, 1.15, 0.10416666666667
80863, 1.5958333333333, 1.15, 0.125
80864, 1.6166666666667, 1.125, 0.125
80865, 1.6166666666667, 1.1, 0.10416666666667
80866, 1.5958333333333, 1.1, 0.125
80867, 1.6166666666667, 1.075, 0.125
80868, 1.6166666666667, 1.05, 0.10416666666667
80869, 1.5958333333333, 1.05, 0.125
80870, 1.6166666666667, 1.025, 0.125
80871, 1.6166666666667, 1, 0.10416666666667
80872, 1.5958333333333, 1, 0.125
80873, 1.6166666666667, 0.975, 0.125
80874, 1.6166666666667, 0.95, 0.10416666666667
80875, 1.5958333333333, 0.95, 0.125
80876, 1.6166666666667, 0.925, 0.125
80877, 1.6166666666667, 0.9, 0.10416666666667
80878, 1.5958333333333, 0.9, 0.125
80879, 1.6166666666667, 0.875, 0.125
80880, 1.6166666666667, 0.85, 0.10416666666667
80881, 1.5958333333333, 0.85, 0.125
80882, 1.6166666666667, 0.825, 0.125
80883, 1.6166666666667, 0.8, 0.10416666666667
80884, 1.5958333333333, 0.8, 0.125
80885, 1.6166666666667, 0.775, 0.125
80886, 1.6166666666667, 0.75, 0.10416666666667
80887, 1.5958333333333, 0.75, 0.125
80888, 1.6166666666667, 0.725, 0.125
80889, 1.6166666666667, 0.7, 0.10416666666667
80890, 1.5958333333333, 0.7, 0.125
80891, 1.6166666666667, 0.675, 0.125
80892, 1.6166666666667, 0.65, 0.10416666666667
80893, 1.5958333333333, 0.65, 0.125
80894, 1.6166666666667, 0.625, 0.125
80895, 1.6166666666667, 0.6, 0.10416666666667
80896, 1.5958333333333, 0.6, 0.125
80897, 1.6166666666667, 0.575, 0.125
80898, 1.6166666666667, 0.55, 0.10416666666667
80899, 1.5958333333333, 0.55, 0.125
80900, 1.6166666666667, 0.525, 0.125
80901, 1.6166666666667, 0.5, 0.10416666666667
80902, 1.5958333333333, 0.5, 0.125
80903, 1.6166666666667, 0.475, 0.125
80904, 1.6166666666667, 0.45, 0.10416666666667
80905, 1.5958333333333, 0.45, 0.125
80906, 1.6166666666667, 0.425, 0.125
80907, 1.6166666666667, 0.4, 0.10416666666667
80908, 1.5958333333333, 0.4, 0.125
80909, 1.6166666666667, 0.375, 0.125
80910, 1.6166666666667, 0.35, 0.10416666666667
80911, 1.5958333333333, 0.35, 0.125
80912, 1.6166666666667, 0.325, 0.125
80913, 1.6166666666667, 0.3, 0.10416666666667
80914, 1.5958333333333, 0.3, 0.125
80915, 1.6166666666667, 0.275, 0.125
80916, 1.6166666666667, 0.25, 0.10416666666667
80917, 1.5958333333333, 0.25, 0.125
80918, 1.6166666666667, 0.225, 0.125
80919, 1.6166666666667, 0.2, 0.10416666666667
80920, 1.5958333333333, 0.2, 0.125
80921, 1.6166666666667, 0.175, 0.125
80922, 1.6583333333333, 1.325, 0.125
80923, 1.6583333333333, 1.3, 0.10416666666667
80924, 1.6375, 1.3, 0.125
80925, 1.6583333333333, 1.275, 0.125
80926, 1.6583333333333, 1.25, 0.10416666666667
80927, 1.6375, 1.25, 0.125
80928, 1.6583333333333, 1.225, 0.125
80929, 1.6583333333333, 1.2, 0.10416666666667
80930, 1.6375, 1.2, 0.125
80931, 1.6583333333333, 1.175, 0.125
80932, 1.6583333333333, 1.15, 0.10416666666667
80933, 1.6375, 1.15, 0.125
80934, 1.6583333333333, 1.125, 0.125
80935, 1.6583333333333, 1.1, 0.10416666666667
80936, 1.6375, 1.1, 0.125
80937, 1.6583333333333, 1.075, 0.125
80938, 1.6583333333333, 1.05, 0.10416666666667
80939, 1.6375, 1.05, 0.125
80940, 1.6583333333333, 1.025, 0.125
80941, 1.6583333333333, 1, 0.10416666666667
80942, 1.6375, 1, 0.125
80943, 1.6583333333333, 0.975, 0.125
80944, 1.6583333333333, 0.95, 0.10416666666667
80945, 1.6375, 0.95, 0.125
80946, 1.6583333333333, 0.925, 0.125
80947, 1.6583333333333, 0.9, 0.10416666666667
80948, 1.6375, 0.9, 0.125
80949, 1.6583333333333, 0.875, 0.125
80950, 1.6583333333333, 0.85, 0.10416666666667
80951, 1.6375, 0.85, 0.125
80952, 1.6583333333333, 0.825, 0.125
80953, 1.6583333333333, 0.8, 0.10416666666667
80954, 1.6375, 0.8, 0.125
80955, 1.6583333333333, 0.775, 0.125
80956, 1.6583333333333, 0.75, 0.10416666666667
80957, 1.6375, 0.75, 0.125
80958, 1.6583333333333, 0.725, 0.125
80959, 1.6583333333333, 0.7, 0.10416666666667
80960, 1.6375, 0.7, 0.125
80961, 1.6583333333333, 0.675, 0.125
80962, 1.6583333333333, 0.65, 0.10416666666667
80963, 1.6375, 0.65, 0.125
80964, 1.6583333333333, 0.625, 0.125
80965, 1.6583333333333, 0.6, 0.10416666666667
80966, 1.6375, 0.6, 0.125
80967, 1.6583333333333, 0.575, 0.125
80968, 1.6583333333333, 0.55, 0.10416666666667
80969, 1.6375, 0.55, 0.125
80970, 1.6583333333333, 0.525, 0.125
80971, 1.6583333333333, 0.5, 0.10416666666667
80972, 1.6375, 0.5, 0.125
80973, 1.6583333333333, 0.475, 0.125
80974, 1.6583333333333, 0.45, 0.10416666666667
80975, 1.6375, 0.45, 0.125
80976, 1.6583333333333, 0.425, 0.125
80977, 1.6583333333333, 0.4, 0.10416666666667
80978, 1.6375, 0.4, 0.125
80979, 1.6583333333333, 0.375, 0.125
80980, 1.6583333333333, 0.35, 0.10416666666667
80981, 1.6375, 0.35, 0.125
80982, 1.6583333333333, 0.325, 0.125
80983, 1.6583333333333, 0.3, 0.10416666666667
80984, 1.6375, 0.3, 0.125
80985, 1.6583333333333, 0.275, 0.125
80986, 1.6583333333333, 0.25, 0.10416666666667
80987, 1.6375, 0.25, 0.125
80988, 1.6583333333333, 0.225, 0.125
80989, 1.6583333333333, 0.2, 0.10416666666667
80990, 1.6375, 0.2, 0.125
80991, 1.6583333333333, 0.175, 0.125
80992, 1.7, 1.325, 0.125
80993, 1.7, 1.3, 0.10416666666667
80994, 1.6791666666667, 1.3, 0.125
80995, 1.7, 1.275, 0.125
80996, 1.7, 1.25, 0.10416666666667
80997, 1.6791666666667, 1.25, 0.125
80998, 1.7, 1.225, 0.125
80999, 1.7, 1.2, 0.10416666666667
81000, 1.6791666666667, 1.2, 0.125
81001, 1.7, 1.175, 0.125
81002, 1.7, 1.15, 0.10416666666667
81003, 1.6791666666667, 1.15, 0.125
81004, 1.7, 1.125, 0.125
81005, 1.7, 1.1, 0.10416666666667
81006, 1.6791666666667, 1.1, 0.125
81007, 1.7, 1.075, 0.125
81008, 1.7, 1.05, 0.10416666666667
81009, 1.6791666666667, 1.05, 0.125
81010, 1.7, 1.025, 0.125
81011, 1.7, 1, 0.10416666666667
81012, 1.6791666666667, 1, 0.125
81013, 1.7, 0.975, 0.125
81014, 1.7, 0.95, 0.10416666666667
81015, 1.6791666666667, 0.95, 0.125
81016, 1.7, 0.925, 0.125
81017, 1.7, 0.9, 0.10416666666667
81018, 1.6791666666667, 0.9, 0.125
81019, 1.7, 0.875, 0.125
81020, 1.7, 0.85, 0.10416666666667
81021, 1.6791666666667, 0.85, 0.125
81022, 1.7, 0.825, 0.125
81023, 1.7, 0.8, 0.10416666666667
81024, 1.6791666666667, 0.8, 0.125
81025, 1.7, 0.775, 0.125
81026, 1.7, 0.75, 0.10416666666667
81027, 1.6791666666667, 0.75, 0.125
81028, 1.7, 0.725, 0.125
81029, 1.7, 0.7, 0.10416666666667
81030, 1.6791666666667, 0.7, 0.125
81031, 1.7, 0.675, 0.125
81032, 1.7, 0.65, 0.10416666666667
81033, 1.6791666666667, 0.65, 0.125
81034, 1.7, 0.625, 0.125
81035, 1.7, 0.6, 0.10416666666667
81036, 1.6791666666667, 0.6, 0.125
81037, 1.7, 0.575, 0.125
81038, 1.7, 0.55, 0.10416666666667
81039, 1.6791666666667, 0.55, 0.125
81040, 1.7, 0.525, 0.125
81041, 1.7, 0.5, 0.10416666666667
81042, 1.6791666666667, 0.5, 0.125
81043, 1.7, 0.475, 0.125
81044, 1.7, 0.45, 0.10416666666667
81045, 1.6791666666667, 0.45, 0.125
81046, 1.7, 0.425, 0.125
81047, 1.7, 0.4, 0.10416666666667
81048, 1.6791666666667, 0.4, 0.125
81049, 1.7, 0.375, 0.125
81050, 1.7, 0.35, 0.10416666666667
81051, 1.6791666666667, 0.35, 0.125
81052, 1.7, 0.325, 0.125
81053, 1.7, 0.3, 0.10416666666667
81054, 1.6791666666667, 0.3, 0.125
81055, 1.7, 0.275, 0.125
81056, 1.7, 0.25, 0.10416666666667
81057, 1.6791666666667, 0.25, 0.125
81058, 1.7, 0.225, 0.125
81059, 1.7, 0.2, 0.10416666666667
81060, 1.6791666666667, 0.2, 0.125
81061, 1.7, 0.175, 0.125
81062, 1.7416666666667, 1.325, 0.125
81063, 1.7416666666667, 1.3, 0.10416666666667
81064, 1.7208333333333, 1.3, 0.125
81065, 1.7416666666667, 1.275, 0.125
81066, 1.7416666666667, 1.25, 0.10416666666667
81067, 1.7208333333333, 1.25, 0.125
81068, 1.7416666666667, 1.225, 0.125
81069, 1.7416666666667, 1.2, 0.10416666666667
81070, 1.7208333333333, 1.2, 0.125
81071, 1.7416666666667, 1.175, 0.125
81072, 1.7416666666667, 1.15, 0.10416666666667
81073, 1.7208333333333, 1.15, 0.125
81074, 1.7416666666667, 1.125, 0.125
81075, 1.7416666666667, 1.1, 0.10416666666667
81076, 1.7208333333333, 1.1, 0.125
81077, 1.7416666666667, 1.075, 0.125
81078, 1.7416666666667, 1.05, 0.10416666666667
81079, 1.7208333333333, 1.05, 0.125
81080, 1.7416666666667, 1.025, 0.125
81081, 1.7416666666667, 1, 0.10416666666667
81082, 1.7208333333333, 1, 0.125
81083, 1.7416666666667, 0.975, 0.125
81084, 1.7416666666667, 0.95, 0.10416666666667
81085, 1.7208333333333, 0.95, 0.125
81086, 1.7416666666667, 0.925, 0.125
81087, 1.7416666666667, 0.9, 0.10416666666667
81088, 1.7208333333333, 0.9, 0.125
81089, 1.7416666666667, 0.875, 0.125
81090, 1.7416666666667, 0.85, 0.10416666666667
81091, 1.7208333333333, 0.85, 0.125
81092, 1.7416666666667, 0.825, 0.125
81093, 1.7416666666667, 0.8, 0.10416666666667
81094, 1.7208333333333, 0.8, 0.125
81095, 1.7416666666667, 0.775, 0.125
81096, 1.7416666666667, 0.75, 0.10416666666667
81097, 1.7208333333333, 0.75, 0.125
81098, 1.7416666666667, 0.725, 0.125
81099, 1.7416666666667, 0.7, 0.10416666666667
81100, 1.7208333333333, 0.7, 0.125
81101, 1.7416666666667, 0.675, 0.125
81102, 1.7416666666667, 0.65, 0.10416666666667
81103, 1.7208333333333, 0.65, 0.125
81104, 1.7416666666667, 0.625, 0.125
81105, 1.7416666666667, 0.6, 0.10416666666667
81106, 1.7208333333333, 0.6, 0.125
81107, 1.7416666666667, 0.575, 0.125
81108, 1.7416666666667, 0.55, 0.10416666666667
81109, 1.7208333333333, 0.55, 0.125
81110, 1.7416666666667, 0.525, 0.125
81111, 1.7416666666667, 0.5, 0.10416666666667
81112, 1.7208333333333, 0.5, 0.125
81113, 1.7416666666667, 0.475, 0.125
81114, 1.7416666666667, 0.45, 0.10416666666667
81115, 1.7208333333333, 0.45, 0.125
81116, 1.7416666666667, 0.425, 0.125
81117, 1.7416666666667, 0.4, 0.10416666666667
81118, 1.7208333333333, 0.4, 0.125
81119, 1.7416666666667, 0.375, 0.125
81120, 1.7416666666667, 0.35, 0.10416666666667
81121, 1.7208333333333, 0.35, 0.125
81122, 1.7416666666667, 0.325, 0.125
81123, 1.7416666666667, 0.3, 0.10416666666667
81124, 1.7208333333333, 0.3, 0.125
81125, 1.7416666666667, 0.275, 0.125
81126, 1.7416666666667, 0.25, 0.10416666666667
81127, 1.7208333333333, 0.25, 0.125
81128, 1.7416666666667, 0.225, 0.125
81129, 1.7416666666667, 0.2, 0.10416666666667
81130, 1.7208333333333, 0.2, 0.125
81131, 1.7416666666667, 0.175, 0.125
81132, 1.7833333333333, 1.325, 0.125
81133, 1.7833333333333, 1.3, 0.10416666666667
81134, 1.7625, 1.3, 0.125
81135, 1.7833333333333, 1.275, 0.125
81136, 1.7833333333333, 1.25, 0.10416666666667
81137, 1.7625, 1.25, 0.125
81138, 1.7833333333333, 1.225, 0.125
81139, 1.7833333333333, 1.2, 0.10416666666667
81140, 1.7625, 1.2, 0.125
81141, 1.7833333333333, 1.175, 0.125
81142, 1.7833333333333, 1.15, 0.10416666666667
81143, 1.7625, 1.15, 0.125
81144, 1.7833333333333, 1.125, 0.125
81145, 1.7833333333333, 1.1, 0.10416666666667
81146, 1.7625, 1.1, 0.125
81147, 1.7833333333333, 1.075, 0.125
81148, 1.7833333333333, 1.05, 0.10416666666667
81149, 1.7625, 1.05, 0.125
81150, 1.7833333333333, 1.025, 0.125
81151, 1.7833333333333, 1, 0.10416666666667
81152, 1.7625, 1, 0.125
81153, 1.7833333333333, 0.975, 0.125
81154, 1.7833333333333, 0.95, 0.10416666666667
81155, 1.7625, 0.95, 0.125
81156, 1.7833333333333, 0.925, 0.125
81157, 1.7833333333333, 0.9, 0.10416666666667
81158, 1.7625, 0.9, 0.125
81159, 1.7833333333333, 0.875, 0.125
81160, 1.7833333333333, 0.85, 0.10416666666667
81161, 1.7625, 0.85, 0.125
81162, 1.7833333333333, 0.825, 0.125
81163, 1.7833333333333, 0.8, 0.10416666666667
81164, 1.7625, 0.8, 0.125
81165, 1.7833333333333, 0.775, 0.125
81166, 1.7833333333333, 0.75, 0.10416666666667
81167, 1.7625, 0.75, 0.125
81168, 1.7833333333333, 0.725, 0.125
81169, 1.7833333333333, 0.7, 0.10416666666667
81170, 1.7625, 0.7, 0.125
81171, 1.7833333333333, 0.675, 0.125
81172, 1.7833333333333, 0.65, 0.10416666666667
81173, 1.7625, 0.65, 0.125
81174, 1.7833333333333, 0.625, 0.125
81175, 1.7833333333333, 0.6, 0.10416666666667
81176, 1.7625, 0.6, 0.125
81177, 1.7833333333333, 0.575, 0.125
81178, 1.7833333333333, 0.55, 0.10416666666667
81179, 1.7625, 0.55, 0.125
81180, 1.7833333333333, 0.525, 0.125
81181, 1.7833333333333, 0.5, 0.10416666666667
81182, 1.7625, 0.5, 0.125
81183, 1.7833333333333, 0.475, 0.125
81184, 1.7833333333333, 0.45, 0.10416666666667
81185, 1.7625, 0.45, 0.125
81186, 1.7833333333333, 0.425, 0.125
81187, 1.7833333333333, 0.4, 0.10416666666667
81188, 1.7625, 0.4, 0.125
81189, 1.7833333333333, 0.375, 0.125
81190, 1.7833333333333, 0.35, 0.10416666666667
81191, 1.7625, 0.35, 0.125
81192, 1.7833333333333, 0.325, 0.125
81193, 1.7833333333333, 0.3, 0.10416666666667
81194, 1.7625, 0.3, 0.125
81195, 1.7833333333333, 0.275, 0.125
81196, 1.7833333333333, 0.25, 0.10416666666667
81197, 1.7625, 0.25, 0.125
81198, 1.7833333333333, 0.225, 0.125
81199, 1.7833333333333, 0.2, 0.10416666666667
81200, 1.7625, 0.2, 0.125
81201, 1.7833333333333, 0.175, 0.125
81202, 1.825, 1.325, 0.125
81203, 1.825, 1.3, 0.10416666666667
81204, 1.8041666666667, 1.3, 0.125
81205, 1.825, 1.275, 0.125
81206, 1.825, 1.25, 0.10416666666667
81207, 1.8041666666667, 1.25, 0.125
81208, 1.825, 1.225, 0.125
81209, 1.825, 1.2, 0.10416666666667
81210, 1.8041666666667, 1.2, 0.125
81211, 1.825, 1.175, 0.125
81212, 1.825, 1.15, 0.10416666666667
81213, 1.8041666666667, 1.15, 0.125
81214, 1.825, 1.125, 0.125
81215, 1.825, 1.1, 0.10416666666667
81216, 1.8041666666667, 1.1, 0.125
81217, 1.825, 1.075, 0.125
81218, 1.825, 1.05, 0.10416666666667
81219, 1.8041666666667, 1.05, 0.125
81220, 1.825, 1.025, 0.125
81221, 1.825, 1, 0.10416666666667
81222, 1.8041666666667, 1, 0.125
81223, 1.825, 0.975, 0.125
81224, 1.825, 0.95, 0.10416666666667
81225, 1.8041666666667, 0.95, 0.125
81226, 1.825, 0.925, 0.125
81227, 1.825, 0.9, 0.10416666666667
81228, 1.8041666666667, 0.9, 0.125
81229, 1.825, 0.875, 0.125
81230, 1.825, 0.85, 0.10416666666667
81231, 1.8041666666667, 0.85, 0.125
81232, 1.825, 0.825, 0.125
81233, 1.825, 0.8, 0.10416666666667
81234, 1.8041666666667, 0.8, 0.125
81235, 1.825, 0.775, 0.125
81236, 1.825, 0.75, 0.10416666666667
81237, 1.8041666666667, 0.75, 0.125
81238, 1.825, 0.725, 0.125
81239, 1.825, 0.7, 0.10416666666667
81240, 1.8041666666667, 0.7, 0.125
81241, 1.825, 0.675, 0.125
81242, 1.825, 0.65, 0.10416666666667
81243, 1.8041666666667, 0.65, 0.125
81244, 1.825, 0.625, 0.125
81245, 1.825, 0.6, 0.10416666666667
81246, 1.8041666666667, 0.6, 0.125
81247, 1.825, 0.575, 0.125
81248, 1.825, 0.55, 0.10416666666667
81249, 1.8041666666667, 0.55, 0.125
81250, 1.825, 0.525, 0.125
81251, 1.825, 0.5, 0.10416666666667
81252, 1.8041666666667, 0.5, 0.125
81253, 1.825, 0.475, 0.125
81254, 1.825, 0.45, 0.10416666666667
81255, 1.8041666666667, 0.45, 0.125
81256, 1.825, 0.425, 0.125
81257, 1.825, 0.4, 0.10416666666667
81258, 1.8041666666667, 0.4, 0.125
81259, 1.825, 0.375, 0.125
81260, 1.825, 0.35, 0.10416666666667
81261, 1.8041666666667, 0.35, 0.125
81262, 1.825, 0.325, 0.125
81263, 1.825, 0.3, 0.10416666666667
81264, 1.8041666666667, 0.3, 0.125
81265, 1.825, 0.275, 0.125
81266, 1.825, 0.25, 0.10416666666667
81267, 1.8041666666667, 0.25, 0.125
81268, 1.825, 0.225, 0.125
81269, 1.825, 0.2, 0.10416666666667
81270, 1.8041666666667, 0.2, 0.125
81271, 1.825, 0.175, 0.125
81272, 1.8666666666667, 1.325, 0.125
81273, 1.8666666666667, 1.3, 0.10416666666667
81274, 1.8458333333333, 1.3, 0.125
81275, 1.8666666666667, 1.275, 0.125
81276, 1.8666666666667, 1.25, 0.10416666666667
81277, 1.8458333333333, 1.25, 0.125
81278, 1.8666666666667, 1.225, 0.125
81279, 1.8666666666667, 1.2, 0.10416666666667
81280, 1.8458333333333, 1.2, 0.125
81281, 1.8666666666667, 1.175, 0.125
81282, 1.8666666666667, 1.15, 0.10416666666667
81283, 1.8458333333333, 1.15, 0.125
81284, 1.8666666666667, 1.125, 0.125
81285, 1.8666666666667, 1.1, 0.10416666666667
81286, 1.8458333333333, 1.1, 0.125
81287, 1.8666666666667, 1.075, 0.125
81288, 1.8666666666667, 1.05, 0.10416666666667
81289, 1.8458333333333, 1.05, 0.125
81290, 1.8666666666667, 1.025, 0.125
81291, 1.8666666666667, 1, 0.10416666666667
81292, 1.8458333333333, 1, 0.125
81293, 1.8666666666667, 0.975, 0.125
81294, 1.8666666666667, 0.95, 0.10416666666667
81295, 1.8458333333333, 0.95, 0.125
81296, 1.8666666666667, 0.925, 0.125
81297, 1.8666666666667, 0.9, 0.10416666666667
81298, 1.8458333333333, 0.9, 0.125
81299, 1.8666666666667, 0.875, 0.125
81300, 1.8666666666667, 0.85, 0.10416666666667
81301, 1.8458333333333, 0.85, 0.125
81302, 1.8666666666667, 0.825, 0.125
81303, 1.8666666666667, 0.8, 0.10416666666667
81304, 1.8458333333333, 0.8, 0.125
81305, 1.8666666666667, 0.775, 0.125
81306, 1.8666666666667, 0.75, 0.10416666666667
81307, 1.8458333333333, 0.75, 0.125
81308, 1.8666666666667, 0.725, 0.125
81309, 1.8666666666667, 0.7, 0.10416666666667
81310, 1.8458333333333, 0.7, 0.125
81311, 1.8666666666667, 0.675, 0.125
81312, 1.8666666666667, 0.65, 0.10416666666667
81313, 1.8458333333333, 0.65, 0.125
81314, 1.8666666666667, 0.625, 0.125
81315, 1.8666666666667, 0.6, 0.10416666666667
81316, 1.8458333333333, 0.6, 0.125
81317, 1.8666666666667, 0.575, 0.125
81318, 1.8666666666667, 0.55, 0.10416666666667
81319, 1.8458333333333, 0.55, 0.125
81320, 1.8666666666667, 0.525, 0.125
81321, 1.8666666666667, 0.5, 0.10416666666667
81322, 1.8458333333333, 0.5, 0.125
81323, 1.8666666666667, 0.475, 0.125
81324, 1.8666666666667, 0.45, 0.10416666666667
81325, 1.8458333333333, 0.45, 0.125
81326, 1.8666666666667, 0.425, 0.125
81327, 1.8666666666667, 0.4, 0.10416666666667
81328, 1.8458333333333, 0.4, 0.125
81329, 1.8666666666667, 0.375, 0.125
81330, 1.8666666666667, 0.35, 0.10416666666667
81331, 1.8458333333333, 0.35, 0.125
81332, 1.8666666666667, 0.325, 0.125
81333, 1.8666666666667, 0.3, 0.10416666666667
81334, 1.8458333333333, 0.3, 0.125
81335, 1.8666666666667, 0.275, 0.125
81336, 1.8666666666667, 0.25, 0.10416666666667
81337, 1.8458333333333, 0.25, 0.125
81338, 1.8666666666667, 0.225, 0.125
81339, 1.8666666666667, 0.2, 0.10416666666667
81340, 1.8458333333333, 0.2, 0.125
81341, 1.8666666666667, 0.175, 0.125
81342, 1.9083333333333, 1.325, 0.125
81343, 1.9083333333333, 1.3, 0.10416666666667
81344, 1.8875, 1.3, 0.125
81345, 1.9083333333333, 1.275, 0.125
81346, 1.9083333333333, 1.25, 0.10416666666667
81347, 1.8875, 1.25, 0.125
81348, 1.9083333333333, 1.225, 0.125
81349, 1.9083333333333, 1.2, 0.10416666666667
81350, 1.8875, 1.2, 0.125
81351, 1.9083333333333, 1.175, 0.125
81352, 1.9083333333333, 1.15, 0.10416666666667
81353, 1.8875, 1.15, 0.125
81354, 1.9083333333333, 1.125, 0.125
81355, 1.9083333333333, 1.1, 0.10416666666667
81356, 1.8875, 1.1, 0.125
81357, 1.9083333333333, 1.075, 0.125
81358, 1.9083333333333, 1.05, 0.10416666666667
81359, 1.8875, 1.05, 0.125
81360, 1.9083333333333, 1.025, 0.125
81361, 1.9083333333333, 1, 0.10416666666667
81362, 1.8875, 1, 0.125
81363, 1.9083333333333, 0.975, 0.125
81364, 1.9083333333333, 0.95, 0.10416666666667
81365, 1.8875, 0.95, 0.125
81366, 1.9083333333333, 0.925, 0.125
81367, 1.9083333333333, 0.9, 0.10416666666667
81368, 1.8875, 0.9, 0.125
81369, 1.9083333333333, 0.875, 0.125
81370, 1.9083333333333, 0.85, 0.10416666666667
81371, 1.8875, 0.85, 0.125
81372, 1.9083333333333, 0.825, 0.125
81373, 1.9083333333333, 0.8, 0.10416666666667
81374, 1.8875, 0.8, 0.125
81375, 1.9083333333333, 0.775, 0.125
81376, 1.9083333333333, 0.75, 0.10416666666667
81377, 1.8875, 0.75, 0.125
81378, 1.9083333333333, 0.725, 0.125
81379, 1.9083333333333, 0.7, 0.10416666666667
81380, 1.8875, 0.7, 0.125
81381, 1.9083333333333, 0.675, 0.125
81382, 1.9083333333333, 0.65, 0.10416666666667
81383, 1.8875, 0.65, 0.125
81384, 1.9083333333333, 0.625, 0.125
81385, 1.9083333333333, 0.6, 0.10416666666667
81386, 1.8875, 0.6, 0.125
81387, 1.9083333333333, 0.575, 0.125
81388, 1.9083333333333, 0.55, 0.10416666666667
81389, 1.8875, 0.55, 0.125
81390, 1.9083333333333, 0.525, 0.125
81391, 1.9083333333333, 0.5, 0.10416666666667
81392, 1.8875, 0.5, 0.125
81393, 1.9083333333333, 0.475, 0.125
81394, 1.9083333333333, 0.45, 0.10416666666667
81395, 1.8875, 0.45, 0.125
81396, 1.9083333333333, 0.425, 0.125
81397, 1.9083333333333, 0.4, 0.10416666666667
81398, 1.8875, 0.4, 0.125
81399, 1.9083333333333, 0.375, 0.125
81400, 1.9083333333333, 0.35, 0.10416666666667
81401, 1.8875, 0.35, 0.125
81402, 1.9083333333333, 0.325, 0.125
81403, 1.9083333333333, 0.3, 0.10416666666667
81404, 1.8875, 0.3, 0.125
81405, 1.9083333333333, 0.275, 0.125
81406, 1.9083333333333, 0.25, 0.10416666666667
81407, 1.8875, 0.25, 0.125
81408, 1.9083333333333, 0.225, 0.125
81409, 1.9083333333333, 0.2, 0.10416666666667
81410, 1.8875, 0.2, 0.125
81411, 1.9083333333333, 0.175, 0.125
81412, 1.95, 1.325, 0.125
81413, 1.95, 1.3, 0.10416666666667
81414, 1.9291666666667, 1.3, 0.125
81415, 1.95, 1.275, 0.125
81416, 1.95, 1.25, 0.10416666666667
81417, 1.9291666666667, 1.25, 0.125
81418, 1.95, 1.225, 0.125
81419, 1.95, 1.2, 0.10416666666667
81420, 1.9291666666667, 1.2, 0.125
81421, 1.95, 1.175, 0.125
81422, 1.95, 1.15, 0.10416666666667
81423, 1.9291666666667, 1.15, 0.125
81424, 1.95, 1.125, 0.125
81425, 1.95, 1.1, 0.10416666666667
81426, 1.9291666666667, 1.1, 0.125
81427, 1.95, 1.075, 0.125
81428, 1.95, 1.05, 0.10416666666667
81429, 1.9291666666667, 1.05, 0.125
81430, 1.95, 1.025, 0.125
81431, 1.95, 1, 0.10416666666667
81432, 1.9291666666667, 1, 0.125
81433, 1.95, 0.975, 0.125
81434, 1.95, 0.95, 0.10416666666667
81435, 1.9291666666667, 0.95, 0.125
81436, 1.95, 0.925, 0.125
81437, 1.95, 0.9, 0.10416666666667
81438, 1.9291666666667, 0.9, 0.125
81439, 1.95, 0.875, 0.125
81440, 1.95, 0.85, 0.10416666666667
81441, 1.9291666666667, 0.85, 0.125
81442, 1.95, 0.825, 0.125
81443, 1.95, 0.8, 0.10416666666667
81444, 1.9291666666667, 0.8, 0.125
81445, 1.95, 0.775, 0.125
81446, 1.95, 0.75, 0.10416666666667
81447, 1.9291666666667, 0.75, 0.125
81448, 1.95, 0.725, 0.125
81449, 1.95, 0.7, 0.10416666666667
81450, 1.9291666666667, 0.7, 0.125
81451, 1.95, 0.675, 0.125
81452, 1.95, 0.65, 0.10416666666667
81453, 1.9291666666667, 0.65, 0.125
81454, 1.95, 0.625, 0.125
81455, 1.95, 0.6, 0.10416666666667
81456, 1.9291666666667, 0.6, 0.125
81457, 1.95, 0.575, 0.125
81458, 1.95, 0.55, 0.10416666666667
81459, 1.9291666666667, 0.55, 0.125
81460, 1.95, 0.525, 0.125
81461, 1.95, 0.5, 0.10416666666667
81462, 1.9291666666667, 0.5, 0.125
81463, 1.95, 0.475, 0.125
81464, 1.95, 0.45, 0.10416666666667
81465, 1.9291666666667, 0.45, 0.125
81466, 1.95, 0.425, 0.125
81467, 1.95, 0.4, 0.10416666666667
81468, 1.9291666666667, 0.4, 0.125
81469, 1.95, 0.375, 0.125
81470, 1.95, 0.35, 0.10416666666667
81471, 1.9291666666667, 0.35, 0.125
81472, 1.95, 0.325, 0.125
81473, 1.95, 0.3, 0.10416666666667
81474, 1.9291666666667, 0.3, 0.125
81475, 1.95, 0.275, 0.125
81476, 1.95, 0.25, 0.10416666666667
81477, 1.9291666666667, 0.25, 0.125
81478, 1.95, 0.225, 0.125
81479, 1.95, 0.2, 0.10416666666667
81480, 1.9291666666667, 0.2, 0.125
81481, 1.95, 0.175, 0.125
81482, 1.9916666666667, 1.325, 0.125
81483, 1.9916666666667, 1.3, 0.10416666666667
81484, 1.9708333333333, 1.3, 0.125
81485, 1.9916666666667, 1.275, 0.125
81486, 1.9916666666667, 1.25, 0.10416666666667
81487, 1.9708333333333, 1.25, 0.125
81488, 1.9916666666667, 1.225, 0.125
81489, 1.9916666666667, 1.2, 0.10416666666667
81490, 1.9708333333333, 1.2, 0.125
81491, 1.9916666666667, 1.175, 0.125
81492, 1.9916666666667, 1.15, 0.10416666666667
81493, 1.9708333333333, 1.15, 0.125
81494, 1.9916666666667, 1.125, 0.125
81495, 1.9916666666667, 1.1, 0.10416666666667
81496, 1.9708333333333, 1.1, 0.125
81497, 1.9916666666667, 1.075, 0.125
81498, 1.9916666666667, 1.05, 0.10416666666667
81499, 1.9708333333333, 1.05, 0.125
81500, 1.9916666666667, 1.025, 0.125
81501, 1.9916666666667, 1, 0.10416666666667
81502, 1.9708333333333, 1, 0.125
81503, 1.9916666666667, 0.975, 0.125
81504, 1.9916666666667, 0.95, 0.10416666666667
81505, 1.9708333333333, 0.95, 0.125
81506, 1.9916666666667, 0.925, 0.125
81507, 1.9916666666667, 0.9, 0.10416666666667
81508, 1.9708333333333, 0.9, 0.125
81509, 1.9916666666667, 0.875, 0.125
81510, 1.9916666666667, 0.85, 0.10416666666667
81511, 1.9708333333333, 0.85, 0.125
81512, 1.9916666666667, 0.825, 0.125
81513, 1.9916666666667, 0.8, 0.10416666666667
81514, 1.9708333333333, 0.8, 0.125
81515, 1.9916666666667, 0.775, 0.125
81516, 1.9916666666667, 0.75, 0.10416666666667
81517, 1.9708333333333, 0.75, 0.125
81518, 1.9916666666667, 0.725, 0.125
81519, 1.9916666666667, 0.7, 0.10416666666667
81520, 1.9708333333333, 0.7, 0.125
81521, 1.9916666666667, 0.675, 0.125
81522, 1.9916666666667, 0.65, 0.10416666666667
81523, 1.9708333333333, 0.65, 0.125
81524, 1.9916666666667, 0.625, 0.125
81525, 1.9916666666667, 0.6, 0.10416666666667
81526, 1.9708333333333, 0.6, 0.125
81527, 1.9916666666667, 0.575, 0.125
81528, 1.9916666666667, 0.55, 0.10416666666667
81529, 1.9708333333333, 0.55, 0.125
81530, 1.9916666666667, 0.525, 0.125
81531, 1.9916666666667, 0.5, 0.10416666666667
81532, 1.9708333333333, 0.5, 0.125
81533, 1.9916666666667, 0.475, 0.125
81534, 1.9916666666667, 0.45, 0.10416666666667
81535, 1.9708333333333, 0.45, 0.125
81536, 1.9916666666667, 0.425, 0.125
81537, 1.9916666666667, 0.4, 0.10416666666667
81538, 1.9708333333333, 0.4, 0.125
81539, 1.9916666666667, 0.375, 0.125
81540, 1.9916666666667, 0.35, 0.10416666666667
81541, 1.9708333333333, 0.35, 0.125
81542, 1.9916666666667, 0.325, 0.125
81543, 1.9916666666667, 0.3, 0.10416666666667
81544, 1.9708333333333, 0.3, 0.125
81545, 1.9916666666667, 0.275, 0.125
81546, 1.9916666666667, 0.25, 0.10416666666667
81547, 1.9708333333333, 0.25, 0.125
81548, 1.9916666666667, 0.225, 0.125
81549, 1.9916666666667, 0.2, 0.10416666666667
81550, 1.9708333333333, 0.2, 0.125
81551, 1.9916666666667, 0.175, 0.125
81552, 2.0333333333333, 1.325, 0.125
81553, 2.0333333333333, 1.3, 0.10416666666667
81554, 2.0125, 1.3, 0.125
81555, 2.0333333333333, 1.275, 0.125
81556, 2.0333333333333, 1.25, 0.10416666666667
81557, 2.0125, 1.25, 0.125
81558, 2.0333333333333, 1.225, 0.125
81559, 2.0333333333333, 1.2, 0.10416666666667
81560, 2.0125, 1.2, 0.125
81561, 2.0333333333333, 1.175, 0.125
81562, 2.0333333333333, 1.15, 0.10416666666667
81563, 2.0125, 1.15, 0.125
81564, 2.0333333333333, 1.125, 0.125
81565, 2.0333333333333, 1.1, 0.10416666666667
81566, 2.0125, 1.1, 0.125
81567, 2.0333333333333, 1.075, 0.125
81568, 2.0333333333333, 1.05, 0.10416666666667
81569, 2.0125, 1.05, 0.125
81570, 2.0333333333333, 1.025, 0.125
81571, 2.0333333333333, 1, 0.10416666666667
81572, 2.0125, 1, 0.125
81573, 2.0333333333333, 0.975, 0.125
81574, 2.0333333333333, 0.95, 0.10416666666667
81575, 2.0125, 0.95, 0.125
81576, 2.0333333333333, 0.925, 0.125
81577, 2.0333333333333, 0.9, 0.10416666666667
81578, 2.0125, 0.9, 0.125
81579, 2.0333333333333, 0.875, 0.125
81580, 2.0333333333333, 0.85, 0.10416666666667
81581, 2.0125, 0.85, 0.125
81582, 2.0333333333333, 0.825, 0.125
81583, 2.0333333333333, 0.8, 0.10416666666667
81584, 2.0125, 0.8, 0.125
81585, 2.0333333333333, 0.775, 0.125
81586, 2.0333333333333, 0.75, 0.10416666666667
81587, 2.0125, 0.75, 0.125
81588, 2.0333333333333, 0.725, 0.125
81589, 2.0333333333333, 0.7, 0.10416666666667
81590, 2.0125, 0.7, 0.125
81591, 2.0333333333333, 0.675, 0.125
81592, 2.0333333333333, 0.65, 0.10416666666667
81593, 2.0125, 0.65, 0.125
81594, 2.0333333333333, 0.625, 0.125
81595, 2.0333333333333, 0.6, 0.10416666666667
81596, 2.0125, 0.6, 0.125
81597, 2.0333333333333, 0.575, 0.125
81598, 2.0333333333333, 0.55, 0.10416666666667
81599, 2.0125, 0.55, 0.125
81600, 2.0333333333333, 0.525, 0.125
81601, 2.0333333333333, 0.5, 0.10416666666667
81602, 2.0125, 0.5, 0.125
81603, 2.0333333333333, 0.475, 0.125
81604, 2.0333333333333, 0.45, 0.10416666666667
81605, 2.0125, 0.45, 0.125
81606, 2.0333333333333, 0.425, 0.125
81607, 2.0333333333333, 0.4, 0.10416666666667
81608, 2.0125, 0.4, 0.125
81609, 2.0333333333333, 0.375, 0.125
81610, 2.0333333333333, 0.35, 0.10416666666667
81611, 2.0125, 0.35, 0.125
81612, 2.0333333333333, 0.325, 0.125
81613, 2.0333333333333, 0.3, 0.10416666666667
81614, 2.0125, 0.3, 0.125
81615, 2.0333333333333, 0.275, 0.125
81616, 2.0333333333333, 0.25, 0.10416666666667
81617, 2.0125, 0.25, 0.125
81618, 2.0333333333333, 0.225, 0.125
81619, 2.0333333333333, 0.2, 0.10416666666667
81620, 2.0125, 0.2, 0.125
81621, 2.0333333333333, 0.175, 0.125
81622, 2.075, 1.325, 0.125
81623, 2.075, 1.3, 0.10416666666667
81624, 2.0541666666667, 1.3, 0.125
81625, 2.075, 1.275, 0.125
81626, 2.075, 1.25, 0.10416666666667
81627, 2.0541666666667, 1.25, 0.125
81628, 2.075, 1.225, 0.125
81629, 2.075, 1.2, 0.10416666666667
81630, 2.0541666666667, 1.2, 0.125
81631, 2.075, 1.175, 0.125
81632, 2.075, 1.15, 0.10416666666667
81633, 2.0541666666667, 1.15, 0.125
81634, 2.075, 1.125, 0.125
81635, 2.075, 1.1, 0.10416666666667
81636, 2.0541666666667, 1.1, 0.125
81637, 2.075, 1.075, 0.125
81638, 2.075, 1.05, 0.10416666666667
81639, 2.0541666666667, 1.05, 0.125
81640, 2.075, 1.025, 0.125
81641, 2.075, 1, 0.10416666666667
81642, 2.0541666666667, 1, 0.125
81643, 2.075, 0.975, 0.125
81644, 2.075, 0.95, 0.10416666666667
81645, 2.0541666666667, 0.95, 0.125
81646, 2.075, 0.925, 0.125
81647, 2.075, 0.9, 0.10416666666667
81648, 2.0541666666667, 0.9, 0.125
81649, 2.075, 0.875, 0.125
81650, 2.075, 0.85, 0.10416666666667
81651, 2.0541666666667, 0.85, 0.125
81652, 2.075, 0.825, 0.125
81653, 2.075, 0.8, 0.10416666666667
81654, 2.0541666666667, 0.8, 0.125
81655, 2.075, 0.775, 0.125
81656, 2.075, 0.75, 0.10416666666667
81657, 2.0541666666667, 0.75, 0.125
81658, 2.075, 0.725, 0.125
81659, 2.075, 0.7, 0.10416666666667
81660, 2.0541666666667, 0.7, 0.125
81661, 2.075, 0.675, 0.125
81662, 2.075, 0.65, 0.10416666666667
81663, 2.0541666666667, 0.65, 0.125
81664, 2.075, 0.625, 0.125
81665, 2.075, 0.6, 0.10416666666667
81666, 2.0541666666667, 0.6, 0.125
81667, 2.075, 0.575, 0.125
81668, 2.075, 0.55, 0.10416666666667
81669, 2.0541666666667, 0.55, 0.125
81670, 2.075, 0.525, 0.125
81671, 2.075, 0.5, 0.10416666666667
81672, 2.0541666666667, 0.5, 0.125
81673, 2.075, 0.475, 0.125
81674, 2.075, 0.45, 0.10416666666667
81675, 2.0541666666667, 0.45, 0.125
81676, 2.075, 0.425, 0.125
81677, 2.075, 0.4, 0.10416666666667
81678, 2.0541666666667, 0.4, 0.125
81679, 2.075, 0.375, 0.125
81680, 2.075, 0.35, 0.10416666666667
81681, 2.0541666666667, 0.35, 0.125
81682, 2.075, 0.325, 0.125
81683, 2.075, 0.3, 0.10416666666667
81684, 2.0541666666667, 0.3, 0.125
81685, 2.075, 0.275, 0.125
81686, 2.075, 0.25, 0.10416666666667
81687, 2.0541666666667, 0.25, 0.125
81688, 2.075, 0.225, 0.125
81689, 2.075, 0.2, 0.10416666666667
81690, 2.0541666666667, 0.2, 0.125
81691, 2.075, 0.175, 0.125
81692, 2.1166666666667, 1.325, 0.125
81693, 2.1166666666667, 1.3, 0.10416666666667
81694, 2.0958333333333, 1.3, 0.125
81695, 2.1166666666667, 1.275, 0.125
81696, 2.1166666666667, 1.25, 0.10416666666667
81697, 2.0958333333333, 1.25, 0.125
81698, 2.1166666666667, 1.225, 0.125
81699, 2.1166666666667, 1.2, 0.10416666666667
81700, 2.0958333333333, 1.2, 0.125
81701, 2.1166666666667, 1.175, 0.125
81702, 2.1166666666667, 1.15, 0.10416666666667
81703, 2.0958333333333, 1.15, 0.125
81704, 2.1166666666667, 1.125, 0.125
81705, 2.1166666666667, 1.1, 0.10416666666667
81706, 2.0958333333333, 1.1, 0.125
81707, 2.1166666666667, 1.075, 0.125
81708, 2.1166666666667, 1.05, 0.10416666666667
81709, 2.0958333333333, 1.05, 0.125
81710, 2.1166666666667, 1.025, 0.125
81711, 2.1166666666667, 1, 0.10416666666667
81712, 2.0958333333333, 1, 0.125
81713, 2.1166666666667, 0.975, 0.125
81714, 2.1166666666667, 0.95, 0.10416666666667
81715, 2.0958333333333, 0.95, 0.125
81716, 2.1166666666667, 0.925, 0.125
81717, 2.1166666666667, 0.9, 0.10416666666667
81718, 2.0958333333333, 0.9, 0.125
81719, 2.1166666666667, 0.875, 0.125
81720, 2.1166666666667, 0.85, 0.10416666666667
81721, 2.0958333333333, 0.85, 0.125
81722, 2.1166666666667, 0.825, 0.125
81723, 2.1166666666667, 0.8, 0.10416666666667
81724, 2.0958333333333, 0.8, 0.125
81725, 2.1166666666667, 0.775, 0.125
81726, 2.1166666666667, 0.75, 0.10416666666667
81727, 2.0958333333333, 0.75, 0.125
81728, 2.1166666666667, 0.725, 0.125
81729, 2.1166666666667, 0.7, 0.10416666666667
81730, 2.0958333333333, 0.7, 0.125
81731, 2.1166666666667, 0.675, 0.125
81732, 2.1166666666667, 0.65, 0.10416666666667
81733, 2.0958333333333, 0.65, 0.125
81734, 2.1166666666667, 0.625, 0.125
81735, 2.1166666666667, 0.6, 0.10416666666667
81736, 2.0958333333333, 0.6, 0.125
81737, 2.1166666666667, 0.575, 0.125
81738, 2.1166666666667, 0.55, 0.10416666666667
81739, 2.0958333333333, 0.55, 0.125
81740, 2.1166666666667, 0.525, 0.125
81741, 2.1166666666667, 0.5, 0.10416666666667
81742, 2.0958333333333, 0.5, 0.125
81743, 2.1166666666667, 0.475, 0.125
81744, 2.1166666666667, 0.45, 0.10416666666667
81745, 2.0958333333333, 0.45, 0.125
81746, 2.1166666666667, 0.425, 0.125
81747, 2.1166666666667, 0.4, 0.10416666666667
81748, 2.0958333333333, 0.4, 0.125
81749, 2.1166666666667, 0.375, 0.125
81750, 2.1166666666667, 0.35, 0.10416666666667
81751, 2.0958333333333, 0.35, 0.125
81752, 2.1166666666667, 0.325, 0.125
81753, 2.1166666666667, 0.3, 0.10416666666667
81754, 2.0958333333333, 0.3, 0.125
81755, 2.1166666666667, 0.275, 0.125
81756, 2.1166666666667, 0.25, 0.10416666666667
81757, 2.0958333333333, 0.25, 0.125
81758, 2.1166666666667, 0.225, 0.125
81759, 2.1166666666667, 0.2, 0.10416666666667
81760, 2.0958333333333, 0.2, 0.125
81761, 2.1166666666667, 0.175, 0.125
81762, 2.1583333333333, 1.325, 0.125
81763, 2.1583333333333, 1.3, 0.10416666666667
81764, 2.1375, 1.3, 0.125
81765, 2.1583333333333, 1.275, 0.125
81766, 2.1583333333333, 1.25, 0.10416666666667
81767, 2.1375, 1.25, 0.125
81768, 2.1583333333333, 1.225, 0.125
81769, 2.1583333333333, 1.2, 0.10416666666667
81770, 2.1375, 1.2, 0.125
81771, 2.1583333333333, 1.175, 0.125
81772, 2.1583333333333, 1.15, 0.10416666666667
81773, 2.1375, 1.15, 0.125
81774, 2.1583333333333, 1.125, 0.125
81775, 2.1583333333333, 1.1, 0.10416666666667
81776, 2.1375, 1.1, 0.125
81777, 2.1583333333333, 1.075, 0.125
81778, 2.1583333333333, 1.05, 0.10416666666667
81779, 2.1375, 1.05, 0.125
81780, 2.1583333333333, 1.025, 0.125
81781, 2.1583333333333, 1, 0.10416666666667
81782, 2.1375, 1, 0.125
81783, 2.1583333333333, 0.975, 0.125
81784, 2.1583333333333, 0.95, 0.10416666666667
81785, 2.1375, 0.95, 0.125
81786, 2.1583333333333, 0.925, 0.125
81787, 2.1583333333333, 0.9, 0.10416666666667
81788, 2.1375, 0.9, 0.125
81789, 2.1583333333333, 0.875, 0.125
81790, 2.1583333333333, 0.85, 0.10416666666667
81791, 2.1375, 0.85, 0.125
81792, 2.1583333333333, 0.825, 0.125
81793, 2.1583333333333, 0.8, 0.10416666666667
81794, 2.1375, 0.8, 0.125
81795, 2.1583333333333, 0.775, 0.125
81796, 2.1583333333333, 0.75, 0.10416666666667
81797, 2.1375, 0.75, 0.125
81798, 2.1583333333333, 0.725, 0.125
81799, 2.1583333333333, 0.7, 0.10416666666667
81800, 2.1375, 0.7, 0.125
81801, 2.1583333333333, 0.675, 0.125
81802, 2.1583333333333, 0.65, 0.10416666666667
81803, 2.1375, 0.65, 0.125
81804, 2.1583333333333, 0.625, 0.125
81805, 2.1583333333333, 0.6, 0.10416666666667
81806, 2.1375, 0.6, 0.125
81807, 2.1583333333333, 0.575, 0.125
81808, 2.1583333333333, 0.55, 0.10416666666667
81809, 2.1375, 0.55, 0.125
81810, 2.1583333333333, 0.525, 0.125
81811, 2.1583333333333, 0.5, 0.10416666666667
81812, 2.1375, 0.5, 0.125
81813, 2.1583333333333, 0.475, 0.125
81814, 2.1583333333333, 0.45, 0.10416666666667
81815, 2.1375, 0.45, 0.125
81816, 2.1583333333333, 0.425, 0.125
81817, 2.1583333333333, 0.4, 0.10416666666667
81818, 2.1375, 0.4, 0.125
81819, 2.1583333333333, 0.375, 0.125
81820, 2.1583333333333, 0.35, 0.10416666666667
81821, 2.1375, 0.35, 0.125
81822, 2.1583333333333, 0.325, 0.125
81823, 2.1583333333333, 0.3, 0.10416666666667
81824, 2.1375, 0.3, 0.125
81825, 2.1583333333333, 0.275, 0.125
81826, 2.1583333333333, 0.25, 0.10416666666667
81827, 2.1375, 0.25, 0.125
81828, 2.1583333333333, 0.225, 0.125
81829, 2.1583333333333, 0.2, 0.10416666666667
81830, 2.1375, 0.2, 0.125
81831, 2.1583333333333, 0.175, 0.125
81832, 2.1791666666667, 1.3, 0.125
81833, 2.1791666666667, 1.25, 0.125
81834, 2.1791666666667, 1.2, 0.125
81835, 2.1791666666667, 1.15, 0.125
81836, 2.1791666666667, 1.1, 0.125
81837, 2.1791666666667, 1.05, 0.125
81838, 2.1791666666667, 1, 0.125
81839, 2.1791666666667, 0.95, 0.125
81840, 2.1791666666667, 0.9, 0.125
81841, 2.1791666666667, 0.85, 0.125
81842, 2.1791666666667, 0.8, 0.125
81843, 2.1791666666667, 0.75, 0.125
81844, 2.1791666666667, 0.7, 0.125
81845, 2.1791666666667, 0.65, 0.125
81846, 2.1791666666667, 0.6, 0.125
81847, 2.1791666666667, 0.55, 0.125
81848, 2.1791666666667, 0.5, 0.125
81849, 2.1791666666667, 0.45, 0.125
81850, 2.1791666666667, 0.4, 0.125
81851, 2.1791666666667, 0.35, 0.125
81852, 2.1791666666667, 0.3, 0.125
81853, 2.1791666666667, 0.25, 0.125
81854, 2.1791666666667, 0.2, 0.125
81855, 1.2416666666667, 1.325, 0.16666666666667
81856, 1.2416666666667, 1.3, 0.14583333333333
81857, 1.2208333333333, 1.3, 0.16666666666667
81858, 1.2416666666667, 1.275, 0.16666666666667
81859, 1.2416666666667, 1.25, 0.14583333333333
81860, 1.2208333333333, 1.25, 0.16666666666667
81861, 1.2416666666667, 1.225, 0.16666666666667
81862, 1.2416666666667, 1.2, 0.14583333333333
81863, 1.2208333333333, 1.2, 0.16666666666667
81864, 1.2416666666667, 1.175, 0.16666666666667
81865, 1.2416666666667, 1.15, 0.14583333333333
81866, 1.2208333333333, 1.15, 0.16666666666667
81867, 1.2416666666667, 1.125, 0.16666666666667
81868, 1.2416666666667, 1.1, 0.14583333333333
81869, 1.2208333333333, 1.1, 0.16666666666667
81870, 1.2416666666667, 1.075, 0.16666666666667
81871, 1.2416666666667, 1.05, 0.14583333333333
81872, 1.2208333333333, 1.05, 0.16666666666667
81873, 1.2416666666667, 1.025, 0.16666666666667
81874, 1.2416666666667, 1, 0.14583333333333
81875, 1.2208333333333, 1, 0.16666666666667
81876, 1.2416666666667, 0.975, 0.16666666666667
81877, 1.2416666666667, 0.95, 0.14583333333333
81878, 1.2208333333333, 0.95, 0.16666666666667
81879, 1.2416666666667, 0.925, 0.16666666666667
81880, 1.2416666666667, 0.9, 0.14583333333333
81881, 1.2208333333333, 0.9, 0.16666666666667
81882, 1.2416666666667, 0.875, 0.16666666666667
81883, 1.2416666666667, 0.85, 0.14583333333333
81884, 1.2208333333333, 0.85, 0.16666666666667
81885, 1.2416666666667, 0.825, 0.16666666666667
81886, 1.2416666666667, 0.8, 0.14583333333333
81887, 1.2208333333333, 0.8, 0.16666666666667
81888, 1.2416666666667, 0.775, 0.16666666666667
81889, 1.2416666666667, 0.75, 0.14583333333333
81890, 1.2208333333333, 0.75, 0.16666666666667
81891, 1.2416666666667, 0.725, 0.16666666666667
81892, 1.2416666666667, 0.7, 0.14583333333333
81893, 1.2208333333333, 0.7, 0.16666666666667
81894, 1.2416666666667, 0.675, 0.16666666666667
81895, 1.2416666666667, 0.65, 0.14583333333333
81896, 1.2208333333333, 0.65, 0.16666666666667
81897, 1.2416666666667, 0.625, 0.16666666666667
81898, 1.2416666666667, 0.6, 0.14583333333333
81899, 1.2208333333333, 0.6, 0.16666666666667
81900, 1.2416666666667, 0.575, 0.16666666666667
81901, 1.2416666666667, 0.55, 0.14583333333333
81902, 1.2208333333333, 0.55, 0.16666666666667
81903, 1.2416666666667, 0.525, 0.16666666666667
81904, 1.2416666666667, 0.5, 0.14583333333333
81905, 1.2208333333333, 0.5, 0.16666666666667
81906, 1.2416666666667, 0.475, 0.16666666666667
81907, 1.2416666666667, 0.45, 0.14583333333333
81908, 1.2208333333333, 0.45, 0.16666666666667
81909, 1.2416666666667, 0.425, 0.16666666666667
81910, 1.2416666666667, 0.4, 0.14583333333333
81911, 1.2208333333333, 0.4, 0.16666666666667
81912, 1.2416666666667, 0.375, 0.16666666666667
81913, 1.2416666666667, 0.35, 0.14583333333333
81914, 1.2208333333333, 0.35, 0.16666666666667
81915, 1.2416666666667, 0.325, 0.16666666666667
81916, 1.2416666666667, 0.3, 0.14583333333333
81917, 1.2208333333333, 0.3, 0.16666666666667
81918, 1.2416666666667, 0.275, 0.16666666666667
81919, 1.2416666666667, 0.25, 0.14583333333333
81920, 1.2208333333333, 0.25, 0.16666666666667
81921, 1.2416666666667, 0.225, 0.16666666666667
81922, 1.2416666666667, 0.2, 0.14583333333333
81923, 1.2208333333333, 0.2, 0.16666666666667
81924, 1.2416666666667, 0.175, 0.16666666666667
81925, 1.2833333333333, 1.325, 0.16666666666667
81926, 1.2833333333333, 1.3, 0.14583333333333
81927, 1.2625, 1.3, 0.16666666666667
81928, 1.2833333333333, 1.275, 0.16666666666667
81929, 1.2833333333333, 1.25, 0.14583333333333
81930, 1.2625, 1.25, 0.16666666666667
81931, 1.2833333333333, 1.225, 0.16666666666667
81932, 1.2833333333333, 1.2, 0.14583333333333
81933, 1.2625, 1.2, 0.16666666666667
81934, 1.2833333333333, 1.175, 0.16666666666667
81935, 1.2833333333333, 1.15, 0.14583333333333
81936, 1.2625, 1.15, 0.16666666666667
81937, 1.2833333333333, 1.125, 0.16666666666667
81938, 1.2833333333333, 1.1, 0.14583333333333
81939, 1.2625, 1.1, 0.16666666666667
81940, 1.2833333333333, 1.075, 0.16666666666667
81941, 1.2833333333333, 1.05, 0.14583333333333
81942, 1.2625, 1.05, 0.16666666666667
81943, 1.2833333333333, 1.025, 0.16666666666667
81944, 1.2833333333333, 1, 0.14583333333333
81945, 1.2625, 1, 0.16666666666667
81946, 1.2833333333333, 0.975, 0.16666666666667
81947, 1.2833333333333, 0.95, 0.14583333333333
81948, 1.2625, 0.95, 0.16666666666667
81949, 1.2833333333333, 0.925, 0.16666666666667
81950, 1.2833333333333, 0.9, 0.14583333333333
81951, 1.2625, 0.9, 0.16666666666667
81952, 1.2833333333333, 0.875, 0.16666666666667
81953, 1.2833333333333, 0.85, 0.14583333333333
81954, 1.2625, 0.85, 0.16666666666667
81955, 1.2833333333333, 0.825, 0.16666666666667
81956, 1.2833333333333, 0.8, 0.14583333333333
81957, 1.2625, 0.8, 0.16666666666667
81958, 1.2833333333333, 0.775, 0.16666666666667
81959, 1.2833333333333, 0.75, 0.14583333333333
81960, 1.2625, 0.75, 0.16666666666667
81961, 1.2833333333333, 0.725, 0.16666666666667
81962, 1.2833333333333, 0.7, 0.14583333333333
81963, 1.2625, 0.7, 0.16666666666667
81964, 1.2833333333333, 0.675, 0.16666666666667
81965, 1.2833333333333, 0.65, 0.14583333333333
81966, 1.2625, 0.65, 0.16666666666667
81967, 1.2833333333333, 0.625, 0.16666666666667
81968, 1.2833333333333, 0.6, 0.14583333333333
81969, 1.2625, 0.6, 0.16666666666667
81970, 1.2833333333333, 0.575, 0.16666666666667
81971, 1.2833333333333, 0.55, 0.14583333333333
81972, 1.2625, 0.55, 0.16666666666667
81973, 1.2833333333333, 0.525, 0.16666666666667
81974, 1.2833333333333, 0.5, 0.14583333333333
81975, 1.2625, 0.5, 0.16666666666667
81976, 1.2833333333333, 0.475, 0.16666666666667
81977, 1.2833333333333, 0.45, 0.14583333333333
81978, 1.2625, 0.45, 0.16666666666667
81979, 1.2833333333333, 0.425, 0.16666666666667
81980, 1.2833333333333, 0.4, 0.14583333333333
81981, 1.2625, 0.4, 0.16666666666667
81982, 1.2833333333333, 0.375, 0.16666666666667
81983, 1.2833333333333, 0.35, 0.14583333333333
81984, 1.2625, 0.35, 0.16666666666667
81985, 1.2833333333333, 0.325, 0.16666666666667
81986, 1.2833333333333, 0.3, 0.14583333333333
81987, 1.2625, 0.3, 0.16666666666667
81988, 1.2833333333333, 0.275, 0.16666666666667
81989, 1.2833333333333, 0.25, 0.14583333333333
81990, 1.2625, 0.25, 0.16666666666667
81991, 1.2833333333333, 0.225, 0.16666666666667
81992, 1.2833333333333, 0.2, 0.14583333333333
81993, 1.2625, 0.2, 0.16666666666667
81994, 1.2833333333333, 0.175, 0.16666666666667
81995, 1.325, 1.325, 0.16666666666667
81996, 1.325, 1.3, 0.14583333333333
81997, 1.3041666666667, 1.3, 0.16666666666667
81998, 1.325, 1.275, 0.16666666666667
81999, 1.325, 1.25, 0.14583333333333
82000, 1.3041666666667, 1.25, 0.16666666666667
82001, 1.325, 1.225, 0.16666666666667
82002, 1.325, 1.2, 0.14583333333333
82003, 1.3041666666667, 1.2, 0.16666666666667
82004, 1.325, 1.175, 0.16666666666667
82005, 1.325, 1.15, 0.14583333333333
82006, 1.3041666666667, 1.15, 0.16666666666667
82007, 1.325, 1.125, 0.16666666666667
82008, 1.325, 1.1, 0.14583333333333
82009, 1.3041666666667, 1.1, 0.16666666666667
82010, 1.325, 1.075, 0.16666666666667
82011, 1.325, 1.05, 0.14583333333333
82012, 1.3041666666667, 1.05, 0.16666666666667
82013, 1.325, 1.025, 0.16666666666667
82014, 1.325, 1, 0.14583333333333
82015, 1.3041666666667, 1, 0.16666666666667
82016, 1.325, 0.975, 0.16666666666667
82017, 1.325, 0.95, 0.14583333333333
82018, 1.3041666666667, 0.95, 0.16666666666667
82019, 1.325, 0.925, 0.16666666666667
82020, 1.325, 0.9, 0.14583333333333
82021, 1.3041666666667, 0.9, 0.16666666666667
82022, 1.325, 0.875, 0.16666666666667
82023, 1.325, 0.85, 0.14583333333333
82024, 1.3041666666667, 0.85, 0.16666666666667
82025, 1.325, 0.825, 0.16666666666667
82026, 1.325, 0.8, 0.14583333333333
82027, 1.3041666666667, 0.8, 0.16666666666667
82028, 1.325, 0.775, 0.16666666666667
82029, 1.325, 0.75, 0.14583333333333
82030, 1.3041666666667, 0.75, 0.16666666666667
82031, 1.325, 0.725, 0.16666666666667
82032, 1.325, 0.7, 0.14583333333333
82033, 1.3041666666667, 0.7, 0.16666666666667
82034, 1.325, 0.675, 0.16666666666667
82035, 1.325, 0.65, 0.14583333333333
82036, 1.3041666666667, 0.65, 0.16666666666667
82037, 1.325, 0.625, 0.16666666666667
82038, 1.325, 0.6, 0.14583333333333
82039, 1.3041666666667, 0.6, 0.16666666666667
82040, 1.325, 0.575, 0.16666666666667
82041, 1.325, 0.55, 0.14583333333333
82042, 1.3041666666667, 0.55, 0.16666666666667
82043, 1.325, 0.525, 0.16666666666667
82044, 1.325, 0.5, 0.14583333333333
82045, 1.3041666666667, 0.5, 0.16666666666667
82046, 1.325, 0.475, 0.16666666666667
82047, 1.325, 0.45, 0.14583333333333
82048, 1.3041666666667, 0.45, 0.16666666666667
82049, 1.325, 0.425, 0.16666666666667
82050, 1.325, 0.4, 0.14583333333333
82051, 1.3041666666667, 0.4, 0.16666666666667
82052, 1.325, 0.375, 0.16666666666667
82053, 1.325, 0.35, 0.14583333333333
82054, 1.3041666666667, 0.35, 0.16666666666667
82055, 1.325, 0.325, 0.16666666666667
82056, 1.325, 0.3, 0.14583333333333
82057, 1.3041666666667, 0.3, 0.16666666666667
82058, 1.325, 0.275, 0.16666666666667
82059, 1.325, 0.25, 0.14583333333333
82060, 1.3041666666667, 0.25, 0.16666666666667
82061, 1.325, 0.225, 0.16666666666667
82062, 1.325, 0.2, 0.14583333333333
82063, 1.3041666666667, 0.2, 0.16666666666667
82064, 1.325, 0.175, 0.16666666666667
82065, 1.3666666666667, 1.325, 0.16666666666667
82066, 1.3666666666667, 1.3, 0.14583333333333
82067, 1.3458333333333, 1.3, 0.16666666666667
82068, 1.3666666666667, 1.275, 0.16666666666667
82069, 1.3666666666667, 1.25, 0.14583333333333
82070, 1.3458333333333, 1.25, 0.16666666666667
82071, 1.3666666666667, 1.225, 0.16666666666667
82072, 1.3666666666667, 1.2, 0.14583333333333
82073, 1.3458333333333, 1.2, 0.16666666666667
82074, 1.3666666666667, 1.175, 0.16666666666667
82075, 1.3666666666667, 1.15, 0.14583333333333
82076, 1.3458333333333, 1.15, 0.16666666666667
82077, 1.3666666666667, 1.125, 0.16666666666667
82078, 1.3666666666667, 1.1, 0.14583333333333
82079, 1.3458333333333, 1.1, 0.16666666666667
82080, 1.3666666666667, 1.075, 0.16666666666667
82081, 1.3666666666667, 1.05, 0.14583333333333
82082, 1.3458333333333, 1.05, 0.16666666666667
82083, 1.3666666666667, 1.025, 0.16666666666667
82084, 1.3666666666667, 1, 0.14583333333333
82085, 1.3458333333333, 1, 0.16666666666667
82086, 1.3666666666667, 0.975, 0.16666666666667
82087, 1.3666666666667, 0.95, 0.14583333333333
82088, 1.3458333333333, 0.95, 0.16666666666667
82089, 1.3666666666667, 0.925, 0.16666666666667
82090, 1.3666666666667, 0.9, 0.14583333333333
82091, 1.3458333333333, 0.9, 0.16666666666667
82092, 1.3666666666667, 0.875, 0.16666666666667
82093, 1.3666666666667, 0.85, 0.14583333333333
82094, 1.3458333333333, 0.85, 0.16666666666667
82095, 1.3666666666667, 0.825, 0.16666666666667
82096, 1.3666666666667, 0.8, 0.14583333333333
82097, 1.3458333333333, 0.8, 0.16666666666667
82098, 1.3666666666667, 0.775, 0.16666666666667
82099, 1.3666666666667, 0.75, 0.14583333333333
82100, 1.3458333333333, 0.75, 0.16666666666667
82101, 1.3666666666667, 0.725, 0.16666666666667
82102, 1.3666666666667, 0.7, 0.14583333333333
82103, 1.3458333333333, 0.7, 0.16666666666667
82104, 1.3666666666667, 0.675, 0.16666666666667
82105, 1.3666666666667, 0.65, 0.14583333333333
82106, 1.3458333333333, 0.65, 0.16666666666667
82107, 1.3666666666667, 0.625, 0.16666666666667
82108, 1.3666666666667, 0.6, 0.14583333333333
82109, 1.3458333333333, 0.6, 0.16666666666667
82110, 1.3666666666667, 0.575, 0.16666666666667
82111, 1.3666666666667, 0.55, 0.14583333333333
82112, 1.3458333333333, 0.55, 0.16666666666667
82113, 1.3666666666667, 0.525, 0.16666666666667
82114, 1.3666666666667, 0.5, 0.14583333333333
82115, 1.3458333333333, 0.5, 0.16666666666667
82116, 1.3666666666667, 0.475, 0.16666666666667
82117, 1.3666666666667, 0.45, 0.14583333333333
82118, 1.3458333333333, 0.45, 0.16666666666667
82119, 1.3666666666667, 0.425, 0.16666666666667
82120, 1.3666666666667, 0.4, 0.14583333333333
82121, 1.3458333333333, 0.4, 0.16666666666667
82122, 1.3666666666667, 0.375, 0.16666666666667
82123, 1.3666666666667, 0.35, 0.14583333333333
82124, 1.3458333333333, 0.35, 0.16666666666667
82125, 1.3666666666667, 0.325, 0.16666666666667
82126, 1.3666666666667, 0.3, 0.14583333333333
82127, 1.3458333333333, 0.3, 0.16666666666667
82128, 1.3666666666667, 0.275, 0.16666666666667
82129, 1.3666666666667, 0.25, 0.14583333333333
82130, 1.3458333333333, 0.25, 0.16666666666667
82131, 1.3666666666667, 0.225, 0.16666666666667
82132, 1.3666666666667, 0.2, 0.14583333333333
82133, 1.3458333333333, 0.2, 0.16666666666667
82134, 1.3666666666667, 0.175, 0.16666666666667
82135, 1.4083333333333, 1.325, 0.16666666666667
82136, 1.4083333333333, 1.3, 0.14583333333333
82137, 1.3875, 1.3, 0.16666666666667
82138, 1.4083333333333, 1.275, 0.16666666666667
82139, 1.4083333333333, 1.25, 0.14583333333333
82140, 1.3875, 1.25, 0.16666666666667
82141, 1.4083333333333, 1.225, 0.16666666666667
82142, 1.4083333333333, 1.2, 0.14583333333333
82143, 1.3875, 1.2, 0.16666666666667
82144, 1.4083333333333, 1.175, 0.16666666666667
82145, 1.4083333333333, 1.15, 0.14583333333333
82146, 1.3875, 1.15, 0.16666666666667
82147, 1.4083333333333, 1.125, 0.16666666666667
82148, 1.4083333333333, 1.1, 0.14583333333333
82149, 1.3875, 1.1, 0.16666666666667
82150, 1.4083333333333, 1.075, 0.16666666666667
82151, 1.4083333333333, 1.05, 0.14583333333333
82152, 1.3875, 1.05, 0.16666666666667
82153, 1.4083333333333, 1.025, 0.16666666666667
82154, 1.4083333333333, 1, 0.14583333333333
82155, 1.3875, 1, 0.16666666666667
82156, 1.4083333333333, 0.975, 0.16666666666667
82157, 1.4083333333333, 0.95, 0.14583333333333
82158, 1.3875, 0.95, 0.16666666666667
82159, 1.4083333333333, 0.925, 0.16666666666667
82160, 1.4083333333333, 0.9, 0.14583333333333
82161, 1.3875, 0.9, 0.16666666666667
82162, 1.4083333333333, 0.875, 0.16666666666667
82163, 1.4083333333333, 0.85, 0.14583333333333
82164, 1.3875, 0.85, 0.16666666666667
82165, 1.4083333333333, 0.825, 0.16666666666667
82166, 1.4083333333333, 0.8, 0.14583333333333
82167, 1.3875, 0.8, 0.16666666666667
82168, 1.4083333333333, 0.775, 0.16666666666667
82169, 1.4083333333333, 0.75, 0.14583333333333
82170, 1.3875, 0.75, 0.16666666666667
82171, 1.4083333333333, 0.725, 0.16666666666667
82172, 1.4083333333333, 0.7, 0.14583333333333
82173, 1.3875, 0.7, 0.16666666666667
82174, 1.4083333333333, 0.675, 0.16666666666667
82175, 1.4083333333333, 0.65, 0.14583333333333
82176, 1.3875, 0.65, 0.16666666666667
82177, 1.4083333333333, 0.625, 0.16666666666667
82178, 1.4083333333333, 0.6, 0.14583333333333
82179, 1.3875, 0.6, 0.16666666666667
82180, 1.4083333333333, 0.575, 0.16666666666667
82181, 1.4083333333333, 0.55, 0.14583333333333
82182, 1.3875, 0.55, 0.16666666666667
82183, 1.4083333333333, 0.525, 0.16666666666667
82184, 1.4083333333333, 0.5, 0.14583333333333
82185, 1.3875, 0.5, 0.16666666666667
82186, 1.4083333333333, 0.475, 0.16666666666667
82187, 1.4083333333333, 0.45, 0.14583333333333
82188, 1.3875, 0.45, 0.16666666666667
82189, 1.4083333333333, 0.425, 0.16666666666667
82190, 1.4083333333333, 0.4, 0.14583333333333
82191, 1.3875, 0.4, 0.16666666666667
82192, 1.4083333333333, 0.375, 0.16666666666667
82193, 1.4083333333333, 0.35, 0.14583333333333
82194, 1.3875, 0.35, 0.16666666666667
82195, 1.4083333333333, 0.325, 0.16666666666667
82196, 1.4083333333333, 0.3, 0.14583333333333
82197, 1.3875, 0.3, 0.16666666666667
82198, 1.4083333333333, 0.275, 0.16666666666667
82199, 1.4083333333333, 0.25, 0.14583333333333
82200, 1.3875, 0.25, 0.16666666666667
82201, 1.4083333333333, 0.225, 0.16666666666667
82202, 1.4083333333333, 0.2, 0.14583333333333
82203, 1.3875, 0.2, 0.16666666666667
82204, 1.4083333333333, 0.175, 0.16666666666667
82205, 1.45, 1.325, 0.16666666666667
82206, 1.45, 1.3, 0.14583333333333
82207, 1.4291666666667, 1.3, 0.16666666666667
82208, 1.45, 1.275, 0.16666666666667
82209, 1.45, 1.25, 0.14583333333333
82210, 1.4291666666667, 1.25, 0.16666666666667
82211, 1.45, 1.225, 0.16666666666667
82212, 1.45, 1.2, 0.14583333333333
82213, 1.4291666666667, 1.2, 0.16666666666667
82214, 1.45, 1.175, 0.16666666666667
82215, 1.45, 1.15, 0.14583333333333
82216, 1.4291666666667, 1.15, 0.16666666666667
82217, 1.45, 1.125, 0.16666666666667
82218, 1.45, 1.1, 0.14583333333333
82219, 1.4291666666667, 1.1, 0.16666666666667
82220, 1.45, 1.075, 0.16666666666667
82221, 1.45, 1.05, 0.14583333333333
82222, 1.4291666666667, 1.05, 0.16666666666667
82223, 1.45, 1.025, 0.16666666666667
82224, 1.45, 1, 0.14583333333333
82225, 1.4291666666667, 1, 0.16666666666667
82226, 1.45, 0.975, 0.16666666666667
82227, 1.45, 0.95, 0.14583333333333
82228, 1.4291666666667, 0.95, 0.16666666666667
82229, 1.45, 0.925, 0.16666666666667
82230, 1.45, 0.9, 0.14583333333333
82231, 1.4291666666667, 0.9, 0.16666666666667
82232, 1.45, 0.875, 0.16666666666667
82233, 1.45, 0.85, 0.14583333333333
82234, 1.4291666666667, 0.85, 0.16666666666667
82235, 1.45, 0.825, 0.16666666666667
82236, 1.45, 0.8, 0.14583333333333
82237, 1.4291666666667, 0.8, 0.16666666666667
82238, 1.45, 0.775, 0.16666666666667
82239, 1.45, 0.75, 0.14583333333333
82240, 1.4291666666667, 0.75, 0.16666666666667
82241, 1.45, 0.725, 0.16666666666667
82242, 1.45, 0.7, 0.14583333333333
82243, 1.4291666666667, 0.7, 0.16666666666667
82244, 1.45, 0.675, 0.16666666666667
82245, 1.45, 0.65, 0.14583333333333
82246, 1.4291666666667, 0.65, 0.16666666666667
82247, 1.45, 0.625, 0.16666666666667
82248, 1.45, 0.6, 0.14583333333333
82249, 1.4291666666667, 0.6, 0.16666666666667
82250, 1.45, 0.575, 0.16666666666667
82251, 1.45, 0.55, 0.14583333333333
82252, 1.4291666666667, 0.55, 0.16666666666667
82253, 1.45, 0.525, 0.16666666666667
82254, 1.45, 0.5, 0.14583333333333
82255, 1.4291666666667, 0.5, 0.16666666666667
82256, 1.45, 0.475, 0.16666666666667
82257, 1.45, 0.45, 0.14583333333333
82258, 1.4291666666667, 0.45, 0.16666666666667
82259, 1.45, 0.425, 0.16666666666667
82260, 1.45, 0.4, 0.14583333333333
82261, 1.4291666666667, 0.4, 0.16666666666667
82262, 1.45, 0.375, 0.16666666666667
82263, 1.45, 0.35, 0.14583333333333
82264, 1.4291666666667, 0.35, 0.16666666666667
82265, 1.45, 0.325, 0.16666666666667
82266, 1.45, 0.3, 0.14583333333333
82267, 1.4291666666667, 0.3, 0.16666666666667
82268, 1.45, 0.275, 0.16666666666667
82269, 1.45, 0.25, 0.14583333333333
82270, 1.4291666666667, 0.25, 0.16666666666667
82271, 1.45, 0.225, 0.16666666666667
82272, 1.45, 0.2, 0.14583333333333
82273, 1.4291666666667, 0.2, 0.16666666666667
82274, 1.45, 0.175, 0.16666666666667
82275, 1.4916666666667, 1.325, 0.16666666666667
82276, 1.4916666666667, 1.3, 0.14583333333333
82277, 1.4708333333333, 1.3, 0.16666666666667
82278, 1.4916666666667, 1.275, 0.16666666666667
82279, 1.4916666666667, 1.25, 0.14583333333333
82280, 1.4708333333333, 1.25, 0.16666666666667
82281, 1.4916666666667, 1.225, 0.16666666666667
82282, 1.4916666666667, 1.2, 0.14583333333333
82283, 1.4708333333333, 1.2, 0.16666666666667
82284, 1.4916666666667, 1.175, 0.16666666666667
82285, 1.4916666666667, 1.15, 0.14583333333333
82286, 1.4708333333333, 1.15, 0.16666666666667
82287, 1.4916666666667, 1.125, 0.16666666666667
82288, 1.4916666666667, 1.1, 0.14583333333333
82289, 1.4708333333333, 1.1, 0.16666666666667
82290, 1.4916666666667, 1.075, 0.16666666666667
82291, 1.4916666666667, 1.05, 0.14583333333333
82292, 1.4708333333333, 1.05, 0.16666666666667
82293, 1.4916666666667, 1.025, 0.16666666666667
82294, 1.4916666666667, 1, 0.14583333333333
82295, 1.4708333333333, 1, 0.16666666666667
82296, 1.4916666666667, 0.975, 0.16666666666667
82297, 1.4916666666667, 0.95, 0.14583333333333
82298, 1.4708333333333, 0.95, 0.16666666666667
82299, 1.4916666666667, 0.925, 0.16666666666667
82300, 1.4916666666667, 0.9, 0.14583333333333
82301, 1.4708333333333, 0.9, 0.16666666666667
82302, 1.4916666666667, 0.875, 0.16666666666667
82303, 1.4916666666667, 0.85, 0.14583333333333
82304, 1.4708333333333, 0.85, 0.16666666666667
82305, 1.4916666666667, 0.825, 0.16666666666667
82306, 1.4916666666667, 0.8, 0.14583333333333
82307, 1.4708333333333, 0.8, 0.16666666666667
82308, 1.4916666666667, 0.775, 0.16666666666667
82309, 1.4916666666667, 0.75, 0.14583333333333
82310, 1.4708333333333, 0.75, 0.16666666666667
82311, 1.4916666666667, 0.725, 0.16666666666667
82312, 1.4916666666667, 0.7, 0.14583333333333
82313, 1.4708333333333, 0.7, 0.16666666666667
82314, 1.4916666666667, 0.675, 0.16666666666667
82315, 1.4916666666667, 0.65, 0.14583333333333
82316, 1.4708333333333, 0.65, 0.16666666666667
82317, 1.4916666666667, 0.625, 0.16666666666667
82318, 1.4916666666667, 0.6, 0.14583333333333
82319, 1.4708333333333, 0.6, 0.16666666666667
82320, 1.4916666666667, 0.575, 0.16666666666667
82321, 1.4916666666667, 0.55, 0.14583333333333
82322, 1.4708333333333, 0.55, 0.16666666666667
82323, 1.4916666666667, 0.525, 0.16666666666667
82324, 1.4916666666667, 0.5, 0.14583333333333
82325, 1.4708333333333, 0.5, 0.16666666666667
82326, 1.4916666666667, 0.475, 0.16666666666667
82327, 1.4916666666667, 0.45, 0.14583333333333
82328, 1.4708333333333, 0.45, 0.16666666666667
82329, 1.4916666666667, 0.425, 0.16666666666667
82330, 1.4916666666667, 0.4, 0.14583333333333
82331, 1.4708333333333, 0.4, 0.16666666666667
82332, 1.4916666666667, 0.375, 0.16666666666667
82333, 1.4916666666667, 0.35, 0.14583333333333
82334, 1.4708333333333, 0.35, 0.16666666666667
82335, 1.4916666666667, 0.325, 0.16666666666667
82336, 1.4916666666667, 0.3, 0.14583333333333
82337, 1.4708333333333, 0.3, 0.16666666666667
82338, 1.4916666666667, 0.275, 0.16666666666667
82339, 1.4916666666667, 0.25, 0.14583333333333
82340, 1.4708333333333, 0.25, 0.16666666666667
82341, 1.4916666666667, 0.225, 0.16666666666667
82342, 1.4916666666667, 0.2, 0.14583333333333
82343, 1.4708333333333, 0.2, 0.16666666666667
82344, 1.4916666666667, 0.175, 0.16666666666667
82345, 1.5333333333333, 1.325, 0.16666666666667
82346, 1.5333333333333, 1.3, 0.14583333333333
82347, 1.5125, 1.3, 0.16666666666667
82348, 1.5333333333333, 1.275, 0.16666666666667
82349, 1.5333333333333, 1.25, 0.14583333333333
82350, 1.5125, 1.25, 0.16666666666667
82351, 1.5333333333333, 1.225, 0.16666666666667
82352, 1.5333333333333, 1.2, 0.14583333333333
82353, 1.5125, 1.2, 0.16666666666667
82354, 1.5333333333333, 1.175, 0.16666666666667
82355, 1.5333333333333, 1.15, 0.14583333333333
82356, 1.5125, 1.15, 0.16666666666667
82357, 1.5333333333333, 1.125, 0.16666666666667
82358, 1.5333333333333, 1.1, 0.14583333333333
82359, 1.5125, 1.1, 0.16666666666667
82360, 1.5333333333333, 1.075, 0.16666666666667
82361, 1.5333333333333, 1.05, 0.14583333333333
82362, 1.5125, 1.05, 0.16666666666667
82363, 1.5333333333333, 1.025, 0.16666666666667
82364, 1.5333333333333, 1, 0.14583333333333
82365, 1.5125, 1, 0.16666666666667
82366, 1.5333333333333, 0.975, 0.16666666666667
82367, 1.5333333333333, 0.95, 0.14583333333333
82368, 1.5125, 0.95, 0.16666666666667
82369, 1.5333333333333, 0.925, 0.16666666666667
82370, 1.5333333333333, 0.9, 0.14583333333333
82371, 1.5125, 0.9, 0.16666666666667
82372, 1.5333333333333, 0.875, 0.16666666666667
82373, 1.5333333333333, 0.85, 0.14583333333333
82374, 1.5125, 0.85, 0.16666666666667
82375, 1.5333333333333, 0.825, 0.16666666666667
82376, 1.5333333333333, 0.8, 0.14583333333333
82377, 1.5125, 0.8, 0.16666666666667
82378, 1.5333333333333, 0.775, 0.16666666666667
82379, 1.5333333333333, 0.75, 0.14583333333333
82380, 1.5125, 0.75, 0.16666666666667
82381, 1.5333333333333, 0.725, 0.16666666666667
82382, 1.5333333333333, 0.7, 0.14583333333333
82383, 1.5125, 0.7, 0.16666666666667
82384, 1.5333333333333, 0.675, 0.16666666666667
82385, 1.5333333333333, 0.65, 0.14583333333333
82386, 1.5125, 0.65, 0.16666666666667
82387, 1.5333333333333, 0.625, 0.16666666666667
82388, 1.5333333333333, 0.6, 0.14583333333333
82389, 1.5125, 0.6, 0.16666666666667
82390, 1.5333333333333, 0.575, 0.16666666666667
82391, 1.5333333333333, 0.55, 0.14583333333333
82392, 1.5125, 0.55, 0.16666666666667
82393, 1.5333333333333, 0.525, 0.16666666666667
82394, 1.5333333333333, 0.5, 0.14583333333333
82395, 1.5125, 0.5, 0.16666666666667
82396, 1.5333333333333, 0.475, 0.16666666666667
82397, 1.5333333333333, 0.45, 0.14583333333333
82398, 1.5125, 0.45, 0.16666666666667
82399, 1.5333333333333, 0.425, 0.16666666666667
82400, 1.5333333333333, 0.4, 0.14583333333333
82401, 1.5125, 0.4, 0.16666666666667
82402, 1.5333333333333, 0.375, 0.16666666666667
82403, 1.5333333333333, 0.35, 0.14583333333333
82404, 1.5125, 0.35, 0.16666666666667
82405, 1.5333333333333, 0.325, 0.16666666666667
82406, 1.5333333333333, 0.3, 0.14583333333333
82407, 1.5125, 0.3, 0.16666666666667
82408, 1.5333333333333, 0.275, 0.16666666666667
82409, 1.5333333333333, 0.25, 0.14583333333333
82410, 1.5125, 0.25, 0.16666666666667
82411, 1.5333333333333, 0.225, 0.16666666666667
82412, 1.5333333333333, 0.2, 0.14583333333333
82413, 1.5125, 0.2, 0.16666666666667
82414, 1.5333333333333, 0.175, 0.16666666666667
82415, 1.575, 1.325, 0.16666666666667
82416, 1.575, 1.3, 0.14583333333333
82417, 1.5541666666667, 1.3, 0.16666666666667
82418, 1.575, 1.275, 0.16666666666667
82419, 1.575, 1.25, 0.14583333333333
82420, 1.5541666666667, 1.25, 0.16666666666667
82421, 1.575, 1.225, 0.16666666666667
82422, 1.575, 1.2, 0.14583333333333
82423, 1.5541666666667, 1.2, 0.16666666666667
82424, 1.575, 1.175, 0.16666666666667
82425, 1.575, 1.15, 0.14583333333333
82426, 1.5541666666667, 1.15, 0.16666666666667
82427, 1.575, 1.125, 0.16666666666667
82428, 1.575, 1.1, 0.14583333333333
82429, 1.5541666666667, 1.1, 0.16666666666667
82430, 1.575, 1.075, 0.16666666666667
82431, 1.575, 1.05, 0.14583333333333
82432, 1.5541666666667, 1.05, 0.16666666666667
82433, 1.575, 1.025, 0.16666666666667
82434, 1.575, 1, 0.14583333333333
82435, 1.5541666666667, 1, 0.16666666666667
82436, 1.575, 0.975, 0.16666666666667
82437, 1.575, 0.95, 0.14583333333333
82438, 1.5541666666667, 0.95, 0.16666666666667
82439, 1.575, 0.925, 0.16666666666667
82440, 1.575, 0.9, 0.14583333333333
82441, 1.5541666666667, 0.9, 0.16666666666667
82442, 1.575, 0.875, 0.16666666666667
82443, 1.575, 0.85, 0.14583333333333
82444, 1.5541666666667, 0.85, 0.16666666666667
82445, 1.575, 0.825, 0.16666666666667
82446, 1.575, 0.8, 0.14583333333333
82447, 1.5541666666667, 0.8, 0.16666666666667
82448, 1.575, 0.775, 0.16666666666667
82449, 1.575, 0.75, 0.14583333333333
82450, 1.5541666666667, 0.75, 0.16666666666667
82451, 1.575, 0.725, 0.16666666666667
82452, 1.575, 0.7, 0.14583333333333
82453, 1.5541666666667, 0.7, 0.16666666666667
82454, 1.575, 0.675, 0.16666666666667
82455, 1.575, 0.65, 0.14583333333333
82456, 1.5541666666667, 0.65, 0.16666666666667
82457, 1.575, 0.625, 0.16666666666667
82458, 1.575, 0.6, 0.14583333333333
82459, 1.5541666666667, 0.6, 0.16666666666667
82460, 1.575, 0.575, 0.16666666666667
82461, 1.575, 0.55, 0.14583333333333
82462, 1.5541666666667, 0.55, 0.16666666666667
82463, 1.575, 0.525, 0.16666666666667
82464, 1.575, 0.5, 0.14583333333333
82465, 1.5541666666667, 0.5, 0.16666666666667
82466, 1.575, 0.475, 0.16666666666667
82467, 1.575, 0.45, 0.14583333333333
82468, 1.5541666666667, 0.45, 0.16666666666667
82469, 1.575, 0.425, 0.16666666666667
82470, 1.575, 0.4, 0.14583333333333
82471, 1.5541666666667, 0.4, 0.16666666666667
82472, 1.575, 0.375, 0.16666666666667
82473, 1.575, 0.35, 0.14583333333333
82474, 1.5541666666667, 0.35, 0.16666666666667
82475, 1.575, 0.325, 0.16666666666667
82476, 1.575, 0.3, 0.14583333333333
82477, 1.5541666666667, 0.3, 0.16666666666667
82478, 1.575, 0.275, 0.16666666666667
82479, 1.575, 0.25, 0.14583333333333
82480, 1.5541666666667, 0.25, 0.16666666666667
82481, 1.575, 0.225, 0.16666666666667
82482, 1.575, 0.2, 0.14583333333333
82483, 1.5541666666667, 0.2, 0.16666666666667
82484, 1.575, 0.175, 0.16666666666667
82485, 1.6166666666667, 1.325, 0.16666666666667
82486, 1.6166666666667, 1.3, 0.14583333333333
82487, 1.5958333333333, 1.3, 0.16666666666667
82488, 1.6166666666667, 1.275, 0.16666666666667
82489, 1.6166666666667, 1.25, 0.14583333333333
