33109, 22943, 22944, 22967, 22966, 23804, 23805, 23828, 23827, 23308, 23354, 23355, 23352, 24169, 24215, 24216, 
24213, 95553, 95554, 95577, 95576
33110, 22944, 22945, 22968, 22967, 23805, 23806, 23829, 23828, 23310, 23356, 23357, 23354, 24171, 24217, 24218, 
24215, 95554, 95555, 95578, 95577
33111, 22945, 22946, 22969, 22968, 23806, 23807, 23830, 23829, 23312, 23358, 23359, 23356, 24173, 24219, 24220, 
24217, 95555, 95556, 95579, 95578
33112, 22946, 22947, 22970, 22969, 23807, 23808, 23831, 23830, 23314, 23360, 23361, 23358, 24175, 24221, 24222, 
24219, 95556, 95557, 95580, 95579
33113, 22947, 22948, 22971, 22970, 23808, 23809, 23832, 23831, 23316, 23362, 23363, 23360, 24177, 24223, 24224, 
24221, 95557, 95558, 95581, 95580
33114, 22948, 22949, 22972, 22971, 23809, 23810, 23833, 23832, 23318, 23364, 23365, 23362, 24179, 24225, 24226, 
24223, 95558, 95559, 95582, 95581
33115, 22949, 22950, 22973, 22972, 23810, 23811, 23834, 23833, 23320, 23366, 23367, 23364, 24181, 24227, 24228, 
24225, 95559, 95560, 95583, 95582
33116, 22950, 22951, 22974, 22973, 23811, 23812, 23835, 23834, 23322, 23368, 23369, 23366, 24183, 24229, 24230, 
24227, 95560, 95561, 95584, 95583
33117, 22951, 22952, 22975, 22974, 23812, 23813, 23836, 23835, 23324, 23370, 23371, 23368, 24185, 24231, 24232, 
24229, 95561, 95562, 95585, 95584
33118, 22952, 1962, 1963, 22975, 23813, 2106, 2107, 23836, 23325, 1974, 23372, 23370, 24186, 2118, 24233, 
24231, 95562, 23692, 23693, 95585
33119, 1940, 22953, 22976, 1941, 2084, 23814, 23837, 2085, 23327, 23373, 23374, 1952, 24188, 24234, 24235, 
2096, 23682, 95563, 95586, 23683
33120, 22953, 22954, 22977, 22976, 23814, 23815, 23838, 23837, 23329, 23375, 23376, 23373, 24190, 24236, 24237, 
24234, 95563, 95564, 95587, 95586
33121, 22954, 22955, 22978, 22977, 23815, 23816, 23839, 23838, 23331, 23377, 23378, 23375, 24192, 24238, 24239, 
24236, 95564, 95565, 95588, 95587
33122, 22955, 22956, 22979, 22978, 23816, 23817, 23840, 23839, 23333, 23379, 23380, 23377, 24194, 24240, 24241, 
24238, 95565, 95566, 95589, 95588
33123, 22956, 22957, 22980, 22979, 23817, 23818, 23841, 23840, 23335, 23381, 23382, 23379, 24196, 24242, 24243, 
24240, 95566, 95567, 95590, 95589
33124, 22957, 22958, 22981, 22980, 23818, 23819, 23842, 23841, 23337, 23383, 23384, 23381, 24198, 24244, 24245, 
24242, 95567, 95568, 95591, 95590
33125, 22958, 22959, 22982, 22981, 23819, 23820, 23843, 23842, 23339, 23385, 23386, 23383, 24200, 24246, 24247, 
24244, 95568, 95569, 95592, 95591
33126, 22959, 22960, 22983, 22982, 23820, 23821, 23844, 23843, 23341, 23387, 23388, 23385, 24202, 24248, 24249, 
24246, 95569, 95570, 95593, 95592
33127, 22960, 22961, 22984, 22983, 23821, 23822, 23845, 23844, 23343, 23389, 23390, 23387, 24204, 24250, 24251, 
24248, 95570, 95571, 95594, 95593
33128, 22961, 22962, 22985, 22984, 23822, 23823, 23846, 23845, 23345, 23391, 23392, 23389, 24206, 24252, 24253, 
24250, 95571, 95572, 95595, 95594
33129, 22962, 22963, 22986, 22985, 23823, 23824, 23847, 23846, 23347, 23393, 23394, 23391, 24208, 24254, 24255, 
24252, 95572, 95573, 95596, 95595
33130, 22963, 22964, 22987, 22986, 23824, 23825, 23848, 23847, 23349, 23395, 23396, 23393, 24210, 24256, 24257, 
24254, 95573, 95574, 95597, 95596
33131, 22964, 22965, 22988, 22987, 23825, 23826, 23849, 23848, 23351, 23397, 23398, 23395, 24212, 24258, 24259, 
24256, 95574, 95575, 95598, 95597
33132, 22965, 22966, 22989, 22988, 23826, 23827, 23850, 23849, 23353, 23399, 23400, 23397, 24214, 24260, 24261, 
24258, 95575, 95576, 95599, 95598
33133, 22966, 22967, 22990, 22989, 23827, 23828, 23851, 23850, 23355, 23401, 23402, 23399, 24216, 24262, 24263, 
24260, 95576, 95577, 95600, 95599
33134, 22967, 22968, 22991, 22990, 23828, 23829, 23852, 23851, 23357, 23403, 23404, 23401, 24218, 24264, 24265, 
24262, 95577, 95578, 95601, 95600
33135, 22968, 22969, 22992, 22991, 23829, 23830, 23853, 23852, 23359, 23405, 23406, 23403, 24220, 24266, 24267, 
24264, 95578, 95579, 95602, 95601
33136, 22969, 22970, 22993, 22992, 23830, 23831, 23854, 23853, 23361, 23407, 23408, 23405, 24222, 24268, 24269, 
24266, 95579, 95580, 95603, 95602
33137, 22970, 22971, 22994, 22993, 23831, 23832, 23855, 23854, 23363, 23409, 23410, 23407, 24224, 24270, 24271, 
24268, 95580, 95581, 95604, 95603
33138, 22971, 22972, 22995, 22994, 23832, 23833, 23856, 23855, 23365, 23411, 23412, 23409, 24226, 24272, 24273, 
24270, 95581, 95582, 95605, 95604
33139, 22972, 22973, 22996, 22995, 23833, 23834, 23857, 23856, 23367, 23413, 23414, 23411, 24228, 24274, 24275, 
24272, 95582, 95583, 95606, 95605
33140, 22973, 22974, 22997, 22996, 23834, 23835, 23858, 23857, 23369, 23415, 23416, 23413, 24230, 24276, 24277, 
24274, 95583, 95584, 95607, 95606
33141, 22974, 22975, 22998, 22997, 23835, 23836, 23859, 23858, 23371, 23417, 23418, 23415, 24232, 24278, 24279, 
24276, 95584, 95585, 95608, 95607
33142, 22975, 1963, 1964, 22998, 23836, 2107, 2108, 23859, 23372, 1975, 23419, 23417, 24233, 2119, 24280, 
24278, 95585, 23693, 23694, 95608
33143, 1941, 22976, 22999, 1942, 2085, 23837, 23860, 2086, 23374, 23420, 23421, 1953, 24235, 24281, 24282, 
2097, 23683, 95586, 95609, 23684
33144, 22976, 22977, 23000, 22999, 23837, 23838, 23861, 23860, 23376, 23422, 23423, 23420, 24237, 24283, 24284, 
24281, 95586, 95587, 95610, 95609
33145, 22977, 22978, 23001, 23000, 23838, 23839, 23862, 23861, 23378, 23424, 23425, 23422, 24239, 24285, 24286, 
24283, 95587, 95588, 95611, 95610
33146, 22978, 22979, 23002, 23001, 23839, 23840, 23863, 23862, 23380, 23426, 23427, 23424, 24241, 24287, 24288, 
24285, 95588, 95589, 95612, 95611
33147, 22979, 22980, 23003, 23002, 23840, 23841, 23864, 23863, 23382, 23428, 23429, 23426, 24243, 24289, 24290, 
24287, 95589, 95590, 95613, 95612
33148, 22980, 22981, 23004, 23003, 23841, 23842, 23865, 23864, 23384, 23430, 23431, 23428, 24245, 24291, 24292, 
24289, 95590, 95591, 95614, 95613
33149, 22981, 22982, 23005, 23004, 23842, 23843, 23866, 23865, 23386, 23432, 23433, 23430, 24247, 24293, 24294, 
24291, 95591, 95592, 95615, 95614
33150, 22982, 22983, 23006, 23005, 23843, 23844, 23867, 23866, 23388, 23434, 23435, 23432, 24249, 24295, 24296, 
24293, 95592, 95593, 95616, 95615
33151, 22983, 22984, 23007, 23006, 23844, 23845, 23868, 23867, 23390, 23436, 23437, 23434, 24251, 24297, 24298, 
24295, 95593, 95594, 95617, 95616
33152, 22984, 22985, 23008, 23007, 23845, 23846, 23869, 23868, 23392, 23438, 23439, 23436, 24253, 24299, 24300, 
24297, 95594, 95595, 95618, 95617
33153, 22985, 22986, 23009, 23008, 23846, 23847, 23870, 23869, 23394, 23440, 23441, 23438, 24255, 24301, 24302, 
24299, 95595, 95596, 95619, 95618
33154, 22986, 22987, 23010, 23009, 23847, 23848, 23871, 23870, 23396, 23442, 23443, 23440, 24257, 24303, 24304, 
24301, 95596, 95597, 95620, 95619
33155, 22987, 22988, 23011, 23010, 23848, 23849, 23872, 23871, 23398, 23444, 23445, 23442, 24259, 24305, 24306, 
24303, 95597, 95598, 95621, 95620
33156, 22988, 22989, 23012, 23011, 23849, 23850, 23873, 23872, 23400, 23446, 23447, 23444, 24261, 24307, 24308, 
24305, 95598, 95599, 95622, 95621
33157, 22989, 22990, 23013, 23012, 23850, 23851, 23874, 23873, 23402, 23448, 23449, 23446, 24263, 24309, 24310, 
24307, 95599, 95600, 95623, 95622
33158, 22990, 22991, 23014, 23013, 23851, 23852, 23875, 23874, 23404, 23450, 23451, 23448, 24265, 24311, 24312, 
24309, 95600, 95601, 95624, 95623
33159, 22991, 22992, 23015, 23014, 23852, 23853, 23876, 23875, 23406, 23452, 23453, 23450, 24267, 24313, 24314, 
24311, 95601, 95602, 95625, 95624
33160, 22992, 22993, 23016, 23015, 23853, 23854, 23877, 23876, 23408, 23454, 23455, 23452, 24269, 24315, 24316, 
24313, 95602, 95603, 95626, 95625
33161, 22993, 22994, 23017, 23016, 23854, 23855, 23878, 23877, 23410, 23456, 23457, 23454, 24271, 24317, 24318, 
24315, 95603, 95604, 95627, 95626
33162, 22994, 22995, 23018, 23017, 23855, 23856, 23879, 23878, 23412, 23458, 23459, 23456, 24273, 24319, 24320, 
24317, 95604, 95605, 95628, 95627
33163, 22995, 22996, 23019, 23018, 23856, 23857, 23880, 23879, 23414, 23460, 23461, 23458, 24275, 24321, 24322, 
24319, 95605, 95606, 95629, 95628
33164, 22996, 22997, 23020, 23019, 23857, 23858, 23881, 23880, 23416, 23462, 23463, 23460, 24277, 24323, 24324, 
24321, 95606, 95607, 95630, 95629
33165, 22997, 22998, 23021, 23020, 23858, 23859, 23882, 23881, 23418, 23464, 23465, 23462, 24279, 24325, 24326, 
24323, 95607, 95608, 95631, 95630
33166, 22998, 1964, 1965, 23021, 23859, 2108, 2109, 23882, 23419, 1976, 23466, 23464, 24280, 2120, 24327, 
24325, 95608, 23694, 23695, 95631
33167, 1942, 22999, 23022, 1943, 2086, 23860, 23883, 2087, 23421, 23467, 23468, 1954, 24282, 24328, 24329, 
2098, 23684, 95609, 95632, 23685
33168, 22999, 23000, 23023, 23022, 23860, 23861, 23884, 23883, 23423, 23469, 23470, 23467, 24284, 24330, 24331, 
24328, 95609, 95610, 95633, 95632
33169, 23000, 23001, 23024, 23023, 23861, 23862, 23885, 23884, 23425, 23471, 23472, 23469, 24286, 24332, 24333, 
24330, 95610, 95611, 95634, 95633
33170, 23001, 23002, 23025, 23024, 23862, 23863, 23886, 23885, 23427, 23473, 23474, 23471, 24288, 24334, 24335, 
24332, 95611, 95612, 95635, 95634
33171, 23002, 23003, 23026, 23025, 23863, 23864, 23887, 23886, 23429, 23475, 23476, 23473, 24290, 24336, 24337, 
24334, 95612, 95613, 95636, 95635
33172, 23003, 23004, 23027, 23026, 23864, 23865, 23888, 23887, 23431, 23477, 23478, 23475, 24292, 24338, 24339, 
24336, 95613, 95614, 95637, 95636
33173, 23004, 23005, 23028, 23027, 23865, 23866, 23889, 23888, 23433, 23479, 23480, 23477, 24294, 24340, 24341, 
24338, 95614, 95615, 95638, 95637
33174, 23005, 23006, 23029, 23028, 23866, 23867, 23890, 23889, 23435, 23481, 23482, 23479, 24296, 24342, 24343, 
24340, 95615, 95616, 95639, 95638
33175, 23006, 23007, 23030, 23029, 23867, 23868, 23891, 23890, 23437, 23483, 23484, 23481, 24298, 24344, 24345, 
24342, 95616, 95617, 95640, 95639
33176, 23007, 23008, 23031, 23030, 23868, 23869, 23892, 23891, 23439, 23485, 23486, 23483, 24300, 24346, 24347, 
24344, 95617, 95618, 95641, 95640
33177, 23008, 23009, 23032, 23031, 23869, 23870, 23893, 23892, 23441, 23487, 23488, 23485, 24302, 24348, 24349, 
24346, 95618, 95619, 95642, 95641
33178, 23009, 23010, 23033, 23032, 23870, 23871, 23894, 23893, 23443, 23489, 23490, 23487, 24304, 24350, 24351, 
24348, 95619, 95620, 95643, 95642
33179, 23010, 23011, 23034, 23033, 23871, 23872, 23895, 23894, 23445, 23491, 23492, 23489, 24306, 24352, 24353, 
24350, 95620, 95621, 95644, 95643
33180, 23011, 23012, 23035, 23034, 23872, 23873, 23896, 23895, 23447, 23493, 23494, 23491, 24308, 24354, 24355, 
24352, 95621, 95622, 95645, 95644
33181, 23012, 23013, 23036, 23035, 23873, 23874, 23897, 23896, 23449, 23495, 23496, 23493, 24310, 24356, 24357, 
24354, 95622, 95623, 95646, 95645
33182, 23013, 23014, 23037, 23036, 23874, 23875, 23898, 23897, 23451, 23497, 23498, 23495, 24312, 24358, 24359, 
24356, 95623, 95624, 95647, 95646
33183, 23014, 23015, 23038, 23037, 23875, 23876, 23899, 23898, 23453, 23499, 23500, 23497, 24314, 24360, 24361, 
24358, 95624, 95625, 95648, 95647
33184, 23015, 23016, 23039, 23038, 23876, 23877, 23900, 23899, 23455, 23501, 23502, 23499, 24316, 24362, 24363, 
24360, 95625, 95626, 95649, 95648
33185, 23016, 23017, 23040, 23039, 23877, 23878, 23901, 23900, 23457, 23503, 23504, 23501, 24318, 24364, 24365, 
24362, 95626, 95627, 95650, 95649
33186, 23017, 23018, 23041, 23040, 23878, 23879, 23902, 23901, 23459, 23505, 23506, 23503, 24320, 24366, 24367, 
24364, 95627, 95628, 95651, 95650
33187, 23018, 23019, 23042, 23041, 23879, 23880, 23903, 23902, 23461, 23507, 23508, 23505, 24322, 24368, 24369, 
24366, 95628, 95629, 95652, 95651
33188, 23019, 23020, 23043, 23042, 23880, 23881, 23904, 23903, 23463, 23509, 23510, 23507, 24324, 24370, 24371, 
24368, 95629, 95630, 95653, 95652
33189, 23020, 23021, 23044, 23043, 23881, 23882, 23905, 23904, 23465, 23511, 23512, 23509, 24326, 24372, 24373, 
24370, 95630, 95631, 95654, 95653
33190, 23021, 1965, 1966, 23044, 23882, 2109, 2110, 23905, 23466, 1977, 23513, 23511, 24327, 2121, 24374, 
24372, 95631, 23695, 23696, 95654
33191, 1943, 23022, 23045, 1944, 2087, 23883, 23906, 2088, 23468, 23514, 23515, 1955, 24329, 24375, 24376, 
2099, 23685, 95632, 95655, 23686
33192, 23022, 23023, 23046, 23045, 23883, 23884, 23907, 23906, 23470, 23516, 23517, 23514, 24331, 24377, 24378, 
24375, 95632, 95633, 95656, 95655
33193, 23023, 23024, 23047, 23046, 23884, 23885, 23908, 23907, 23472, 23518, 23519, 23516, 24333, 24379, 24380, 
24377, 95633, 95634, 95657, 95656
33194, 23024, 23025, 23048, 23047, 23885, 23886, 23909, 23908, 23474, 23520, 23521, 23518, 24335, 24381, 24382, 
24379, 95634, 95635, 95658, 95657
33195, 23025, 23026, 23049, 23048, 23886, 23887, 23910, 23909, 23476, 23522, 23523, 23520, 24337, 24383, 24384, 
24381, 95635, 95636, 95659, 95658
33196, 23026, 23027, 23050, 23049, 23887, 23888, 23911, 23910, 23478, 23524, 23525, 23522, 24339, 24385, 24386, 
24383, 95636, 95637, 95660, 95659
33197, 23027, 23028, 23051, 23050, 23888, 23889, 23912, 23911, 23480, 23526, 23527, 23524, 24341, 24387, 24388, 
24385, 95637, 95638, 95661, 95660
33198, 23028, 23029, 23052, 23051, 23889, 23890, 23913, 23912, 23482, 23528, 23529, 23526, 24343, 24389, 24390, 
24387, 95638, 95639, 95662, 95661
33199, 23029, 23030, 23053, 23052, 23890, 23891, 23914, 23913, 23484, 23530, 23531, 23528, 24345, 24391, 24392, 
24389, 95639, 95640, 95663, 95662
33200, 23030, 23031, 23054, 23053, 23891, 23892, 23915, 23914, 23486, 23532, 23533, 23530, 24347, 24393, 24394, 
24391, 95640, 95641, 95664, 95663
33201, 23031, 23032, 23055, 23054, 23892, 23893, 23916, 23915, 23488, 23534, 23535, 23532, 24349, 24395, 24396, 
24393, 95641, 95642, 95665, 95664
33202, 23032, 23033, 23056, 23055, 23893, 23894, 23917, 23916, 23490, 23536, 23537, 23534, 24351, 24397, 24398, 
24395, 95642, 95643, 95666, 95665
33203, 23033, 23034, 23057, 23056, 23894, 23895, 23918, 23917, 23492, 23538, 23539, 23536, 24353, 24399, 24400, 
24397, 95643, 95644, 95667, 95666
33204, 23034, 23035, 23058, 23057, 23895, 23896, 23919, 23918, 23494, 23540, 23541, 23538, 24355, 24401, 24402, 
24399, 95644, 95645, 95668, 95667
33205, 23035, 23036, 23059, 23058, 23896, 23897, 23920, 23919, 23496, 23542, 23543, 23540, 24357, 24403, 24404, 
24401, 95645, 95646, 95669, 95668
33206, 23036, 23037, 23060, 23059, 23897, 23898, 23921, 23920, 23498, 23544, 23545, 23542, 24359, 24405, 24406, 
24403, 95646, 95647, 95670, 95669
33207, 23037, 23038, 23061, 23060, 23898, 23899, 23922, 23921, 23500, 23546, 23547, 23544, 24361, 24407, 24408, 
24405, 95647, 95648, 95671, 95670
33208, 23038, 23039, 23062, 23061, 23899, 23900, 23923, 23922, 23502, 23548, 23549, 23546, 24363, 24409, 24410, 
24407, 95648, 95649, 95672, 95671
33209, 23039, 23040, 23063, 23062, 23900, 23901, 23924, 23923, 23504, 23550, 23551, 23548, 24365, 24411, 24412, 
24409, 95649, 95650, 95673, 95672
33210, 23040, 23041, 23064, 23063, 23901, 23902, 23925, 23924, 23506, 23552, 23553, 23550, 24367, 24413, 24414, 
24411, 95650, 95651, 95674, 95673
33211, 23041, 23042, 23065, 23064, 23902, 23903, 23926, 23925, 23508, 23554, 23555, 23552, 24369, 24415, 24416, 
24413, 95651, 95652, 95675, 95674
33212, 23042, 23043, 23066, 23065, 23903, 23904, 23927, 23926, 23510, 23556, 23557, 23554, 24371, 24417, 24418, 
24415, 95652, 95653, 95676, 95675
33213, 23043, 23044, 23067, 23066, 23904, 23905, 23928, 23927, 23512, 23558, 23559, 23556, 24373, 24419, 24420, 
24417, 95653, 95654, 95677, 95676
33214, 23044, 1966, 1967, 23067, 23905, 2110, 2111, 23928, 23513, 1978, 23560, 23558, 24374, 2122, 24421, 
24419, 95654, 23696, 23697, 95677
33215, 1944, 23045, 23068, 1945, 2088, 23906, 23929, 2089, 23515, 23561, 23562, 1956, 24376, 24422, 24423, 
2100, 23686, 95655, 95678, 23687
33216, 23045, 23046, 23069, 23068, 23906, 23907, 23930, 23929, 23517, 23563, 23564, 23561, 24378, 24424, 24425, 
24422, 95655, 95656, 95679, 95678
33217, 23046, 23047, 23070, 23069, 23907, 23908, 23931, 23930, 23519, 23565, 23566, 23563, 24380, 24426, 24427, 
24424, 95656, 95657, 95680, 95679
33218, 23047, 23048, 23071, 23070, 23908, 23909, 23932, 23931, 23521, 23567, 23568, 23565, 24382, 24428, 24429, 
24426, 95657, 95658, 95681, 95680
33219, 23048, 23049, 23072, 23071, 23909, 23910, 23933, 23932, 23523, 23569, 23570, 23567, 24384, 24430, 24431, 
24428, 95658, 95659, 95682, 95681
33220, 23049, 23050, 23073, 23072, 23910, 23911, 23934, 23933, 23525, 23571, 23572, 23569, 24386, 24432, 24433, 
24430, 95659, 95660, 95683, 95682
33221, 23050, 23051, 23074, 23073, 23911, 23912, 23935, 23934, 23527, 23573, 23574, 23571, 24388, 24434, 24435, 
24432, 95660, 95661, 95684, 95683
33222, 23051, 23052, 23075, 23074, 23912, 23913, 23936, 23935, 23529, 23575, 23576, 23573, 24390, 24436, 24437, 
24434, 95661, 95662, 95685, 95684
33223, 23052, 23053, 23076, 23075, 23913, 23914, 23937, 23936, 23531, 23577, 23578, 23575, 24392, 24438, 24439, 
24436, 95662, 95663, 95686, 95685
33224, 23053, 23054, 23077, 23076, 23914, 23915, 23938, 23937, 23533, 23579, 23580, 23577, 24394, 24440, 24441, 
24438, 95663, 95664, 95687, 95686
33225, 23054, 23055, 23078, 23077, 23915, 23916, 23939, 23938, 23535, 23581, 23582, 23579, 24396, 24442, 24443, 
24440, 95664, 95665, 95688, 95687
33226, 23055, 23056, 23079, 23078, 23916, 23917, 23940, 23939, 23537, 23583, 23584, 23581, 24398, 24444, 24445, 
24442, 95665, 95666, 95689, 95688
33227, 23056, 23057, 23080, 23079, 23917, 23918, 23941, 23940, 23539, 23585, 23586, 23583, 24400, 24446, 24447, 
24444, 95666, 95667, 95690, 95689
33228, 23057, 23058, 23081, 23080, 23918, 23919, 23942, 23941, 23541, 23587, 23588, 23585, 24402, 24448, 24449, 
24446, 95667, 95668, 95691, 95690
33229, 23058, 23059, 23082, 23081, 23919, 23920, 23943, 23942, 23543, 23589, 23590, 23587, 24404, 24450, 24451, 
24448, 95668, 95669, 95692, 95691
33230, 23059, 23060, 23083, 23082, 23920, 23921, 23944, 23943, 23545, 23591, 23592, 23589, 24406, 24452, 24453, 
24450, 95669, 95670, 95693, 95692
33231, 23060, 23061, 23084, 23083, 23921, 23922, 23945, 23944, 23547, 23593, 23594, 23591, 24408, 24454, 24455, 
24452, 95670, 95671, 95694, 95693
33232, 23061, 23062, 23085, 23084, 23922, 23923, 23946, 23945, 23549, 23595, 23596, 23593, 24410, 24456, 24457, 
24454, 95671, 95672, 95695, 95694
33233, 23062, 23063, 23086, 23085, 23923, 23924, 23947, 23946, 23551, 23597, 23598, 23595, 24412, 24458, 24459, 
24456, 95672, 95673, 95696, 95695
33234, 23063, 23064, 23087, 23086, 23924, 23925, 23948, 23947, 23553, 23599, 23600, 23597, 24414, 24460, 24461, 
24458, 95673, 95674, 95697, 95696
33235, 23064, 23065, 23088, 23087, 23925, 23926, 23949, 23948, 23555, 23601, 23602, 23599, 24416, 24462, 24463, 
24460, 95674, 95675, 95698, 95697
33236, 23065, 23066, 23089, 23088, 23926, 23927, 23950, 23949, 23557, 23603, 23604, 23601, 24418, 24464, 24465, 
24462, 95675, 95676, 95699, 95698
33237, 23066, 23067, 23090, 23089, 23927, 23928, 23951, 23950, 23559, 23605, 23606, 23603, 24420, 24466, 24467, 
24464, 95676, 95677, 95700, 95699
33238, 23067, 1967, 1968, 23090, 23928, 2111, 2112, 23951, 23560, 1979, 23607, 23605, 24421, 2123, 24468, 
24466, 95677, 23697, 23698, 95700
33239, 1945, 23068, 1747, 37, 2089, 23929, 1983, 41, 23562, 23608, 1770, 1957, 24423, 24469, 2006, 
2101, 23687, 95678, 23631, 1981
33240, 23068, 23069, 1748, 1747, 23929, 23930, 1984, 1983, 23564, 23609, 1771, 23608, 24425, 24470, 2007, 
24469, 95678, 95679, 23632, 23631
33241, 23069, 23070, 1749, 1748, 23930, 23931, 1985, 1984, 23566, 23610, 1772, 23609, 24427, 24471, 2008, 
24470, 95679, 95680, 23633, 23632
33242, 23070, 23071, 1750, 1749, 23931, 23932, 1986, 1985, 23568, 23611, 1773, 23610, 24429, 24472, 2009, 
24471, 95680, 95681, 23634, 23633
33243, 23071, 23072, 1751, 1750, 23932, 23933, 1987, 1986, 23570, 23612, 1774, 23611, 24431, 24473, 2010, 
24472, 95681, 95682, 23635, 23634
33244, 23072, 23073, 1752, 1751, 23933, 23934, 1988, 1987, 23572, 23613, 1775, 23612, 24433, 24474, 2011, 
24473, 95682, 95683, 23636, 23635
33245, 23073, 23074, 1753, 1752, 23934, 23935, 1989, 1988, 23574, 23614, 1776, 23613, 24435, 24475, 2012, 
24474, 95683, 95684, 23637, 23636
33246, 23074, 23075, 1754, 1753, 23935, 23936, 1990, 1989, 23576, 23615, 1777, 23614, 24437, 24476, 2013, 
24475, 95684, 95685, 23638, 23637
33247, 23075, 23076, 1755, 1754, 23936, 23937, 1991, 1990, 23578, 23616, 1778, 23615, 24439, 24477, 2014, 
24476, 95685, 95686, 23639, 23638
33248, 23076, 23077, 1756, 1755, 23937, 23938, 1992, 1991, 23580, 23617, 1779, 23616, 24441, 24478, 2015, 
24477, 95686, 95687, 23640, 23639
33249, 23077, 23078, 1757, 1756, 23938, 23939, 1993, 1992, 23582, 23618, 1780, 23617, 24443, 24479, 2016, 
24478, 95687, 95688, 23641, 23640
33250, 23078, 23079, 1758, 1757, 23939, 23940, 1994, 1993, 23584, 23619, 1781, 23618, 24445, 24480, 2017, 
24479, 95688, 95689, 23642, 23641
33251, 23079, 23080, 1759, 1758, 23940, 23941, 1995, 1994, 23586, 23620, 1782, 23619, 24447, 24481, 2018, 
24480, 95689, 95690, 23643, 23642
33252, 23080, 23081, 1760, 1759, 23941, 23942, 1996, 1995, 23588, 23621, 1783, 23620, 24449, 24482, 2019, 
24481, 95690, 95691, 23644, 23643
33253, 23081, 23082, 1761, 1760, 23942, 23943, 1997, 1996, 23590, 23622, 1784, 23621, 24451, 24483, 2020, 
24482, 95691, 95692, 23645, 23644
33254, 23082, 23083, 1762, 1761, 23943, 23944, 1998, 1997, 23592, 23623, 1785, 23622, 24453, 24484, 2021, 
24483, 95692, 95693, 23646, 23645
33255, 23083, 23084, 1763, 1762, 23944, 23945, 1999, 1998, 23594, 23624, 1786, 23623, 24455, 24485, 2022, 
24484, 95693, 95694, 23647, 23646
33256, 23084, 23085, 1764, 1763, 23945, 23946, 2000, 1999, 23596, 23625, 1787, 23624, 24457, 24486, 2023, 
24485, 95694, 95695, 23648, 23647
33257, 23085, 23086, 1765, 1764, 23946, 23947, 2001, 2000, 23598, 23626, 1788, 23625, 24459, 24487, 2024, 
24486, 95695, 95696, 23649, 23648
33258, 23086, 23087, 1766, 1765, 23947, 23948, 2002, 2001, 23600, 23627, 1789, 23626, 24461, 24488, 2025, 
24487, 95696, 95697, 23650, 23649
33259, 23087, 23088, 1767, 1766, 23948, 23949, 2003, 2002, 23602, 23628, 1790, 23627, 24463, 24489, 2026, 
24488, 95697, 95698, 23651, 23650
33260, 23088, 23089, 1768, 1767, 23949, 23950, 2004, 2003, 23604, 23629, 1791, 23628, 24465, 24490, 2027, 
24489, 95698, 95699, 23652, 23651
33261, 23089, 23090, 1769, 1768, 23950, 23951, 2005, 2004, 23606, 23630, 1792, 23629, 24467, 24491, 2028, 
24490, 95699, 95700, 23653, 23652
33262, 23090, 1968, 38, 1769, 23951, 2112, 42, 2005, 23607, 1980, 1793, 23630, 24468, 2124, 2029, 
24491, 95700, 23698, 1982, 23653
*ELEMENT, type=C3D20, ELSET=Volume11
33263, 43, 2032, 23699, 2079, 2182, 24655, 95701, 24818, 2055, 23952, 23953, 2090, 24702, 96208, 96209, 
24840, 2184, 24701, 96207, 24841
33264, 2182, 24655, 95701, 24818, 2183, 24656, 95702, 24819, 24702, 96208, 96209, 24840, 24704, 96211, 96212, 
24842, 2185, 24703, 96210, 24843
33265, 2183, 24656, 95702, 24819, 47, 2192, 24976, 2239, 24704, 96211, 96212, 24842, 2215, 25229, 25230, 
2250, 2186, 24705, 96213, 24844
33266, 2032, 2033, 23700, 23699, 24655, 24657, 95703, 95701, 2056, 23954, 23955, 23952, 24707, 96215, 96216, 
96208, 24701, 24706, 96214, 96207
33267, 24655, 24657, 95703, 95701, 24656, 24658, 95704, 95702, 24707, 96215, 96216, 96208, 24709, 96218, 96219, 
96211, 24703, 24708, 96217, 96210
33268, 24656, 24658, 95704, 95702, 2192, 2193, 24977, 24976, 24709, 96218, 96219, 96211, 2216, 25231, 25232, 
25229, 24705, 24710, 96220, 96213
33269, 2033, 2034, 23701, 23700, 24657, 24659, 95705, 95703, 2057, 23956, 23957, 23954, 24712, 96222, 96223, 
96215, 24706, 24711, 96221, 96214
33270, 24657, 24659, 95705, 95703, 24658, 24660, 95706, 95704, 24712, 96222, 96223, 96215, 24714, 96225, 96226, 
96218, 24708, 24713, 96224, 96217
33271, 24658, 24660, 95706, 95704, 2193, 2194, 24978, 24977, 24714, 96225, 96226, 96218, 2217, 25233, 25234, 
25231, 24710, 24715, 96227, 96220
33272, 2034, 2035, 23702, 23701, 24659, 24661, 95707, 95705, 2058, 23958, 23959, 23956, 24717, 96229, 96230, 
96222, 24711, 24716, 96228, 96221
33273, 24659, 24661, 95707, 95705, 24660, 24662, 95708, 95706, 24717, 96229, 96230, 96222, 24719, 96232, 96233, 
96225, 24713, 24718, 96231, 96224
33274, 24660, 24662, 95708, 95706, 2194, 2195, 24979, 24978, 24719, 96232, 96233, 96225, 2218, 25235, 25236, 
25233, 24715, 24720, 96234, 96227
33275, 2035, 2036, 23703, 23702, 24661, 24663, 95709, 95707, 2059, 23960, 23961, 23958, 24722, 96236, 96237, 
96229, 24716, 24721, 96235, 96228
33276, 24661, 24663, 95709, 95707, 24662, 24664, 95710, 95708, 24722, 96236, 96237, 96229, 24724, 96239, 96240, 
96232, 24718, 24723, 96238, 96231
33277, 24662, 24664, 95710, 95708, 2195, 2196, 24980, 24979, 24724, 96239, 96240, 96232, 2219, 25237, 25238, 
25235, 24720, 24725, 96241, 96234
33278, 2036, 2037, 23704, 23703, 24663, 24665, 95711, 95709, 2060, 23962, 23963, 23960, 24727, 96243, 96244, 
96236, 24721, 24726, 96242, 96235
33279, 24663, 24665, 95711, 95709, 24664, 24666, 95712, 95710, 24727, 96243, 96244, 96236, 24729, 96246, 96247, 
96239, 24723, 24728, 96245, 96238
33280, 24664, 24666, 95712, 95710, 2196, 2197, 24981, 24980, 24729, 96246, 96247, 96239, 2220, 25239, 25240, 
25237, 24725, 24730, 96248, 96241
33281, 2037, 2038, 23705, 23704, 24665, 24667, 95713, 95711, 2061, 23964, 23965, 23962, 24732, 96250, 96251, 
96243, 24726, 24731, 96249, 96242
33282, 24665, 24667, 95713, 95711, 24666, 24668, 95714, 95712, 24732, 96250, 96251, 96243, 24734, 96253, 96254, 
96246, 24728, 24733, 96252, 96245
33283, 24666, 24668, 95714, 95712, 2197, 2198, 24982, 24981, 24734, 96253, 96254, 96246, 2221, 25241, 25242, 
25239, 24730, 24735, 96255, 96248
33284, 2038, 2039, 23706, 23705, 24667, 24669, 95715, 95713, 2062, 23966, 23967, 23964, 24737, 96257, 96258, 
96250, 24731, 24736, 96256, 96249
33285, 24667, 24669, 95715, 95713, 24668, 24670, 95716, 95714, 24737, 96257, 96258, 96250, 24739, 96260, 96261, 
96253, 24733, 24738, 96259, 96252
33286, 24668, 24670, 95716, 95714, 2198, 2199, 24983, 24982, 24739, 96260, 96261, 96253, 2222, 25243, 25244, 
25241, 24735, 24740, 96262, 96255
33287, 2039, 2040, 23707, 23706, 24669, 24671, 95717, 95715, 2063, 23968, 23969, 23966, 24742, 96264, 96265, 
96257, 24736, 24741, 96263, 96256
33288, 24669, 24671, 95717, 95715, 24670, 24672, 95718, 95716, 24742, 96264, 96265, 96257, 24744, 96267, 96268, 
96260, 24738, 24743, 96266, 96259
33289, 24670, 24672, 95718, 95716, 2199, 2200, 24984, 24983, 24744, 96267, 96268, 96260, 2223, 25245, 25246, 
25243, 24740, 24745, 96269, 96262
33290, 2040, 2041, 23708, 23707, 24671, 24673, 95719, 95717, 2064, 23970, 23971, 23968, 24747, 96271, 96272, 
96264, 24741, 24746, 96270, 96263
33291, 24671, 24673, 95719, 95717, 24672, 24674, 95720, 95718, 24747, 96271, 96272, 96264, 24749, 96274, 96275, 
96267, 24743, 24748, 96273, 96266
33292, 24672, 24674, 95720, 95718, 2200, 2201, 24985, 24984, 24749, 96274, 96275, 96267, 2224, 25247, 25248, 
25245, 24745, 24750, 96276, 96269
33293, 2041, 2042, 23709, 23708, 24673, 24675, 95721, 95719, 2065, 23972, 23973, 23970, 24752, 96278, 96279, 
96271, 24746, 24751, 96277, 96270
33294, 24673, 24675, 95721, 95719, 24674, 24676, 95722, 95720, 24752, 96278, 96279, 96271, 24754, 96281, 96282, 
96274, 24748, 24753, 96280, 96273
33295, 24674, 24676, 95722, 95720, 2201, 2202, 24986, 24985, 24754, 96281, 96282, 96274, 2225, 25249, 25250, 
25247, 24750, 24755, 96283, 96276
33296, 2042, 2043, 23710, 23709, 24675, 24677, 95723, 95721, 2066, 23974, 23975, 23972, 24757, 96285, 96286, 
96278, 24751, 24756, 96284, 96277
33297, 24675, 24677, 95723, 95721, 24676, 24678, 95724, 95722, 24757, 96285, 96286, 96278, 24759, 96288, 96289, 
96281, 24753, 24758, 96287, 96280
33298, 24676, 24678, 95724, 95722, 2202, 2203, 24987, 24986, 24759, 96288, 96289, 96281, 2226, 25251, 25252, 
25249, 24755, 24760, 96290, 96283
33299, 2043, 2044, 23711, 23710, 24677, 24679, 95725, 95723, 2067, 23976, 23977, 23974, 24762, 96292, 96293, 
96285, 24756, 24761, 96291, 96284
33300, 24677, 24679, 95725, 95723, 24678, 24680, 95726, 95724, 24762, 96292, 96293, 96285, 24764, 96295, 96296, 
96288, 24758, 24763, 96294, 96287
33301, 24678, 24680, 95726, 95724, 2203, 2204, 24988, 24987, 24764, 96295, 96296, 96288, 2227, 25253, 25254, 
25251, 24760, 24765, 96297, 96290
33302, 2044, 2045, 23712, 23711, 24679, 24681, 95727, 95725, 2068, 23978, 23979, 23976, 24767, 96299, 96300, 
96292, 24761, 24766, 96298, 96291
33303, 24679, 24681, 95727, 95725, 24680, 24682, 95728, 95726, 24767, 96299, 96300, 96292, 24769, 96302, 96303, 
96295, 24763, 24768, 96301, 96294
33304, 24680, 24682, 95728, 95726, 2204, 2205, 24989, 24988, 24769, 96302, 96303, 96295, 2228, 25255, 25256, 
25253, 24765, 24770, 96304, 96297
33305, 2045, 2046, 23713, 23712, 24681, 24683, 95729, 95727, 2069, 23980, 23981, 23978, 24772, 96306, 96307, 
96299, 24766, 24771, 96305, 96298
33306, 24681, 24683, 95729, 95727, 24682, 24684, 95730, 95728, 24772, 96306, 96307, 96299, 24774, 96309, 96310, 
96302, 24768, 24773, 96308, 96301
33307, 24682, 24684, 95730, 95728, 2205, 2206, 24990, 24989, 24774, 96309, 96310, 96302, 2229, 25257, 25258, 
25255, 24770, 24775, 96311, 96304
33308, 2046, 2047, 23714, 23713, 24683, 24685, 95731, 95729, 2070, 23982, 23983, 23980, 24777, 96313, 96314, 
96306, 24771, 24776, 96312, 96305
33309, 24683, 24685, 95731, 95729, 24684, 24686, 95732, 95730, 24777, 96313, 96314, 96306, 24779, 96316, 96317, 
96309, 24773, 24778, 96315, 96308
33310, 24684, 24686, 95732, 95730, 2206, 2207, 24991, 24990, 24779, 96316, 96317, 96309, 2230, 25259, 25260, 
25257, 24775, 24780, 96318, 96311
33311, 2047, 2048, 23715, 23714, 24685, 24687, 95733, 95731, 2071, 23984, 23985, 23982, 24782, 96320, 96321, 
96313, 24776, 24781, 96319, 96312
33312, 24685, 24687, 95733, 95731, 24686, 24688, 95734, 95732, 24782, 96320, 96321, 96313, 24784, 96323, 96324, 
96316, 24778, 24783, 96322, 96315
33313, 24686, 24688, 95734, 95732, 2207, 2208, 24992, 24991, 24784, 96323, 96324, 96316, 2231, 25261, 25262, 
25259, 24780, 24785, 96325, 96318
33314, 2048, 2049, 23716, 23715, 24687, 24689, 95735, 95733, 2072, 23986, 23987, 23984, 24787, 96327, 96328, 
96320, 24781, 24786, 96326, 96319
33315, 24687, 24689, 95735, 95733, 24688, 24690, 95736, 95734, 24787, 96327, 96328, 96320, 24789, 96330, 96331, 
96323, 24783, 24788, 96329, 96322
33316, 24688, 24690, 95736, 95734, 2208, 2209, 24993, 24992, 24789, 96330, 96331, 96323, 2232, 25263, 25264, 
25261, 24785, 24790, 96332, 96325
33317, 2049, 2050, 23717, 23716, 24689, 24691, 95737, 95735, 2073, 23988, 23989, 23986, 24792, 96334, 96335, 
96327, 24786, 24791, 96333, 96326
33318, 24689, 24691, 95737, 95735, 24690, 24692, 95738, 95736, 24792, 96334, 96335, 96327, 24794, 96337, 96338, 
96330, 24788, 24793, 96336, 96329
33319, 24690, 24692, 95738, 95736, 2209, 2210, 24994, 24993, 24794, 96337, 96338, 96330, 2233, 25265, 25266, 
25263, 24790, 24795, 96339, 96332
33320, 2050, 2051, 23718, 23717, 24691, 24693, 95739, 95737, 2074, 23990, 23991, 23988, 24797, 96341, 96342, 
96334, 24791, 24796, 96340, 96333
33321, 24691, 24693, 95739, 95737, 24692, 24694, 95740, 95738, 24797, 96341, 96342, 96334, 24799, 96344, 96345, 
96337, 24793, 24798, 96343, 96336
33322, 24692, 24694, 95740, 95738, 2210, 2211, 24995, 24994, 24799, 96344, 96345, 96337, 2234, 25267, 25268, 
25265, 24795, 24800, 96346, 96339
33323, 2051, 2052, 23719, 23718, 24693, 24695, 95741, 95739, 2075, 23992, 23993, 23990, 24802, 96348, 96349, 
96341, 24796, 24801, 96347, 96340
33324, 24693, 24695, 95741, 95739, 24694, 24696, 95742, 95740, 24802, 96348, 96349, 96341, 24804, 96351, 96352, 
96344, 24798, 24803, 96350, 96343
33325, 24694, 24696, 95742, 95740, 2211, 2212, 24996, 24995, 24804, 96351, 96352, 96344, 2235, 25269, 25270, 
25267, 24800, 24805, 96353, 96346
33326, 2052, 2053, 23720, 23719, 24695, 24697, 95743, 95741, 2076, 23994, 23995, 23992, 24807, 96355, 96356, 
96348, 24801, 24806, 96354, 96347
33327, 24695, 24697, 95743, 95741, 24696, 24698, 95744, 95742, 24807, 96355, 96356, 96348, 24809, 96358, 96359, 
96351, 24803, 24808, 96357, 96350
33328, 24696, 24698, 95744, 95742, 2212, 2213, 24997, 24996, 24809, 96358, 96359, 96351, 2236, 25271, 25272, 
25269, 24805, 24810, 96360, 96353
33329, 2053, 2054, 23721, 23720, 24697, 24699, 95745, 95743, 2077, 23996, 23997, 23994, 24812, 96362, 96363, 
96355, 24806, 24811, 96361, 96354
33330, 24697, 24699, 95745, 95743, 24698, 24700, 95746, 95744, 24812, 96362, 96363, 96355, 24814, 96365, 96366, 
96358, 24808, 24813, 96364, 96357
33331, 24698, 24700, 95746, 95744, 2213, 2214, 24998, 24997, 24814, 96365, 96366, 96358, 2237, 25273, 25274, 
25271, 24810, 24815, 96367, 96360
33332, 2054, 44, 2102, 23721, 24699, 2187, 24897, 95745, 2078, 2113, 23998, 23996, 24816, 24920, 96368, 
96362, 24811, 2189, 24919, 96361
33333, 24699, 2187, 24897, 95745, 24700, 2188, 24898, 95746, 24816, 24920, 96368, 96362, 24817, 24922, 96369, 
96365, 24813, 2190, 24921, 96364
33334, 24700, 2188, 24898, 95746, 2214, 48, 2262, 24998, 24817, 24922, 96369, 96365, 2238, 2273, 25275, 
25273, 24815, 2191, 24923, 96367
33335, 2079, 23699, 23722, 2080, 24818, 95701, 95747, 24820, 23953, 23999, 24000, 2091, 96209, 96371, 96372, 
24845, 24841, 96207, 96370, 24846
33336, 24818, 95701, 95747, 24820, 24819, 95702, 95748, 24821, 96209, 96371, 96372, 24845, 96212, 96374, 96375, 
24847, 24843, 96210, 96373, 24848
33337, 24819, 95702, 95748, 24821, 2239, 24976, 24999, 2240, 96212, 96374, 96375, 24847, 25230, 25276, 25277, 
2251, 24844, 96213, 96376, 24849
33338, 23699, 23700, 23723, 23722, 95701, 95703, 95749, 95747, 23955, 24001, 24002, 23999, 96216, 96378, 96379, 
96371, 96207, 96214, 96377, 96370
33339, 95701, 95703, 95749, 95747, 95702, 95704, 95750, 95748, 96216, 96378, 96379, 96371, 96219, 96381, 96382, 
96374, 96210, 96217, 96380, 96373
33340, 95702, 95704, 95750, 95748, 24976, 24977, 25000, 24999, 96219, 96381, 96382, 96374, 25232, 25278, 25279, 
25276, 96213, 96220, 96383, 96376
33341, 23700, 23701, 23724, 23723, 95703, 95705, 95751, 95749, 23957, 24003, 24004, 24001, 96223, 96385, 96386, 
96378, 96214, 96221, 96384, 96377
33342, 95703, 95705, 95751, 95749, 95704, 95706, 95752, 95750, 96223, 96385, 96386, 96378, 96226, 96388, 96389, 
96381, 96217, 96224, 96387, 96380
33343, 95704, 95706, 95752, 95750, 24977, 24978, 25001, 25000, 96226, 96388, 96389, 96381, 25234, 25280, 25281, 
25278, 96220, 96227, 96390, 96383
33344, 23701, 23702, 23725, 23724, 95705, 95707, 95753, 95751, 23959, 24005, 24006, 24003, 96230, 96392, 96393, 
96385, 96221, 96228, 96391, 96384
33345, 95705, 95707, 95753, 95751, 95706, 95708, 95754, 95752, 96230, 96392, 96393, 96385, 96233, 96395, 96396, 
96388, 96224, 96231, 96394, 96387
33346, 95706, 95708, 95754, 95752, 24978, 24979, 25002, 25001, 96233, 96395, 96396, 96388, 25236, 25282, 25283, 
25280, 96227, 96234, 96397, 96390
33347, 23702, 23703, 23726, 23725, 95707, 95709, 95755, 95753, 23961, 24007, 24008, 24005, 96237, 96399, 96400, 
96392, 96228, 96235, 96398, 96391
33348, 95707, 95709, 95755, 95753, 95708, 95710, 95756, 95754, 96237, 96399, 96400, 96392, 96240, 96402, 96403, 
96395, 96231, 96238, 96401, 96394
33349, 95708, 95710, 95756, 95754, 24979, 24980, 25003, 25002, 96240, 96402, 96403, 96395, 25238, 25284, 25285, 
25282, 96234, 96241, 96404, 96397
33350, 23703, 23704, 23727, 23726, 95709, 95711, 95757, 95755, 23963, 24009, 24010, 24007, 96244, 96406, 96407, 
96399, 96235, 96242, 96405, 96398
33351, 95709, 95711, 95757, 95755, 95710, 95712, 95758, 95756, 96244, 96406, 96407, 96399, 96247, 96409, 96410, 
96402, 96238, 96245, 96408, 96401
33352, 95710, 95712, 95758, 95756, 24980, 24981, 25004, 25003, 96247, 96409, 96410, 96402, 25240, 25286, 25287, 
25284, 96241, 96248, 96411, 96404
33353, 23704, 23705, 23728, 23727, 95711, 95713, 95759, 95757, 23965, 24011, 24012, 24009, 96251, 96413, 96414, 
96406, 96242, 96249, 96412, 96405
33354, 95711, 95713, 95759, 95757, 95712, 95714, 95760, 95758, 96251, 96413, 96414, 96406, 96254, 96416, 96417, 
96409, 96245, 96252, 96415, 96408
33355, 95712, 95714, 95760, 95758, 24981, 24982, 25005, 25004, 96254, 96416, 96417, 96409, 25242, 25288, 25289, 
25286, 96248, 96255, 96418, 96411
33356, 23705, 23706, 23729, 23728, 95713, 95715, 95761, 95759, 23967, 24013, 24014, 24011, 96258, 96420, 96421, 
96413, 96249, 96256, 96419, 96412
33357, 95713, 95715, 95761, 95759, 95714, 95716, 95762, 95760, 96258, 96420, 96421, 96413, 96261, 96423, 96424, 
96416, 96252, 96259, 96422, 96415
33358, 95714, 95716, 95762, 95760, 24982, 24983, 25006, 25005, 96261, 96423, 96424, 96416, 25244, 25290, 25291, 
25288, 96255, 96262, 96425, 96418
33359, 23706, 23707, 23730, 23729, 95715, 95717, 95763, 95761, 23969, 24015, 24016, 24013, 96265, 96427, 96428, 
96420, 96256, 96263, 96426, 96419
33360, 95715, 95717, 95763, 95761, 95716, 95718, 95764, 95762, 96265, 96427, 96428, 96420, 96268, 96430, 96431, 
96423, 96259, 96266, 96429, 96422
33361, 95716, 95718, 95764, 95762, 24983, 24984, 25007, 25006, 96268, 96430, 96431, 96423, 25246, 25292, 25293, 
25290, 96262, 96269, 96432, 96425
33362, 23707, 23708, 23731, 23730, 95717, 95719, 95765, 95763, 23971, 24017, 24018, 24015, 96272, 96434, 96435, 
96427, 96263, 96270, 96433, 96426
33363, 95717, 95719, 95765, 95763, 95718, 95720, 95766, 95764, 96272, 96434, 96435, 96427, 96275, 96437, 96438, 
96430, 96266, 96273, 96436, 96429
33364, 95718, 95720, 95766, 95764, 24984, 24985, 25008, 25007, 96275, 96437, 96438, 96430, 25248, 25294, 25295, 
25292, 96269, 96276, 96439, 96432
33365, 23708, 23709, 23732, 23731, 95719, 95721, 95767, 95765, 23973, 24019, 24020, 24017, 96279, 96441, 96442, 
96434, 96270, 96277, 96440, 96433
33366, 95719, 95721, 95767, 95765, 95720, 95722, 95768, 95766, 96279, 96441, 96442, 96434, 96282, 96444, 96445, 
96437, 96273, 96280, 96443, 96436
33367, 95720, 95722, 95768, 95766, 24985, 24986, 25009, 25008, 96282, 96444, 96445, 96437, 25250, 25296, 25297, 
25294, 96276, 96283, 96446, 96439
33368, 23709, 23710, 23733, 23732, 95721, 95723, 95769, 95767, 23975, 24021, 24022, 24019, 96286, 96448, 96449, 
96441, 96277, 96284, 96447, 96440
33369, 95721, 95723, 95769, 95767, 95722, 95724, 95770, 95768, 96286, 96448, 96449, 96441, 96289, 96451, 96452, 
96444, 96280, 96287, 96450, 96443
33370, 95722, 95724, 95770, 95768, 24986, 24987, 25010, 25009, 96289, 96451, 96452, 96444, 25252, 25298, 25299, 
25296, 96283, 96290, 96453, 96446
33371, 23710, 23711, 23734, 23733, 95723, 95725, 95771, 95769, 23977, 24023, 24024, 24021, 96293, 96455, 96456, 
96448, 96284, 96291, 96454, 96447
33372, 95723, 95725, 95771, 95769, 95724, 95726, 95772, 95770, 96293, 96455, 96456, 96448, 96296, 96458, 96459, 
96451, 96287, 96294, 96457, 96450
33373, 95724, 95726, 95772, 95770, 24987, 24988, 25011, 25010, 96296, 96458, 96459, 96451, 25254, 25300, 25301, 
25298, 96290, 96297, 96460, 96453
33374, 23711, 23712, 23735, 23734, 95725, 95727, 95773, 95771, 23979, 24025, 24026, 24023, 96300, 96462, 96463, 
96455, 96291, 96298, 96461, 96454
33375, 95725, 95727, 95773, 95771, 95726, 95728, 95774, 95772, 96300, 96462, 96463, 96455, 96303, 96465, 96466, 
96458, 96294, 96301, 96464, 96457
33376, 95726, 95728, 95774, 95772, 24988, 24989, 25012, 25011, 96303, 96465, 96466, 96458, 25256, 25302, 25303, 
25300, 96297, 96304, 96467, 96460
33377, 23712, 23713, 23736, 23735, 95727, 95729, 95775, 95773, 23981, 24027, 24028, 24025, 96307, 96469, 96470, 
96462, 96298, 96305, 96468, 96461
33378, 95727, 95729, 95775, 95773, 95728, 95730, 95776, 95774, 96307, 96469, 96470, 96462, 96310, 96472, 96473, 
96465, 96301, 96308, 96471, 96464
33379, 95728, 95730, 95776, 95774, 24989, 24990, 25013, 25012, 96310, 96472, 96473, 96465, 25258, 25304, 25305, 
25302, 96304, 96311, 96474, 96467
33380, 23713, 23714, 23737, 23736, 95729, 95731, 95777, 95775, 23983, 24029, 24030, 24027, 96314, 96476, 96477, 
96469, 96305, 96312, 96475, 96468
33381, 95729, 95731, 95777, 95775, 95730, 95732, 95778, 95776, 96314, 96476, 96477, 96469, 96317, 96479, 96480, 
96472, 96308, 96315, 96478, 96471
33382, 95730, 95732, 95778, 95776, 24990, 24991, 25014, 25013, 96317, 96479, 96480, 96472, 25260, 25306, 25307, 
25304, 96311, 96318, 96481, 96474
33383, 23714, 23715, 23738, 23737, 95731, 95733, 95779, 95777, 23985, 24031, 24032, 24029, 96321, 96483, 96484, 
96476, 96312, 96319, 96482, 96475
33384, 95731, 95733, 95779, 95777, 95732, 95734, 95780, 95778, 96321, 96483, 96484, 96476, 96324, 96486, 96487, 
96479, 96315, 96322, 96485, 96478
33385, 95732, 95734, 95780, 95778, 24991, 24992, 25015, 25014, 96324, 96486, 96487, 96479, 25262, 25308, 25309, 
25306, 96318, 96325, 96488, 96481
33386, 23715, 23716, 23739, 23738, 95733, 95735, 95781, 95779, 23987, 24033, 24034, 24031, 96328, 96490, 96491, 
96483, 96319, 96326, 96489, 96482
33387, 95733, 95735, 95781, 95779, 95734, 95736, 95782, 95780, 96328, 96490, 96491, 96483, 96331, 96493, 96494, 
96486, 96322, 96329, 96492, 96485
33388, 95734, 95736, 95782, 95780, 24992, 24993, 25016, 25015, 96331, 96493, 96494, 96486, 25264, 25310, 25311, 
25308, 96325, 96332, 96495, 96488
33389, 23716, 23717, 23740, 23739, 95735, 95737, 95783, 95781, 23989, 24035, 24036, 24033, 96335, 96497, 96498, 
96490, 96326, 96333, 96496, 96489
33390, 95735, 95737, 95783, 95781, 95736, 95738, 95784, 95782, 96335, 96497, 96498, 96490, 96338, 96500, 96501, 
96493, 96329, 96336, 96499, 96492
33391, 95736, 95738, 95784, 95782, 24993, 24994, 25017, 25016, 96338, 96500, 96501, 96493, 25266, 25312, 25313, 
25310, 96332, 96339, 96502, 96495
33392, 23717, 23718, 23741, 23740, 95737, 95739, 95785, 95783, 23991, 24037, 24038, 24035, 96342, 96504, 96505, 
96497, 96333, 96340, 96503, 96496
33393, 95737, 95739, 95785, 95783, 95738, 95740, 95786, 95784, 96342, 96504, 96505, 96497, 96345, 96507, 96508, 
96500, 96336, 96343, 96506, 96499
33394, 95738, 95740, 95786, 95784, 24994, 24995, 25018, 25017, 96345, 96507, 96508, 96500, 25268, 25314, 25315, 
25312, 96339, 96346, 96509, 96502
33395, 23718, 23719, 23742, 23741, 95739, 95741, 95787, 95785, 23993, 24039, 24040, 24037, 96349, 96511, 96512, 
96504, 96340, 96347, 96510, 96503
33396, 95739, 95741, 95787, 95785, 95740, 95742, 95788, 95786, 96349, 96511, 96512, 96504, 96352, 96514, 96515, 
96507, 96343, 96350, 96513, 96506
33397, 95740, 95742, 95788, 95786, 24995, 24996, 25019, 25018, 96352, 96514, 96515, 96507, 25270, 25316, 25317, 
25314, 96346, 96353, 96516, 96509
33398, 23719, 23720, 23743, 23742, 95741, 95743, 95789, 95787, 23995, 24041, 24042, 24039, 96356, 96518, 96519, 
96511, 96347, 96354, 96517, 96510
33399, 95741, 95743, 95789, 95787, 95742, 95744, 95790, 95788, 96356, 96518, 96519, 96511, 96359, 96521, 96522, 
96514, 96350, 96357, 96520, 96513
33400, 95742, 95744, 95790, 95788, 24996, 24997, 25020, 25019, 96359, 96521, 96522, 96514, 25272, 25318, 25319, 
25316, 96353, 96360, 96523, 96516
33401, 23720, 23721, 23744, 23743, 95743, 95745, 95791, 95789, 23997, 24043, 24044, 24041, 96363, 96525, 96526, 
96518, 96354, 96361, 96524, 96517
33402, 95743, 95745, 95791, 95789, 95744, 95746, 95792, 95790, 96363, 96525, 96526, 96518, 96366, 96528, 96529, 
96521, 96357, 96364, 96527, 96520
33403, 95744, 95746, 95792, 95790, 24997, 24998, 25021, 25020, 96366, 96528, 96529, 96521, 25274, 25320, 25321, 
25318, 96360, 96367, 96530, 96523
33404, 23721, 2102, 2103, 23744, 95745, 24897, 24899, 95791, 23998, 2114, 24045, 24043, 96368, 24925, 96531, 
96525, 96361, 24919, 24924, 96524
33405, 95745, 24897, 24899, 95791, 95746, 24898, 24900, 95792, 96368, 24925, 96531, 96525, 96369, 24927, 96532, 
96528, 96364, 24921, 24926, 96527
33406, 95746, 24898, 24900, 95792, 24998, 2262, 2263, 25021, 96369, 24927, 96532, 96528, 25275, 2274, 25322, 
25320, 96367, 24923, 24928, 96530
33407, 2080, 23722, 23745, 2081, 24820, 95747, 95793, 24822, 24000, 24046, 24047, 2092, 96372, 96534, 96535, 
24850, 24846, 96370, 96533, 24851
33408, 24820, 95747, 95793, 24822, 24821, 95748, 95794, 24823, 96372, 96534, 96535, 24850, 96375, 96537, 96538, 
24852, 24848, 96373, 96536, 24853
33409, 24821, 95748, 95794, 24823, 2240, 24999, 25022, 2241, 96375, 96537, 96538, 24852, 25277, 25323, 25324, 
2252, 24849, 96376, 96539, 24854
33410, 23722, 23723, 23746, 23745, 95747, 95749, 95795, 95793, 24002, 24048, 24049, 24046, 96379, 96541, 96542, 
96534, 96370, 96377, 96540, 96533
33411, 95747, 95749, 95795, 95793, 95748, 95750, 95796, 95794, 96379, 96541, 96542, 96534, 96382, 96544, 96545, 
96537, 96373, 96380, 96543, 96536
33412, 95748, 95750, 95796, 95794, 24999, 25000, 25023, 25022, 96382, 96544, 96545, 96537, 25279, 25325, 25326, 
25323, 96376, 96383, 96546, 96539
33413, 23723, 23724, 23747, 23746, 95749, 95751, 95797, 95795, 24004, 24050, 24051, 24048, 96386, 96548, 96549, 
96541, 96377, 96384, 96547, 96540
33414, 95749, 95751, 95797, 95795, 95750, 95752, 95798, 95796, 96386, 96548, 96549, 96541, 96389, 96551, 96552, 
96544, 96380, 96387, 96550, 96543
33415, 95750, 95752, 95798, 95796, 25000, 25001, 25024, 25023, 96389, 96551, 96552, 96544, 25281, 25327, 25328, 
25325, 96383, 96390, 96553, 96546
33416, 23724, 23725, 23748, 23747, 95751, 95753, 95799, 95797, 24006, 24052, 24053, 24050, 96393, 96555, 96556, 
96548, 96384, 96391, 96554, 96547
33417, 95751, 95753, 95799, 95797, 95752, 95754, 95800, 95798, 96393, 96555, 96556, 96548, 96396, 96558, 96559, 
96551, 96387, 96394, 96557, 96550
33418, 95752, 95754, 95800, 95798, 25001, 25002, 25025, 25024, 96396, 96558, 96559, 96551, 25283, 25329, 25330, 
25327, 96390, 96397, 96560, 96553
33419, 23725, 23726, 23749, 23748, 95753, 95755, 95801, 95799, 24008, 24054, 24055, 24052, 96400, 96562, 96563, 
96555, 96391, 96398, 96561, 96554
33420, 95753, 95755, 95801, 95799, 95754, 95756, 95802, 95800, 96400, 96562, 96563, 96555, 96403, 96565, 96566, 
96558, 96394, 96401, 96564, 96557
33421, 95754, 95756, 95802, 95800, 25002, 25003, 25026, 25025, 96403, 96565, 96566, 96558, 25285, 25331, 25332, 
25329, 96397, 96404, 96567, 96560
33422, 23726, 23727, 23750, 23749, 95755, 95757, 95803, 95801, 24010, 24056, 24057, 24054, 96407, 96569, 96570, 
96562, 96398, 96405, 96568, 96561
33423, 95755, 95757, 95803, 95801, 95756, 95758, 95804, 95802, 96407, 96569, 96570, 96562, 96410, 96572, 96573, 
96565, 96401, 96408, 96571, 96564
33424, 95756, 95758, 95804, 95802, 25003, 25004, 25027, 25026, 96410, 96572, 96573, 96565, 25287, 25333, 25334, 
25331, 96404, 96411, 96574, 96567
33425, 23727, 23728, 23751, 23750, 95757, 95759, 95805, 95803, 24012, 24058, 24059, 24056, 96414, 96576, 96577, 
96569, 96405, 96412, 96575, 96568
33426, 95757, 95759, 95805, 95803, 95758, 95760, 95806, 95804, 96414, 96576, 96577, 96569, 96417, 96579, 96580, 
96572, 96408, 96415, 96578, 96571
33427, 95758, 95760, 95806, 95804, 25004, 25005, 25028, 25027, 96417, 96579, 96580, 96572, 25289, 25335, 25336, 
25333, 96411, 96418, 96581, 96574
33428, 23728, 23729, 23752, 23751, 95759, 95761, 95807, 95805, 24014, 24060, 24061, 24058, 96421, 96583, 96584, 
96576, 96412, 96419, 96582, 96575
33429, 95759, 95761, 95807, 95805, 95760, 95762, 95808, 95806, 96421, 96583, 96584, 96576, 96424, 96586, 96587, 
96579, 96415, 96422, 96585, 96578
33430, 95760, 95762, 95808, 95806, 25005, 25006, 25029, 25028, 96424, 96586, 96587, 96579, 25291, 25337, 25338, 
25335, 96418, 96425, 96588, 96581
33431, 23729, 23730, 23753, 23752, 95761, 95763, 95809, 95807, 24016, 24062, 24063, 24060, 96428, 96590, 96591, 
96583, 96419, 96426, 96589, 96582
33432, 95761, 95763, 95809, 95807, 95762, 95764, 95810, 95808, 96428, 96590, 96591, 96583, 96431, 96593, 96594, 
96586, 96422, 96429, 96592, 96585
33433, 95762, 95764, 95810, 95808, 25006, 25007, 25030, 25029, 96431, 96593, 96594, 96586, 25293, 25339, 25340, 
25337, 96425, 96432, 96595, 96588
33434, 23730, 23731, 23754, 23753, 95763, 95765, 95811, 95809, 24018, 24064, 24065, 24062, 96435, 96597, 96598, 
96590, 96426, 96433, 96596, 96589
33435, 95763, 95765, 95811, 95809, 95764, 95766, 95812, 95810, 96435, 96597, 96598, 96590, 96438, 96600, 96601, 
96593, 96429, 96436, 96599, 96592
33436, 95764, 95766, 95812, 95810, 25007, 25008, 25031, 25030, 96438, 96600, 96601, 96593, 25295, 25341, 25342, 
25339, 96432, 96439, 96602, 96595
33437, 23731, 23732, 23755, 23754, 95765, 95767, 95813, 95811, 24020, 24066, 24067, 24064, 96442, 96604, 96605, 
96597, 96433, 96440, 96603, 96596
33438, 95765, 95767, 95813, 95811, 95766, 95768, 95814, 95812, 96442, 96604, 96605, 96597, 96445, 96607, 96608, 
96600, 96436, 96443, 96606, 96599
33439, 95766, 95768, 95814, 95812, 25008, 25009, 25032, 25031, 96445, 96607, 96608, 96600, 25297, 25343, 25344, 
25341, 96439, 96446, 96609, 96602
33440, 23732, 23733, 23756, 23755, 95767, 95769, 95815, 95813, 24022, 24068, 24069, 24066, 96449, 96611, 96612, 
96604, 96440, 96447, 96610, 96603
33441, 95767, 95769, 95815, 95813, 95768, 95770, 95816, 95814, 96449, 96611, 96612, 96604, 96452, 96614, 96615, 
96607, 96443, 96450, 96613, 96606
33442, 95768, 95770, 95816, 95814, 25009, 25010, 25033, 25032, 96452, 96614, 96615, 96607, 25299, 25345, 25346, 
25343, 96446, 96453, 96616, 96609
33443, 23733, 23734, 23757, 23756, 95769, 95771, 95817, 95815, 24024, 24070, 24071, 24068, 96456, 96618, 96619, 
96611, 96447, 96454, 96617, 96610
33444, 95769, 95771, 95817, 95815, 95770, 95772, 95818, 95816, 96456, 96618, 96619, 96611, 96459, 96621, 96622, 
96614, 96450, 96457, 96620, 96613
33445, 95770, 95772, 95818, 95816, 25010, 25011, 25034, 25033, 96459, 96621, 96622, 96614, 25301, 25347, 25348, 
25345, 96453, 96460, 96623, 96616
33446, 23734, 23735, 23758, 23757, 95771, 95773, 95819, 95817, 24026, 24072, 24073, 24070, 96463, 96625, 96626, 
96618, 96454, 96461, 96624, 96617
33447, 95771, 95773, 95819, 95817, 95772, 95774, 95820, 95818, 96463, 96625, 96626, 96618, 96466, 96628, 96629, 
96621, 96457, 96464, 96627, 96620
33448, 95772, 95774, 95820, 95818, 25011, 25012, 25035, 25034, 96466, 96628, 96629, 96621, 25303, 25349, 25350, 
25347, 96460, 96467, 96630, 96623
33449, 23735, 23736, 23759, 23758, 95773, 95775, 95821, 95819, 24028, 24074, 24075, 24072, 96470, 96632, 96633, 
96625, 96461, 96468, 96631, 96624
33450, 95773, 95775, 95821, 95819, 95774, 95776, 95822, 95820, 96470, 96632, 96633, 96625, 96473, 96635, 96636, 
96628, 96464, 96471, 96634, 96627
33451, 95774, 95776, 95822, 95820, 25012, 25013, 25036, 25035, 96473, 96635, 96636, 96628, 25305, 25351, 25352, 
25349, 96467, 96474, 96637, 96630
33452, 23736, 23737, 23760, 23759, 95775, 95777, 95823, 95821, 24030, 24076, 24077, 24074, 96477, 96639, 96640, 
96632, 96468, 96475, 96638, 96631
33453, 95775, 95777, 95823, 95821, 95776, 95778, 95824, 95822, 96477, 96639, 96640, 96632, 96480, 96642, 96643, 
96635, 96471, 96478, 96641, 96634
33454, 95776, 95778, 95824, 95822, 25013, 25014, 25037, 25036, 96480, 96642, 96643, 96635, 25307, 25353, 25354, 
25351, 96474, 96481, 96644, 96637
33455, 23737, 23738, 23761, 23760, 95777, 95779, 95825, 95823, 24032, 24078, 24079, 24076, 96484, 96646, 96647, 
96639, 96475, 96482, 96645, 96638
33456, 95777, 95779, 95825, 95823, 95778, 95780, 95826, 95824, 96484, 96646, 96647, 96639, 96487, 96649, 96650, 
96642, 96478, 96485, 96648, 96641
33457, 95778, 95780, 95826, 95824, 25014, 25015, 25038, 25037, 96487, 96649, 96650, 96642, 25309, 25355, 25356, 
25353, 96481, 96488, 96651, 96644
33458, 23738, 23739, 23762, 23761, 95779, 95781, 95827, 95825, 24034, 24080, 24081, 24078, 96491, 96653, 96654, 
96646, 96482, 96489, 96652, 96645
33459, 95779, 95781, 95827, 95825, 95780, 95782, 95828, 95826, 96491, 96653, 96654, 96646, 96494, 96656, 96657, 
96649, 96485, 96492, 96655, 96648
33460, 95780, 95782, 95828, 95826, 25015, 25016, 25039, 25038, 96494, 96656, 96657, 96649, 25311, 25357, 25358, 
25355, 96488, 96495, 96658, 96651
33461, 23739, 23740, 23763, 23762, 95781, 95783, 95829, 95827, 24036, 24082, 24083, 24080, 96498, 96660, 96661, 
96653, 96489, 96496, 96659, 96652
33462, 95781, 95783, 95829, 95827, 95782, 95784, 95830, 95828, 96498, 96660, 96661, 96653, 96501, 96663, 96664, 
96656, 96492, 96499, 96662, 96655
33463, 95782, 95784, 95830, 95828, 25016, 25017, 25040, 25039, 96501, 96663, 96664, 96656, 25313, 25359, 25360, 
25357, 96495, 96502, 96665, 96658
33464, 23740, 23741, 23764, 23763, 95783, 95785, 95831, 95829, 24038, 24084, 24085, 24082, 96505, 96667, 96668, 
96660, 96496, 96503, 96666, 96659
33465, 95783, 95785, 95831, 95829, 95784, 95786, 95832, 95830, 96505, 96667, 96668, 96660, 96508, 96670, 96671, 
96663, 96499, 96506, 96669, 96662
33466, 95784, 95786, 95832, 95830, 25017, 25018, 25041, 25040, 96508, 96670, 96671, 96663, 25315, 25361, 25362, 
25359, 96502, 96509, 96672, 96665
33467, 23741, 23742, 23765, 23764, 95785, 95787, 95833, 95831, 24040, 24086, 24087, 24084, 96512, 96674, 96675, 
96667, 96503, 96510, 96673, 96666
33468, 95785, 95787, 95833, 95831, 95786, 95788, 95834, 95832, 96512, 96674, 96675, 96667, 96515, 96677, 96678, 
96670, 96506, 96513, 96676, 96669
33469, 95786, 95788, 95834, 95832, 25018, 25019, 25042, 25041, 96515, 96677, 96678, 96670, 25317, 25363, 25364, 
25361, 96509, 96516, 96679, 96672
33470, 23742, 23743, 23766, 23765, 95787, 95789, 95835, 95833, 24042, 24088, 24089, 24086, 96519, 96681, 96682, 
96674, 96510, 96517, 96680, 96673
33471, 95787, 95789, 95835, 95833, 95788, 95790, 95836, 95834, 96519, 96681, 96682, 96674, 96522, 96684, 96685, 
96677, 96513, 96520, 96683, 96676
33472, 95788, 95790, 95836, 95834, 25019, 25020, 25043, 25042, 96522, 96684, 96685, 96677, 25319, 25365, 25366, 
25363, 96516, 96523, 96686, 96679
33473, 23743, 23744, 23767, 23766, 95789, 95791, 95837, 95835, 24044, 24090, 24091, 24088, 96526, 96688, 96689, 
96681, 96517, 96524, 96687, 96680
33474, 95789, 95791, 95837, 95835, 95790, 95792, 95838, 95836, 96526, 96688, 96689, 96681, 96529, 96691, 96692, 
96684, 96520, 96527, 96690, 96683
33475, 95790, 95792, 95838, 95836, 25020, 25021, 25044, 25043, 96529, 96691, 96692, 96684, 25321, 25367, 25368, 
25365, 96523, 96530, 96693, 96686
33476, 23744, 2103, 2104, 23767, 95791, 24899, 24901, 95837, 24045, 2115, 24092, 24090, 96531, 24930, 96694, 
96688, 96524, 24924, 24929, 96687
33477, 95791, 24899, 24901, 95837, 95792, 24900, 24902, 95838, 96531, 24930, 96694, 96688, 96532, 24932, 96695, 
96691, 96527, 24926, 24931, 96690
33478, 95792, 24900, 24902, 95838, 25021, 2263, 2264, 25044, 96532, 24932, 96695, 96691, 25322, 2275, 25369, 
25367, 96530, 24928, 24933, 96693
33479, 2081, 23745, 23768, 2082, 24822, 95793, 95839, 24824, 24047, 24093, 24094, 2093, 96535, 96697, 96698, 
24855, 24851, 96533, 96696, 24856
33480, 24822, 95793, 95839, 24824, 24823, 95794, 95840, 24825, 96535, 96697, 96698, 24855, 96538, 96700, 96701, 
24857, 24853, 96536, 96699, 24858
33481, 24823, 95794, 95840, 24825, 2241, 25022, 25045, 2242, 96538, 96700, 96701, 24857, 25324, 25370, 25371, 
2253, 24854, 96539, 96702, 24859
33482, 23745, 23746, 23769, 23768, 95793, 95795, 95841, 95839, 24049, 24095, 24096, 24093, 96542, 96704, 96705, 
96697, 96533, 96540, 96703, 96696
33483, 95793, 95795, 95841, 95839, 95794, 95796, 95842, 95840, 96542, 96704, 96705, 96697, 96545, 96707, 96708, 
96700, 96536, 96543, 96706, 96699
33484, 95794, 95796, 95842, 95840, 25022, 25023, 25046, 25045, 96545, 96707, 96708, 96700, 25326, 25372, 25373, 
25370, 96539, 96546, 96709, 96702
33485, 23746, 23747, 23770, 23769, 95795, 95797, 95843, 95841, 24051, 24097, 24098, 24095, 96549, 96711, 96712, 
96704, 96540, 96547, 96710, 96703
33486, 95795, 95797, 95843, 95841, 95796, 95798, 95844, 95842, 96549, 96711, 96712, 96704, 96552, 96714, 96715, 
96707, 96543, 96550, 96713, 96706
33487, 95796, 95798, 95844, 95842, 25023, 25024, 25047, 25046, 96552, 96714, 96715, 96707, 25328, 25374, 25375, 
25372, 96546, 96553, 96716, 96709
33488, 23747, 23748, 23771, 23770, 95797, 95799, 95845, 95843, 24053, 24099, 24100, 24097, 96556, 96718, 96719, 
96711, 96547, 96554, 96717, 96710
33489, 95797, 95799, 95845, 95843, 95798, 95800, 95846, 95844, 96556, 96718, 96719, 96711, 96559, 96721, 96722, 
96714, 96550, 96557, 96720, 96713
33490, 95798, 95800, 95846, 95844, 25024, 25025, 25048, 25047, 96559, 96721, 96722, 96714, 25330, 25376, 25377, 
25374, 96553, 96560, 96723, 96716
33491, 23748, 23749, 23772, 23771, 95799, 95801, 95847, 95845, 24055, 24101, 24102, 24099, 96563, 96725, 96726, 
96718, 96554, 96561, 96724, 96717
33492, 95799, 95801, 95847, 95845, 95800, 95802, 95848, 95846, 96563, 96725, 96726, 96718, 96566, 96728, 96729, 
96721, 96557, 96564, 96727, 96720
33493, 95800, 95802, 95848, 95846, 25025, 25026, 25049, 25048, 96566, 96728, 96729, 96721, 25332, 25378, 25379, 
25376, 96560, 96567, 96730, 96723
33494, 23749, 23750, 23773, 23772, 95801, 95803, 95849, 95847, 24057, 24103, 24104, 24101, 96570, 96732, 96733, 
96725, 96561, 96568, 96731, 96724
33495, 95801, 95803, 95849, 95847, 95802, 95804, 95850, 95848, 96570, 96732, 96733, 96725, 96573, 96735, 96736, 
96728, 96564, 96571, 96734, 96727
33496, 95802, 95804, 95850, 95848, 25026, 25027, 25050, 25049, 96573, 96735, 96736, 96728, 25334, 25380, 25381, 
25378, 96567, 96574, 96737, 96730
33497, 23750, 23751, 23774, 23773, 95803, 95805, 95851, 95849, 24059, 24105, 24106, 24103, 96577, 96739, 96740, 
96732, 96568, 96575, 96738, 96731
33498, 95803, 95805, 95851, 95849, 95804, 95806, 95852, 95850, 96577, 96739, 96740, 96732, 96580, 96742, 96743, 
96735, 96571, 96578, 96741, 96734
33499, 95804, 95806, 95852, 95850, 25027, 25028, 25051, 25050, 96580, 96742, 96743, 96735, 25336, 25382, 25383, 
25380, 96574, 96581, 96744, 96737
33500, 23751, 23752, 23775, 23774, 95805, 95807, 95853, 95851, 24061, 24107, 24108, 24105, 96584, 96746, 96747, 
96739, 96575, 96582, 96745, 96738
33501, 95805, 95807, 95853, 95851, 95806, 95808, 95854, 95852, 96584, 96746, 96747, 96739, 96587, 96749, 96750, 
96742, 96578, 96585, 96748, 96741
33502, 95806, 95808, 95854, 95852, 25028, 25029, 25052, 25051, 96587, 96749, 96750, 96742, 25338, 25384, 25385, 
25382, 96581, 96588, 96751, 96744
33503, 23752, 23753, 23776, 23775, 95807, 95809, 95855, 95853, 24063, 24109, 24110, 24107, 96591, 96753, 96754, 
96746, 96582, 96589, 96752, 96745
33504, 95807, 95809, 95855, 95853, 95808, 95810, 95856, 95854, 96591, 96753, 96754, 96746, 96594, 96756, 96757, 
96749, 96585, 96592, 96755, 96748
33505, 95808, 95810, 95856, 95854, 25029, 25030, 25053, 25052, 96594, 96756, 96757, 96749, 25340, 25386, 25387, 
25384, 96588, 96595, 96758, 96751
33506, 23753, 23754, 23777, 23776, 95809, 95811, 95857, 95855, 24065, 24111, 24112, 24109, 96598, 96760, 96761, 
96753, 96589, 96596, 96759, 96752
33507, 95809, 95811, 95857, 95855, 95810, 95812, 95858, 95856, 96598, 96760, 96761, 96753, 96601, 96763, 96764, 
96756, 96592, 96599, 96762, 96755
33508, 95810, 95812, 95858, 95856, 25030, 25031, 25054, 25053, 96601, 96763, 96764, 96756, 25342, 25388, 25389, 
25386, 96595, 96602, 96765, 96758
33509, 23754, 23755, 23778, 23777, 95811, 95813, 95859, 95857, 24067, 24113, 24114, 24111, 96605, 96767, 96768, 
96760, 96596, 96603, 96766, 96759
33510, 95811, 95813, 95859, 95857, 95812, 95814, 95860, 95858, 96605, 96767, 96768, 96760, 96608, 96770, 96771, 
96763, 96599, 96606, 96769, 96762
33511, 95812, 95814, 95860, 95858, 25031, 25032, 25055, 25054, 96608, 96770, 96771, 96763, 25344, 25390, 25391, 
25388, 96602, 96609, 96772, 96765
33512, 23755, 23756, 23779, 23778, 95813, 95815, 95861, 95859, 24069, 24115, 24116, 24113, 96612, 96774, 96775, 
96767, 96603, 96610, 96773, 96766
33513, 95813, 95815, 95861, 95859, 95814, 95816, 95862, 95860, 96612, 96774, 96775, 96767, 96615, 96777, 96778, 
96770, 96606, 96613, 96776, 96769
33514, 95814, 95816, 95862, 95860, 25032, 25033, 25056, 25055, 96615, 96777, 96778, 96770, 25346, 25392, 25393, 
25390, 96609, 96616, 96779, 96772
33515, 23756, 23757, 23780, 23779, 95815, 95817, 95863, 95861, 24071, 24117, 24118, 24115, 96619, 96781, 96782, 
96774, 96610, 96617, 96780, 96773
33516, 95815, 95817, 95863, 95861, 95816, 95818, 95864, 95862, 96619, 96781, 96782, 96774, 96622, 96784, 96785, 
96777, 96613, 96620, 96783, 96776
33517, 95816, 95818, 95864, 95862, 25033, 25034, 25057, 25056, 96622, 96784, 96785, 96777, 25348, 25394, 25395, 
25392, 96616, 96623, 96786, 96779
33518, 23757, 23758, 23781, 23780, 95817, 95819, 95865, 95863, 24073, 24119, 24120, 24117, 96626, 96788, 96789, 
96781, 96617, 96624, 96787, 96780
33519, 95817, 95819, 95865, 95863, 95818, 95820, 95866, 95864, 96626, 96788, 96789, 96781, 96629, 96791, 96792, 
96784, 96620, 96627, 96790, 96783
33520, 95818, 95820, 95866, 95864, 25034, 25035, 25058, 25057, 96629, 96791, 96792, 96784, 25350, 25396, 25397, 
25394, 96623, 96630, 96793, 96786
33521, 23758, 23759, 23782, 23781, 95819, 95821, 95867, 95865, 24075, 24121, 24122, 24119, 96633, 96795, 96796, 
96788, 96624, 96631, 96794, 96787
33522, 95819, 95821, 95867, 95865, 95820, 95822, 95868, 95866, 96633, 96795, 96796, 96788, 96636, 96798, 96799, 
96791, 96627, 96634, 96797, 96790
33523, 95820, 95822, 95868, 95866, 25035, 25036, 25059, 25058, 96636, 96798, 96799, 96791, 25352, 25398, 25399, 
25396, 96630, 96637, 96800, 96793
33524, 23759, 23760, 23783, 23782, 95821, 95823, 95869, 95867, 24077, 24123, 24124, 24121, 96640, 96802, 96803, 
96795, 96631, 96638, 96801, 96794
33525, 95821, 95823, 95869, 95867, 95822, 95824, 95870, 95868, 96640, 96802, 96803, 96795, 96643, 96805, 96806, 
96798, 96634, 96641, 96804, 96797
33526, 95822, 95824, 95870, 95868, 25036, 25037, 25060, 25059, 96643, 96805, 96806, 96798, 25354, 25400, 25401, 
25398, 96637, 96644, 96807, 96800
33527, 23760, 23761, 23784, 23783, 95823, 95825, 95871, 95869, 24079, 24125, 24126, 24123, 96647, 96809, 96810, 
96802, 96638, 96645, 96808, 96801
33528, 95823, 95825, 95871, 95869, 95824, 95826, 95872, 95870, 96647, 96809, 96810, 96802, 96650, 96812, 96813, 
96805, 96641, 96648, 96811, 96804
33529, 95824, 95826, 95872, 95870, 25037, 25038, 25061, 25060, 96650, 96812, 96813, 96805, 25356, 25402, 25403, 
25400, 96644, 96651, 96814, 96807
33530, 23761, 23762, 23785, 23784, 95825, 95827, 95873, 95871, 24081, 24127, 24128, 24125, 96654, 96816, 96817, 
96809, 96645, 96652, 96815, 96808
33531, 95825, 95827, 95873, 95871, 95826, 95828, 95874, 95872, 96654, 96816, 96817, 96809, 96657, 96819, 96820, 
96812, 96648, 96655, 96818, 96811
33532, 95826, 95828, 95874, 95872, 25038, 25039, 25062, 25061, 96657, 96819, 96820, 96812, 25358, 25404, 25405, 
25402, 96651, 96658, 96821, 96814
33533, 23762, 23763, 23786, 23785, 95827, 95829, 95875, 95873, 24083, 24129, 24130, 24127, 96661, 96823, 96824, 
96816, 96652, 96659, 96822, 96815
33534, 95827, 95829, 95875, 95873, 95828, 95830, 95876, 95874, 96661, 96823, 96824, 96816, 96664, 96826, 96827, 
96819, 96655, 96662, 96825, 96818
33535, 95828, 95830, 95876, 95874, 25039, 25040, 25063, 25062, 96664, 96826, 96827, 96819, 25360, 25406, 25407, 
25404, 96658, 96665, 96828, 96821
33536, 23763, 23764, 23787, 23786, 95829, 95831, 95877, 95875, 24085, 24131, 24132, 24129, 96668, 96830, 96831, 
96823, 96659, 96666, 96829, 96822
33537, 95829, 95831, 95877, 95875, 95830, 95832, 95878, 95876, 96668, 96830, 96831, 96823, 96671, 96833, 96834, 
96826, 96662, 96669, 96832, 96825
33538, 95830, 95832, 95878, 95876, 25040, 25041, 25064, 25063, 96671, 96833, 96834, 96826, 25362, 25408, 25409, 
25406, 96665, 96672, 96835, 96828
33539, 23764, 23765, 23788, 23787, 95831, 95833, 95879, 95877, 24087, 24133, 24134, 24131, 96675, 96837, 96838, 
96830, 96666, 96673, 96836, 96829
33540, 95831, 95833, 95879, 95877, 95832, 95834, 95880, 95878, 96675, 96837, 96838, 96830, 96678, 96840, 96841, 
96833, 96669, 96676, 96839, 96832
33541, 95832, 95834, 95880, 95878, 25041, 25042, 25065, 25064, 96678, 96840, 96841, 96833, 25364, 25410, 25411, 
25408, 96672, 96679, 96842, 96835
33542, 23765, 23766, 23789, 23788, 95833, 95835, 95881, 95879, 24089, 24135, 24136, 24133, 96682, 96844, 96845, 
96837, 96673, 96680, 96843, 96836
33543, 95833, 95835, 95881, 95879, 95834, 95836, 95882, 95880, 96682, 96844, 96845, 96837, 96685, 96847, 96848, 
96840, 96676, 96683, 96846, 96839
33544, 95834, 95836, 95882, 95880, 25042, 25043, 25066, 25065, 96685, 96847, 96848, 96840, 25366, 25412, 25413, 
25410, 96679, 96686, 96849, 96842
33545, 23766, 23767, 23790, 23789, 95835, 95837, 95883, 95881, 24091, 24137, 24138, 24135, 96689, 96851, 96852, 
96844, 96680, 96687, 96850, 96843
33546, 95835, 95837, 95883, 95881, 95836, 95838, 95884, 95882, 96689, 96851, 96852, 96844, 96692, 96854, 96855, 
96847, 96683, 96690, 96853, 96846
33547, 95836, 95838, 95884, 95882, 25043, 25044, 25067, 25066, 96692, 96854, 96855, 96847, 25368, 25414, 25415, 
25412, 96686, 96693, 96856, 96849
33548, 23767, 2104, 2105, 23790, 95837, 24901, 24903, 95883, 24092, 2116, 24139, 24137, 96694, 24935, 96857, 
96851, 96687, 24929, 24934, 96850
33549, 95837, 24901, 24903, 95883, 95838, 24902, 24904, 95884, 96694, 24935, 96857, 96851, 96695, 24937, 96858, 
96854, 96690, 24931, 24936, 96853
33550, 95838, 24902, 24904, 95884, 25044, 2264, 2265, 25067, 96695, 24937, 96858, 96854, 25369, 2276, 25416, 
25414, 96693, 24933, 24938, 96856
33551, 2082, 23768, 23791, 2083, 24824, 95839, 95885, 24826, 24094, 24140, 24141, 2094, 96698, 96860, 96861, 
24860, 24856, 96696, 96859, 24861
33552, 24824, 95839, 95885, 24826, 24825, 95840, 95886, 24827, 96698, 96860, 96861, 24860, 96701, 96863, 96864, 
24862, 24858, 96699, 96862, 24863
33553, 24825, 95840, 95886, 24827, 2242, 25045, 25068, 2243, 96701, 96863, 96864, 24862, 25371, 25417, 25418, 
2254, 24859, 96702, 96865, 24864
33554, 23768, 23769, 23792, 23791, 95839, 95841, 95887, 95885, 24096, 24142, 24143, 24140, 96705, 96867, 96868, 
96860, 96696, 96703, 96866, 96859
33555, 95839, 95841, 95887, 95885, 95840, 95842, 95888, 95886, 96705, 96867, 96868, 96860, 96708, 96870, 96871, 
96863, 96699, 96706, 96869, 96862
33556, 95840, 95842, 95888, 95886, 25045, 25046, 25069, 25068, 96708, 96870, 96871, 96863, 25373, 25419, 25420, 
25417, 96702, 96709, 96872, 96865
33557, 23769, 23770, 23793, 23792, 95841, 95843, 95889, 95887, 24098, 24144, 24145, 24142, 96712, 96874, 96875, 
96867, 96703, 96710, 96873, 96866
33558, 95841, 95843, 95889, 95887, 95842, 95844, 95890, 95888, 96712, 96874, 96875, 96867, 96715, 96877, 96878, 
96870, 96706, 96713, 96876, 96869
33559, 95842, 95844, 95890, 95888, 25046, 25047, 25070, 25069, 96715, 96877, 96878, 96870, 25375, 25421, 25422, 
25419, 96709, 96716, 96879, 96872
33560, 23770, 23771, 23794, 23793, 95843, 95845, 95891, 95889, 24100, 24146, 24147, 24144, 96719, 96881, 96882, 
96874, 96710, 96717, 96880, 96873
33561, 95843, 95845, 95891, 95889, 95844, 95846, 95892, 95890, 96719, 96881, 96882, 96874, 96722, 96884, 96885, 
96877, 96713, 96720, 96883, 96876
33562, 95844, 95846, 95892, 95890, 25047, 25048, 25071, 25070, 96722, 96884, 96885, 96877, 25377, 25423, 25424, 
25421, 96716, 96723, 96886, 96879
33563, 23771, 23772, 23795, 23794, 95845, 95847, 95893, 95891, 24102, 24148, 24149, 24146, 96726, 96888, 96889, 
96881, 96717, 96724, 96887, 96880
33564, 95845, 95847, 95893, 95891, 95846, 95848, 95894, 95892, 96726, 96888, 96889, 96881, 96729, 96891, 96892, 
96884, 96720, 96727, 96890, 96883
33565, 95846, 95848, 95894, 95892, 25048, 25049, 25072, 25071, 96729, 96891, 96892, 96884, 25379, 25425, 25426, 
25423, 96723, 96730, 96893, 96886
33566, 23772, 23773, 23796, 23795, 95847, 95849, 95895, 95893, 24104, 24150, 24151, 24148, 96733, 96895, 96896, 
96888, 96724, 96731, 96894, 96887
33567, 95847, 95849, 95895, 95893, 95848, 95850, 95896, 95894, 96733, 96895, 96896, 96888, 96736, 96898, 96899, 
96891, 96727, 96734, 96897, 96890
33568, 95848, 95850, 95896, 95894, 25049, 25050, 25073, 25072, 96736, 96898, 96899, 96891, 25381, 25427, 25428, 
25425, 96730, 96737, 96900, 96893
33569, 23773, 23774, 23797, 23796, 95849, 95851, 95897, 95895, 24106, 24152, 24153, 24150, 96740, 96902, 96903, 
96895, 96731, 96738, 96901, 96894
33570, 95849, 95851, 95897, 95895, 95850, 95852, 95898, 95896, 96740, 96902, 96903, 96895, 96743, 96905, 96906, 
96898, 96734, 96741, 96904, 96897
33571, 95850, 95852, 95898, 95896, 25050, 25051, 25074, 25073, 96743, 96905, 96906, 96898, 25383, 25429, 25430, 
25427, 96737, 96744, 96907, 96900
33572, 23774, 23775, 23798, 23797, 95851, 95853, 95899, 95897, 24108, 24154, 24155, 24152, 96747, 96909, 96910, 
96902, 96738, 96745, 96908, 96901
33573, 95851, 95853, 95899, 95897, 95852, 95854, 95900, 95898, 96747, 96909, 96910, 96902, 96750, 96912, 96913, 
96905, 96741, 96748, 96911, 96904
33574, 95852, 95854, 95900, 95898, 25051, 25052, 25075, 25074, 96750, 96912, 96913, 96905, 25385, 25431, 25432, 
25429, 96744, 96751, 96914, 96907
33575, 23775, 23776, 23799, 23798, 95853, 95855, 95901, 95899, 24110, 24156, 24157, 24154, 96754, 96916, 96917, 
96909, 96745, 96752, 96915, 96908
33576, 95853, 95855, 95901, 95899, 95854, 95856, 95902, 95900, 96754, 96916, 96917, 96909, 96757, 96919, 96920, 
96912, 96748, 96755, 96918, 96911
33577, 95854, 95856, 95902, 95900, 25052, 25053, 25076, 25075, 96757, 96919, 96920, 96912, 25387, 25433, 25434, 
25431, 96751, 96758, 96921, 96914
33578, 23776, 23777, 23800, 23799, 95855, 95857, 95903, 95901, 24112, 24158, 24159, 24156, 96761, 96923, 96924, 
96916, 96752, 96759, 96922, 96915
33579, 95855, 95857, 95903, 95901, 95856, 95858, 95904, 95902, 96761, 96923, 96924, 96916, 96764, 96926, 96927, 
96919, 96755, 96762, 96925, 96918
33580, 95856, 95858, 95904, 95902, 25053, 25054, 25077, 25076, 96764, 96926, 96927, 96919, 25389, 25435, 25436, 
25433, 96758, 96765, 96928, 96921
33581, 23777, 23778, 23801, 23800, 95857, 95859, 95905, 95903, 24114, 24160, 24161, 24158, 96768, 96930, 96931, 
96923, 96759, 96766, 96929, 96922
33582, 95857, 95859, 95905, 95903, 95858, 95860, 95906, 95904, 96768, 96930, 96931, 96923, 96771, 96933, 96934, 
96926, 96762, 96769, 96932, 96925
33583, 95858, 95860, 95906, 95904, 25054, 25055, 25078, 25077, 96771, 96933, 96934, 96926, 25391, 25437, 25438, 
25435, 96765, 96772, 96935, 96928
33584, 23778, 23779, 23802, 23801, 95859, 95861, 95907, 95905, 24116, 24162, 24163, 24160, 96775, 96937, 96938, 
96930, 96766, 96773, 96936, 96929
33585, 95859, 95861, 95907, 95905, 95860, 95862, 95908, 95906, 96775, 96937, 96938, 96930, 96778, 96940, 96941, 
96933, 96769, 96776, 96939, 96932
33586, 95860, 95862, 95908, 95906, 25055, 25056, 25079, 25078, 96778, 96940, 96941, 96933, 25393, 25439, 25440, 
25437, 96772, 96779, 96942, 96935
33587, 23779, 23780, 23803, 23802, 95861, 95863, 95909, 95907, 24118, 24164, 24165, 24162, 96782, 96944, 96945, 
96937, 96773, 96780, 96943, 96936
33588, 95861, 95863, 95909, 95907, 95862, 95864, 95910, 95908, 96782, 96944, 96945, 96937, 96785, 96947, 96948, 
96940, 96776, 96783, 96946, 96939
33589, 95862, 95864, 95910, 95908, 25056, 25057, 25080, 25079, 96785, 96947, 96948, 96940, 25395, 25441, 25442, 
25439, 96779, 96786, 96949, 96942
33590, 23780, 23781, 23804, 23803, 95863, 95865, 95911, 95909, 24120, 24166, 24167, 24164, 96789, 96951, 96952, 
96944, 96780, 96787, 96950, 96943
33591, 95863, 95865, 95911, 95909, 95864, 95866, 95912, 95910, 96789, 96951, 96952, 96944, 96792, 96954, 96955, 
96947, 96783, 96790, 96953, 96946
33592, 95864, 95866, 95912, 95910, 25057, 25058, 25081, 25080, 96792, 96954, 96955, 96947, 25397, 25443, 25444, 
25441, 96786, 96793, 96956, 96949
33593, 23781, 23782, 23805, 23804, 95865, 95867, 95913, 95911, 24122, 24168, 24169, 24166, 96796, 96958, 96959, 
96951, 96787, 96794, 96957, 96950
33594, 95865, 95867, 95913, 95911, 95866, 95868, 95914, 95912, 96796, 96958, 96959, 96951, 96799, 96961, 96962, 
96954, 96790, 96797, 96960, 96953
33595, 95866, 95868, 95914, 95912, 25058, 25059, 25082, 25081, 96799, 96961, 96962, 96954, 25399, 25445, 25446, 
25443, 96793, 96800, 96963, 96956
33596, 23782, 23783, 23806, 23805, 95867, 95869, 95915, 95913, 24124, 24170, 24171, 24168, 96803, 96965, 96966, 
96958, 96794, 96801, 96964, 96957
33597, 95867, 95869, 95915, 95913, 95868, 95870, 95916, 95914, 96803, 96965, 96966, 96958, 96806, 96968, 96969, 
96961, 96797, 96804, 96967, 96960
33598, 95868, 95870, 95916, 95914, 25059, 25060, 25083, 25082, 96806, 96968, 96969, 96961, 25401, 25447, 25448, 
25445, 96800, 96807, 96970, 96963
33599, 23783, 23784, 23807, 23806, 95869, 95871, 95917, 95915, 24126, 24172, 24173, 24170, 96810, 96972, 96973, 
96965, 96801, 96808, 96971, 96964
33600, 95869, 95871, 95917, 95915, 95870, 95872, 95918, 95916, 96810, 96972, 96973, 96965, 96813, 96975, 96976, 
96968, 96804, 96811, 96974, 96967
33601, 95870, 95872, 95918, 95916, 25060, 25061, 25084, 25083, 96813, 96975, 96976, 96968, 25403, 25449, 25450, 
25447, 96807, 96814, 96977, 96970
33602, 23784, 23785, 23808, 23807, 95871, 95873, 95919, 95917, 24128, 24174, 24175, 24172, 96817, 96979, 96980, 
96972, 96808, 96815, 96978, 96971
33603, 95871, 95873, 95919, 95917, 95872, 95874, 95920, 95918, 96817, 96979, 96980, 96972, 96820, 96982, 96983, 
96975, 96811, 96818, 96981, 96974
33604, 95872, 95874, 95920, 95918, 25061, 25062, 25085, 25084, 96820, 96982, 96983, 96975, 25405, 25451, 25452, 
25449, 96814, 96821, 96984, 96977
33605, 23785, 23786, 23809, 23808, 95873, 95875, 95921, 95919, 24130, 24176, 24177, 24174, 96824, 96986, 96987, 
96979, 96815, 96822, 96985, 96978
33606, 95873, 95875, 95921, 95919, 95874, 95876, 95922, 95920, 96824, 96986, 96987, 96979, 96827, 96989, 96990, 
96982, 96818, 96825, 96988, 96981
33607, 95874, 95876, 95922, 95920, 25062, 25063, 25086, 25085, 96827, 96989, 96990, 96982, 25407, 25453, 25454, 
25451, 96821, 96828, 96991, 96984
33608, 23786, 23787, 23810, 23809, 95875, 95877, 95923, 95921, 24132, 24178, 24179, 24176, 96831, 96993, 96994, 
96986, 96822, 96829, 96992, 96985
33609, 95875, 95877, 95923, 95921, 95876, 95878, 95924, 95922, 96831, 96993, 96994, 96986, 96834, 96996, 96997, 
96989, 96825, 96832, 96995, 96988
33610, 95876, 95878, 95924, 95922, 25063, 25064, 25087, 25086, 96834, 96996, 96997, 96989, 25409, 25455, 25456, 
25453, 96828, 96835, 96998, 96991
33611, 23787, 23788, 23811, 23810, 95877, 95879, 95925, 95923, 24134, 24180, 24181, 24178, 96838, 97000, 97001, 
96993, 96829, 96836, 96999, 96992
33612, 95877, 95879, 95925, 95923, 95878, 95880, 95926, 95924, 96838, 97000, 97001, 96993, 96841, 97003, 97004, 
96996, 96832, 96839, 97002, 96995
33613, 95878, 95880, 95926, 95924, 25064, 25065, 25088, 25087, 96841, 97003, 97004, 96996, 25411, 25457, 25458, 
25455, 96835, 96842, 97005, 96998
33614, 23788, 23789, 23812, 23811, 95879, 95881, 95927, 95925, 24136, 24182, 24183, 24180, 96845, 97007, 97008, 
97000, 96836, 96843, 97006, 96999
33615, 95879, 95881, 95927, 95925, 95880, 95882, 95928, 95926, 96845, 97007, 97008, 97000, 96848, 97010, 97011, 
97003, 96839, 96846, 97009, 97002
33616, 95880, 95882, 95928, 95926, 25065, 25066, 25089, 25088, 96848, 97010, 97011, 97003, 25413, 25459, 25460, 
25457, 96842, 96849, 97012, 97005
33617, 23789, 23790, 23813, 23812, 95881, 95883, 95929, 95927, 24138, 24184, 24185, 24182, 96852, 97014, 97015, 
97007, 96843, 96850, 97013, 97006
33618, 95881, 95883, 95929, 95927, 95882, 95884, 95930, 95928, 96852, 97014, 97015, 97007, 96855, 97017, 97018, 
97010, 96846, 96853, 97016, 97009
33619, 95882, 95884, 95930, 95928, 25066, 25067, 25090, 25089, 96855, 97017, 97018, 97010, 25415, 25461, 25462, 
25459, 96849, 96856, 97019, 97012
33620, 23790, 2105, 2106, 23813, 95883, 24903, 24905, 95929, 24139, 2117, 24186, 24184, 96857, 24940, 97020, 
97014, 96850, 24934, 24939, 97013
33621, 95883, 24903, 24905, 95929, 95884, 24904, 24906, 95930, 96857, 24940, 97020, 97014, 96858, 24942, 97021, 
97017, 96853, 24936, 24941, 97016
33622, 95884, 24904, 24906, 95930, 25067, 2265, 2266, 25090, 96858, 24942, 97021, 97017, 25416, 2277, 25463, 
25461, 96856, 24938, 24943, 97019
33623, 2083, 23791, 23814, 2084, 24826, 95885, 95931, 24828, 24141, 24187, 24188, 2095, 96861, 97023, 97024, 
24865, 24861, 96859, 97022, 24866
33624, 24826, 95885, 95931, 24828, 24827, 95886, 95932, 24829, 96861, 97023, 97024, 24865, 96864, 97026, 97027, 
24867, 24863, 96862, 97025, 24868
33625, 24827, 95886, 95932, 24829, 2243, 25068, 25091, 2244, 96864, 97026, 97027, 24867, 25418, 25464, 25465, 
2255, 24864, 96865, 97028, 24869
33626, 23791, 23792, 23815, 23814, 95885, 95887, 95933, 95931, 24143, 24189, 24190, 24187, 96868, 97030, 97031, 
97023, 96859, 96866, 97029, 97022
33627, 95885, 95887, 95933, 95931, 95886, 95888, 95934, 95932, 96868, 97030, 97031, 97023, 96871, 97033, 97034, 
97026, 96862, 96869, 97032, 97025
33628, 95886, 95888, 95934, 95932, 25068, 25069, 25092, 25091, 96871, 97033, 97034, 97026, 25420, 25466, 25467, 
25464, 96865, 96872, 97035, 97028
33629, 23792, 23793, 23816, 23815, 95887, 95889, 95935, 95933, 24145, 24191, 24192, 24189, 96875, 97037, 97038, 
97030, 96866, 96873, 97036, 97029
33630, 95887, 95889, 95935, 95933, 95888, 95890, 95936, 95934, 96875, 97037, 97038, 97030, 96878, 97040, 97041, 
97033, 96869, 96876, 97039, 97032
33631, 95888, 95890, 95936, 95934, 25069, 25070, 25093, 25092, 96878, 97040, 97041, 97033, 25422, 25468, 25469, 
25466, 96872, 96879, 97042, 97035
33632, 23793, 23794, 23817, 23816, 95889, 95891, 95937, 95935, 24147, 24193, 24194, 24191, 96882, 97044, 97045, 
97037, 96873, 96880, 97043, 97036
33633, 95889, 95891, 95937, 95935, 95890, 95892, 95938, 95936, 96882, 97044, 97045, 97037, 96885, 97047, 97048, 
97040, 96876, 96883, 97046, 97039
33634, 95890, 95892, 95938, 95936, 25070, 25071, 25094, 25093, 96885, 97047, 97048, 97040, 25424, 25470, 25471, 
25468, 96879, 96886, 97049, 97042
33635, 23794, 23795, 23818, 23817, 95891, 95893, 95939, 95937, 24149, 24195, 24196, 24193, 96889, 97051, 97052, 
97044, 96880, 96887, 97050, 97043
33636, 95891, 95893, 95939, 95937, 95892, 95894, 95940, 95938, 96889, 97051, 97052, 97044, 96892, 97054, 97055, 
97047, 96883, 96890, 97053, 97046
33637, 95892, 95894, 95940, 95938, 25071, 25072, 25095, 25094, 96892, 97054, 97055, 97047, 25426, 25472, 25473, 
25470, 96886, 96893, 97056, 97049
33638, 23795, 23796, 23819, 23818, 95893, 95895, 95941, 95939, 24151, 24197, 24198, 24195, 96896, 97058, 97059, 
97051, 96887, 96894, 97057, 97050
33639, 95893, 95895, 95941, 95939, 95894, 95896, 95942, 95940, 96896, 97058, 97059, 97051, 96899, 97061, 97062, 
97054, 96890, 96897, 97060, 97053
33640, 95894, 95896, 95942, 95940, 25072, 25073, 25096, 25095, 96899, 97061, 97062, 97054, 25428, 25474, 25475, 
25472, 96893, 96900, 97063, 97056
33641, 23796, 23797, 23820, 23819, 95895, 95897, 95943, 95941, 24153, 24199, 24200, 24197, 96903, 97065, 97066, 
97058, 96894, 96901, 97064, 97057
33642, 95895, 95897, 95943, 95941, 95896, 95898, 95944, 95942, 96903, 97065, 97066, 97058, 96906, 97068, 97069, 
97061, 96897, 96904, 97067, 97060
33643, 95896, 95898, 95944, 95942, 25073, 25074, 25097, 25096, 96906, 97068, 97069, 97061, 25430, 25476, 25477, 
25474, 96900, 96907, 97070, 97063
33644, 23797, 23798, 23821, 23820, 95897, 95899, 95945, 95943, 24155, 24201, 24202, 24199, 96910, 97072, 97073, 
97065, 96901, 96908, 97071, 97064
33645, 95897, 95899, 95945, 95943, 95898, 95900, 95946, 95944, 96910, 97072, 97073, 97065, 96913, 97075, 97076, 
97068, 96904, 96911, 97074, 97067
33646, 95898, 95900, 95946, 95944, 25074, 25075, 25098, 25097, 96913, 97075, 97076, 97068, 25432, 25478, 25479, 
25476, 96907, 96914, 97077, 97070
33647, 23798, 23799, 23822, 23821, 95899, 95901, 95947, 95945, 24157, 24203, 24204, 24201, 96917, 97079, 97080, 
97072, 96908, 96915, 97078, 97071
33648, 95899, 95901, 95947, 95945, 95900, 95902, 95948, 95946, 96917, 97079, 97080, 97072, 96920, 97082, 97083, 
97075, 96911, 96918, 97081, 97074
33649, 95900, 95902, 95948, 95946, 25075, 25076, 25099, 25098, 96920, 97082, 97083, 97075, 25434, 25480, 25481, 
25478, 96914, 96921, 97084, 97077
33650, 23799, 23800, 23823, 23822, 95901, 95903, 95949, 95947, 24159, 24205, 24206, 24203, 96924, 97086, 97087, 
97079, 96915, 96922, 97085, 97078
33651, 95901, 95903, 95949, 95947, 95902, 95904, 95950, 95948, 96924, 97086, 97087, 97079, 96927, 97089, 97090, 
97082, 96918, 96925, 97088, 97081
33652, 95902, 95904, 95950, 95948, 25076, 25077, 25100, 25099, 96927, 97089, 97090, 97082, 25436, 25482, 25483, 
25480, 96921, 96928, 97091, 97084
33653, 23800, 23801, 23824, 23823, 95903, 95905, 95951, 95949, 24161, 24207, 24208, 24205, 96931, 97093, 97094, 
97086, 96922, 96929, 97092, 97085
33654, 95903, 95905, 95951, 95949, 95904, 95906, 95952, 95950, 96931, 97093, 97094, 97086, 96934, 97096, 97097, 
97089, 96925, 96932, 97095, 97088
33655, 95904, 95906, 95952, 95950, 25077, 25078, 25101, 25100, 96934, 97096, 97097, 97089, 25438, 25484, 25485, 
25482, 96928, 96935, 97098, 97091
33656, 23801, 23802, 23825, 23824, 95905, 95907, 95953, 95951, 24163, 24209, 24210, 24207, 96938, 97100, 97101, 
97093, 96929, 96936, 97099, 97092
33657, 95905, 95907, 95953, 95951, 95906, 95908, 95954, 95952, 96938, 97100, 97101, 97093, 96941, 97103, 97104, 
97096, 96932, 96939, 97102, 97095
33658, 95906, 95908, 95954, 95952, 25078, 25079, 25102, 25101, 96941, 97103, 97104, 97096, 25440, 25486, 25487, 
25484, 96935, 96942, 97105, 97098
33659, 23802, 23803, 23826, 23825, 95907, 95909, 95955, 95953, 24165, 24211, 24212, 24209, 96945, 97107, 97108, 
97100, 96936, 96943, 97106, 97099
33660, 95907, 95909, 95955, 95953, 95908, 95910, 95956, 95954, 96945, 97107, 97108, 97100, 96948, 97110, 97111, 
97103, 96939, 96946, 97109, 97102
33661, 95908, 95910, 95956, 95954, 25079, 25080, 25103, 25102, 96948, 97110, 97111, 97103, 25442, 25488, 25489, 
25486, 96942, 96949, 97112, 97105
33662, 23803, 23804, 23827, 23826, 95909, 95911, 95957, 95955, 24167, 24213, 24214, 24211, 96952, 97114, 97115, 
97107, 96943, 96950, 97113, 97106
33663, 95909, 95911, 95957, 95955, 95910, 95912, 95958, 95956, 96952, 97114, 97115, 97107, 96955, 97117, 97118, 
97110, 96946, 96953, 97116, 97109
33664, 95910, 95912, 95958, 95956, 25080, 25081, 25104, 25103, 96955, 97117, 97118, 97110, 25444, 25490, 25491, 
25488, 96949, 96956, 97119, 97112
33665, 23804, 23805, 23828, 23827, 95911, 95913, 95959, 95957, 24169, 24215, 24216, 24213, 96959, 97121, 97122, 
97114, 96950, 96957, 97120, 97113
33666, 95911, 95913, 95959, 95957, 95912, 95914, 95960, 95958, 96959, 97121, 97122, 97114, 96962, 97124, 97125, 
97117, 96953, 96960, 97123, 97116
33667, 95912, 95914, 95960, 95958, 25081, 25082, 25105, 25104, 96962, 97124, 97125, 97117, 25446, 25492, 25493, 
25490, 96956, 96963, 97126, 97119
33668, 23805, 23806, 23829, 23828, 95913, 95915, 95961, 95959, 24171, 24217, 24218, 24215, 96966, 97128, 97129, 
97121, 96957, 96964, 97127, 97120
33669, 95913, 95915, 95961, 95959, 95914, 95916, 95962, 95960, 96966, 97128, 97129, 97121, 96969, 97131, 97132, 
97124, 96960, 96967, 97130, 97123
33670, 95914, 95916, 95962, 95960, 25082, 25083, 25106, 25105, 96969, 97131, 97132, 97124, 25448, 25494, 25495, 
25492, 96963, 96970, 97133, 97126
33671, 23806, 23807, 23830, 23829, 95915, 95917, 95963, 95961, 24173, 24219, 24220, 24217, 96973, 97135, 97136, 
97128, 96964, 96971, 97134, 97127
33672, 95915, 95917, 95963, 95961, 95916, 95918, 95964, 95962, 96973, 97135, 97136, 97128, 96976, 97138, 97139, 
97131, 96967, 96974, 97137, 97130
33673, 95916, 95918, 95964, 95962, 25083, 25084, 25107, 25106, 96976, 97138, 97139, 97131, 25450, 25496, 25497, 
25494, 96970, 96977, 97140, 97133
33674, 23807, 23808, 23831, 23830, 95917, 95919, 95965, 95963, 24175, 24221, 24222, 24219, 96980, 97142, 97143, 
97135, 96971, 96978, 97141, 97134
33675, 95917, 95919, 95965, 95963, 95918, 95920, 95966, 95964, 96980, 97142, 97143, 97135, 96983, 97145, 97146, 
97138, 96974, 96981, 97144, 97137
33676, 95918, 95920, 95966, 95964, 25084, 25085, 25108, 25107, 96983, 97145, 97146, 97138, 25452, 25498, 25499, 
25496, 96977, 96984, 97147, 97140
33677, 23808, 23809, 23832, 23831, 95919, 95921, 95967, 95965, 24177, 24223, 24224, 24221, 96987, 97149, 97150, 
97142, 96978, 96985, 97148, 97141
33678, 95919, 95921, 95967, 95965, 95920, 95922, 95968, 95966, 96987, 97149, 97150, 97142, 96990, 97152, 97153, 
97145, 96981, 96988, 97151, 97144
33679, 95920, 95922, 95968, 95966, 25085, 25086, 25109, 25108, 96990, 97152, 97153, 97145, 25454, 25500, 25501, 
25498, 96984, 96991, 97154, 97147
33680, 23809, 23810, 23833, 23832, 95921, 95923, 95969, 95967, 24179, 24225, 24226, 24223, 96994, 97156, 97157, 
97149, 96985, 96992, 97155, 97148
33681, 95921, 95923, 95969, 95967, 95922, 95924, 95970, 95968, 96994, 97156, 97157, 97149, 96997, 97159, 97160, 
97152, 96988, 96995, 97158, 97151
33682, 95922, 95924, 95970, 95968, 25086, 25087, 25110, 25109, 96997, 97159, 97160, 97152, 25456, 25502, 25503, 
25500, 96991, 96998, 97161, 97154
33683, 23810, 23811, 23834, 23833, 95923, 95925, 95971, 95969, 24181, 24227, 24228, 24225, 97001, 97163, 97164, 
97156, 96992, 96999, 97162, 97155
33684, 95923, 95925, 95971, 95969, 95924, 95926, 95972, 95970, 97001, 97163, 97164, 97156, 97004, 97166, 97167, 
97159, 96995, 97002, 97165, 97158
33685, 95924, 95926, 95972, 95970, 25087, 25088, 25111, 25110, 97004, 97166, 97167, 97159, 25458, 25504, 25505, 
25502, 96998, 97005, 97168, 97161
33686, 23811, 23812, 23835, 23834, 95925, 95927, 95973, 95971, 24183, 24229, 24230, 24227, 97008, 97170, 97171, 
97163, 96999, 97006, 97169, 97162
33687, 95925, 95927, 95973, 95971, 95926, 95928, 95974, 95972, 97008, 97170, 97171, 97163, 97011, 97173, 97174, 
97166, 97002, 97009, 97172, 97165
33688, 95926, 95928, 95974, 95972, 25088, 25089, 25112, 25111, 97011, 97173, 97174, 97166, 25460, 25506, 25507, 
25504, 97005, 97012, 97175, 97168
33689, 23812, 23813, 23836, 23835, 95927, 95929, 95975, 95973, 24185, 24231, 24232, 24229, 97015, 97177, 97178, 
97170, 97006, 97013, 97176, 97169
33690, 95927, 95929, 95975, 95973, 95928, 95930, 95976, 95974, 97015, 97177, 97178, 97170, 97018, 97180, 97181, 
97173, 97009, 97016, 97179, 97172
33691, 95928, 95930, 95976, 95974, 25089, 25090, 25113, 25112, 97018, 97180, 97181, 97173, 25462, 25508, 25509, 
25506, 97012, 97019, 97182, 97175
33692, 23813, 2106, 2107, 23836, 95929, 24905, 24907, 95975, 24186, 2118, 24233, 24231, 97020, 24945, 97183, 
97177, 97013, 24939, 24944, 97176
33693, 95929, 24905, 24907, 95975, 95930, 24906, 24908, 95976, 97020, 24945, 97183, 97177, 97021, 24947, 97184, 
97180, 97016, 24941, 24946, 97179
33694, 95930, 24906, 24908, 95976, 25090, 2266, 2267, 25113, 97021, 24947, 97184, 97180, 25463, 2278, 25510, 
25508, 97019, 24943, 24948, 97182
33695, 2084, 23814, 23837, 2085, 24828, 95931, 95977, 24830, 24188, 24234, 24235, 2096, 97024, 97186, 97187, 
24870, 24866, 97022, 97185, 24871
33696, 24828, 95931, 95977, 24830, 24829, 95932, 95978, 24831, 97024, 97186, 97187, 24870, 97027, 97189, 97190, 
24872, 24868, 97025, 97188, 24873
33697, 24829, 95932, 95978, 24831, 2244, 25091, 25114, 2245, 97027, 97189, 97190, 24872, 25465, 25511, 25512, 
2256, 24869, 97028, 97191, 24874
33698, 23814, 23815, 23838, 23837, 95931, 95933, 95979, 95977, 24190, 24236, 24237, 24234, 97031, 97193, 97194, 
97186, 97022, 97029, 97192, 97185
33699, 95931, 95933, 95979, 95977, 95932, 95934, 95980, 95978, 97031, 97193, 97194, 97186, 97034, 97196, 97197, 
97189, 97025, 97032, 97195, 97188
33700, 95932, 95934, 95980, 95978, 25091, 25092, 25115, 25114, 97034, 97196, 97197, 97189, 25467, 25513, 25514, 
25511, 97028, 97035, 97198, 97191
33701, 23815, 23816, 23839, 23838, 95933, 95935, 95981, 95979, 24192, 24238, 24239, 24236, 97038, 97200, 97201, 
97193, 97029, 97036, 97199, 97192
33702, 95933, 95935, 95981, 95979, 95934, 95936, 95982, 95980, 97038, 97200, 97201, 97193, 97041, 97203, 97204, 
97196, 97032, 97039, 97202, 97195
33703, 95934, 95936, 95982, 95980, 25092, 25093, 25116, 25115, 97041, 97203, 97204, 97196, 25469, 25515, 25516, 
25513, 97035, 97042, 97205, 97198
33704, 23816, 23817, 23840, 23839, 95935, 95937, 95983, 95981, 24194, 24240, 24241, 24238, 97045, 97207, 97208, 
97200, 97036, 97043, 97206, 97199
33705, 95935, 95937, 95983, 95981, 95936, 95938, 95984, 95982, 97045, 97207, 97208, 97200, 97048, 97210, 97211, 
97203, 97039, 97046, 97209, 97202
33706, 95936, 95938, 95984, 95982, 25093, 25094, 25117, 25116, 97048, 97210, 97211, 97203, 25471, 25517, 25518, 
25515, 97042, 97049, 97212, 97205
33707, 23817, 23818, 23841, 23840, 95937, 95939, 95985, 95983, 24196, 24242, 24243, 24240, 97052, 97214, 97215, 
97207, 97043, 97050, 97213, 97206
33708, 95937, 95939, 95985, 95983, 95938, 95940, 95986, 95984, 97052, 97214, 97215, 97207, 97055, 97217, 97218, 
97210, 97046, 97053, 97216, 97209
33709, 95938, 95940, 95986, 95984, 25094, 25095, 25118, 25117, 97055, 97217, 97218, 97210, 25473, 25519, 25520, 
25517, 97049, 97056, 97219, 97212
33710, 23818, 23819, 23842, 23841, 95939, 95941, 95987, 95985, 24198, 24244, 24245, 24242, 97059, 97221, 97222, 
97214, 97050, 97057, 97220, 97213
33711, 95939, 95941, 95987, 95985, 95940, 95942, 95988, 95986, 97059, 97221, 97222, 97214, 97062, 97224, 97225, 
97217, 97053, 97060, 97223, 97216
33712, 95940, 95942, 95988, 95986, 25095, 25096, 25119, 25118, 97062, 97224, 97225, 97217, 25475, 25521, 25522, 
25519, 97056, 97063, 97226, 97219
33713, 23819, 23820, 23843, 23842, 95941, 95943, 95989, 95987, 24200, 24246, 24247, 24244, 97066, 97228, 97229, 
97221, 97057, 97064, 97227, 97220
33714, 95941, 95943, 95989, 95987, 95942, 95944, 95990, 95988, 97066, 97228, 97229, 97221, 97069, 97231, 97232, 
97224, 97060, 97067, 97230, 97223
33715, 95942, 95944, 95990, 95988, 25096, 25097, 25120, 25119, 97069, 97231, 97232, 97224, 25477, 25523, 25524, 
25521, 97063, 97070, 97233, 97226
33716, 23820, 23821, 23844, 23843, 95943, 95945, 95991, 95989, 24202, 24248, 24249, 24246, 97073, 97235, 97236, 
97228, 97064, 97071, 97234, 97227
33717, 95943, 95945, 95991, 95989, 95944, 95946, 95992, 95990, 97073, 97235, 97236, 97228, 97076, 97238, 97239, 
97231, 97067, 97074, 97237, 97230
33718, 95944, 95946, 95992, 95990, 25097, 25098, 25121, 25120, 97076, 97238, 97239, 97231, 25479, 25525, 25526, 
25523, 97070, 97077, 97240, 97233
33719, 23821, 23822, 23845, 23844, 95945, 95947, 95993, 95991, 24204, 24250, 24251, 24248, 97080, 97242, 97243, 
97235, 97071, 97078, 97241, 97234
33720, 95945, 95947, 95993, 95991, 95946, 95948, 95994, 95992, 97080, 97242, 97243, 97235, 97083, 97245, 97246, 
97238, 97074, 97081, 97244, 97237
33721, 95946, 95948, 95994, 95992, 25098, 25099, 25122, 25121, 97083, 97245, 97246, 97238, 25481, 25527, 25528, 
25525, 97077, 97084, 97247, 97240
33722, 23822, 23823, 23846, 23845, 95947, 95949, 95995, 95993, 24206, 24252, 24253, 24250, 97087, 97249, 97250, 
97242, 97078, 97085, 97248, 97241
33723, 95947, 95949, 95995, 95993, 95948, 95950, 95996, 95994, 97087, 97249, 97250, 97242, 97090, 97252, 97253, 
97245, 97081, 97088, 97251, 97244
33724, 95948, 95950, 95996, 95994, 25099, 25100, 25123, 25122, 97090, 97252, 97253, 97245, 25483, 25529, 25530, 
25527, 97084, 97091, 97254, 97247
33725, 23823, 23824, 23847, 23846, 95949, 95951, 95997, 95995, 24208, 24254, 24255, 24252, 97094, 97256, 97257, 
97249, 97085, 97092, 97255, 97248
33726, 95949, 95951, 95997, 95995, 95950, 95952, 95998, 95996, 97094, 97256, 97257, 97249, 97097, 97259, 97260, 
97252, 97088, 97095, 97258, 97251
33727, 95950, 95952, 95998, 95996, 25100, 25101, 25124, 25123, 97097, 97259, 97260, 97252, 25485, 25531, 25532, 
25529, 97091, 97098, 97261, 97254
33728, 23824, 23825, 23848, 23847, 95951, 95953, 95999, 95997, 24210, 24256, 24257, 24254, 97101, 97263, 97264, 
97256, 97092, 97099, 97262, 97255
33729, 95951, 95953, 95999, 95997, 95952, 95954, 96000, 95998, 97101, 97263, 97264, 97256, 97104, 97266, 97267, 
97259, 97095, 97102, 97265, 97258
33730, 95952, 95954, 96000, 95998, 25101, 25102, 25125, 25124, 97104, 97266, 97267, 97259, 25487, 25533, 25534, 
25531, 97098, 97105, 97268, 97261
33731, 23825, 23826, 23849, 23848, 95953, 95955, 96001, 95999, 24212, 24258, 24259, 24256, 97108, 97270, 97271, 
97263, 97099, 97106, 97269, 97262
33732, 95953, 95955, 96001, 95999, 95954, 95956, 96002, 96000, 97108, 97270, 97271, 97263, 97111, 97273, 97274, 
97266, 97102, 97109, 97272, 97265
33733, 95954, 95956, 96002, 96000, 25102, 25103, 25126, 25125, 97111, 97273, 97274, 97266, 25489, 25535, 25536, 
25533, 97105, 97112, 97275, 97268
33734, 23826, 23827, 23850, 23849, 95955, 95957, 96003, 96001, 24214, 24260, 24261, 24258, 97115, 97277, 97278, 
97270, 97106, 97113, 97276, 97269
33735, 95955, 95957, 96003, 96001, 95956, 95958, 96004, 96002, 97115, 97277, 97278, 97270, 97118, 97280, 97281, 
97273, 97109, 97116, 97279, 97272
33736, 95956, 95958, 96004, 96002, 25103, 25104, 25127, 25126, 97118, 97280, 97281, 97273, 25491, 25537, 25538, 
25535, 97112, 97119, 97282, 97275
33737, 23827, 23828, 23851, 23850, 95957, 95959, 96005, 96003, 24216, 24262, 24263, 24260, 97122, 97284, 97285, 
97277, 97113, 97120, 97283, 97276
33738, 95957, 95959, 96005, 96003, 95958, 95960, 96006, 96004, 97122, 97284, 97285, 97277, 97125, 97287, 97288, 
97280, 97116, 97123, 97286, 97279
33739, 95958, 95960, 96006, 96004, 25104, 25105, 25128, 25127, 97125, 97287, 97288, 97280, 25493, 25539, 25540, 
25537, 97119, 97126, 97289, 97282
33740, 23828, 23829, 23852, 23851, 95959, 95961, 96007, 96005, 24218, 24264, 24265, 24262, 97129, 97291, 97292, 
97284, 97120, 97127, 97290, 97283
33741, 95959, 95961, 96007, 96005, 95960, 95962, 96008, 96006, 97129, 97291, 97292, 97284, 97132, 97294, 97295, 
97287, 97123, 97130, 97293, 97286
33742, 95960, 95962, 96008, 96006, 25105, 25106, 25129, 25128, 97132, 97294, 97295, 97287, 25495, 25541, 25542, 
25539, 97126, 97133, 97296, 97289
33743, 23829, 23830, 23853, 23852, 95961, 95963, 96009, 96007, 24220, 24266, 24267, 24264, 97136, 97298, 97299, 
97291, 97127, 97134, 97297, 97290
33744, 95961, 95963, 96009, 96007, 95962, 95964, 96010, 96008, 97136, 97298, 97299, 97291, 97139, 97301, 97302, 
97294, 97130, 97137, 97300, 97293
33745, 95962, 95964, 96010, 96008, 25106, 25107, 25130, 25129, 97139, 97301, 97302, 97294, 25497, 25543, 25544, 
25541, 97133, 97140, 97303, 97296
33746, 23830, 23831, 23854, 23853, 95963, 95965, 96011, 96009, 24222, 24268, 24269, 24266, 97143, 97305, 97306, 
97298, 97134, 97141, 97304, 97297
33747, 95963, 95965, 96011, 96009, 95964, 95966, 96012, 96010, 97143, 97305, 97306, 97298, 97146, 97308, 97309, 
97301, 97137, 97144, 97307, 97300
33748, 95964, 95966, 96012, 96010, 25107, 25108, 25131, 25130, 97146, 97308, 97309, 97301, 25499, 25545, 25546, 
25543, 97140, 97147, 97310, 97303
33749, 23831, 23832, 23855, 23854, 95965, 95967, 96013, 96011, 24224, 24270, 24271, 24268, 97150, 97312, 97313, 
97305, 97141, 97148, 97311, 97304
33750, 95965, 95967, 96013, 96011, 95966, 95968, 96014, 96012, 97150, 97312, 97313, 97305, 97153, 97315, 97316, 
97308, 97144, 97151, 97314, 97307
33751, 95966, 95968, 96014, 96012, 25108, 25109, 25132, 25131, 97153, 97315, 97316, 97308, 25501, 25547, 25548, 
25545, 97147, 97154, 97317, 97310
33752, 23832, 23833, 23856, 23855, 95967, 95969, 96015, 96013, 24226, 24272, 24273, 24270, 97157, 97319, 97320, 
97312, 97148, 97155, 97318, 97311
33753, 95967, 95969, 96015, 96013, 95968, 95970, 96016, 96014, 97157, 97319, 97320, 97312, 97160, 97322, 97323, 
97315, 97151, 97158, 97321, 97314
33754, 95968, 95970, 96016, 96014, 25109, 25110, 25133, 25132, 97160, 97322, 97323, 97315, 25503, 25549, 25550, 
25547, 97154, 97161, 97324, 97317
33755, 23833, 23834, 23857, 23856, 95969, 95971, 96017, 96015, 24228, 24274, 24275, 24272, 97164, 97326, 97327, 
97319, 97155, 97162, 97325, 97318
33756, 95969, 95971, 96017, 96015, 95970, 95972, 96018, 96016, 97164, 97326, 97327, 97319, 97167, 97329, 97330, 
97322, 97158, 97165, 97328, 97321
33757, 95970, 95972, 96018, 96016, 25110, 25111, 25134, 25133, 97167, 97329, 97330, 97322, 25505, 25551, 25552, 
25549, 97161, 97168, 97331, 97324
33758, 23834, 23835, 23858, 23857, 95971, 95973, 96019, 96017, 24230, 24276, 24277, 24274, 97171, 97333, 97334, 
97326, 97162, 97169, 97332, 97325
33759, 95971, 95973, 96019, 96017, 95972, 95974, 96020, 96018, 97171, 97333, 97334, 97326, 97174, 97336, 97337, 
97329, 97165, 97172, 97335, 97328
33760, 95972, 95974, 96020, 96018, 25111, 25112, 25135, 25134, 97174, 97336, 97337, 97329, 25507, 25553, 25554, 
25551, 97168, 97175, 97338, 97331
33761, 23835, 23836, 23859, 23858, 95973, 95975, 96021, 96019, 24232, 24278, 24279, 24276, 97178, 97340, 97341, 
97333, 97169, 97176, 97339, 97332
33762, 95973, 95975, 96021, 96019, 95974, 95976, 96022, 96020, 97178, 97340, 97341, 97333, 97181, 97343, 97344, 
97336, 97172, 97179, 97342, 97335
33763, 95974, 95976, 96022, 96020, 25112, 25113, 25136, 25135, 97181, 97343, 97344, 97336, 25509, 25555, 25556, 
25553, 97175, 97182, 97345, 97338
33764, 23836, 2107, 2108, 23859, 95975, 24907, 24909, 96021, 24233, 2119, 24280, 24278, 97183, 24950, 97346, 
97340, 97176, 24944, 24949, 97339
33765, 95975, 24907, 24909, 96021, 95976, 24908, 24910, 96022, 97183, 24950, 97346, 97340, 97184, 24952, 97347, 
97343, 97179, 24946, 24951, 97342
33766, 95976, 24908, 24910, 96022, 25113, 2267, 2268, 25136, 97184, 24952, 97347, 97343, 25510, 2279, 25557, 
25555, 97182, 24948, 24953, 97345
33767, 2085, 23837, 23860, 2086, 24830, 95977, 96023, 24832, 24235, 24281, 24282, 2097, 97187, 97349, 97350, 
24875, 24871, 97185, 97348, 24876
33768, 24830, 95977, 96023, 24832, 24831, 95978, 96024, 24833, 97187, 97349, 97350, 24875, 97190, 97352, 97353, 
24877, 24873, 97188, 97351, 24878
33769, 24831, 95978, 96024, 24833, 2245, 25114, 25137, 2246, 97190, 97352, 97353, 24877, 25512, 25558, 25559, 
2257, 24874, 97191, 97354, 24879
33770, 23837, 23838, 23861, 23860, 95977, 95979, 96025, 96023, 24237, 24283, 24284, 24281, 97194, 97356, 97357, 
97349, 97185, 97192, 97355, 97348
33771, 95977, 95979, 96025, 96023, 95978, 95980, 96026, 96024, 97194, 97356, 97357, 97349, 97197, 97359, 97360, 
97352, 97188, 97195, 97358, 97351
33772, 95978, 95980, 96026, 96024, 25114, 25115, 25138, 25137, 97197, 97359, 97360, 97352, 25514, 25560, 25561, 
25558, 97191, 97198, 97361, 97354
33773, 23838, 23839, 23862, 23861, 95979, 95981, 96027, 96025, 24239, 24285, 24286, 24283, 97201, 97363, 97364, 
97356, 97192, 97199, 97362, 97355
33774, 95979, 95981, 96027, 96025, 95980, 95982, 96028, 96026, 97201, 97363, 97364, 97356, 97204, 97366, 97367, 
97359, 97195, 97202, 97365, 97358
33775, 95980, 95982, 96028, 96026, 25115, 25116, 25139, 25138, 97204, 97366, 97367, 97359, 25516, 25562, 25563, 
25560, 97198, 97205, 97368, 97361
33776, 23839, 23840, 23863, 23862, 95981, 95983, 96029, 96027, 24241, 24287, 24288, 24285, 97208, 97370, 97371, 
97363, 97199, 97206, 97369, 97362
33777, 95981, 95983, 96029, 96027, 95982, 95984, 96030, 96028, 97208, 97370, 97371, 97363, 97211, 97373, 97374, 
97366, 97202, 97209, 97372, 97365
33778, 95982, 95984, 96030, 96028, 25116, 25117, 25140, 25139, 97211, 97373, 97374, 97366, 25518, 25564, 25565, 
25562, 97205, 97212, 97375, 97368
33779, 23840, 23841, 23864, 23863, 95983, 95985, 96031, 96029, 24243, 24289, 24290, 24287, 97215, 97377, 97378, 
97370, 97206, 97213, 97376, 97369
33780, 95983, 95985, 96031, 96029, 95984, 95986, 96032, 96030, 97215, 97377, 97378, 97370, 97218, 97380, 97381, 
97373, 97209, 97216, 97379, 97372
33781, 95984, 95986, 96032, 96030, 25117, 25118, 25141, 25140, 97218, 97380, 97381, 97373, 25520, 25566, 25567, 
25564, 97212, 97219, 97382, 97375
33782, 23841, 23842, 23865, 23864, 95985, 95987, 96033, 96031, 24245, 24291, 24292, 24289, 97222, 97384, 97385, 
97377, 97213, 97220, 97383, 97376
33783, 95985, 95987, 96033, 96031, 95986, 95988, 96034, 96032, 97222, 97384, 97385, 97377, 97225, 97387, 97388, 
97380, 97216, 97223, 97386, 97379
33784, 95986, 95988, 96034, 96032, 25118, 25119, 25142, 25141, 97225, 97387, 97388, 97380, 25522, 25568, 25569, 
25566, 97219, 97226, 97389, 97382
33785, 23842, 23843, 23866, 23865, 95987, 95989, 96035, 96033, 24247, 24293, 24294, 24291, 97229, 97391, 97392, 
97384, 97220, 97227, 97390, 97383
33786, 95987, 95989, 96035, 96033, 95988, 95990, 96036, 96034, 97229, 97391, 97392, 97384, 97232, 97394, 97395, 
97387, 97223, 97230, 97393, 97386
33787, 95988, 95990, 96036, 96034, 25119, 25120, 25143, 25142, 97232, 97394, 97395, 97387, 25524, 25570, 25571, 
25568, 97226, 97233, 97396, 97389
33788, 23843, 23844, 23867, 23866, 95989, 95991, 96037, 96035, 24249, 24295, 24296, 24293, 97236, 97398, 97399, 
97391, 97227, 97234, 97397, 97390
33789, 95989, 95991, 96037, 96035, 95990, 95992, 96038, 96036, 97236, 97398, 97399, 97391, 97239, 97401, 97402, 
97394, 97230, 97237, 97400, 97393
33790, 95990, 95992, 96038, 96036, 25120, 25121, 25144, 25143, 97239, 97401, 97402, 97394, 25526, 25572, 25573, 
25570, 97233, 97240, 97403, 97396
33791, 23844, 23845, 23868, 23867, 95991, 95993, 96039, 96037, 24251, 24297, 24298, 24295, 97243, 97405, 97406, 
97398, 97234, 97241, 97404, 97397
