42323, 0.20833333333333, 0.95, 0.20833333333333
42324, 0.20833333333333, 1, 0.20833333333333
42325, 0.20833333333333, 1.05, 0.20833333333333
42326, 0.20833333333333, 1.1, 0.20833333333333
42327, 0.20833333333333, 1.15, 0.20833333333333
42328, 0.20833333333333, 1.2, 0.20833333333333
42329, 0.20833333333333, 1.25, 0.20833333333333
42330, 0.20833333333333, 1.3, 0.20833333333333
42331, 0.20833333333333, 0.2, 0.25
42332, 0.20833333333333, 0.25, 0.25
42333, 0.20833333333333, 0.3, 0.25
42334, 0.20833333333333, 0.35, 0.25
42335, 0.20833333333333, 0.4, 0.25
42336, 0.20833333333333, 0.45, 0.25
42337, 0.20833333333333, 0.5, 0.25
42338, 0.20833333333333, 0.55, 0.25
42339, 0.20833333333333, 0.6, 0.25
42340, 0.20833333333333, 0.65, 0.25
42341, 0.20833333333333, 0.7, 0.25
42342, 0.20833333333333, 0.75, 0.25
42343, 0.20833333333333, 0.8, 0.25
42344, 0.20833333333333, 0.85, 0.25
42345, 0.20833333333333, 0.9, 0.25
42346, 0.20833333333333, 0.95, 0.25
42347, 0.20833333333333, 1, 0.25
42348, 0.20833333333333, 1.05, 0.25
42349, 0.20833333333333, 1.1, 0.25
42350, 0.20833333333333, 1.15, 0.25
42351, 0.20833333333333, 1.2, 0.25
42352, 0.20833333333333, 1.25, 0.25
42353, 0.20833333333333, 1.3, 0.25
42354, 0.20833333333333, 0.2, 0.29166666666667
42355, 0.20833333333333, 0.25, 0.29166666666667
42356, 0.20833333333333, 0.3, 0.29166666666667
42357, 0.20833333333333, 0.35, 0.29166666666667
42358, 0.20833333333333, 0.4, 0.29166666666667
42359, 0.20833333333333, 0.45, 0.29166666666667
42360, 0.20833333333333, 0.5, 0.29166666666667
42361, 0.20833333333333, 0.55, 0.29166666666667
42362, 0.20833333333333, 0.6, 0.29166666666667
42363, 0.20833333333333, 0.65, 0.29166666666667
42364, 0.20833333333333, 0.7, 0.29166666666667
42365, 0.20833333333333, 0.75, 0.29166666666667
42366, 0.20833333333333, 0.8, 0.29166666666667
42367, 0.20833333333333, 0.85, 0.29166666666667
42368, 0.20833333333333, 0.9, 0.29166666666667
42369, 0.20833333333333, 0.95, 0.29166666666667
42370, 0.20833333333333, 1, 0.29166666666667
42371, 0.20833333333333, 1.05, 0.29166666666667
42372, 0.20833333333333, 1.1, 0.29166666666667
42373, 0.20833333333333, 1.15, 0.29166666666667
42374, 0.20833333333333, 1.2, 0.29166666666667
42375, 0.20833333333333, 1.25, 0.29166666666667
42376, 0.20833333333333, 1.3, 0.29166666666667
42377, 0.20833333333333, 0.2, 0.33333333333333
42378, 0.20833333333333, 0.25, 0.33333333333333
42379, 0.20833333333333, 0.3, 0.33333333333333
42380, 0.20833333333333, 0.35, 0.33333333333333
42381, 0.20833333333333, 0.4, 0.33333333333333
42382, 0.20833333333333, 0.45, 0.33333333333333
42383, 0.20833333333333, 0.5, 0.33333333333333
42384, 0.20833333333333, 0.55, 0.33333333333333
42385, 0.20833333333333, 0.6, 0.33333333333333
42386, 0.20833333333333, 0.65, 0.33333333333333
42387, 0.20833333333333, 0.7, 0.33333333333333
42388, 0.20833333333333, 0.75, 0.33333333333333
42389, 0.20833333333333, 0.8, 0.33333333333333
42390, 0.20833333333333, 0.85, 0.33333333333333
42391, 0.20833333333333, 0.9, 0.33333333333333
42392, 0.20833333333333, 0.95, 0.33333333333333
42393, 0.20833333333333, 1, 0.33333333333333
42394, 0.20833333333333, 1.05, 0.33333333333333
42395, 0.20833333333333, 1.1, 0.33333333333333
42396, 0.20833333333333, 1.15, 0.33333333333333
42397, 0.20833333333333, 1.2, 0.33333333333333
42398, 0.20833333333333, 1.25, 0.33333333333333
42399, 0.20833333333333, 1.3, 0.33333333333333
42400, 0.20833333333333, 0.2, 0.375
42401, 0.20833333333333, 0.25, 0.375
42402, 0.20833333333333, 0.3, 0.375
42403, 0.20833333333333, 0.35, 0.375
42404, 0.20833333333333, 0.4, 0.375
42405, 0.20833333333333, 0.45, 0.375
42406, 0.20833333333333, 0.5, 0.375
42407, 0.20833333333333, 0.55, 0.375
42408, 0.20833333333333, 0.6, 0.375
42409, 0.20833333333333, 0.65, 0.375
42410, 0.20833333333333, 0.7, 0.375
42411, 0.20833333333333, 0.75, 0.375
42412, 0.20833333333333, 0.8, 0.375
42413, 0.20833333333333, 0.85, 0.375
42414, 0.20833333333333, 0.9, 0.375
42415, 0.20833333333333, 0.95, 0.375
42416, 0.20833333333333, 1, 0.375
42417, 0.20833333333333, 1.05, 0.375
42418, 0.20833333333333, 1.1, 0.375
42419, 0.20833333333333, 1.15, 0.375
42420, 0.20833333333333, 1.2, 0.375
42421, 0.20833333333333, 1.25, 0.375
42422, 0.20833333333333, 1.3, 0.375
42423, 0.20833333333333, 0.2, 0.41666666666667
42424, 0.20833333333333, 0.25, 0.41666666666667
42425, 0.20833333333333, 0.3, 0.41666666666667
42426, 0.20833333333333, 0.35, 0.41666666666667
42427, 0.20833333333333, 0.4, 0.41666666666667
42428, 0.20833333333333, 0.45, 0.41666666666667
42429, 0.20833333333333, 0.5, 0.41666666666667
42430, 0.20833333333333, 0.55, 0.41666666666667
42431, 0.20833333333333, 0.6, 0.41666666666667
42432, 0.20833333333333, 0.65, 0.41666666666667
42433, 0.20833333333333, 0.7, 0.41666666666667
42434, 0.20833333333333, 0.75, 0.41666666666667
42435, 0.20833333333333, 0.8, 0.41666666666667
42436, 0.20833333333333, 0.85, 0.41666666666667
42437, 0.20833333333333, 0.9, 0.41666666666667
42438, 0.20833333333333, 0.95, 0.41666666666667
42439, 0.20833333333333, 1, 0.41666666666667
42440, 0.20833333333333, 1.05, 0.41666666666667
42441, 0.20833333333333, 1.1, 0.41666666666667
42442, 0.20833333333333, 1.15, 0.41666666666667
42443, 0.20833333333333, 1.2, 0.41666666666667
42444, 0.20833333333333, 1.25, 0.41666666666667
42445, 0.20833333333333, 1.3, 0.41666666666667
42446, 0.20833333333333, 0.2, 0.45833333333333
42447, 0.20833333333333, 0.25, 0.45833333333333
42448, 0.20833333333333, 0.3, 0.45833333333333
42449, 0.20833333333333, 0.35, 0.45833333333333
42450, 0.20833333333333, 0.4, 0.45833333333333
42451, 0.20833333333333, 0.45, 0.45833333333333
42452, 0.20833333333333, 0.5, 0.45833333333333
42453, 0.20833333333333, 0.55, 0.45833333333333
42454, 0.20833333333333, 0.6, 0.45833333333333
42455, 0.20833333333333, 0.65, 0.45833333333333
42456, 0.20833333333333, 0.7, 0.45833333333333
42457, 0.20833333333333, 0.75, 0.45833333333333
42458, 0.20833333333333, 0.8, 0.45833333333333
42459, 0.20833333333333, 0.85, 0.45833333333333
42460, 0.20833333333333, 0.9, 0.45833333333333
42461, 0.20833333333333, 0.95, 0.45833333333333
42462, 0.20833333333333, 1, 0.45833333333333
42463, 0.20833333333333, 1.05, 0.45833333333333
42464, 0.20833333333333, 1.1, 0.45833333333333
42465, 0.20833333333333, 1.15, 0.45833333333333
42466, 0.20833333333333, 1.2, 0.45833333333333
42467, 0.20833333333333, 1.25, 0.45833333333333
42468, 0.20833333333333, 1.3, 0.45833333333333
42469, 0.25, 0.2, 0.041666666666667
42470, 0.25, 0.25, 0.041666666666667
42471, 0.25, 0.3, 0.041666666666667
42472, 0.25, 0.35, 0.041666666666667
42473, 0.25, 0.4, 0.041666666666667
42474, 0.25, 0.45, 0.041666666666667
42475, 0.25, 0.5, 0.041666666666667
42476, 0.25, 0.55, 0.041666666666667
42477, 0.25, 0.6, 0.041666666666667
42478, 0.25, 0.65, 0.041666666666667
42479, 0.25, 0.7, 0.041666666666667
42480, 0.25, 0.75, 0.041666666666667
42481, 0.25, 0.8, 0.041666666666667
42482, 0.25, 0.85, 0.041666666666667
42483, 0.25, 0.9, 0.041666666666667
42484, 0.25, 0.95, 0.041666666666667
42485, 0.25, 1, 0.041666666666667
42486, 0.25, 1.05, 0.041666666666667
42487, 0.25, 1.1, 0.041666666666667
42488, 0.25, 1.15, 0.041666666666667
42489, 0.25, 1.2, 0.041666666666667
42490, 0.25, 1.25, 0.041666666666667
42491, 0.25, 1.3, 0.041666666666667
42492, 0.25, 0.2, 0.083333333333333
42493, 0.25, 0.25, 0.083333333333333
42494, 0.25, 0.3, 0.083333333333333
42495, 0.25, 0.35, 0.083333333333333
42496, 0.25, 0.4, 0.083333333333333
42497, 0.25, 0.45, 0.083333333333333
42498, 0.25, 0.5, 0.083333333333333
42499, 0.25, 0.55, 0.083333333333333
42500, 0.25, 0.6, 0.083333333333333
42501, 0.25, 0.65, 0.083333333333333
42502, 0.25, 0.7, 0.083333333333333
42503, 0.25, 0.75, 0.083333333333333
42504, 0.25, 0.8, 0.083333333333333
42505, 0.25, 0.85, 0.083333333333333
42506, 0.25, 0.9, 0.083333333333333
42507, 0.25, 0.95, 0.083333333333333
42508, 0.25, 1, 0.083333333333333
42509, 0.25, 1.05, 0.083333333333333
42510, 0.25, 1.1, 0.083333333333333
42511, 0.25, 1.15, 0.083333333333333
42512, 0.25, 1.2, 0.083333333333333
42513, 0.25, 1.25, 0.083333333333333
42514, 0.25, 1.3, 0.083333333333333
42515, 0.25, 0.2, 0.125
42516, 0.25, 0.25, 0.125
42517, 0.25, 0.3, 0.125
42518, 0.25, 0.35, 0.125
42519, 0.25, 0.4, 0.125
42520, 0.25, 0.45, 0.125
42521, 0.25, 0.5, 0.125
42522, 0.25, 0.55, 0.125
42523, 0.25, 0.6, 0.125
42524, 0.25, 0.65, 0.125
42525, 0.25, 0.7, 0.125
42526, 0.25, 0.75, 0.125
42527, 0.25, 0.8, 0.125
42528, 0.25, 0.85, 0.125
42529, 0.25, 0.9, 0.125
42530, 0.25, 0.95, 0.125
42531, 0.25, 1, 0.125
42532, 0.25, 1.05, 0.125
42533, 0.25, 1.1, 0.125
42534, 0.25, 1.15, 0.125
42535, 0.25, 1.2, 0.125
42536, 0.25, 1.25, 0.125
42537, 0.25, 1.3, 0.125
42538, 0.25, 0.2, 0.16666666666667
42539, 0.25, 0.25, 0.16666666666667
42540, 0.25, 0.3, 0.16666666666667
42541, 0.25, 0.35, 0.16666666666667
42542, 0.25, 0.4, 0.16666666666667
42543, 0.25, 0.45, 0.16666666666667
42544, 0.25, 0.5, 0.16666666666667
42545, 0.25, 0.55, 0.16666666666667
42546, 0.25, 0.6, 0.16666666666667
42547, 0.25, 0.65, 0.16666666666667
42548, 0.25, 0.7, 0.16666666666667
42549, 0.25, 0.75, 0.16666666666667
42550, 0.25, 0.8, 0.16666666666667
42551, 0.25, 0.85, 0.16666666666667
42552, 0.25, 0.9, 0.16666666666667
42553, 0.25, 0.95, 0.16666666666667
42554, 0.25, 1, 0.16666666666667
42555, 0.25, 1.05, 0.16666666666667
42556, 0.25, 1.1, 0.16666666666667
42557, 0.25, 1.15, 0.16666666666667
42558, 0.25, 1.2, 0.16666666666667
42559, 0.25, 1.25, 0.16666666666667
42560, 0.25, 1.3, 0.16666666666667
42561, 0.25, 0.2, 0.20833333333333
42562, 0.25, 0.25, 0.20833333333333
42563, 0.25, 0.3, 0.20833333333333
42564, 0.25, 0.35, 0.20833333333333
42565, 0.25, 0.4, 0.20833333333333
42566, 0.25, 0.45, 0.20833333333333
42567, 0.25, 0.5, 0.20833333333333
42568, 0.25, 0.55, 0.20833333333333
42569, 0.25, 0.6, 0.20833333333333
42570, 0.25, 0.65, 0.20833333333333
42571, 0.25, 0.7, 0.20833333333333
42572, 0.25, 0.75, 0.20833333333333
42573, 0.25, 0.8, 0.20833333333333
42574, 0.25, 0.85, 0.20833333333333
42575, 0.25, 0.9, 0.20833333333333
42576, 0.25, 0.95, 0.20833333333333
42577, 0.25, 1, 0.20833333333333
42578, 0.25, 1.05, 0.20833333333333
42579, 0.25, 1.1, 0.20833333333333
42580, 0.25, 1.15, 0.20833333333333
42581, 0.25, 1.2, 0.20833333333333
42582, 0.25, 1.25, 0.20833333333333
42583, 0.25, 1.3, 0.20833333333333
42584, 0.25, 0.2, 0.25
42585, 0.25, 0.25, 0.25
42586, 0.25, 0.3, 0.25
42587, 0.25, 0.35, 0.25
42588, 0.25, 0.4, 0.25
42589, 0.25, 0.45, 0.25
42590, 0.25, 0.5, 0.25
42591, 0.25, 0.55, 0.25
42592, 0.25, 0.6, 0.25
42593, 0.25, 0.65, 0.25
42594, 0.25, 0.7, 0.25
42595, 0.25, 0.75, 0.25
42596, 0.25, 0.8, 0.25
42597, 0.25, 0.85, 0.25
42598, 0.25, 0.9, 0.25
42599, 0.25, 0.95, 0.25
42600, 0.25, 1, 0.25
42601, 0.25, 1.05, 0.25
42602, 0.25, 1.1, 0.25
42603, 0.25, 1.15, 0.25
42604, 0.25, 1.2, 0.25
42605, 0.25, 1.25, 0.25
42606, 0.25, 1.3, 0.25
42607, 0.25, 0.2, 0.29166666666667
42608, 0.25, 0.25, 0.29166666666667
42609, 0.25, 0.3, 0.29166666666667
42610, 0.25, 0.35, 0.29166666666667
42611, 0.25, 0.4, 0.29166666666667
42612, 0.25, 0.45, 0.29166666666667
42613, 0.25, 0.5, 0.29166666666667
42614, 0.25, 0.55, 0.29166666666667
42615, 0.25, 0.6, 0.29166666666667
42616, 0.25, 0.65, 0.29166666666667
42617, 0.25, 0.7, 0.29166666666667
42618, 0.25, 0.75, 0.29166666666667
42619, 0.25, 0.8, 0.29166666666667
42620, 0.25, 0.85, 0.29166666666667
42621, 0.25, 0.9, 0.29166666666667
42622, 0.25, 0.95, 0.29166666666667
42623, 0.25, 1, 0.29166666666667
42624, 0.25, 1.05, 0.29166666666667
42625, 0.25, 1.1, 0.29166666666667
42626, 0.25, 1.15, 0.29166666666667
42627, 0.25, 1.2, 0.29166666666667
42628, 0.25, 1.25, 0.29166666666667
42629, 0.25, 1.3, 0.29166666666667
42630, 0.25, 0.2, 0.33333333333333
42631, 0.25, 0.25, 0.33333333333333
42632, 0.25, 0.3, 0.33333333333333
42633, 0.25, 0.35, 0.33333333333333
42634, 0.25, 0.4, 0.33333333333333
42635, 0.25, 0.45, 0.33333333333333
42636, 0.25, 0.5, 0.33333333333333
42637, 0.25, 0.55, 0.33333333333333
42638, 0.25, 0.6, 0.33333333333333
42639, 0.25, 0.65, 0.33333333333333
42640, 0.25, 0.7, 0.33333333333333
42641, 0.25, 0.75, 0.33333333333333
42642, 0.25, 0.8, 0.33333333333333
42643, 0.25, 0.85, 0.33333333333333
42644, 0.25, 0.9, 0.33333333333333
42645, 0.25, 0.95, 0.33333333333333
42646, 0.25, 1, 0.33333333333333
42647, 0.25, 1.05, 0.33333333333333
42648, 0.25, 1.1, 0.33333333333333
42649, 0.25, 1.15, 0.33333333333333
42650, 0.25, 1.2, 0.33333333333333
42651, 0.25, 1.25, 0.33333333333333
42652, 0.25, 1.3, 0.33333333333333
42653, 0.25, 0.2, 0.375
42654, 0.25, 0.25, 0.375
42655, 0.25, 0.3, 0.375
42656, 0.25, 0.35, 0.375
42657, 0.25, 0.4, 0.375
42658, 0.25, 0.45, 0.375
42659, 0.25, 0.5, 0.375
42660, 0.25, 0.55, 0.375
42661, 0.25, 0.6, 0.375
42662, 0.25, 0.65, 0.375
42663, 0.25, 0.7, 0.375
42664, 0.25, 0.75, 0.375
42665, 0.25, 0.8, 0.375
42666, 0.25, 0.85, 0.375
42667, 0.25, 0.9, 0.375
42668, 0.25, 0.95, 0.375
42669, 0.25, 1, 0.375
42670, 0.25, 1.05, 0.375
42671, 0.25, 1.1, 0.375
42672, 0.25, 1.15, 0.375
42673, 0.25, 1.2, 0.375
42674, 0.25, 1.25, 0.375
42675, 0.25, 1.3, 0.375
42676, 0.25, 0.2, 0.41666666666667
42677, 0.25, 0.25, 0.41666666666667
42678, 0.25, 0.3, 0.41666666666667
42679, 0.25, 0.35, 0.41666666666667
42680, 0.25, 0.4, 0.41666666666667
42681, 0.25, 0.45, 0.41666666666667
42682, 0.25, 0.5, 0.41666666666667
42683, 0.25, 0.55, 0.41666666666667
42684, 0.25, 0.6, 0.41666666666667
42685, 0.25, 0.65, 0.41666666666667
42686, 0.25, 0.7, 0.41666666666667
42687, 0.25, 0.75, 0.41666666666667
42688, 0.25, 0.8, 0.41666666666667
42689, 0.25, 0.85, 0.41666666666667
42690, 0.25, 0.9, 0.41666666666667
42691, 0.25, 0.95, 0.41666666666667
42692, 0.25, 1, 0.41666666666667
42693, 0.25, 1.05, 0.41666666666667
42694, 0.25, 1.1, 0.41666666666667
42695, 0.25, 1.15, 0.41666666666667
42696, 0.25, 1.2, 0.41666666666667
42697, 0.25, 1.25, 0.41666666666667
42698, 0.25, 1.3, 0.41666666666667
42699, 0.25, 0.2, 0.45833333333333
42700, 0.25, 0.25, 0.45833333333333
42701, 0.25, 0.3, 0.45833333333333
42702, 0.25, 0.35, 0.45833333333333
42703, 0.25, 0.4, 0.45833333333333
42704, 0.25, 0.45, 0.45833333333333
42705, 0.25, 0.5, 0.45833333333333
42706, 0.25, 0.55, 0.45833333333333
42707, 0.25, 0.6, 0.45833333333333
42708, 0.25, 0.65, 0.45833333333333
42709, 0.25, 0.7, 0.45833333333333
42710, 0.25, 0.75, 0.45833333333333
42711, 0.25, 0.8, 0.45833333333333
42712, 0.25, 0.85, 0.45833333333333
42713, 0.25, 0.9, 0.45833333333333
42714, 0.25, 0.95, 0.45833333333333
42715, 0.25, 1, 0.45833333333333
42716, 0.25, 1.05, 0.45833333333333
42717, 0.25, 1.1, 0.45833333333333
42718, 0.25, 1.15, 0.45833333333333
42719, 0.25, 1.2, 0.45833333333333
42720, 0.25, 1.25, 0.45833333333333
42721, 0.25, 1.3, 0.45833333333333
42722, 0.29166666666667, 0.2, 0.041666666666667
42723, 0.29166666666667, 0.25, 0.041666666666667
42724, 0.29166666666667, 0.3, 0.041666666666667
42725, 0.29166666666667, 0.35, 0.041666666666667
42726, 0.29166666666667, 0.4, 0.041666666666667
42727, 0.29166666666667, 0.45, 0.041666666666667
42728, 0.29166666666667, 0.5, 0.041666666666667
42729, 0.29166666666667, 0.55, 0.041666666666667
42730, 0.29166666666667, 0.6, 0.041666666666667
42731, 0.29166666666667, 0.65, 0.041666666666667
42732, 0.29166666666667, 0.7, 0.041666666666667
42733, 0.29166666666667, 0.75, 0.041666666666667
42734, 0.29166666666667, 0.8, 0.041666666666667
42735, 0.29166666666667, 0.85, 0.041666666666667
42736, 0.29166666666667, 0.9, 0.041666666666667
42737, 0.29166666666667, 0.95, 0.041666666666667
42738, 0.29166666666667, 1, 0.041666666666667
42739, 0.29166666666667, 1.05, 0.041666666666667
42740, 0.29166666666667, 1.1, 0.041666666666667
42741, 0.29166666666667, 1.15, 0.041666666666667
42742, 0.29166666666667, 1.2, 0.041666666666667
42743, 0.29166666666667, 1.25, 0.041666666666667
42744, 0.29166666666667, 1.3, 0.041666666666667
42745, 0.29166666666667, 0.2, 0.083333333333333
42746, 0.29166666666667, 0.25, 0.083333333333333
42747, 0.29166666666667, 0.3, 0.083333333333333
42748, 0.29166666666667, 0.35, 0.083333333333333
42749, 0.29166666666667, 0.4, 0.083333333333333
42750, 0.29166666666667, 0.45, 0.083333333333333
42751, 0.29166666666667, 0.5, 0.083333333333333
42752, 0.29166666666667, 0.55, 0.083333333333333
42753, 0.29166666666667, 0.6, 0.083333333333333
42754, 0.29166666666667, 0.65, 0.083333333333333
42755, 0.29166666666667, 0.7, 0.083333333333333
42756, 0.29166666666667, 0.75, 0.083333333333333
42757, 0.29166666666667, 0.8, 0.083333333333333
42758, 0.29166666666667, 0.85, 0.083333333333333
42759, 0.29166666666667, 0.9, 0.083333333333333
42760, 0.29166666666667, 0.95, 0.083333333333333
42761, 0.29166666666667, 1, 0.083333333333333
42762, 0.29166666666667, 1.05, 0.083333333333333
42763, 0.29166666666667, 1.1, 0.083333333333333
42764, 0.29166666666667, 1.15, 0.083333333333333
42765, 0.29166666666667, 1.2, 0.083333333333333
42766, 0.29166666666667, 1.25, 0.083333333333333
42767, 0.29166666666667, 1.3, 0.083333333333333
42768, 0.29166666666667, 0.2, 0.125
42769, 0.29166666666667, 0.25, 0.125
42770, 0.29166666666667, 0.3, 0.125
42771, 0.29166666666667, 0.35, 0.125
42772, 0.29166666666667, 0.4, 0.125
42773, 0.29166666666667, 0.45, 0.125
42774, 0.29166666666667, 0.5, 0.125
42775, 0.29166666666667, 0.55, 0.125
42776, 0.29166666666667, 0.6, 0.125
42777, 0.29166666666667, 0.65, 0.125
42778, 0.29166666666667, 0.7, 0.125
42779, 0.29166666666667, 0.75, 0.125
42780, 0.29166666666667, 0.8, 0.125
42781, 0.29166666666667, 0.85, 0.125
42782, 0.29166666666667, 0.9, 0.125
42783, 0.29166666666667, 0.95, 0.125
42784, 0.29166666666667, 1, 0.125
42785, 0.29166666666667, 1.05, 0.125
42786, 0.29166666666667, 1.1, 0.125
42787, 0.29166666666667, 1.15, 0.125
42788, 0.29166666666667, 1.2, 0.125
42789, 0.29166666666667, 1.25, 0.125
42790, 0.29166666666667, 1.3, 0.125
42791, 0.29166666666667, 0.2, 0.16666666666667
42792, 0.29166666666667, 0.25, 0.16666666666667
42793, 0.29166666666667, 0.3, 0.16666666666667
42794, 0.29166666666667, 0.35, 0.16666666666667
42795, 0.29166666666667, 0.4, 0.16666666666667
42796, 0.29166666666667, 0.45, 0.16666666666667
42797, 0.29166666666667, 0.5, 0.16666666666667
42798, 0.29166666666667, 0.55, 0.16666666666667
42799, 0.29166666666667, 0.6, 0.16666666666667
42800, 0.29166666666667, 0.65, 0.16666666666667
42801, 0.29166666666667, 0.7, 0.16666666666667
42802, 0.29166666666667, 0.75, 0.16666666666667
42803, 0.29166666666667, 0.8, 0.16666666666667
42804, 0.29166666666667, 0.85, 0.16666666666667
42805, 0.29166666666667, 0.9, 0.16666666666667
42806, 0.29166666666667, 0.95, 0.16666666666667
42807, 0.29166666666667, 1, 0.16666666666667
42808, 0.29166666666667, 1.05, 0.16666666666667
42809, 0.29166666666667, 1.1, 0.16666666666667
42810, 0.29166666666667, 1.15, 0.16666666666667
42811, 0.29166666666667, 1.2, 0.16666666666667
42812, 0.29166666666667, 1.25, 0.16666666666667
42813, 0.29166666666667, 1.3, 0.16666666666667
42814, 0.29166666666667, 0.2, 0.20833333333333
42815, 0.29166666666667, 0.25, 0.20833333333333
42816, 0.29166666666667, 0.3, 0.20833333333333
42817, 0.29166666666667, 0.35, 0.20833333333333
42818, 0.29166666666667, 0.4, 0.20833333333333
42819, 0.29166666666667, 0.45, 0.20833333333333
42820, 0.29166666666667, 0.5, 0.20833333333333
42821, 0.29166666666667, 0.55, 0.20833333333333
42822, 0.29166666666667, 0.6, 0.20833333333333
42823, 0.29166666666667, 0.65, 0.20833333333333
42824, 0.29166666666667, 0.7, 0.20833333333333
42825, 0.29166666666667, 0.75, 0.20833333333333
42826, 0.29166666666667, 0.8, 0.20833333333333
42827, 0.29166666666667, 0.85, 0.20833333333333
42828, 0.29166666666667, 0.9, 0.20833333333333
42829, 0.29166666666667, 0.95, 0.20833333333333
42830, 0.29166666666667, 1, 0.20833333333333
42831, 0.29166666666667, 1.05, 0.20833333333333
42832, 0.29166666666667, 1.1, 0.20833333333333
42833, 0.29166666666667, 1.15, 0.20833333333333
42834, 0.29166666666667, 1.2, 0.20833333333333
42835, 0.29166666666667, 1.25, 0.20833333333333
42836, 0.29166666666667, 1.3, 0.20833333333333
42837, 0.29166666666667, 0.2, 0.25
42838, 0.29166666666667, 0.25, 0.25
42839, 0.29166666666667, 0.3, 0.25
42840, 0.29166666666667, 0.35, 0.25
42841, 0.29166666666667, 0.4, 0.25
42842, 0.29166666666667, 0.45, 0.25
42843, 0.29166666666667, 0.5, 0.25
42844, 0.29166666666667, 0.55, 0.25
42845, 0.29166666666667, 0.6, 0.25
42846, 0.29166666666667, 0.65, 0.25
42847, 0.29166666666667, 0.7, 0.25
42848, 0.29166666666667, 0.75, 0.25
42849, 0.29166666666667, 0.8, 0.25
42850, 0.29166666666667, 0.85, 0.25
42851, 0.29166666666667, 0.9, 0.25
42852, 0.29166666666667, 0.95, 0.25
42853, 0.29166666666667, 1, 0.25
42854, 0.29166666666667, 1.05, 0.25
42855, 0.29166666666667, 1.1, 0.25
42856, 0.29166666666667, 1.15, 0.25
42857, 0.29166666666667, 1.2, 0.25
42858, 0.29166666666667, 1.25, 0.25
42859, 0.29166666666667, 1.3, 0.25
42860, 0.29166666666667, 0.2, 0.29166666666667
42861, 0.29166666666667, 0.25, 0.29166666666667
42862, 0.29166666666667, 0.3, 0.29166666666667
42863, 0.29166666666667, 0.35, 0.29166666666667
42864, 0.29166666666667, 0.4, 0.29166666666667
42865, 0.29166666666667, 0.45, 0.29166666666667
42866, 0.29166666666667, 0.5, 0.29166666666667
42867, 0.29166666666667, 0.55, 0.29166666666667
42868, 0.29166666666667, 0.6, 0.29166666666667
42869, 0.29166666666667, 0.65, 0.29166666666667
42870, 0.29166666666667, 0.7, 0.29166666666667
42871, 0.29166666666667, 0.75, 0.29166666666667
42872, 0.29166666666667, 0.8, 0.29166666666667
42873, 0.29166666666667, 0.85, 0.29166666666667
42874, 0.29166666666667, 0.9, 0.29166666666667
42875, 0.29166666666667, 0.95, 0.29166666666667
42876, 0.29166666666667, 1, 0.29166666666667
42877, 0.29166666666667, 1.05, 0.29166666666667
42878, 0.29166666666667, 1.1, 0.29166666666667
42879, 0.29166666666667, 1.15, 0.29166666666667
42880, 0.29166666666667, 1.2, 0.29166666666667
42881, 0.29166666666667, 1.25, 0.29166666666667
42882, 0.29166666666667, 1.3, 0.29166666666667
42883, 0.29166666666667, 0.2, 0.33333333333333
42884, 0.29166666666667, 0.25, 0.33333333333333
42885, 0.29166666666667, 0.3, 0.33333333333333
42886, 0.29166666666667, 0.35, 0.33333333333333
42887, 0.29166666666667, 0.4, 0.33333333333333
42888, 0.29166666666667, 0.45, 0.33333333333333
42889, 0.29166666666667, 0.5, 0.33333333333333
42890, 0.29166666666667, 0.55, 0.33333333333333
42891, 0.29166666666667, 0.6, 0.33333333333333
42892, 0.29166666666667, 0.65, 0.33333333333333
42893, 0.29166666666667, 0.7, 0.33333333333333
42894, 0.29166666666667, 0.75, 0.33333333333333
42895, 0.29166666666667, 0.8, 0.33333333333333
42896, 0.29166666666667, 0.85, 0.33333333333333
42897, 0.29166666666667, 0.9, 0.33333333333333
42898, 0.29166666666667, 0.95, 0.33333333333333
42899, 0.29166666666667, 1, 0.33333333333333
42900, 0.29166666666667, 1.05, 0.33333333333333
42901, 0.29166666666667, 1.1, 0.33333333333333
42902, 0.29166666666667, 1.15, 0.33333333333333
42903, 0.29166666666667, 1.2, 0.33333333333333
42904, 0.29166666666667, 1.25, 0.33333333333333
42905, 0.29166666666667, 1.3, 0.33333333333333
42906, 0.29166666666667, 0.2, 0.375
42907, 0.29166666666667, 0.25, 0.375
42908, 0.29166666666667, 0.3, 0.375
42909, 0.29166666666667, 0.35, 0.375
42910, 0.29166666666667, 0.4, 0.375
42911, 0.29166666666667, 0.45, 0.375
42912, 0.29166666666667, 0.5, 0.375
42913, 0.29166666666667, 0.55, 0.375
42914, 0.29166666666667, 0.6, 0.375
42915, 0.29166666666667, 0.65, 0.375
42916, 0.29166666666667, 0.7, 0.375
42917, 0.29166666666667, 0.75, 0.375
42918, 0.29166666666667, 0.8, 0.375
42919, 0.29166666666667, 0.85, 0.375
42920, 0.29166666666667, 0.9, 0.375
42921, 0.29166666666667, 0.95, 0.375
42922, 0.29166666666667, 1, 0.375
42923, 0.29166666666667, 1.05, 0.375
42924, 0.29166666666667, 1.1, 0.375
42925, 0.29166666666667, 1.15, 0.375
42926, 0.29166666666667, 1.2, 0.375
42927, 0.29166666666667, 1.25, 0.375
42928, 0.29166666666667, 1.3, 0.375
42929, 0.29166666666667, 0.2, 0.41666666666667
42930, 0.29166666666667, 0.25, 0.41666666666667
42931, 0.29166666666667, 0.3, 0.41666666666667
42932, 0.29166666666667, 0.35, 0.41666666666667
42933, 0.29166666666667, 0.4, 0.41666666666667
42934, 0.29166666666667, 0.45, 0.41666666666667
42935, 0.29166666666667, 0.5, 0.41666666666667
42936, 0.29166666666667, 0.55, 0.41666666666667
42937, 0.29166666666667, 0.6, 0.41666666666667
42938, 0.29166666666667, 0.65, 0.41666666666667
42939, 0.29166666666667, 0.7, 0.41666666666667
42940, 0.29166666666667, 0.75, 0.41666666666667
42941, 0.29166666666667, 0.8, 0.41666666666667
42942, 0.29166666666667, 0.85, 0.41666666666667
42943, 0.29166666666667, 0.9, 0.41666666666667
42944, 0.29166666666667, 0.95, 0.41666666666667
42945, 0.29166666666667, 1, 0.41666666666667
42946, 0.29166666666667, 1.05, 0.41666666666667
42947, 0.29166666666667, 1.1, 0.41666666666667
42948, 0.29166666666667, 1.15, 0.41666666666667
42949, 0.29166666666667, 1.2, 0.41666666666667
42950, 0.29166666666667, 1.25, 0.41666666666667
42951, 0.29166666666667, 1.3, 0.41666666666667
42952, 0.29166666666667, 0.2, 0.45833333333333
42953, 0.29166666666667, 0.25, 0.45833333333333
42954, 0.29166666666667, 0.3, 0.45833333333333
42955, 0.29166666666667, 0.35, 0.45833333333333
42956, 0.29166666666667, 0.4, 0.45833333333333
42957, 0.29166666666667, 0.45, 0.45833333333333
42958, 0.29166666666667, 0.5, 0.45833333333333
42959, 0.29166666666667, 0.55, 0.45833333333333
42960, 0.29166666666667, 0.6, 0.45833333333333
42961, 0.29166666666667, 0.65, 0.45833333333333
42962, 0.29166666666667, 0.7, 0.45833333333333
42963, 0.29166666666667, 0.75, 0.45833333333333
42964, 0.29166666666667, 0.8, 0.45833333333333
42965, 0.29166666666667, 0.85, 0.45833333333333
42966, 0.29166666666667, 0.9, 0.45833333333333
42967, 0.29166666666667, 0.95, 0.45833333333333
42968, 0.29166666666667, 1, 0.45833333333333
42969, 0.29166666666667, 1.05, 0.45833333333333
42970, 0.29166666666667, 1.1, 0.45833333333333
42971, 0.29166666666667, 1.15, 0.45833333333333
42972, 0.29166666666667, 1.2, 0.45833333333333
42973, 0.29166666666667, 1.25, 0.45833333333333
42974, 0.29166666666667, 1.3, 0.45833333333333
42975, 0.33333333333333, 0.2, 0.041666666666667
42976, 0.33333333333333, 0.25, 0.041666666666667
42977, 0.33333333333333, 0.3, 0.041666666666667
42978, 0.33333333333333, 0.35, 0.041666666666667
42979, 0.33333333333333, 0.4, 0.041666666666667
42980, 0.33333333333333, 0.45, 0.041666666666667
42981, 0.33333333333333, 0.5, 0.041666666666667
42982, 0.33333333333333, 0.55, 0.041666666666667
42983, 0.33333333333333, 0.6, 0.041666666666667
42984, 0.33333333333333, 0.65, 0.041666666666667
42985, 0.33333333333333, 0.7, 0.041666666666667
42986, 0.33333333333333, 0.75, 0.041666666666667
42987, 0.33333333333333, 0.8, 0.041666666666667
42988, 0.33333333333333, 0.85, 0.041666666666667
42989, 0.33333333333333, 0.9, 0.041666666666667
42990, 0.33333333333333, 0.95, 0.041666666666667
42991, 0.33333333333333, 1, 0.041666666666667
42992, 0.33333333333333, 1.05, 0.041666666666667
42993, 0.33333333333333, 1.1, 0.041666666666667
42994, 0.33333333333333, 1.15, 0.041666666666667
42995, 0.33333333333333, 1.2, 0.041666666666667
42996, 0.33333333333333, 1.25, 0.041666666666667
42997, 0.33333333333333, 1.3, 0.041666666666667
42998, 0.33333333333333, 0.2, 0.083333333333333
42999, 0.33333333333333, 0.25, 0.083333333333333
43000, 0.33333333333333, 0.3, 0.083333333333333
43001, 0.33333333333333, 0.35, 0.083333333333333
43002, 0.33333333333333, 0.4, 0.083333333333333
43003, 0.33333333333333, 0.45, 0.083333333333333
43004, 0.33333333333333, 0.5, 0.083333333333333
43005, 0.33333333333333, 0.55, 0.083333333333333
43006, 0.33333333333333, 0.6, 0.083333333333333
43007, 0.33333333333333, 0.65, 0.083333333333333
43008, 0.33333333333333, 0.7, 0.083333333333333
43009, 0.33333333333333, 0.75, 0.083333333333333
43010, 0.33333333333333, 0.8, 0.083333333333333
43011, 0.33333333333333, 0.85, 0.083333333333333
43012, 0.33333333333333, 0.9, 0.083333333333333
43013, 0.33333333333333, 0.95, 0.083333333333333
43014, 0.33333333333333, 1, 0.083333333333333
43015, 0.33333333333333, 1.05, 0.083333333333333
43016, 0.33333333333333, 1.1, 0.083333333333333
43017, 0.33333333333333, 1.15, 0.083333333333333
43018, 0.33333333333333, 1.2, 0.083333333333333
43019, 0.33333333333333, 1.25, 0.083333333333333
43020, 0.33333333333333, 1.3, 0.083333333333333
43021, 0.33333333333333, 0.2, 0.125
43022, 0.33333333333333, 0.25, 0.125
43023, 0.33333333333333, 0.3, 0.125
43024, 0.33333333333333, 0.35, 0.125
43025, 0.33333333333333, 0.4, 0.125
43026, 0.33333333333333, 0.45, 0.125
43027, 0.33333333333333, 0.5, 0.125
43028, 0.33333333333333, 0.55, 0.125
43029, 0.33333333333333, 0.6, 0.125
43030, 0.33333333333333, 0.65, 0.125
43031, 0.33333333333333, 0.7, 0.125
43032, 0.33333333333333, 0.75, 0.125
43033, 0.33333333333333, 0.8, 0.125
43034, 0.33333333333333, 0.85, 0.125
43035, 0.33333333333333, 0.9, 0.125
43036, 0.33333333333333, 0.95, 0.125
43037, 0.33333333333333, 1, 0.125
43038, 0.33333333333333, 1.05, 0.125
43039, 0.33333333333333, 1.1, 0.125
43040, 0.33333333333333, 1.15, 0.125
43041, 0.33333333333333, 1.2, 0.125
43042, 0.33333333333333, 1.25, 0.125
43043, 0.33333333333333, 1.3, 0.125
43044, 0.33333333333333, 0.2, 0.16666666666667
43045, 0.33333333333333, 0.25, 0.16666666666667
43046, 0.33333333333333, 0.3, 0.16666666666667
43047, 0.33333333333333, 0.35, 0.16666666666667
43048, 0.33333333333333, 0.4, 0.16666666666667
43049, 0.33333333333333, 0.45, 0.16666666666667
43050, 0.33333333333333, 0.5, 0.16666666666667
43051, 0.33333333333333, 0.55, 0.16666666666667
43052, 0.33333333333333, 0.6, 0.16666666666667
43053, 0.33333333333333, 0.65, 0.16666666666667
43054, 0.33333333333333, 0.7, 0.16666666666667
43055, 0.33333333333333, 0.75, 0.16666666666667
43056, 0.33333333333333, 0.8, 0.16666666666667
43057, 0.33333333333333, 0.85, 0.16666666666667
43058, 0.33333333333333, 0.9, 0.16666666666667
43059, 0.33333333333333, 0.95, 0.16666666666667
43060, 0.33333333333333, 1, 0.16666666666667
43061, 0.33333333333333, 1.05, 0.16666666666667
43062, 0.33333333333333, 1.1, 0.16666666666667
43063, 0.33333333333333, 1.15, 0.16666666666667
43064, 0.33333333333333, 1.2, 0.16666666666667
43065, 0.33333333333333, 1.25, 0.16666666666667
43066, 0.33333333333333, 1.3, 0.16666666666667
43067, 0.33333333333333, 0.2, 0.20833333333333
43068, 0.33333333333333, 0.25, 0.20833333333333
43069, 0.33333333333333, 0.3, 0.20833333333333
43070, 0.33333333333333, 0.35, 0.20833333333333
43071, 0.33333333333333, 0.4, 0.20833333333333
43072, 0.33333333333333, 0.45, 0.20833333333333
43073, 0.33333333333333, 0.5, 0.20833333333333
43074, 0.33333333333333, 0.55, 0.20833333333333
43075, 0.33333333333333, 0.6, 0.20833333333333
43076, 0.33333333333333, 0.65, 0.20833333333333
43077, 0.33333333333333, 0.7, 0.20833333333333
43078, 0.33333333333333, 0.75, 0.20833333333333
43079, 0.33333333333333, 0.8, 0.20833333333333
43080, 0.33333333333333, 0.85, 0.20833333333333
43081, 0.33333333333333, 0.9, 0.20833333333333
43082, 0.33333333333333, 0.95, 0.20833333333333
43083, 0.33333333333333, 1, 0.20833333333333
43084, 0.33333333333333, 1.05, 0.20833333333333
43085, 0.33333333333333, 1.1, 0.20833333333333
43086, 0.33333333333333, 1.15, 0.20833333333333
43087, 0.33333333333333, 1.2, 0.20833333333333
43088, 0.33333333333333, 1.25, 0.20833333333333
43089, 0.33333333333333, 1.3, 0.20833333333333
43090, 0.33333333333333, 0.2, 0.25
43091, 0.33333333333333, 0.25, 0.25
43092, 0.33333333333333, 0.3, 0.25
43093, 0.33333333333333, 0.35, 0.25
43094, 0.33333333333333, 0.4, 0.25
43095, 0.33333333333333, 0.45, 0.25
43096, 0.33333333333333, 0.5, 0.25
43097, 0.33333333333333, 0.55, 0.25
43098, 0.33333333333333, 0.6, 0.25
43099, 0.33333333333333, 0.65, 0.25
43100, 0.33333333333333, 0.7, 0.25
43101, 0.33333333333333, 0.75, 0.25
43102, 0.33333333333333, 0.8, 0.25
43103, 0.33333333333333, 0.85, 0.25
43104, 0.33333333333333, 0.9, 0.25
43105, 0.33333333333333, 0.95, 0.25
43106, 0.33333333333333, 1, 0.25
43107, 0.33333333333333, 1.05, 0.25
43108, 0.33333333333333, 1.1, 0.25
43109, 0.33333333333333, 1.15, 0.25
43110, 0.33333333333333, 1.2, 0.25
43111, 0.33333333333333, 1.25, 0.25
43112, 0.33333333333333, 1.3, 0.25
43113, 0.33333333333333, 0.2, 0.29166666666667
43114, 0.33333333333333, 0.25, 0.29166666666667
43115, 0.33333333333333, 0.3, 0.29166666666667
43116, 0.33333333333333, 0.35, 0.29166666666667
43117, 0.33333333333333, 0.4, 0.29166666666667
43118, 0.33333333333333, 0.45, 0.29166666666667
43119, 0.33333333333333, 0.5, 0.29166666666667
43120, 0.33333333333333, 0.55, 0.29166666666667
43121, 0.33333333333333, 0.6, 0.29166666666667
43122, 0.33333333333333, 0.65, 0.29166666666667
43123, 0.33333333333333, 0.7, 0.29166666666667
43124, 0.33333333333333, 0.75, 0.29166666666667
43125, 0.33333333333333, 0.8, 0.29166666666667
43126, 0.33333333333333, 0.85, 0.29166666666667
43127, 0.33333333333333, 0.9, 0.29166666666667
43128, 0.33333333333333, 0.95, 0.29166666666667
43129, 0.33333333333333, 1, 0.29166666666667
43130, 0.33333333333333, 1.05, 0.29166666666667
43131, 0.33333333333333, 1.1, 0.29166666666667
43132, 0.33333333333333, 1.15, 0.29166666666667
43133, 0.33333333333333, 1.2, 0.29166666666667
43134, 0.33333333333333, 1.25, 0.29166666666667
43135, 0.33333333333333, 1.3, 0.29166666666667
43136, 0.33333333333333, 0.2, 0.33333333333333
43137, 0.33333333333333, 0.25, 0.33333333333333
43138, 0.33333333333333, 0.3, 0.33333333333333
43139, 0.33333333333333, 0.35, 0.33333333333333
43140, 0.33333333333333, 0.4, 0.33333333333333
43141, 0.33333333333333, 0.45, 0.33333333333333
43142, 0.33333333333333, 0.5, 0.33333333333333
43143, 0.33333333333333, 0.55, 0.33333333333333
43144, 0.33333333333333, 0.6, 0.33333333333333
43145, 0.33333333333333, 0.65, 0.33333333333333
43146, 0.33333333333333, 0.7, 0.33333333333333
43147, 0.33333333333333, 0.75, 0.33333333333333
43148, 0.33333333333333, 0.8, 0.33333333333333
43149, 0.33333333333333, 0.85, 0.33333333333333
43150, 0.33333333333333, 0.9, 0.33333333333333
43151, 0.33333333333333, 0.95, 0.33333333333333
43152, 0.33333333333333, 1, 0.33333333333333
43153, 0.33333333333333, 1.05, 0.33333333333333
43154, 0.33333333333333, 1.1, 0.33333333333333
43155, 0.33333333333333, 1.15, 0.33333333333333
43156, 0.33333333333333, 1.2, 0.33333333333333
43157, 0.33333333333333, 1.25, 0.33333333333333
43158, 0.33333333333333, 1.3, 0.33333333333333
43159, 0.33333333333333, 0.2, 0.375
43160, 0.33333333333333, 0.25, 0.375
43161, 0.33333333333333, 0.3, 0.375
43162, 0.33333333333333, 0.35, 0.375
43163, 0.33333333333333, 0.4, 0.375
43164, 0.33333333333333, 0.45, 0.375
43165, 0.33333333333333, 0.5, 0.375
43166, 0.33333333333333, 0.55, 0.375
43167, 0.33333333333333, 0.6, 0.375
43168, 0.33333333333333, 0.65, 0.375
43169, 0.33333333333333, 0.7, 0.375
43170, 0.33333333333333, 0.75, 0.375
43171, 0.33333333333333, 0.8, 0.375
43172, 0.33333333333333, 0.85, 0.375
43173, 0.33333333333333, 0.9, 0.375
43174, 0.33333333333333, 0.95, 0.375
43175, 0.33333333333333, 1, 0.375
43176, 0.33333333333333, 1.05, 0.375
43177, 0.33333333333333, 1.1, 0.375
43178, 0.33333333333333, 1.15, 0.375
43179, 0.33333333333333, 1.2, 0.375
43180, 0.33333333333333, 1.25, 0.375
43181, 0.33333333333333, 1.3, 0.375
43182, 0.33333333333333, 0.2, 0.41666666666667
43183, 0.33333333333333, 0.25, 0.41666666666667
43184, 0.33333333333333, 0.3, 0.41666666666667
43185, 0.33333333333333, 0.35, 0.41666666666667
43186, 0.33333333333333, 0.4, 0.41666666666667
43187, 0.33333333333333, 0.45, 0.41666666666667
43188, 0.33333333333333, 0.5, 0.41666666666667
43189, 0.33333333333333, 0.55, 0.41666666666667
43190, 0.33333333333333, 0.6, 0.41666666666667
43191, 0.33333333333333, 0.65, 0.41666666666667
43192, 0.33333333333333, 0.7, 0.41666666666667
43193, 0.33333333333333, 0.75, 0.41666666666667
43194, 0.33333333333333, 0.8, 0.41666666666667
43195, 0.33333333333333, 0.85, 0.41666666666667
43196, 0.33333333333333, 0.9, 0.41666666666667
43197, 0.33333333333333, 0.95, 0.41666666666667
43198, 0.33333333333333, 1, 0.41666666666667
43199, 0.33333333333333, 1.05, 0.41666666666667
43200, 0.33333333333333, 1.1, 0.41666666666667
43201, 0.33333333333333, 1.15, 0.41666666666667
43202, 0.33333333333333, 1.2, 0.41666666666667
43203, 0.33333333333333, 1.25, 0.41666666666667
43204, 0.33333333333333, 1.3, 0.41666666666667
43205, 0.33333333333333, 0.2, 0.45833333333333
43206, 0.33333333333333, 0.25, 0.45833333333333
43207, 0.33333333333333, 0.3, 0.45833333333333
43208, 0.33333333333333, 0.35, 0.45833333333333
43209, 0.33333333333333, 0.4, 0.45833333333333
43210, 0.33333333333333, 0.45, 0.45833333333333
43211, 0.33333333333333, 0.5, 0.45833333333333
43212, 0.33333333333333, 0.55, 0.45833333333333
43213, 0.33333333333333, 0.6, 0.45833333333333
43214, 0.33333333333333, 0.65, 0.45833333333333
43215, 0.33333333333333, 0.7, 0.45833333333333
43216, 0.33333333333333, 0.75, 0.45833333333333
43217, 0.33333333333333, 0.8, 0.45833333333333
43218, 0.33333333333333, 0.85, 0.45833333333333
43219, 0.33333333333333, 0.9, 0.45833333333333
43220, 0.33333333333333, 0.95, 0.45833333333333
43221, 0.33333333333333, 1, 0.45833333333333
43222, 0.33333333333333, 1.05, 0.45833333333333
43223, 0.33333333333333, 1.1, 0.45833333333333
43224, 0.33333333333333, 1.15, 0.45833333333333
43225, 0.33333333333333, 1.2, 0.45833333333333
43226, 0.33333333333333, 1.25, 0.45833333333333
43227, 0.33333333333333, 1.3, 0.45833333333333
43228, 0.375, 0.2, 0.041666666666667
43229, 0.375, 0.25, 0.041666666666667
43230, 0.375, 0.3, 0.041666666666667
43231, 0.375, 0.35, 0.041666666666667
43232, 0.375, 0.4, 0.041666666666667
43233, 0.375, 0.45, 0.041666666666667
43234, 0.375, 0.5, 0.041666666666667
43235, 0.375, 0.55, 0.041666666666667
43236, 0.375, 0.6, 0.041666666666667
43237, 0.375, 0.65, 0.041666666666667
43238, 0.375, 0.7, 0.041666666666667
43239, 0.375, 0.75, 0.041666666666667
43240, 0.375, 0.8, 0.041666666666667
43241, 0.375, 0.85, 0.041666666666667
43242, 0.375, 0.9, 0.041666666666667
43243, 0.375, 0.95, 0.041666666666667
43244, 0.375, 1, 0.041666666666667
43245, 0.375, 1.05, 0.041666666666667
43246, 0.375, 1.1, 0.041666666666667
43247, 0.375, 1.15, 0.041666666666667
43248, 0.375, 1.2, 0.041666666666667
43249, 0.375, 1.25, 0.041666666666667
43250, 0.375, 1.3, 0.041666666666667
43251, 0.375, 0.2, 0.083333333333333
43252, 0.375, 0.25, 0.083333333333333
43253, 0.375, 0.3, 0.083333333333333
43254, 0.375, 0.35, 0.083333333333333
43255, 0.375, 0.4, 0.083333333333333
43256, 0.375, 0.45, 0.083333333333333
43257, 0.375, 0.5, 0.083333333333333
43258, 0.375, 0.55, 0.083333333333333
43259, 0.375, 0.6, 0.083333333333333
43260, 0.375, 0.65, 0.083333333333333
43261, 0.375, 0.7, 0.083333333333333
43262, 0.375, 0.75, 0.083333333333333
43263, 0.375, 0.8, 0.083333333333333
43264, 0.375, 0.85, 0.083333333333333
43265, 0.375, 0.9, 0.083333333333333
43266, 0.375, 0.95, 0.083333333333333
43267, 0.375, 1, 0.083333333333333
43268, 0.375, 1.05, 0.083333333333333
43269, 0.375, 1.1, 0.083333333333333
43270, 0.375, 1.15, 0.083333333333333
43271, 0.375, 1.2, 0.083333333333333
43272, 0.375, 1.25, 0.083333333333333
43273, 0.375, 1.3, 0.083333333333333
43274, 0.375, 0.2, 0.125
43275, 0.375, 0.25, 0.125
43276, 0.375, 0.3, 0.125
43277, 0.375, 0.35, 0.125
43278, 0.375, 0.4, 0.125
43279, 0.375, 0.45, 0.125
43280, 0.375, 0.5, 0.125
43281, 0.375, 0.55, 0.125
43282, 0.375, 0.6, 0.125
43283, 0.375, 0.65, 0.125
43284, 0.375, 0.7, 0.125
43285, 0.375, 0.75, 0.125
43286, 0.375, 0.8, 0.125
43287, 0.375, 0.85, 0.125
43288, 0.375, 0.9, 0.125
43289, 0.375, 0.95, 0.125
43290, 0.375, 1, 0.125
43291, 0.375, 1.05, 0.125
43292, 0.375, 1.1, 0.125
43293, 0.375, 1.15, 0.125
43294, 0.375, 1.2, 0.125
43295, 0.375, 1.25, 0.125
43296, 0.375, 1.3, 0.125
43297, 0.375, 0.2, 0.16666666666667
43298, 0.375, 0.25, 0.16666666666667
43299, 0.375, 0.3, 0.16666666666667
43300, 0.375, 0.35, 0.16666666666667
43301, 0.375, 0.4, 0.16666666666667
43302, 0.375, 0.45, 0.16666666666667
43303, 0.375, 0.5, 0.16666666666667
43304, 0.375, 0.55, 0.16666666666667
43305, 0.375, 0.6, 0.16666666666667
43306, 0.375, 0.65, 0.16666666666667
43307, 0.375, 0.7, 0.16666666666667
43308, 0.375, 0.75, 0.16666666666667
43309, 0.375, 0.8, 0.16666666666667
43310, 0.375, 0.85, 0.16666666666667
43311, 0.375, 0.9, 0.16666666666667
43312, 0.375, 0.95, 0.16666666666667
43313, 0.375, 1, 0.16666666666667
43314, 0.375, 1.05, 0.16666666666667
43315, 0.375, 1.1, 0.16666666666667
43316, 0.375, 1.15, 0.16666666666667
43317, 0.375, 1.2, 0.16666666666667
43318, 0.375, 1.25, 0.16666666666667
43319, 0.375, 1.3, 0.16666666666667
43320, 0.375, 0.2, 0.20833333333333
43321, 0.375, 0.25, 0.20833333333333
43322, 0.375, 0.3, 0.20833333333333
43323, 0.375, 0.35, 0.20833333333333
43324, 0.375, 0.4, 0.20833333333333
43325, 0.375, 0.45, 0.20833333333333
43326, 0.375, 0.5, 0.20833333333333
43327, 0.375, 0.55, 0.20833333333333
43328, 0.375, 0.6, 0.20833333333333
43329, 0.375, 0.65, 0.20833333333333
43330, 0.375, 0.7, 0.20833333333333
43331, 0.375, 0.75, 0.20833333333333
43332, 0.375, 0.8, 0.20833333333333
43333, 0.375, 0.85, 0.20833333333333
43334, 0.375, 0.9, 0.20833333333333
43335, 0.375, 0.95, 0.20833333333333
43336, 0.375, 1, 0.20833333333333
43337, 0.375, 1.05, 0.20833333333333
43338, 0.375, 1.1, 0.20833333333333
43339, 0.375, 1.15, 0.20833333333333
43340, 0.375, 1.2, 0.20833333333333
43341, 0.375, 1.25, 0.20833333333333
43342, 0.375, 1.3, 0.20833333333333
43343, 0.375, 0.2, 0.25
43344, 0.375, 0.25, 0.25
43345, 0.375, 0.3, 0.25
43346, 0.375, 0.35, 0.25
43347, 0.375, 0.4, 0.25
43348, 0.375, 0.45, 0.25
43349, 0.375, 0.5, 0.25
43350, 0.375, 0.55, 0.25
43351, 0.375, 0.6, 0.25
43352, 0.375, 0.65, 0.25
43353, 0.375, 0.7, 0.25
43354, 0.375, 0.75, 0.25
43355, 0.375, 0.8, 0.25
43356, 0.375, 0.85, 0.25
43357, 0.375, 0.9, 0.25
43358, 0.375, 0.95, 0.25
43359, 0.375, 1, 0.25
43360, 0.375, 1.05, 0.25
43361, 0.375, 1.1, 0.25
43362, 0.375, 1.15, 0.25
43363, 0.375, 1.2, 0.25
43364, 0.375, 1.25, 0.25
43365, 0.375, 1.3, 0.25
43366, 0.375, 0.2, 0.29166666666667
43367, 0.375, 0.25, 0.29166666666667
43368, 0.375, 0.3, 0.29166666666667
43369, 0.375, 0.35, 0.29166666666667
43370, 0.375, 0.4, 0.29166666666667
43371, 0.375, 0.45, 0.29166666666667
43372, 0.375, 0.5, 0.29166666666667
43373, 0.375, 0.55, 0.29166666666667
43374, 0.375, 0.6, 0.29166666666667
43375, 0.375, 0.65, 0.29166666666667
43376, 0.375, 0.7, 0.29166666666667
43377, 0.375, 0.75, 0.29166666666667
43378, 0.375, 0.8, 0.29166666666667
43379, 0.375, 0.85, 0.29166666666667
43380, 0.375, 0.9, 0.29166666666667
43381, 0.375, 0.95, 0.29166666666667
43382, 0.375, 1, 0.29166666666667
43383, 0.375, 1.05, 0.29166666666667
43384, 0.375, 1.1, 0.29166666666667
43385, 0.375, 1.15, 0.29166666666667
43386, 0.375, 1.2, 0.29166666666667
43387, 0.375, 1.25, 0.29166666666667
43388, 0.375, 1.3, 0.29166666666667
43389, 0.375, 0.2, 0.33333333333333
43390, 0.375, 0.25, 0.33333333333333
43391, 0.375, 0.3, 0.33333333333333
43392, 0.375, 0.35, 0.33333333333333
43393, 0.375, 0.4, 0.33333333333333
43394, 0.375, 0.45, 0.33333333333333
43395, 0.375, 0.5, 0.33333333333333
43396, 0.375, 0.55, 0.33333333333333
43397, 0.375, 0.6, 0.33333333333333
43398, 0.375, 0.65, 0.33333333333333
43399, 0.375, 0.7, 0.33333333333333
43400, 0.375, 0.75, 0.33333333333333
43401, 0.375, 0.8, 0.33333333333333
43402, 0.375, 0.85, 0.33333333333333
43403, 0.375, 0.9, 0.33333333333333
43404, 0.375, 0.95, 0.33333333333333
43405, 0.375, 1, 0.33333333333333
43406, 0.375, 1.05, 0.33333333333333
43407, 0.375, 1.1, 0.33333333333333
43408, 0.375, 1.15, 0.33333333333333
43409, 0.375, 1.2, 0.33333333333333
43410, 0.375, 1.25, 0.33333333333333
43411, 0.375, 1.3, 0.33333333333333
43412, 0.375, 0.2, 0.375
43413, 0.375, 0.25, 0.375
43414, 0.375, 0.3, 0.375
43415, 0.375, 0.35, 0.375
43416, 0.375, 0.4, 0.375
43417, 0.375, 0.45, 0.375
43418, 0.375, 0.5, 0.375
43419, 0.375, 0.55, 0.375
43420, 0.375, 0.6, 0.375
43421, 0.375, 0.65, 0.375
43422, 0.375, 0.7, 0.375
43423, 0.375, 0.75, 0.375
43424, 0.375, 0.8, 0.375
43425, 0.375, 0.85, 0.375
43426, 0.375, 0.9, 0.375
43427, 0.375, 0.95, 0.375
43428, 0.375, 1, 0.375
43429, 0.375, 1.05, 0.375
43430, 0.375, 1.1, 0.375
43431, 0.375, 1.15, 0.375
43432, 0.375, 1.2, 0.375
43433, 0.375, 1.25, 0.375
43434, 0.375, 1.3, 0.375
43435, 0.375, 0.2, 0.41666666666667
43436, 0.375, 0.25, 0.41666666666667
43437, 0.375, 0.3, 0.41666666666667
43438, 0.375, 0.35, 0.41666666666667
43439, 0.375, 0.4, 0.41666666666667
43440, 0.375, 0.45, 0.41666666666667
43441, 0.375, 0.5, 0.41666666666667
43442, 0.375, 0.55, 0.41666666666667
43443, 0.375, 0.6, 0.41666666666667
43444, 0.375, 0.65, 0.41666666666667
43445, 0.375, 0.7, 0.41666666666667
43446, 0.375, 0.75, 0.41666666666667
43447, 0.375, 0.8, 0.41666666666667
43448, 0.375, 0.85, 0.41666666666667
43449, 0.375, 0.9, 0.41666666666667
43450, 0.375, 0.95, 0.41666666666667
43451, 0.375, 1, 0.41666666666667
43452, 0.375, 1.05, 0.41666666666667
43453, 0.375, 1.1, 0.41666666666667
43454, 0.375, 1.15, 0.41666666666667
43455, 0.375, 1.2, 0.41666666666667
43456, 0.375, 1.25, 0.41666666666667
43457, 0.375, 1.3, 0.41666666666667
43458, 0.375, 0.2, 0.45833333333333
43459, 0.375, 0.25, 0.45833333333333
43460, 0.375, 0.3, 0.45833333333333
43461, 0.375, 0.35, 0.45833333333333
43462, 0.375, 0.4, 0.45833333333333
43463, 0.375, 0.45, 0.45833333333333
43464, 0.375, 0.5, 0.45833333333333
43465, 0.375, 0.55, 0.45833333333333
43466, 0.375, 0.6, 0.45833333333333
43467, 0.375, 0.65, 0.45833333333333
43468, 0.375, 0.7, 0.45833333333333
43469, 0.375, 0.75, 0.45833333333333
43470, 0.375, 0.8, 0.45833333333333
43471, 0.375, 0.85, 0.45833333333333
43472, 0.375, 0.9, 0.45833333333333
43473, 0.375, 0.95, 0.45833333333333
43474, 0.375, 1, 0.45833333333333
43475, 0.375, 1.05, 0.45833333333333
43476, 0.375, 1.1, 0.45833333333333
43477, 0.375, 1.15, 0.45833333333333
43478, 0.375, 1.2, 0.45833333333333
43479, 0.375, 1.25, 0.45833333333333
43480, 0.375, 1.3, 0.45833333333333
43481, 0.41666666666667, 0.2, 0.041666666666667
43482, 0.41666666666667, 0.25, 0.041666666666667
43483, 0.41666666666667, 0.3, 0.041666666666667
43484, 0.41666666666667, 0.35, 0.041666666666667
43485, 0.41666666666667, 0.4, 0.041666666666667
43486, 0.41666666666667, 0.45, 0.041666666666667
43487, 0.41666666666667, 0.5, 0.041666666666667
43488, 0.41666666666667, 0.55, 0.041666666666667
43489, 0.41666666666667, 0.6, 0.041666666666667
43490, 0.41666666666667, 0.65, 0.041666666666667
43491, 0.41666666666667, 0.7, 0.041666666666667
43492, 0.41666666666667, 0.75, 0.041666666666667
43493, 0.41666666666667, 0.8, 0.041666666666667
43494, 0.41666666666667, 0.85, 0.041666666666667
43495, 0.41666666666667, 0.9, 0.041666666666667
43496, 0.41666666666667, 0.95, 0.041666666666667
43497, 0.41666666666667, 1, 0.041666666666667
43498, 0.41666666666667, 1.05, 0.041666666666667
43499, 0.41666666666667, 1.1, 0.041666666666667
43500, 0.41666666666667, 1.15, 0.041666666666667
43501, 0.41666666666667, 1.2, 0.041666666666667
43502, 0.41666666666667, 1.25, 0.041666666666667
43503, 0.41666666666667, 1.3, 0.041666666666667
43504, 0.41666666666667, 0.2, 0.083333333333333
43505, 0.41666666666667, 0.25, 0.083333333333333
43506, 0.41666666666667, 0.3, 0.083333333333333
43507, 0.41666666666667, 0.35, 0.083333333333333
43508, 0.41666666666667, 0.4, 0.083333333333333
43509, 0.41666666666667, 0.45, 0.083333333333333
43510, 0.41666666666667, 0.5, 0.083333333333333
43511, 0.41666666666667, 0.55, 0.083333333333333
43512, 0.41666666666667, 0.6, 0.083333333333333
43513, 0.41666666666667, 0.65, 0.083333333333333
43514, 0.41666666666667, 0.7, 0.083333333333333
43515, 0.41666666666667, 0.75, 0.083333333333333
43516, 0.41666666666667, 0.8, 0.083333333333333
43517, 0.41666666666667, 0.85, 0.083333333333333
43518, 0.41666666666667, 0.9, 0.083333333333333
43519, 0.41666666666667, 0.95, 0.083333333333333
43520, 0.41666666666667, 1, 0.083333333333333
43521, 0.41666666666667, 1.05, 0.083333333333333
43522, 0.41666666666667, 1.1, 0.083333333333333
43523, 0.41666666666667, 1.15, 0.083333333333333
43524, 0.41666666666667, 1.2, 0.083333333333333
43525, 0.41666666666667, 1.25, 0.083333333333333
43526, 0.41666666666667, 1.3, 0.083333333333333
43527, 0.41666666666667, 0.2, 0.125
43528, 0.41666666666667, 0.25, 0.125
43529, 0.41666666666667, 0.3, 0.125
43530, 0.41666666666667, 0.35, 0.125
43531, 0.41666666666667, 0.4, 0.125
43532, 0.41666666666667, 0.45, 0.125
43533, 0.41666666666667, 0.5, 0.125
43534, 0.41666666666667, 0.55, 0.125
43535, 0.41666666666667, 0.6, 0.125
43536, 0.41666666666667, 0.65, 0.125
43537, 0.41666666666667, 0.7, 0.125
43538, 0.41666666666667, 0.75, 0.125
43539, 0.41666666666667, 0.8, 0.125
43540, 0.41666666666667, 0.85, 0.125
43541, 0.41666666666667, 0.9, 0.125
43542, 0.41666666666667, 0.95, 0.125
43543, 0.41666666666667, 1, 0.125
43544, 0.41666666666667, 1.05, 0.125
43545, 0.41666666666667, 1.1, 0.125
43546, 0.41666666666667, 1.15, 0.125
43547, 0.41666666666667, 1.2, 0.125
43548, 0.41666666666667, 1.25, 0.125
43549, 0.41666666666667, 1.3, 0.125
43550, 0.41666666666667, 0.2, 0.16666666666667
43551, 0.41666666666667, 0.25, 0.16666666666667
43552, 0.41666666666667, 0.3, 0.16666666666667
43553, 0.41666666666667, 0.35, 0.16666666666667
43554, 0.41666666666667, 0.4, 0.16666666666667
43555, 0.41666666666667, 0.45, 0.16666666666667
43556, 0.41666666666667, 0.5, 0.16666666666667
43557, 0.41666666666667, 0.55, 0.16666666666667
43558, 0.41666666666667, 0.6, 0.16666666666667
43559, 0.41666666666667, 0.65, 0.16666666666667
43560, 0.41666666666667, 0.7, 0.16666666666667
43561, 0.41666666666667, 0.75, 0.16666666666667
43562, 0.41666666666667, 0.8, 0.16666666666667
43563, 0.41666666666667, 0.85, 0.16666666666667
43564, 0.41666666666667, 0.9, 0.16666666666667
43565, 0.41666666666667, 0.95, 0.16666666666667
43566, 0.41666666666667, 1, 0.16666666666667
43567, 0.41666666666667, 1.05, 0.16666666666667
43568, 0.41666666666667, 1.1, 0.16666666666667
43569, 0.41666666666667, 1.15, 0.16666666666667
43570, 0.41666666666667, 1.2, 0.16666666666667
43571, 0.41666666666667, 1.25, 0.16666666666667
43572, 0.41666666666667, 1.3, 0.16666666666667
43573, 0.41666666666667, 0.2, 0.20833333333333
43574, 0.41666666666667, 0.25, 0.20833333333333
43575, 0.41666666666667, 0.3, 0.20833333333333
43576, 0.41666666666667, 0.35, 0.20833333333333
43577, 0.41666666666667, 0.4, 0.20833333333333
43578, 0.41666666666667, 0.45, 0.20833333333333
43579, 0.41666666666667, 0.5, 0.20833333333333
43580, 0.41666666666667, 0.55, 0.20833333333333
43581, 0.41666666666667, 0.6, 0.20833333333333
43582, 0.41666666666667, 0.65, 0.20833333333333
43583, 0.41666666666667, 0.7, 0.20833333333333
43584, 0.41666666666667, 0.75, 0.20833333333333
43585, 0.41666666666667, 0.8, 0.20833333333333
43586, 0.41666666666667, 0.85, 0.20833333333333
43587, 0.41666666666667, 0.9, 0.20833333333333
43588, 0.41666666666667, 0.95, 0.20833333333333
43589, 0.41666666666667, 1, 0.20833333333333
43590, 0.41666666666667, 1.05, 0.20833333333333
43591, 0.41666666666667, 1.1, 0.20833333333333
43592, 0.41666666666667, 1.15, 0.20833333333333
43593, 0.41666666666667, 1.2, 0.20833333333333
43594, 0.41666666666667, 1.25, 0.20833333333333
43595, 0.41666666666667, 1.3, 0.20833333333333
43596, 0.41666666666667, 0.2, 0.25
43597, 0.41666666666667, 0.25, 0.25
43598, 0.41666666666667, 0.3, 0.25
43599, 0.41666666666667, 0.35, 0.25
43600, 0.41666666666667, 0.4, 0.25
43601, 0.41666666666667, 0.45, 0.25
43602, 0.41666666666667, 0.5, 0.25
43603, 0.41666666666667, 0.55, 0.25
43604, 0.41666666666667, 0.6, 0.25
43605, 0.41666666666667, 0.65, 0.25
43606, 0.41666666666667, 0.7, 0.25
43607, 0.41666666666667, 0.75, 0.25
43608, 0.41666666666667, 0.8, 0.25
43609, 0.41666666666667, 0.85, 0.25
43610, 0.41666666666667, 0.9, 0.25
43611, 0.41666666666667, 0.95, 0.25
43612, 0.41666666666667, 1, 0.25
43613, 0.41666666666667, 1.05, 0.25
43614, 0.41666666666667, 1.1, 0.25
43615, 0.41666666666667, 1.15, 0.25
43616, 0.41666666666667, 1.2, 0.25
43617, 0.41666666666667, 1.25, 0.25
43618, 0.41666666666667, 1.3, 0.25
43619, 0.41666666666667, 0.2, 0.29166666666667
43620, 0.41666666666667, 0.25, 0.29166666666667
43621, 0.41666666666667, 0.3, 0.29166666666667
43622, 0.41666666666667, 0.35, 0.29166666666667
43623, 0.41666666666667, 0.4, 0.29166666666667
43624, 0.41666666666667, 0.45, 0.29166666666667
43625, 0.41666666666667, 0.5, 0.29166666666667
43626, 0.41666666666667, 0.55, 0.29166666666667
43627, 0.41666666666667, 0.6, 0.29166666666667
43628, 0.41666666666667, 0.65, 0.29166666666667
43629, 0.41666666666667, 0.7, 0.29166666666667
43630, 0.41666666666667, 0.75, 0.29166666666667
43631, 0.41666666666667, 0.8, 0.29166666666667
43632, 0.41666666666667, 0.85, 0.29166666666667
43633, 0.41666666666667, 0.9, 0.29166666666667
43634, 0.41666666666667, 0.95, 0.29166666666667
43635, 0.41666666666667, 1, 0.29166666666667
43636, 0.41666666666667, 1.05, 0.29166666666667
43637, 0.41666666666667, 1.1, 0.29166666666667
43638, 0.41666666666667, 1.15, 0.29166666666667
43639, 0.41666666666667, 1.2, 0.29166666666667
43640, 0.41666666666667, 1.25, 0.29166666666667
43641, 0.41666666666667, 1.3, 0.29166666666667
43642, 0.41666666666667, 0.2, 0.33333333333333
43643, 0.41666666666667, 0.25, 0.33333333333333
43644, 0.41666666666667, 0.3, 0.33333333333333
43645, 0.41666666666667, 0.35, 0.33333333333333
43646, 0.41666666666667, 0.4, 0.33333333333333
43647, 0.41666666666667, 0.45, 0.33333333333333
43648, 0.41666666666667, 0.5, 0.33333333333333
43649, 0.41666666666667, 0.55, 0.33333333333333
43650, 0.41666666666667, 0.6, 0.33333333333333
43651, 0.41666666666667, 0.65, 0.33333333333333
43652, 0.41666666666667, 0.7, 0.33333333333333
43653, 0.41666666666667, 0.75, 0.33333333333333
43654, 0.41666666666667, 0.8, 0.33333333333333
43655, 0.41666666666667, 0.85, 0.33333333333333
43656, 0.41666666666667, 0.9, 0.33333333333333
43657, 0.41666666666667, 0.95, 0.33333333333333
43658, 0.41666666666667, 1, 0.33333333333333
43659, 0.41666666666667, 1.05, 0.33333333333333
43660, 0.41666666666667, 1.1, 0.33333333333333
43661, 0.41666666666667, 1.15, 0.33333333333333
43662, 0.41666666666667, 1.2, 0.33333333333333
43663, 0.41666666666667, 1.25, 0.33333333333333
43664, 0.41666666666667, 1.3, 0.33333333333333
43665, 0.41666666666667, 0.2, 0.375
43666, 0.41666666666667, 0.25, 0.375
43667, 0.41666666666667, 0.3, 0.375
43668, 0.41666666666667, 0.35, 0.375
43669, 0.41666666666667, 0.4, 0.375
43670, 0.41666666666667, 0.45, 0.375
43671, 0.41666666666667, 0.5, 0.375
43672, 0.41666666666667, 0.55, 0.375
43673, 0.41666666666667, 0.6, 0.375
43674, 0.41666666666667, 0.65, 0.375
43675, 0.41666666666667, 0.7, 0.375
43676, 0.41666666666667, 0.75, 0.375
43677, 0.41666666666667, 0.8, 0.375
43678, 0.41666666666667, 0.85, 0.375
43679, 0.41666666666667, 0.9, 0.375
43680, 0.41666666666667, 0.95, 0.375
43681, 0.41666666666667, 1, 0.375
43682, 0.41666666666667, 1.05, 0.375
43683, 0.41666666666667, 1.1, 0.375
43684, 0.41666666666667, 1.15, 0.375
43685, 0.41666666666667, 1.2, 0.375
43686, 0.41666666666667, 1.25, 0.375
43687, 0.41666666666667, 1.3, 0.375
43688, 0.41666666666667, 0.2, 0.41666666666667
43689, 0.41666666666667, 0.25, 0.41666666666667
43690, 0.41666666666667, 0.3, 0.41666666666667
43691, 0.41666666666667, 0.35, 0.41666666666667
43692, 0.41666666666667, 0.4, 0.41666666666667
43693, 0.41666666666667, 0.45, 0.41666666666667
43694, 0.41666666666667, 0.5, 0.41666666666667
43695, 0.41666666666667, 0.55, 0.41666666666667
43696, 0.41666666666667, 0.6, 0.41666666666667
43697, 0.41666666666667, 0.65, 0.41666666666667
43698, 0.41666666666667, 0.7, 0.41666666666667
43699, 0.41666666666667, 0.75, 0.41666666666667
43700, 0.41666666666667, 0.8, 0.41666666666667
43701, 0.41666666666667, 0.85, 0.41666666666667
43702, 0.41666666666667, 0.9, 0.41666666666667
43703, 0.41666666666667, 0.95, 0.41666666666667
43704, 0.41666666666667, 1, 0.41666666666667
43705, 0.41666666666667, 1.05, 0.41666666666667
43706, 0.41666666666667, 1.1, 0.41666666666667
43707, 0.41666666666667, 1.15, 0.41666666666667
43708, 0.41666666666667, 1.2, 0.41666666666667
43709, 0.41666666666667, 1.25, 0.41666666666667
43710, 0.41666666666667, 1.3, 0.41666666666667
43711, 0.41666666666667, 0.2, 0.45833333333333
43712, 0.41666666666667, 0.25, 0.45833333333333
43713, 0.41666666666667, 0.3, 0.45833333333333
43714, 0.41666666666667, 0.35, 0.45833333333333
43715, 0.41666666666667, 0.4, 0.45833333333333
43716, 0.41666666666667, 0.45, 0.45833333333333
43717, 0.41666666666667, 0.5, 0.45833333333333
43718, 0.41666666666667, 0.55, 0.45833333333333
43719, 0.41666666666667, 0.6, 0.45833333333333
43720, 0.41666666666667, 0.65, 0.45833333333333
43721, 0.41666666666667, 0.7, 0.45833333333333
43722, 0.41666666666667, 0.75, 0.45833333333333
43723, 0.41666666666667, 0.8, 0.45833333333333
43724, 0.41666666666667, 0.85, 0.45833333333333
43725, 0.41666666666667, 0.9, 0.45833333333333
43726, 0.41666666666667, 0.95, 0.45833333333333
43727, 0.41666666666667, 1, 0.45833333333333
43728, 0.41666666666667, 1.05, 0.45833333333333
43729, 0.41666666666667, 1.1, 0.45833333333333
43730, 0.41666666666667, 1.15, 0.45833333333333
43731, 0.41666666666667, 1.2, 0.45833333333333
43732, 0.41666666666667, 1.25, 0.45833333333333
43733, 0.41666666666667, 1.3, 0.45833333333333
43734, 0.45833333333333, 0.2, 0.041666666666667
43735, 0.45833333333333, 0.25, 0.041666666666667
43736, 0.45833333333333, 0.3, 0.041666666666667
43737, 0.45833333333333, 0.35, 0.041666666666667
43738, 0.45833333333333, 0.4, 0.041666666666667
43739, 0.45833333333333, 0.45, 0.041666666666667
43740, 0.45833333333333, 0.5, 0.041666666666667
43741, 0.45833333333333, 0.55, 0.041666666666667
43742, 0.45833333333333, 0.6, 0.041666666666667
43743, 0.45833333333333, 0.65, 0.041666666666667
43744, 0.45833333333333, 0.7, 0.041666666666667
43745, 0.45833333333333, 0.75, 0.041666666666667
43746, 0.45833333333333, 0.8, 0.041666666666667
43747, 0.45833333333333, 0.85, 0.041666666666667
43748, 0.45833333333333, 0.9, 0.041666666666667
43749, 0.45833333333333, 0.95, 0.041666666666667
43750, 0.45833333333333, 1, 0.041666666666667
43751, 0.45833333333333, 1.05, 0.041666666666667
43752, 0.45833333333333, 1.1, 0.041666666666667
43753, 0.45833333333333, 1.15, 0.041666666666667
43754, 0.45833333333333, 1.2, 0.041666666666667
43755, 0.45833333333333, 1.25, 0.041666666666667
43756, 0.45833333333333, 1.3, 0.041666666666667
43757, 0.45833333333333, 0.2, 0.083333333333333
43758, 0.45833333333333, 0.25, 0.083333333333333
43759, 0.45833333333333, 0.3, 0.083333333333333
43760, 0.45833333333333, 0.35, 0.083333333333333
43761, 0.45833333333333, 0.4, 0.083333333333333
43762, 0.45833333333333, 0.45, 0.083333333333333
43763, 0.45833333333333, 0.5, 0.083333333333333
43764, 0.45833333333333, 0.55, 0.083333333333333
43765, 0.45833333333333, 0.6, 0.083333333333333
43766, 0.45833333333333, 0.65, 0.083333333333333
43767, 0.45833333333333, 0.7, 0.083333333333333
43768, 0.45833333333333, 0.75, 0.083333333333333
43769, 0.45833333333333, 0.8, 0.083333333333333
43770, 0.45833333333333, 0.85, 0.083333333333333
43771, 0.45833333333333, 0.9, 0.083333333333333
43772, 0.45833333333333, 0.95, 0.083333333333333
43773, 0.45833333333333, 1, 0.083333333333333
43774, 0.45833333333333, 1.05, 0.083333333333333
43775, 0.45833333333333, 1.1, 0.083333333333333
43776, 0.45833333333333, 1.15, 0.083333333333333
43777, 0.45833333333333, 1.2, 0.083333333333333
43778, 0.45833333333333, 1.25, 0.083333333333333
43779, 0.45833333333333, 1.3, 0.083333333333333
43780, 0.45833333333333, 0.2, 0.125
43781, 0.45833333333333, 0.25, 0.125
43782, 0.45833333333333, 0.3, 0.125
43783, 0.45833333333333, 0.35, 0.125
43784, 0.45833333333333, 0.4, 0.125
43785, 0.45833333333333, 0.45, 0.125
43786, 0.45833333333333, 0.5, 0.125
43787, 0.45833333333333, 0.55, 0.125
43788, 0.45833333333333, 0.6, 0.125
43789, 0.45833333333333, 0.65, 0.125
43790, 0.45833333333333, 0.7, 0.125
43791, 0.45833333333333, 0.75, 0.125
43792, 0.45833333333333, 0.8, 0.125
43793, 0.45833333333333, 0.85, 0.125
43794, 0.45833333333333, 0.9, 0.125
43795, 0.45833333333333, 0.95, 0.125
43796, 0.45833333333333, 1, 0.125
43797, 0.45833333333333, 1.05, 0.125
43798, 0.45833333333333, 1.1, 0.125
43799, 0.45833333333333, 1.15, 0.125
43800, 0.45833333333333, 1.2, 0.125
43801, 0.45833333333333, 1.25, 0.125
43802, 0.45833333333333, 1.3, 0.125
43803, 0.45833333333333, 0.2, 0.16666666666667
43804, 0.45833333333333, 0.25, 0.16666666666667
43805, 0.45833333333333, 0.3, 0.16666666666667
43806, 0.45833333333333, 0.35, 0.16666666666667
43807, 0.45833333333333, 0.4, 0.16666666666667
43808, 0.45833333333333, 0.45, 0.16666666666667
43809, 0.45833333333333, 0.5, 0.16666666666667
43810, 0.45833333333333, 0.55, 0.16666666666667
43811, 0.45833333333333, 0.6, 0.16666666666667
43812, 0.45833333333333, 0.65, 0.16666666666667
43813, 0.45833333333333, 0.7, 0.16666666666667
43814, 0.45833333333333, 0.75, 0.16666666666667
43815, 0.45833333333333, 0.8, 0.16666666666667
43816, 0.45833333333333, 0.85, 0.16666666666667
43817, 0.45833333333333, 0.9, 0.16666666666667
43818, 0.45833333333333, 0.95, 0.16666666666667
43819, 0.45833333333333, 1, 0.16666666666667
43820, 0.45833333333333, 1.05, 0.16666666666667
43821, 0.45833333333333, 1.1, 0.16666666666667
43822, 0.45833333333333, 1.15, 0.16666666666667
43823, 0.45833333333333, 1.2, 0.16666666666667
43824, 0.45833333333333, 1.25, 0.16666666666667
43825, 0.45833333333333, 1.3, 0.16666666666667
43826, 0.45833333333333, 0.2, 0.20833333333333
43827, 0.45833333333333, 0.25, 0.20833333333333
43828, 0.45833333333333, 0.3, 0.20833333333333
43829, 0.45833333333333, 0.35, 0.20833333333333
43830, 0.45833333333333, 0.4, 0.20833333333333
43831, 0.45833333333333, 0.45, 0.20833333333333
43832, 0.45833333333333, 0.5, 0.20833333333333
43833, 0.45833333333333, 0.55, 0.20833333333333
43834, 0.45833333333333, 0.6, 0.20833333333333
43835, 0.45833333333333, 0.65, 0.20833333333333
43836, 0.45833333333333, 0.7, 0.20833333333333
43837, 0.45833333333333, 0.75, 0.20833333333333
43838, 0.45833333333333, 0.8, 0.20833333333333
43839, 0.45833333333333, 0.85, 0.20833333333333
43840, 0.45833333333333, 0.9, 0.20833333333333
43841, 0.45833333333333, 0.95, 0.20833333333333
43842, 0.45833333333333, 1, 0.20833333333333
43843, 0.45833333333333, 1.05, 0.20833333333333
43844, 0.45833333333333, 1.1, 0.20833333333333
43845, 0.45833333333333, 1.15, 0.20833333333333
43846, 0.45833333333333, 1.2, 0.20833333333333
43847, 0.45833333333333, 1.25, 0.20833333333333
43848, 0.45833333333333, 1.3, 0.20833333333333
43849, 0.45833333333333, 0.2, 0.25
43850, 0.45833333333333, 0.25, 0.25
43851, 0.45833333333333, 0.3, 0.25
43852, 0.45833333333333, 0.35, 0.25
43853, 0.45833333333333, 0.4, 0.25
43854, 0.45833333333333, 0.45, 0.25
43855, 0.45833333333333, 0.5, 0.25
43856, 0.45833333333333, 0.55, 0.25
43857, 0.45833333333333, 0.6, 0.25
43858, 0.45833333333333, 0.65, 0.25
43859, 0.45833333333333, 0.7, 0.25
43860, 0.45833333333333, 0.75, 0.25
43861, 0.45833333333333, 0.8, 0.25
43862, 0.45833333333333, 0.85, 0.25
43863, 0.45833333333333, 0.9, 0.25
43864, 0.45833333333333, 0.95, 0.25
43865, 0.45833333333333, 1, 0.25
43866, 0.45833333333333, 1.05, 0.25
43867, 0.45833333333333, 1.1, 0.25
43868, 0.45833333333333, 1.15, 0.25
43869, 0.45833333333333, 1.2, 0.25
43870, 0.45833333333333, 1.25, 0.25
43871, 0.45833333333333, 1.3, 0.25
43872, 0.45833333333333, 0.2, 0.29166666666667
43873, 0.45833333333333, 0.25, 0.29166666666667
43874, 0.45833333333333, 0.3, 0.29166666666667
43875, 0.45833333333333, 0.35, 0.29166666666667
43876, 0.45833333333333, 0.4, 0.29166666666667
43877, 0.45833333333333, 0.45, 0.29166666666667
43878, 0.45833333333333, 0.5, 0.29166666666667
43879, 0.45833333333333, 0.55, 0.29166666666667
43880, 0.45833333333333, 0.6, 0.29166666666667
43881, 0.45833333333333, 0.65, 0.29166666666667
43882, 0.45833333333333, 0.7, 0.29166666666667
43883, 0.45833333333333, 0.75, 0.29166666666667
43884, 0.45833333333333, 0.8, 0.29166666666667
43885, 0.45833333333333, 0.85, 0.29166666666667
43886, 0.45833333333333, 0.9, 0.29166666666667
43887, 0.45833333333333, 0.95, 0.29166666666667
43888, 0.45833333333333, 1, 0.29166666666667
43889, 0.45833333333333, 1.05, 0.29166666666667
43890, 0.45833333333333, 1.1, 0.29166666666667
43891, 0.45833333333333, 1.15, 0.29166666666667
43892, 0.45833333333333, 1.2, 0.29166666666667
43893, 0.45833333333333, 1.25, 0.29166666666667
43894, 0.45833333333333, 1.3, 0.29166666666667
43895, 0.45833333333333, 0.2, 0.33333333333333
43896, 0.45833333333333, 0.25, 0.33333333333333
43897, 0.45833333333333, 0.3, 0.33333333333333
43898, 0.45833333333333, 0.35, 0.33333333333333
43899, 0.45833333333333, 0.4, 0.33333333333333
43900, 0.45833333333333, 0.45, 0.33333333333333
43901, 0.45833333333333, 0.5, 0.33333333333333
43902, 0.45833333333333, 0.55, 0.33333333333333
43903, 0.45833333333333, 0.6, 0.33333333333333
43904, 0.45833333333333, 0.65, 0.33333333333333
43905, 0.45833333333333, 0.7, 0.33333333333333
43906, 0.45833333333333, 0.75, 0.33333333333333
43907, 0.45833333333333, 0.8, 0.33333333333333
43908, 0.45833333333333, 0.85, 0.33333333333333
43909, 0.45833333333333, 0.9, 0.33333333333333
43910, 0.45833333333333, 0.95, 0.33333333333333
43911, 0.45833333333333, 1, 0.33333333333333
43912, 0.45833333333333, 1.05, 0.33333333333333
43913, 0.45833333333333, 1.1, 0.33333333333333
43914, 0.45833333333333, 1.15, 0.33333333333333
43915, 0.45833333333333, 1.2, 0.33333333333333
43916, 0.45833333333333, 1.25, 0.33333333333333
43917, 0.45833333333333, 1.3, 0.33333333333333
43918, 0.45833333333333, 0.2, 0.375
43919, 0.45833333333333, 0.25, 0.375
43920, 0.45833333333333, 0.3, 0.375
43921, 0.45833333333333, 0.35, 0.375
43922, 0.45833333333333, 0.4, 0.375
43923, 0.45833333333333, 0.45, 0.375
43924, 0.45833333333333, 0.5, 0.375
43925, 0.45833333333333, 0.55, 0.375
43926, 0.45833333333333, 0.6, 0.375
43927, 0.45833333333333, 0.65, 0.375
43928, 0.45833333333333, 0.7, 0.375
43929, 0.45833333333333, 0.75, 0.375
43930, 0.45833333333333, 0.8, 0.375
43931, 0.45833333333333, 0.85, 0.375
43932, 0.45833333333333, 0.9, 0.375
43933, 0.45833333333333, 0.95, 0.375
43934, 0.45833333333333, 1, 0.375
43935, 0.45833333333333, 1.05, 0.375
43936, 0.45833333333333, 1.1, 0.375
43937, 0.45833333333333, 1.15, 0.375
43938, 0.45833333333333, 1.2, 0.375
43939, 0.45833333333333, 1.25, 0.375
43940, 0.45833333333333, 1.3, 0.375
43941, 0.45833333333333, 0.2, 0.41666666666667
43942, 0.45833333333333, 0.25, 0.41666666666667
43943, 0.45833333333333, 0.3, 0.41666666666667
43944, 0.45833333333333, 0.35, 0.41666666666667
43945, 0.45833333333333, 0.4, 0.41666666666667
43946, 0.45833333333333, 0.45, 0.41666666666667
43947, 0.45833333333333, 0.5, 0.41666666666667
43948, 0.45833333333333, 0.55, 0.41666666666667
43949, 0.45833333333333, 0.6, 0.41666666666667
43950, 0.45833333333333, 0.65, 0.41666666666667
43951, 0.45833333333333, 0.7, 0.41666666666667
43952, 0.45833333333333, 0.75, 0.41666666666667
43953, 0.45833333333333, 0.8, 0.41666666666667
43954, 0.45833333333333, 0.85, 0.41666666666667
43955, 0.45833333333333, 0.9, 0.41666666666667
43956, 0.45833333333333, 0.95, 0.41666666666667
43957, 0.45833333333333, 1, 0.41666666666667
43958, 0.45833333333333, 1.05, 0.41666666666667
43959, 0.45833333333333, 1.1, 0.41666666666667
43960, 0.45833333333333, 1.15, 0.41666666666667
43961, 0.45833333333333, 1.2, 0.41666666666667
43962, 0.45833333333333, 1.25, 0.41666666666667
43963, 0.45833333333333, 1.3, 0.41666666666667
43964, 0.45833333333333, 0.2, 0.45833333333333
43965, 0.45833333333333, 0.25, 0.45833333333333
43966, 0.45833333333333, 0.3, 0.45833333333333
43967, 0.45833333333333, 0.35, 0.45833333333333
43968, 0.45833333333333, 0.4, 0.45833333333333
43969, 0.45833333333333, 0.45, 0.45833333333333
43970, 0.45833333333333, 0.5, 0.45833333333333
43971, 0.45833333333333, 0.55, 0.45833333333333
43972, 0.45833333333333, 0.6, 0.45833333333333
43973, 0.45833333333333, 0.65, 0.45833333333333
43974, 0.45833333333333, 0.7, 0.45833333333333
43975, 0.45833333333333, 0.75, 0.45833333333333
43976, 0.45833333333333, 0.8, 0.45833333333333
43977, 0.45833333333333, 0.85, 0.45833333333333
43978, 0.45833333333333, 0.9, 0.45833333333333
43979, 0.45833333333333, 0.95, 0.45833333333333
43980, 0.45833333333333, 1, 0.45833333333333
43981, 0.45833333333333, 1.05, 0.45833333333333
43982, 0.45833333333333, 1.1, 0.45833333333333
43983, 0.45833333333333, 1.15, 0.45833333333333
43984, 0.45833333333333, 1.2, 0.45833333333333
43985, 0.45833333333333, 1.25, 0.45833333333333
43986, 0.45833333333333, 1.3, 0.45833333333333
43987, 0.5, 0.2, 0.041666666666667
43988, 0.5, 0.25, 0.041666666666667
43989, 0.5, 0.3, 0.041666666666667
43990, 0.5, 0.35, 0.041666666666667
43991, 0.5, 0.4, 0.041666666666667
43992, 0.5, 0.45, 0.041666666666667
43993, 0.5, 0.5, 0.041666666666667
43994, 0.5, 0.55, 0.041666666666667
43995, 0.5, 0.6, 0.041666666666667
43996, 0.5, 0.65, 0.041666666666667
43997, 0.5, 0.7, 0.041666666666667
43998, 0.5, 0.75, 0.041666666666667
43999, 0.5, 0.8, 0.041666666666667
44000, 0.5, 0.85, 0.041666666666667
44001, 0.5, 0.9, 0.041666666666667
44002, 0.5, 0.95, 0.041666666666667
44003, 0.5, 1, 0.041666666666667
44004, 0.5, 1.05, 0.041666666666667
44005, 0.5, 1.1, 0.041666666666667
44006, 0.5, 1.15, 0.041666666666667
44007, 0.5, 1.2, 0.041666666666667
44008, 0.5, 1.25, 0.041666666666667
44009, 0.5, 1.3, 0.041666666666667
44010, 0.5, 0.2, 0.083333333333333
44011, 0.5, 0.25, 0.083333333333333
44012, 0.5, 0.3, 0.083333333333333
44013, 0.5, 0.35, 0.083333333333333
44014, 0.5, 0.4, 0.083333333333333
44015, 0.5, 0.45, 0.083333333333333
44016, 0.5, 0.5, 0.083333333333333
44017, 0.5, 0.55, 0.083333333333333
44018, 0.5, 0.6, 0.083333333333333
44019, 0.5, 0.65, 0.083333333333333
44020, 0.5, 0.7, 0.083333333333333
44021, 0.5, 0.75, 0.083333333333333
44022, 0.5, 0.8, 0.083333333333333
44023, 0.5, 0.85, 0.083333333333333
44024, 0.5, 0.9, 0.083333333333333
44025, 0.5, 0.95, 0.083333333333333
44026, 0.5, 1, 0.083333333333333
44027, 0.5, 1.05, 0.083333333333333
44028, 0.5, 1.1, 0.083333333333333
44029, 0.5, 1.15, 0.083333333333333
44030, 0.5, 1.2, 0.083333333333333
44031, 0.5, 1.25, 0.083333333333333
44032, 0.5, 1.3, 0.083333333333333
44033, 0.5, 0.2, 0.125
44034, 0.5, 0.25, 0.125
44035, 0.5, 0.3, 0.125
44036, 0.5, 0.35, 0.125
44037, 0.5, 0.4, 0.125
44038, 0.5, 0.45, 0.125
44039, 0.5, 0.5, 0.125
44040, 0.5, 0.55, 0.125
44041, 0.5, 0.6, 0.125
44042, 0.5, 0.65, 0.125
44043, 0.5, 0.7, 0.125
44044, 0.5, 0.75, 0.125
44045, 0.5, 0.8, 0.125
44046, 0.5, 0.85, 0.125
44047, 0.5, 0.9, 0.125
44048, 0.5, 0.95, 0.125
44049, 0.5, 1, 0.125
44050, 0.5, 1.05, 0.125
44051, 0.5, 1.1, 0.125
44052, 0.5, 1.15, 0.125
44053, 0.5, 1.2, 0.125
44054, 0.5, 1.25, 0.125
44055, 0.5, 1.3, 0.125
44056, 0.5, 0.2, 0.16666666666667
44057, 0.5, 0.25, 0.16666666666667
44058, 0.5, 0.3, 0.16666666666667
44059, 0.5, 0.35, 0.16666666666667
44060, 0.5, 0.4, 0.16666666666667
44061, 0.5, 0.45, 0.16666666666667
44062, 0.5, 0.5, 0.16666666666667
44063, 0.5, 0.55, 0.16666666666667
44064, 0.5, 0.6, 0.16666666666667
44065, 0.5, 0.65, 0.16666666666667
44066, 0.5, 0.7, 0.16666666666667
44067, 0.5, 0.75, 0.16666666666667
44068, 0.5, 0.8, 0.16666666666667
44069, 0.5, 0.85, 0.16666666666667
44070, 0.5, 0.9, 0.16666666666667
44071, 0.5, 0.95, 0.16666666666667
44072, 0.5, 1, 0.16666666666667
44073, 0.5, 1.05, 0.16666666666667
44074, 0.5, 1.1, 0.16666666666667
44075, 0.5, 1.15, 0.16666666666667
44076, 0.5, 1.2, 0.16666666666667
44077, 0.5, 1.25, 0.16666666666667
44078, 0.5, 1.3, 0.16666666666667
44079, 0.5, 0.2, 0.20833333333333
44080, 0.5, 0.25, 0.20833333333333
44081, 0.5, 0.3, 0.20833333333333
44082, 0.5, 0.35, 0.20833333333333
44083, 0.5, 0.4, 0.20833333333333
44084, 0.5, 0.45, 0.20833333333333
44085, 0.5, 0.5, 0.20833333333333
44086, 0.5, 0.55, 0.20833333333333
44087, 0.5, 0.6, 0.20833333333333
44088, 0.5, 0.65, 0.20833333333333
44089, 0.5, 0.7, 0.20833333333333
44090, 0.5, 0.75, 0.20833333333333
44091, 0.5, 0.8, 0.20833333333333
44092, 0.5, 0.85, 0.20833333333333
44093, 0.5, 0.9, 0.20833333333333
44094, 0.5, 0.95, 0.20833333333333
44095, 0.5, 1, 0.20833333333333
44096, 0.5, 1.05, 0.20833333333333
44097, 0.5, 1.1, 0.20833333333333
44098, 0.5, 1.15, 0.20833333333333
44099, 0.5, 1.2, 0.20833333333333
44100, 0.5, 1.25, 0.20833333333333
44101, 0.5, 1.3, 0.20833333333333
44102, 0.5, 0.2, 0.25
44103, 0.5, 0.25, 0.25
44104, 0.5, 0.3, 0.25
44105, 0.5, 0.35, 0.25
44106, 0.5, 0.4, 0.25
44107, 0.5, 0.45, 0.25
44108, 0.5, 0.5, 0.25
44109, 0.5, 0.55, 0.25
44110, 0.5, 0.6, 0.25
44111, 0.5, 0.65, 0.25
44112, 0.5, 0.7, 0.25
44113, 0.5, 0.75, 0.25
44114, 0.5, 0.8, 0.25
44115, 0.5, 0.85, 0.25
44116, 0.5, 0.9, 0.25
44117, 0.5, 0.95, 0.25
44118, 0.5, 1, 0.25
44119, 0.5, 1.05, 0.25
44120, 0.5, 1.1, 0.25
44121, 0.5, 1.15, 0.25
44122, 0.5, 1.2, 0.25
44123, 0.5, 1.25, 0.25
44124, 0.5, 1.3, 0.25
44125, 0.5, 0.2, 0.29166666666667
44126, 0.5, 0.25, 0.29166666666667
44127, 0.5, 0.3, 0.29166666666667
44128, 0.5, 0.35, 0.29166666666667
44129, 0.5, 0.4, 0.29166666666667
44130, 0.5, 0.45, 0.29166666666667
44131, 0.5, 0.5, 0.29166666666667
44132, 0.5, 0.55, 0.29166666666667
44133, 0.5, 0.6, 0.29166666666667
44134, 0.5, 0.65, 0.29166666666667
44135, 0.5, 0.7, 0.29166666666667
44136, 0.5, 0.75, 0.29166666666667
44137, 0.5, 0.8, 0.29166666666667
44138, 0.5, 0.85, 0.29166666666667
44139, 0.5, 0.9, 0.29166666666667
44140, 0.5, 0.95, 0.29166666666667
44141, 0.5, 1, 0.29166666666667
44142, 0.5, 1.05, 0.29166666666667
44143, 0.5, 1.1, 0.29166666666667
44144, 0.5, 1.15, 0.29166666666667
44145, 0.5, 1.2, 0.29166666666667
44146, 0.5, 1.25, 0.29166666666667
44147, 0.5, 1.3, 0.29166666666667
44148, 0.5, 0.2, 0.33333333333333
44149, 0.5, 0.25, 0.33333333333333
44150, 0.5, 0.3, 0.33333333333333
44151, 0.5, 0.35, 0.33333333333333
44152, 0.5, 0.4, 0.33333333333333
44153, 0.5, 0.45, 0.33333333333333
44154, 0.5, 0.5, 0.33333333333333
44155, 0.5, 0.55, 0.33333333333333
44156, 0.5, 0.6, 0.33333333333333
44157, 0.5, 0.65, 0.33333333333333
44158, 0.5, 0.7, 0.33333333333333
44159, 0.5, 0.75, 0.33333333333333
44160, 0.5, 0.8, 0.33333333333333
44161, 0.5, 0.85, 0.33333333333333
44162, 0.5, 0.9, 0.33333333333333
44163, 0.5, 0.95, 0.33333333333333
44164, 0.5, 1, 0.33333333333333
44165, 0.5, 1.05, 0.33333333333333
44166, 0.5, 1.1, 0.33333333333333
44167, 0.5, 1.15, 0.33333333333333
44168, 0.5, 1.2, 0.33333333333333
44169, 0.5, 1.25, 0.33333333333333
44170, 0.5, 1.3, 0.33333333333333
44171, 0.5, 0.2, 0.375
44172, 0.5, 0.25, 0.375
44173, 0.5, 0.3, 0.375
44174, 0.5, 0.35, 0.375
44175, 0.5, 0.4, 0.375
44176, 0.5, 0.45, 0.375
44177, 0.5, 0.5, 0.375
44178, 0.5, 0.55, 0.375
44179, 0.5, 0.6, 0.375
44180, 0.5, 0.65, 0.375
44181, 0.5, 0.7, 0.375
44182, 0.5, 0.75, 0.375
44183, 0.5, 0.8, 0.375
44184, 0.5, 0.85, 0.375
44185, 0.5, 0.9, 0.375
44186, 0.5, 0.95, 0.375
44187, 0.5, 1, 0.375
44188, 0.5, 1.05, 0.375
44189, 0.5, 1.1, 0.375
44190, 0.5, 1.15, 0.375
44191, 0.5, 1.2, 0.375
44192, 0.5, 1.25, 0.375
44193, 0.5, 1.3, 0.375
44194, 0.5, 0.2, 0.41666666666667
44195, 0.5, 0.25, 0.41666666666667
44196, 0.5, 0.3, 0.41666666666667
44197, 0.5, 0.35, 0.41666666666667
44198, 0.5, 0.4, 0.41666666666667
44199, 0.5, 0.45, 0.41666666666667
44200, 0.5, 0.5, 0.41666666666667
44201, 0.5, 0.55, 0.41666666666667
44202, 0.5, 0.6, 0.41666666666667
44203, 0.5, 0.65, 0.41666666666667
44204, 0.5, 0.7, 0.41666666666667
44205, 0.5, 0.75, 0.41666666666667
44206, 0.5, 0.8, 0.41666666666667
44207, 0.5, 0.85, 0.41666666666667
44208, 0.5, 0.9, 0.41666666666667
44209, 0.5, 0.95, 0.41666666666667
44210, 0.5, 1, 0.41666666666667
44211, 0.5, 1.05, 0.41666666666667
44212, 0.5, 1.1, 0.41666666666667
44213, 0.5, 1.15, 0.41666666666667
44214, 0.5, 1.2, 0.41666666666667
44215, 0.5, 1.25, 0.41666666666667
44216, 0.5, 1.3, 0.41666666666667
44217, 0.5, 0.2, 0.45833333333333
44218, 0.5, 0.25, 0.45833333333333
44219, 0.5, 0.3, 0.45833333333333
44220, 0.5, 0.35, 0.45833333333333
44221, 0.5, 0.4, 0.45833333333333
44222, 0.5, 0.45, 0.45833333333333
44223, 0.5, 0.5, 0.45833333333333
44224, 0.5, 0.55, 0.45833333333333
44225, 0.5, 0.6, 0.45833333333333
44226, 0.5, 0.65, 0.45833333333333
44227, 0.5, 0.7, 0.45833333333333
44228, 0.5, 0.75, 0.45833333333333
44229, 0.5, 0.8, 0.45833333333333
44230, 0.5, 0.85, 0.45833333333333
44231, 0.5, 0.9, 0.45833333333333
44232, 0.5, 0.95, 0.45833333333333
44233, 0.5, 1, 0.45833333333333
44234, 0.5, 1.05, 0.45833333333333
44235, 0.5, 1.1, 0.45833333333333
44236, 0.5, 1.15, 0.45833333333333
44237, 0.5, 1.2, 0.45833333333333
44238, 0.5, 1.25, 0.45833333333333
44239, 0.5, 1.3, 0.45833333333333
44240, 0.54166666666667, 0.2, 0.041666666666667
44241, 0.54166666666667, 0.25, 0.041666666666667
44242, 0.54166666666667, 0.3, 0.041666666666667
44243, 0.54166666666667, 0.35, 0.041666666666667
44244, 0.54166666666667, 0.4, 0.041666666666667
44245, 0.54166666666667, 0.45, 0.041666666666667
44246, 0.54166666666667, 0.5, 0.041666666666667
44247, 0.54166666666667, 0.55, 0.041666666666667
44248, 0.54166666666667, 0.6, 0.041666666666667
44249, 0.54166666666667, 0.65, 0.041666666666667
44250, 0.54166666666667, 0.7, 0.041666666666667
44251, 0.54166666666667, 0.75, 0.041666666666667
44252, 0.54166666666667, 0.8, 0.041666666666667
44253, 0.54166666666667, 0.85, 0.041666666666667
44254, 0.54166666666667, 0.9, 0.041666666666667
44255, 0.54166666666667, 0.95, 0.041666666666667
44256, 0.54166666666667, 1, 0.041666666666667
44257, 0.54166666666667, 1.05, 0.041666666666667
44258, 0.54166666666667, 1.1, 0.041666666666667
44259, 0.54166666666667, 1.15, 0.041666666666667
44260, 0.54166666666667, 1.2, 0.041666666666667
44261, 0.54166666666667, 1.25, 0.041666666666667
44262, 0.54166666666667, 1.3, 0.041666666666667
44263, 0.54166666666667, 0.2, 0.083333333333333
44264, 0.54166666666667, 0.25, 0.083333333333333
44265, 0.54166666666667, 0.3, 0.083333333333333
44266, 0.54166666666667, 0.35, 0.083333333333333
44267, 0.54166666666667, 0.4, 0.083333333333333
44268, 0.54166666666667, 0.45, 0.083333333333333
44269, 0.54166666666667, 0.5, 0.083333333333333
44270, 0.54166666666667, 0.55, 0.083333333333333
44271, 0.54166666666667, 0.6, 0.083333333333333
44272, 0.54166666666667, 0.65, 0.083333333333333
44273, 0.54166666666667, 0.7, 0.083333333333333
44274, 0.54166666666667, 0.75, 0.083333333333333
44275, 0.54166666666667, 0.8, 0.083333333333333
44276, 0.54166666666667, 0.85, 0.083333333333333
44277, 0.54166666666667, 0.9, 0.083333333333333
44278, 0.54166666666667, 0.95, 0.083333333333333
44279, 0.54166666666667, 1, 0.083333333333333
44280, 0.54166666666667, 1.05, 0.083333333333333
44281, 0.54166666666667, 1.1, 0.083333333333333
44282, 0.54166666666667, 1.15, 0.083333333333333
44283, 0.54166666666667, 1.2, 0.083333333333333
44284, 0.54166666666667, 1.25, 0.083333333333333
44285, 0.54166666666667, 1.3, 0.083333333333333
44286, 0.54166666666667, 0.2, 0.125
44287, 0.54166666666667, 0.25, 0.125
44288, 0.54166666666667, 0.3, 0.125
44289, 0.54166666666667, 0.35, 0.125
44290, 0.54166666666667, 0.4, 0.125
44291, 0.54166666666667, 0.45, 0.125
44292, 0.54166666666667, 0.5, 0.125
44293, 0.54166666666667, 0.55, 0.125
44294, 0.54166666666667, 0.6, 0.125
44295, 0.54166666666667, 0.65, 0.125
44296, 0.54166666666667, 0.7, 0.125
44297, 0.54166666666667, 0.75, 0.125
44298, 0.54166666666667, 0.8, 0.125
44299, 0.54166666666667, 0.85, 0.125
44300, 0.54166666666667, 0.9, 0.125
44301, 0.54166666666667, 0.95, 0.125
44302, 0.54166666666667, 1, 0.125
44303, 0.54166666666667, 1.05, 0.125
44304, 0.54166666666667, 1.1, 0.125
44305, 0.54166666666667, 1.15, 0.125
44306, 0.54166666666667, 1.2, 0.125
44307, 0.54166666666667, 1.25, 0.125
44308, 0.54166666666667, 1.3, 0.125
44309, 0.54166666666667, 0.2, 0.16666666666667
44310, 0.54166666666667, 0.25, 0.16666666666667
44311, 0.54166666666667, 0.3, 0.16666666666667
44312, 0.54166666666667, 0.35, 0.16666666666667
44313, 0.54166666666667, 0.4, 0.16666666666667
44314, 0.54166666666667, 0.45, 0.16666666666667
44315, 0.54166666666667, 0.5, 0.16666666666667
44316, 0.54166666666667, 0.55, 0.16666666666667
44317, 0.54166666666667, 0.6, 0.16666666666667
44318, 0.54166666666667, 0.65, 0.16666666666667
44319, 0.54166666666667, 0.7, 0.16666666666667
44320, 0.54166666666667, 0.75, 0.16666666666667
44321, 0.54166666666667, 0.8, 0.16666666666667
44322, 0.54166666666667, 0.85, 0.16666666666667
44323, 0.54166666666667, 0.9, 0.16666666666667
44324, 0.54166666666667, 0.95, 0.16666666666667
44325, 0.54166666666667, 1, 0.16666666666667
44326, 0.54166666666667, 1.05, 0.16666666666667
44327, 0.54166666666667, 1.1, 0.16666666666667
44328, 0.54166666666667, 1.15, 0.16666666666667
44329, 0.54166666666667, 1.2, 0.16666666666667
44330, 0.54166666666667, 1.25, 0.16666666666667
44331, 0.54166666666667, 1.3, 0.16666666666667
44332, 0.54166666666667, 0.2, 0.20833333333333
44333, 0.54166666666667, 0.25, 0.20833333333333
44334, 0.54166666666667, 0.3, 0.20833333333333
44335, 0.54166666666667, 0.35, 0.20833333333333
44336, 0.54166666666667, 0.4, 0.20833333333333
44337, 0.54166666666667, 0.45, 0.20833333333333
44338, 0.54166666666667, 0.5, 0.20833333333333
44339, 0.54166666666667, 0.55, 0.20833333333333
44340, 0.54166666666667, 0.6, 0.20833333333333
44341, 0.54166666666667, 0.65, 0.20833333333333
44342, 0.54166666666667, 0.7, 0.20833333333333
44343, 0.54166666666667, 0.75, 0.20833333333333
44344, 0.54166666666667, 0.8, 0.20833333333333
44345, 0.54166666666667, 0.85, 0.20833333333333
44346, 0.54166666666667, 0.9, 0.20833333333333
44347, 0.54166666666667, 0.95, 0.20833333333333
44348, 0.54166666666667, 1, 0.20833333333333
44349, 0.54166666666667, 1.05, 0.20833333333333
44350, 0.54166666666667, 1.1, 0.20833333333333
44351, 0.54166666666667, 1.15, 0.20833333333333
44352, 0.54166666666667, 1.2, 0.20833333333333
44353, 0.54166666666667, 1.25, 0.20833333333333
44354, 0.54166666666667, 1.3, 0.20833333333333
44355, 0.54166666666667, 0.2, 0.25
44356, 0.54166666666667, 0.25, 0.25
44357, 0.54166666666667, 0.3, 0.25
44358, 0.54166666666667, 0.35, 0.25
44359, 0.54166666666667, 0.4, 0.25
44360, 0.54166666666667, 0.45, 0.25
44361, 0.54166666666667, 0.5, 0.25
44362, 0.54166666666667, 0.55, 0.25
44363, 0.54166666666667, 0.6, 0.25
44364, 0.54166666666667, 0.65, 0.25
44365, 0.54166666666667, 0.7, 0.25
44366, 0.54166666666667, 0.75, 0.25
44367, 0.54166666666667, 0.8, 0.25
44368, 0.54166666666667, 0.85, 0.25
44369, 0.54166666666667, 0.9, 0.25
44370, 0.54166666666667, 0.95, 0.25
44371, 0.54166666666667, 1, 0.25
44372, 0.54166666666667, 1.05, 0.25
44373, 0.54166666666667, 1.1, 0.25
44374, 0.54166666666667, 1.15, 0.25
44375, 0.54166666666667, 1.2, 0.25
44376, 0.54166666666667, 1.25, 0.25
44377, 0.54166666666667, 1.3, 0.25
44378, 0.54166666666667, 0.2, 0.29166666666667
44379, 0.54166666666667, 0.25, 0.29166666666667
44380, 0.54166666666667, 0.3, 0.29166666666667
44381, 0.54166666666667, 0.35, 0.29166666666667
44382, 0.54166666666667, 0.4, 0.29166666666667
44383, 0.54166666666667, 0.45, 0.29166666666667
44384, 0.54166666666667, 0.5, 0.29166666666667
44385, 0.54166666666667, 0.55, 0.29166666666667
44386, 0.54166666666667, 0.6, 0.29166666666667
44387, 0.54166666666667, 0.65, 0.29166666666667
44388, 0.54166666666667, 0.7, 0.29166666666667
44389, 0.54166666666667, 0.75, 0.29166666666667
44390, 0.54166666666667, 0.8, 0.29166666666667
44391, 0.54166666666667, 0.85, 0.29166666666667
44392, 0.54166666666667, 0.9, 0.29166666666667
44393, 0.54166666666667, 0.95, 0.29166666666667
44394, 0.54166666666667, 1, 0.29166666666667
44395, 0.54166666666667, 1.05, 0.29166666666667
44396, 0.54166666666667, 1.1, 0.29166666666667
44397, 0.54166666666667, 1.15, 0.29166666666667
44398, 0.54166666666667, 1.2, 0.29166666666667
44399, 0.54166666666667, 1.25, 0.29166666666667
44400, 0.54166666666667, 1.3, 0.29166666666667
44401, 0.54166666666667, 0.2, 0.33333333333333
44402, 0.54166666666667, 0.25, 0.33333333333333
44403, 0.54166666666667, 0.3, 0.33333333333333
44404, 0.54166666666667, 0.35, 0.33333333333333
44405, 0.54166666666667, 0.4, 0.33333333333333
44406, 0.54166666666667, 0.45, 0.33333333333333
44407, 0.54166666666667, 0.5, 0.33333333333333
44408, 0.54166666666667, 0.55, 0.33333333333333
44409, 0.54166666666667, 0.6, 0.33333333333333
44410, 0.54166666666667, 0.65, 0.33333333333333
44411, 0.54166666666667, 0.7, 0.33333333333333
44412, 0.54166666666667, 0.75, 0.33333333333333
44413, 0.54166666666667, 0.8, 0.33333333333333
44414, 0.54166666666667, 0.85, 0.33333333333333
44415, 0.54166666666667, 0.9, 0.33333333333333
44416, 0.54166666666667, 0.95, 0.33333333333333
44417, 0.54166666666667, 1, 0.33333333333333
44418, 0.54166666666667, 1.05, 0.33333333333333
44419, 0.54166666666667, 1.1, 0.33333333333333
44420, 0.54166666666667, 1.15, 0.33333333333333
44421, 0.54166666666667, 1.2, 0.33333333333333
44422, 0.54166666666667, 1.25, 0.33333333333333
44423, 0.54166666666667, 1.3, 0.33333333333333
44424, 0.54166666666667, 0.2, 0.375
44425, 0.54166666666667, 0.25, 0.375
44426, 0.54166666666667, 0.3, 0.375
44427, 0.54166666666667, 0.35, 0.375
44428, 0.54166666666667, 0.4, 0.375
44429, 0.54166666666667, 0.45, 0.375
44430, 0.54166666666667, 0.5, 0.375
44431, 0.54166666666667, 0.55, 0.375
44432, 0.54166666666667, 0.6, 0.375
44433, 0.54166666666667, 0.65, 0.375
44434, 0.54166666666667, 0.7, 0.375
44435, 0.54166666666667, 0.75, 0.375
44436, 0.54166666666667, 0.8, 0.375
44437, 0.54166666666667, 0.85, 0.375
44438, 0.54166666666667, 0.9, 0.375
44439, 0.54166666666667, 0.95, 0.375
44440, 0.54166666666667, 1, 0.375
44441, 0.54166666666667, 1.05, 0.375
44442, 0.54166666666667, 1.1, 0.375
44443, 0.54166666666667, 1.15, 0.375
44444, 0.54166666666667, 1.2, 0.375
44445, 0.54166666666667, 1.25, 0.375
44446, 0.54166666666667, 1.3, 0.375
44447, 0.54166666666667, 0.2, 0.41666666666667
44448, 0.54166666666667, 0.25, 0.41666666666667
44449, 0.54166666666667, 0.3, 0.41666666666667
44450, 0.54166666666667, 0.35, 0.41666666666667
44451, 0.54166666666667, 0.4, 0.41666666666667
44452, 0.54166666666667, 0.45, 0.41666666666667
44453, 0.54166666666667, 0.5, 0.41666666666667
44454, 0.54166666666667, 0.55, 0.41666666666667
44455, 0.54166666666667, 0.6, 0.41666666666667
44456, 0.54166666666667, 0.65, 0.41666666666667
44457, 0.54166666666667, 0.7, 0.41666666666667
44458, 0.54166666666667, 0.75, 0.41666666666667
44459, 0.54166666666667, 0.8, 0.41666666666667
44460, 0.54166666666667, 0.85, 0.41666666666667
44461, 0.54166666666667, 0.9, 0.41666666666667
44462, 0.54166666666667, 0.95, 0.41666666666667
44463, 0.54166666666667, 1, 0.41666666666667
44464, 0.54166666666667, 1.05, 0.41666666666667
44465, 0.54166666666667, 1.1, 0.41666666666667
44466, 0.54166666666667, 1.15, 0.41666666666667
44467, 0.54166666666667, 1.2, 0.41666666666667
44468, 0.54166666666667, 1.25, 0.41666666666667
44469, 0.54166666666667, 1.3, 0.41666666666667
44470, 0.54166666666667, 0.2, 0.45833333333333
44471, 0.54166666666667, 0.25, 0.45833333333333
44472, 0.54166666666667, 0.3, 0.45833333333333
44473, 0.54166666666667, 0.35, 0.45833333333333
44474, 0.54166666666667, 0.4, 0.45833333333333
44475, 0.54166666666667, 0.45, 0.45833333333333
44476, 0.54166666666667, 0.5, 0.45833333333333
44477, 0.54166666666667, 0.55, 0.45833333333333
44478, 0.54166666666667, 0.6, 0.45833333333333
44479, 0.54166666666667, 0.65, 0.45833333333333
44480, 0.54166666666667, 0.7, 0.45833333333333
44481, 0.54166666666667, 0.75, 0.45833333333333
44482, 0.54166666666667, 0.8, 0.45833333333333
44483, 0.54166666666667, 0.85, 0.45833333333333
44484, 0.54166666666667, 0.9, 0.45833333333333
44485, 0.54166666666667, 0.95, 0.45833333333333
44486, 0.54166666666667, 1, 0.45833333333333
44487, 0.54166666666667, 1.05, 0.45833333333333
44488, 0.54166666666667, 1.1, 0.45833333333333
44489, 0.54166666666667, 1.15, 0.45833333333333
44490, 0.54166666666667, 1.2, 0.45833333333333
44491, 0.54166666666667, 1.25, 0.45833333333333
44492, 0.54166666666667, 1.3, 0.45833333333333
44493, 0.58333333333333, 0.2, 0.041666666666667
44494, 0.58333333333333, 0.25, 0.041666666666667
44495, 0.58333333333333, 0.3, 0.041666666666667
44496, 0.58333333333333, 0.35, 0.041666666666667
44497, 0.58333333333333, 0.4, 0.041666666666667
44498, 0.58333333333333, 0.45, 0.041666666666667
44499, 0.58333333333333, 0.5, 0.041666666666667
44500, 0.58333333333333, 0.55, 0.041666666666667
44501, 0.58333333333333, 0.6, 0.041666666666667
44502, 0.58333333333333, 0.65, 0.041666666666667
44503, 0.58333333333333, 0.7, 0.041666666666667
44504, 0.58333333333333, 0.75, 0.041666666666667
44505, 0.58333333333333, 0.8, 0.041666666666667
44506, 0.58333333333333, 0.85, 0.041666666666667
44507, 0.58333333333333, 0.9, 0.041666666666667
44508, 0.58333333333333, 0.95, 0.041666666666667
44509, 0.58333333333333, 1, 0.041666666666667
44510, 0.58333333333333, 1.05, 0.041666666666667
44511, 0.58333333333333, 1.1, 0.041666666666667
44512, 0.58333333333333, 1.15, 0.041666666666667
44513, 0.58333333333333, 1.2, 0.041666666666667
44514, 0.58333333333333, 1.25, 0.041666666666667
44515, 0.58333333333333, 1.3, 0.041666666666667
44516, 0.58333333333333, 0.2, 0.083333333333333
44517, 0.58333333333333, 0.25, 0.083333333333333
44518, 0.58333333333333, 0.3, 0.083333333333333
44519, 0.58333333333333, 0.35, 0.083333333333333
44520, 0.58333333333333, 0.4, 0.083333333333333
44521, 0.58333333333333, 0.45, 0.083333333333333
44522, 0.58333333333333, 0.5, 0.083333333333333
44523, 0.58333333333333, 0.55, 0.083333333333333
44524, 0.58333333333333, 0.6, 0.083333333333333
44525, 0.58333333333333, 0.65, 0.083333333333333
44526, 0.58333333333333, 0.7, 0.083333333333333
44527, 0.58333333333333, 0.75, 0.083333333333333
44528, 0.58333333333333, 0.8, 0.083333333333333
44529, 0.58333333333333, 0.85, 0.083333333333333
44530, 0.58333333333333, 0.9, 0.083333333333333
44531, 0.58333333333333, 0.95, 0.083333333333333
44532, 0.58333333333333, 1, 0.083333333333333
44533, 0.58333333333333, 1.05, 0.083333333333333
44534, 0.58333333333333, 1.1, 0.083333333333333
44535, 0.58333333333333, 1.15, 0.083333333333333
44536, 0.58333333333333, 1.2, 0.083333333333333
44537, 0.58333333333333, 1.25, 0.083333333333333
44538, 0.58333333333333, 1.3, 0.083333333333333
44539, 0.58333333333333, 0.2, 0.125
44540, 0.58333333333333, 0.25, 0.125
44541, 0.58333333333333, 0.3, 0.125
44542, 0.58333333333333, 0.35, 0.125
44543, 0.58333333333333, 0.4, 0.125
44544, 0.58333333333333, 0.45, 0.125
44545, 0.58333333333333, 0.5, 0.125
44546, 0.58333333333333, 0.55, 0.125
44547, 0.58333333333333, 0.6, 0.125
44548, 0.58333333333333, 0.65, 0.125
44549, 0.58333333333333, 0.7, 0.125
44550, 0.58333333333333, 0.75, 0.125
44551, 0.58333333333333, 0.8, 0.125
44552, 0.58333333333333, 0.85, 0.125
44553, 0.58333333333333, 0.9, 0.125
44554, 0.58333333333333, 0.95, 0.125
44555, 0.58333333333333, 1, 0.125
44556, 0.58333333333333, 1.05, 0.125
44557, 0.58333333333333, 1.1, 0.125
44558, 0.58333333333333, 1.15, 0.125
44559, 0.58333333333333, 1.2, 0.125
44560, 0.58333333333333, 1.25, 0.125
44561, 0.58333333333333, 1.3, 0.125
44562, 0.58333333333333, 0.2, 0.16666666666667
44563, 0.58333333333333, 0.25, 0.16666666666667
44564, 0.58333333333333, 0.3, 0.16666666666667
44565, 0.58333333333333, 0.35, 0.16666666666667
44566, 0.58333333333333, 0.4, 0.16666666666667
44567, 0.58333333333333, 0.45, 0.16666666666667
44568, 0.58333333333333, 0.5, 0.16666666666667
44569, 0.58333333333333, 0.55, 0.16666666666667
44570, 0.58333333333333, 0.6, 0.16666666666667
44571, 0.58333333333333, 0.65, 0.16666666666667
44572, 0.58333333333333, 0.7, 0.16666666666667
44573, 0.58333333333333, 0.75, 0.16666666666667
44574, 0.58333333333333, 0.8, 0.16666666666667
44575, 0.58333333333333, 0.85, 0.16666666666667
44576, 0.58333333333333, 0.9, 0.16666666666667
44577, 0.58333333333333, 0.95, 0.16666666666667
44578, 0.58333333333333, 1, 0.16666666666667
44579, 0.58333333333333, 1.05, 0.16666666666667
44580, 0.58333333333333, 1.1, 0.16666666666667
44581, 0.58333333333333, 1.15, 0.16666666666667
44582, 0.58333333333333, 1.2, 0.16666666666667
44583, 0.58333333333333, 1.25, 0.16666666666667
44584, 0.58333333333333, 1.3, 0.16666666666667
44585, 0.58333333333333, 0.2, 0.20833333333333
44586, 0.58333333333333, 0.25, 0.20833333333333
44587, 0.58333333333333, 0.3, 0.20833333333333
44588, 0.58333333333333, 0.35, 0.20833333333333
44589, 0.58333333333333, 0.4, 0.20833333333333
44590, 0.58333333333333, 0.45, 0.20833333333333
44591, 0.58333333333333, 0.5, 0.20833333333333
44592, 0.58333333333333, 0.55, 0.20833333333333
44593, 0.58333333333333, 0.6, 0.20833333333333
44594, 0.58333333333333, 0.65, 0.20833333333333
44595, 0.58333333333333, 0.7, 0.20833333333333
44596, 0.58333333333333, 0.75, 0.20833333333333
44597, 0.58333333333333, 0.8, 0.20833333333333
44598, 0.58333333333333, 0.85, 0.20833333333333
44599, 0.58333333333333, 0.9, 0.20833333333333
44600, 0.58333333333333, 0.95, 0.20833333333333
44601, 0.58333333333333, 1, 0.20833333333333
44602, 0.58333333333333, 1.05, 0.20833333333333
44603, 0.58333333333333, 1.1, 0.20833333333333
44604, 0.58333333333333, 1.15, 0.20833333333333
44605, 0.58333333333333, 1.2, 0.20833333333333
44606, 0.58333333333333, 1.25, 0.20833333333333
44607, 0.58333333333333, 1.3, 0.20833333333333
44608, 0.58333333333333, 0.2, 0.25
44609, 0.58333333333333, 0.25, 0.25
44610, 0.58333333333333, 0.3, 0.25
44611, 0.58333333333333, 0.35, 0.25
44612, 0.58333333333333, 0.4, 0.25
44613, 0.58333333333333, 0.45, 0.25
44614, 0.58333333333333, 0.5, 0.25
44615, 0.58333333333333, 0.55, 0.25
44616, 0.58333333333333, 0.6, 0.25
44617, 0.58333333333333, 0.65, 0.25
44618, 0.58333333333333, 0.7, 0.25
44619, 0.58333333333333, 0.75, 0.25
44620, 0.58333333333333, 0.8, 0.25
44621, 0.58333333333333, 0.85, 0.25
44622, 0.58333333333333, 0.9, 0.25
44623, 0.58333333333333, 0.95, 0.25
44624, 0.58333333333333, 1, 0.25
44625, 0.58333333333333, 1.05, 0.25
44626, 0.58333333333333, 1.1, 0.25
44627, 0.58333333333333, 1.15, 0.25
44628, 0.58333333333333, 1.2, 0.25
44629, 0.58333333333333, 1.25, 0.25
44630, 0.58333333333333, 1.3, 0.25
44631, 0.58333333333333, 0.2, 0.29166666666667
44632, 0.58333333333333, 0.25, 0.29166666666667
44633, 0.58333333333333, 0.3, 0.29166666666667
44634, 0.58333333333333, 0.35, 0.29166666666667
44635, 0.58333333333333, 0.4, 0.29166666666667
44636, 0.58333333333333, 0.45, 0.29166666666667
44637, 0.58333333333333, 0.5, 0.29166666666667
44638, 0.58333333333333, 0.55, 0.29166666666667
44639, 0.58333333333333, 0.6, 0.29166666666667
44640, 0.58333333333333, 0.65, 0.29166666666667
44641, 0.58333333333333, 0.7, 0.29166666666667
44642, 0.58333333333333, 0.75, 0.29166666666667
44643, 0.58333333333333, 0.8, 0.29166666666667
44644, 0.58333333333333, 0.85, 0.29166666666667
44645, 0.58333333333333, 0.9, 0.29166666666667
44646, 0.58333333333333, 0.95, 0.29166666666667
44647, 0.58333333333333, 1, 0.29166666666667
44648, 0.58333333333333, 1.05, 0.29166666666667
44649, 0.58333333333333, 1.1, 0.29166666666667
44650, 0.58333333333333, 1.15, 0.29166666666667
44651, 0.58333333333333, 1.2, 0.29166666666667
44652, 0.58333333333333, 1.25, 0.29166666666667
44653, 0.58333333333333, 1.3, 0.29166666666667
44654, 0.58333333333333, 0.2, 0.33333333333333
44655, 0.58333333333333, 0.25, 0.33333333333333
44656, 0.58333333333333, 0.3, 0.33333333333333
44657, 0.58333333333333, 0.35, 0.33333333333333
44658, 0.58333333333333, 0.4, 0.33333333333333
44659, 0.58333333333333, 0.45, 0.33333333333333
44660, 0.58333333333333, 0.5, 0.33333333333333
44661, 0.58333333333333, 0.55, 0.33333333333333
44662, 0.58333333333333, 0.6, 0.33333333333333
44663, 0.58333333333333, 0.65, 0.33333333333333
44664, 0.58333333333333, 0.7, 0.33333333333333
44665, 0.58333333333333, 0.75, 0.33333333333333
44666, 0.58333333333333, 0.8, 0.33333333333333
44667, 0.58333333333333, 0.85, 0.33333333333333
44668, 0.58333333333333, 0.9, 0.33333333333333
44669, 0.58333333333333, 0.95, 0.33333333333333
44670, 0.58333333333333, 1, 0.33333333333333
44671, 0.58333333333333, 1.05, 0.33333333333333
44672, 0.58333333333333, 1.1, 0.33333333333333
44673, 0.58333333333333, 1.15, 0.33333333333333
44674, 0.58333333333333, 1.2, 0.33333333333333
44675, 0.58333333333333, 1.25, 0.33333333333333
44676, 0.58333333333333, 1.3, 0.33333333333333
44677, 0.58333333333333, 0.2, 0.375
44678, 0.58333333333333, 0.25, 0.375
44679, 0.58333333333333, 0.3, 0.375
44680, 0.58333333333333, 0.35, 0.375
44681, 0.58333333333333, 0.4, 0.375
44682, 0.58333333333333, 0.45, 0.375
44683, 0.58333333333333, 0.5, 0.375
44684, 0.58333333333333, 0.55, 0.375
44685, 0.58333333333333, 0.6, 0.375
44686, 0.58333333333333, 0.65, 0.375
44687, 0.58333333333333, 0.7, 0.375
44688, 0.58333333333333, 0.75, 0.375
44689, 0.58333333333333, 0.8, 0.375
44690, 0.58333333333333, 0.85, 0.375
44691, 0.58333333333333, 0.9, 0.375
44692, 0.58333333333333, 0.95, 0.375
44693, 0.58333333333333, 1, 0.375
44694, 0.58333333333333, 1.05, 0.375
44695, 0.58333333333333, 1.1, 0.375
44696, 0.58333333333333, 1.15, 0.375
44697, 0.58333333333333, 1.2, 0.375
44698, 0.58333333333333, 1.25, 0.375
44699, 0.58333333333333, 1.3, 0.375
44700, 0.58333333333333, 0.2, 0.41666666666667
44701, 0.58333333333333, 0.25, 0.41666666666667
44702, 0.58333333333333, 0.3, 0.41666666666667
44703, 0.58333333333333, 0.35, 0.41666666666667
44704, 0.58333333333333, 0.4, 0.41666666666667
44705, 0.58333333333333, 0.45, 0.41666666666667
44706, 0.58333333333333, 0.5, 0.41666666666667
44707, 0.58333333333333, 0.55, 0.41666666666667
44708, 0.58333333333333, 0.6, 0.41666666666667
44709, 0.58333333333333, 0.65, 0.41666666666667
44710, 0.58333333333333, 0.7, 0.41666666666667
44711, 0.58333333333333, 0.75, 0.41666666666667
44712, 0.58333333333333, 0.8, 0.41666666666667
44713, 0.58333333333333, 0.85, 0.41666666666667
44714, 0.58333333333333, 0.9, 0.41666666666667
44715, 0.58333333333333, 0.95, 0.41666666666667
44716, 0.58333333333333, 1, 0.41666666666667
44717, 0.58333333333333, 1.05, 0.41666666666667
44718, 0.58333333333333, 1.1, 0.41666666666667
44719, 0.58333333333333, 1.15, 0.41666666666667
44720, 0.58333333333333, 1.2, 0.41666666666667
44721, 0.58333333333333, 1.25, 0.41666666666667
44722, 0.58333333333333, 1.3, 0.41666666666667
44723, 0.58333333333333, 0.2, 0.45833333333333
44724, 0.58333333333333, 0.25, 0.45833333333333
44725, 0.58333333333333, 0.3, 0.45833333333333
44726, 0.58333333333333, 0.35, 0.45833333333333
44727, 0.58333333333333, 0.4, 0.45833333333333
44728, 0.58333333333333, 0.45, 0.45833333333333
44729, 0.58333333333333, 0.5, 0.45833333333333
44730, 0.58333333333333, 0.55, 0.45833333333333
44731, 0.58333333333333, 0.6, 0.45833333333333
44732, 0.58333333333333, 0.65, 0.45833333333333
44733, 0.58333333333333, 0.7, 0.45833333333333
44734, 0.58333333333333, 0.75, 0.45833333333333
44735, 0.58333333333333, 0.8, 0.45833333333333
44736, 0.58333333333333, 0.85, 0.45833333333333
44737, 0.58333333333333, 0.9, 0.45833333333333
44738, 0.58333333333333, 0.95, 0.45833333333333
44739, 0.58333333333333, 1, 0.45833333333333
44740, 0.58333333333333, 1.05, 0.45833333333333
44741, 0.58333333333333, 1.1, 0.45833333333333
44742, 0.58333333333333, 1.15, 0.45833333333333
44743, 0.58333333333333, 1.2, 0.45833333333333
44744, 0.58333333333333, 1.25, 0.45833333333333
44745, 0.58333333333333, 1.3, 0.45833333333333
44746, 0.625, 0.2, 0.041666666666667
44747, 0.625, 0.25, 0.041666666666667
44748, 0.625, 0.3, 0.041666666666667
44749, 0.625, 0.35, 0.041666666666667
44750, 0.625, 0.4, 0.041666666666667
44751, 0.625, 0.45, 0.041666666666667
44752, 0.625, 0.5, 0.041666666666667
44753, 0.625, 0.55, 0.041666666666667
44754, 0.625, 0.6, 0.041666666666667
44755, 0.625, 0.65, 0.041666666666667
44756, 0.625, 0.7, 0.041666666666667
44757, 0.625, 0.75, 0.041666666666667
44758, 0.625, 0.8, 0.041666666666667
44759, 0.625, 0.85, 0.041666666666667
44760, 0.625, 0.9, 0.041666666666667
44761, 0.625, 0.95, 0.041666666666667
44762, 0.625, 1, 0.041666666666667
44763, 0.625, 1.05, 0.041666666666667
44764, 0.625, 1.1, 0.041666666666667
44765, 0.625, 1.15, 0.041666666666667
44766, 0.625, 1.2, 0.041666666666667
44767, 0.625, 1.25, 0.041666666666667
44768, 0.625, 1.3, 0.041666666666667
44769, 0.625, 0.2, 0.083333333333333
44770, 0.625, 0.25, 0.083333333333333
44771, 0.625, 0.3, 0.083333333333333
44772, 0.625, 0.35, 0.083333333333333
44773, 0.625, 0.4, 0.083333333333333
44774, 0.625, 0.45, 0.083333333333333
44775, 0.625, 0.5, 0.083333333333333
44776, 0.625, 0.55, 0.083333333333333
44777, 0.625, 0.6, 0.083333333333333
44778, 0.625, 0.65, 0.083333333333333
44779, 0.625, 0.7, 0.083333333333333
44780, 0.625, 0.75, 0.083333333333333
44781, 0.625, 0.8, 0.083333333333333
44782, 0.625, 0.85, 0.083333333333333
44783, 0.625, 0.9, 0.083333333333333
