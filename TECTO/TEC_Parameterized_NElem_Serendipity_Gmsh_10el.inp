61730, 0.77083333333333, 0.4, 0.29166666666667
61731, 0.79166666666667, 0.4, 0.27083333333333
61732, 0.79166666666667, 0.425, 0.29166666666667
61733, 0.77083333333333, 0.45, 0.29166666666667
61734, 0.79166666666667, 0.45, 0.27083333333333
61735, 0.79166666666667, 0.475, 0.29166666666667
61736, 0.77083333333333, 0.5, 0.29166666666667
61737, 0.79166666666667, 0.5, 0.27083333333333
61738, 0.79166666666667, 0.525, 0.29166666666667
61739, 0.77083333333333, 0.55, 0.29166666666667
61740, 0.79166666666667, 0.55, 0.27083333333333
61741, 0.79166666666667, 0.575, 0.29166666666667
61742, 0.77083333333333, 0.6, 0.29166666666667
61743, 0.79166666666667, 0.6, 0.27083333333333
61744, 0.79166666666667, 0.625, 0.29166666666667
61745, 0.77083333333333, 0.65, 0.29166666666667
61746, 0.79166666666667, 0.65, 0.27083333333333
61747, 0.79166666666667, 0.675, 0.29166666666667
61748, 0.77083333333333, 0.7, 0.29166666666667
61749, 0.79166666666667, 0.7, 0.27083333333333
61750, 0.79166666666667, 0.725, 0.29166666666667
61751, 0.77083333333333, 0.75, 0.29166666666667
61752, 0.79166666666667, 0.75, 0.27083333333333
61753, 0.79166666666667, 0.775, 0.29166666666667
61754, 0.77083333333333, 0.8, 0.29166666666667
61755, 0.79166666666667, 0.8, 0.27083333333333
61756, 0.79166666666667, 0.825, 0.29166666666667
61757, 0.77083333333333, 0.85, 0.29166666666667
61758, 0.79166666666667, 0.85, 0.27083333333333
61759, 0.79166666666667, 0.875, 0.29166666666667
61760, 0.77083333333333, 0.9, 0.29166666666667
61761, 0.79166666666667, 0.9, 0.27083333333333
61762, 0.79166666666667, 0.925, 0.29166666666667
61763, 0.77083333333333, 0.95, 0.29166666666667
61764, 0.79166666666667, 0.95, 0.27083333333333
61765, 0.79166666666667, 0.975, 0.29166666666667
61766, 0.77083333333333, 1, 0.29166666666667
61767, 0.79166666666667, 1, 0.27083333333333
61768, 0.79166666666667, 1.025, 0.29166666666667
61769, 0.77083333333333, 1.05, 0.29166666666667
61770, 0.79166666666667, 1.05, 0.27083333333333
61771, 0.79166666666667, 1.075, 0.29166666666667
61772, 0.77083333333333, 1.1, 0.29166666666667
61773, 0.79166666666667, 1.1, 0.27083333333333
61774, 0.79166666666667, 1.125, 0.29166666666667
61775, 0.77083333333333, 1.15, 0.29166666666667
61776, 0.79166666666667, 1.15, 0.27083333333333
61777, 0.79166666666667, 1.175, 0.29166666666667
61778, 0.77083333333333, 1.2, 0.29166666666667
61779, 0.79166666666667, 1.2, 0.27083333333333
61780, 0.79166666666667, 1.225, 0.29166666666667
61781, 0.77083333333333, 1.25, 0.29166666666667
61782, 0.79166666666667, 1.25, 0.27083333333333
61783, 0.79166666666667, 1.275, 0.29166666666667
61784, 0.77083333333333, 1.3, 0.29166666666667
61785, 0.79166666666667, 1.3, 0.27083333333333
61786, 0.79166666666667, 1.325, 0.29166666666667
61787, 0.79166666666667, 0.175, 0.33333333333333
61788, 0.77083333333333, 0.2, 0.33333333333333
61789, 0.79166666666667, 0.2, 0.3125
61790, 0.79166666666667, 0.225, 0.33333333333333
61791, 0.77083333333333, 0.25, 0.33333333333333
61792, 0.79166666666667, 0.25, 0.3125
61793, 0.79166666666667, 0.275, 0.33333333333333
61794, 0.77083333333333, 0.3, 0.33333333333333
61795, 0.79166666666667, 0.3, 0.3125
61796, 0.79166666666667, 0.325, 0.33333333333333
61797, 0.77083333333333, 0.35, 0.33333333333333
61798, 0.79166666666667, 0.35, 0.3125
61799, 0.79166666666667, 0.375, 0.33333333333333
61800, 0.77083333333333, 0.4, 0.33333333333333
61801, 0.79166666666667, 0.4, 0.3125
61802, 0.79166666666667, 0.425, 0.33333333333333
61803, 0.77083333333333, 0.45, 0.33333333333333
61804, 0.79166666666667, 0.45, 0.3125
61805, 0.79166666666667, 0.475, 0.33333333333333
61806, 0.77083333333333, 0.5, 0.33333333333333
61807, 0.79166666666667, 0.5, 0.3125
61808, 0.79166666666667, 0.525, 0.33333333333333
61809, 0.77083333333333, 0.55, 0.33333333333333
61810, 0.79166666666667, 0.55, 0.3125
61811, 0.79166666666667, 0.575, 0.33333333333333
61812, 0.77083333333333, 0.6, 0.33333333333333
61813, 0.79166666666667, 0.6, 0.3125
61814, 0.79166666666667, 0.625, 0.33333333333333
61815, 0.77083333333333, 0.65, 0.33333333333333
61816, 0.79166666666667, 0.65, 0.3125
61817, 0.79166666666667, 0.675, 0.33333333333333
61818, 0.77083333333333, 0.7, 0.33333333333333
61819, 0.79166666666667, 0.7, 0.3125
61820, 0.79166666666667, 0.725, 0.33333333333333
61821, 0.77083333333333, 0.75, 0.33333333333333
61822, 0.79166666666667, 0.75, 0.3125
61823, 0.79166666666667, 0.775, 0.33333333333333
61824, 0.77083333333333, 0.8, 0.33333333333333
61825, 0.79166666666667, 0.8, 0.3125
61826, 0.79166666666667, 0.825, 0.33333333333333
61827, 0.77083333333333, 0.85, 0.33333333333333
61828, 0.79166666666667, 0.85, 0.3125
61829, 0.79166666666667, 0.875, 0.33333333333333
61830, 0.77083333333333, 0.9, 0.33333333333333
61831, 0.79166666666667, 0.9, 0.3125
61832, 0.79166666666667, 0.925, 0.33333333333333
61833, 0.77083333333333, 0.95, 0.33333333333333
61834, 0.79166666666667, 0.95, 0.3125
61835, 0.79166666666667, 0.975, 0.33333333333333
61836, 0.77083333333333, 1, 0.33333333333333
61837, 0.79166666666667, 1, 0.3125
61838, 0.79166666666667, 1.025, 0.33333333333333
61839, 0.77083333333333, 1.05, 0.33333333333333
61840, 0.79166666666667, 1.05, 0.3125
61841, 0.79166666666667, 1.075, 0.33333333333333
61842, 0.77083333333333, 1.1, 0.33333333333333
61843, 0.79166666666667, 1.1, 0.3125
61844, 0.79166666666667, 1.125, 0.33333333333333
61845, 0.77083333333333, 1.15, 0.33333333333333
61846, 0.79166666666667, 1.15, 0.3125
61847, 0.79166666666667, 1.175, 0.33333333333333
61848, 0.77083333333333, 1.2, 0.33333333333333
61849, 0.79166666666667, 1.2, 0.3125
61850, 0.79166666666667, 1.225, 0.33333333333333
61851, 0.77083333333333, 1.25, 0.33333333333333
61852, 0.79166666666667, 1.25, 0.3125
61853, 0.79166666666667, 1.275, 0.33333333333333
61854, 0.77083333333333, 1.3, 0.33333333333333
61855, 0.79166666666667, 1.3, 0.3125
61856, 0.79166666666667, 1.325, 0.33333333333333
61857, 0.79166666666667, 0.175, 0.375
61858, 0.77083333333333, 0.2, 0.375
61859, 0.79166666666667, 0.2, 0.35416666666667
61860, 0.79166666666667, 0.225, 0.375
61861, 0.77083333333333, 0.25, 0.375
61862, 0.79166666666667, 0.25, 0.35416666666667
61863, 0.79166666666667, 0.275, 0.375
61864, 0.77083333333333, 0.3, 0.375
61865, 0.79166666666667, 0.3, 0.35416666666667
61866, 0.79166666666667, 0.325, 0.375
61867, 0.77083333333333, 0.35, 0.375
61868, 0.79166666666667, 0.35, 0.35416666666667
61869, 0.79166666666667, 0.375, 0.375
61870, 0.77083333333333, 0.4, 0.375
61871, 0.79166666666667, 0.4, 0.35416666666667
61872, 0.79166666666667, 0.425, 0.375
61873, 0.77083333333333, 0.45, 0.375
61874, 0.79166666666667, 0.45, 0.35416666666667
61875, 0.79166666666667, 0.475, 0.375
61876, 0.77083333333333, 0.5, 0.375
61877, 0.79166666666667, 0.5, 0.35416666666667
61878, 0.79166666666667, 0.525, 0.375
61879, 0.77083333333333, 0.55, 0.375
61880, 0.79166666666667, 0.55, 0.35416666666667
61881, 0.79166666666667, 0.575, 0.375
61882, 0.77083333333333, 0.6, 0.375
61883, 0.79166666666667, 0.6, 0.35416666666667
61884, 0.79166666666667, 0.625, 0.375
61885, 0.77083333333333, 0.65, 0.375
61886, 0.79166666666667, 0.65, 0.35416666666667
61887, 0.79166666666667, 0.675, 0.375
61888, 0.77083333333333, 0.7, 0.375
61889, 0.79166666666667, 0.7, 0.35416666666667
61890, 0.79166666666667, 0.725, 0.375
61891, 0.77083333333333, 0.75, 0.375
61892, 0.79166666666667, 0.75, 0.35416666666667
61893, 0.79166666666667, 0.775, 0.375
61894, 0.77083333333333, 0.8, 0.375
61895, 0.79166666666667, 0.8, 0.35416666666667
61896, 0.79166666666667, 0.825, 0.375
61897, 0.77083333333333, 0.85, 0.375
61898, 0.79166666666667, 0.85, 0.35416666666667
61899, 0.79166666666667, 0.875, 0.375
61900, 0.77083333333333, 0.9, 0.375
61901, 0.79166666666667, 0.9, 0.35416666666667
61902, 0.79166666666667, 0.925, 0.375
61903, 0.77083333333333, 0.95, 0.375
61904, 0.79166666666667, 0.95, 0.35416666666667
61905, 0.79166666666667, 0.975, 0.375
61906, 0.77083333333333, 1, 0.375
61907, 0.79166666666667, 1, 0.35416666666667
61908, 0.79166666666667, 1.025, 0.375
61909, 0.77083333333333, 1.05, 0.375
61910, 0.79166666666667, 1.05, 0.35416666666667
61911, 0.79166666666667, 1.075, 0.375
61912, 0.77083333333333, 1.1, 0.375
61913, 0.79166666666667, 1.1, 0.35416666666667
61914, 0.79166666666667, 1.125, 0.375
61915, 0.77083333333333, 1.15, 0.375
61916, 0.79166666666667, 1.15, 0.35416666666667
61917, 0.79166666666667, 1.175, 0.375
61918, 0.77083333333333, 1.2, 0.375
61919, 0.79166666666667, 1.2, 0.35416666666667
61920, 0.79166666666667, 1.225, 0.375
61921, 0.77083333333333, 1.25, 0.375
61922, 0.79166666666667, 1.25, 0.35416666666667
61923, 0.79166666666667, 1.275, 0.375
61924, 0.77083333333333, 1.3, 0.375
61925, 0.79166666666667, 1.3, 0.35416666666667
61926, 0.79166666666667, 1.325, 0.375
61927, 0.79166666666667, 0.175, 0.41666666666667
61928, 0.77083333333333, 0.2, 0.41666666666667
61929, 0.79166666666667, 0.2, 0.39583333333333
61930, 0.79166666666667, 0.225, 0.41666666666667
61931, 0.77083333333333, 0.25, 0.41666666666667
61932, 0.79166666666667, 0.25, 0.39583333333333
61933, 0.79166666666667, 0.275, 0.41666666666667
61934, 0.77083333333333, 0.3, 0.41666666666667
61935, 0.79166666666667, 0.3, 0.39583333333333
61936, 0.79166666666667, 0.325, 0.41666666666667
61937, 0.77083333333333, 0.35, 0.41666666666667
61938, 0.79166666666667, 0.35, 0.39583333333333
61939, 0.79166666666667, 0.375, 0.41666666666667
61940, 0.77083333333333, 0.4, 0.41666666666667
61941, 0.79166666666667, 0.4, 0.39583333333333
61942, 0.79166666666667, 0.425, 0.41666666666667
61943, 0.77083333333333, 0.45, 0.41666666666667
61944, 0.79166666666667, 0.45, 0.39583333333333
61945, 0.79166666666667, 0.475, 0.41666666666667
61946, 0.77083333333333, 0.5, 0.41666666666667
61947, 0.79166666666667, 0.5, 0.39583333333333
61948, 0.79166666666667, 0.525, 0.41666666666667
61949, 0.77083333333333, 0.55, 0.41666666666667
61950, 0.79166666666667, 0.55, 0.39583333333333
61951, 0.79166666666667, 0.575, 0.41666666666667
61952, 0.77083333333333, 0.6, 0.41666666666667
61953, 0.79166666666667, 0.6, 0.39583333333333
61954, 0.79166666666667, 0.625, 0.41666666666667
61955, 0.77083333333333, 0.65, 0.41666666666667
61956, 0.79166666666667, 0.65, 0.39583333333333
61957, 0.79166666666667, 0.675, 0.41666666666667
61958, 0.77083333333333, 0.7, 0.41666666666667
61959, 0.79166666666667, 0.7, 0.39583333333333
61960, 0.79166666666667, 0.725, 0.41666666666667
61961, 0.77083333333333, 0.75, 0.41666666666667
61962, 0.79166666666667, 0.75, 0.39583333333333
61963, 0.79166666666667, 0.775, 0.41666666666667
61964, 0.77083333333333, 0.8, 0.41666666666667
61965, 0.79166666666667, 0.8, 0.39583333333333
61966, 0.79166666666667, 0.825, 0.41666666666667
61967, 0.77083333333333, 0.85, 0.41666666666667
61968, 0.79166666666667, 0.85, 0.39583333333333
61969, 0.79166666666667, 0.875, 0.41666666666667
61970, 0.77083333333333, 0.9, 0.41666666666667
61971, 0.79166666666667, 0.9, 0.39583333333333
61972, 0.79166666666667, 0.925, 0.41666666666667
61973, 0.77083333333333, 0.95, 0.41666666666667
61974, 0.79166666666667, 0.95, 0.39583333333333
61975, 0.79166666666667, 0.975, 0.41666666666667
61976, 0.77083333333333, 1, 0.41666666666667
61977, 0.79166666666667, 1, 0.39583333333333
61978, 0.79166666666667, 1.025, 0.41666666666667
61979, 0.77083333333333, 1.05, 0.41666666666667
61980, 0.79166666666667, 1.05, 0.39583333333333
61981, 0.79166666666667, 1.075, 0.41666666666667
61982, 0.77083333333333, 1.1, 0.41666666666667
61983, 0.79166666666667, 1.1, 0.39583333333333
61984, 0.79166666666667, 1.125, 0.41666666666667
61985, 0.77083333333333, 1.15, 0.41666666666667
61986, 0.79166666666667, 1.15, 0.39583333333333
61987, 0.79166666666667, 1.175, 0.41666666666667
61988, 0.77083333333333, 1.2, 0.41666666666667
61989, 0.79166666666667, 1.2, 0.39583333333333
61990, 0.79166666666667, 1.225, 0.41666666666667
61991, 0.77083333333333, 1.25, 0.41666666666667
61992, 0.79166666666667, 1.25, 0.39583333333333
61993, 0.79166666666667, 1.275, 0.41666666666667
61994, 0.77083333333333, 1.3, 0.41666666666667
61995, 0.79166666666667, 1.3, 0.39583333333333
61996, 0.79166666666667, 1.325, 0.41666666666667
61997, 0.79166666666667, 0.175, 0.45833333333333
61998, 0.77083333333333, 0.2, 0.45833333333333
61999, 0.79166666666667, 0.2, 0.4375
62000, 0.79166666666667, 0.225, 0.45833333333333
62001, 0.77083333333333, 0.25, 0.45833333333333
62002, 0.79166666666667, 0.25, 0.4375
62003, 0.79166666666667, 0.275, 0.45833333333333
62004, 0.77083333333333, 0.3, 0.45833333333333
62005, 0.79166666666667, 0.3, 0.4375
62006, 0.79166666666667, 0.325, 0.45833333333333
62007, 0.77083333333333, 0.35, 0.45833333333333
62008, 0.79166666666667, 0.35, 0.4375
62009, 0.79166666666667, 0.375, 0.45833333333333
62010, 0.77083333333333, 0.4, 0.45833333333333
62011, 0.79166666666667, 0.4, 0.4375
62012, 0.79166666666667, 0.425, 0.45833333333333
62013, 0.77083333333333, 0.45, 0.45833333333333
62014, 0.79166666666667, 0.45, 0.4375
62015, 0.79166666666667, 0.475, 0.45833333333333
62016, 0.77083333333333, 0.5, 0.45833333333333
62017, 0.79166666666667, 0.5, 0.4375
62018, 0.79166666666667, 0.525, 0.45833333333333
62019, 0.77083333333333, 0.55, 0.45833333333333
62020, 0.79166666666667, 0.55, 0.4375
62021, 0.79166666666667, 0.575, 0.45833333333333
62022, 0.77083333333333, 0.6, 0.45833333333333
62023, 0.79166666666667, 0.6, 0.4375
62024, 0.79166666666667, 0.625, 0.45833333333333
62025, 0.77083333333333, 0.65, 0.45833333333333
62026, 0.79166666666667, 0.65, 0.4375
62027, 0.79166666666667, 0.675, 0.45833333333333
62028, 0.77083333333333, 0.7, 0.45833333333333
62029, 0.79166666666667, 0.7, 0.4375
62030, 0.79166666666667, 0.725, 0.45833333333333
62031, 0.77083333333333, 0.75, 0.45833333333333
62032, 0.79166666666667, 0.75, 0.4375
62033, 0.79166666666667, 0.775, 0.45833333333333
62034, 0.77083333333333, 0.8, 0.45833333333333
62035, 0.79166666666667, 0.8, 0.4375
62036, 0.79166666666667, 0.825, 0.45833333333333
62037, 0.77083333333333, 0.85, 0.45833333333333
62038, 0.79166666666667, 0.85, 0.4375
62039, 0.79166666666667, 0.875, 0.45833333333333
62040, 0.77083333333333, 0.9, 0.45833333333333
62041, 0.79166666666667, 0.9, 0.4375
62042, 0.79166666666667, 0.925, 0.45833333333333
62043, 0.77083333333333, 0.95, 0.45833333333333
62044, 0.79166666666667, 0.95, 0.4375
62045, 0.79166666666667, 0.975, 0.45833333333333
62046, 0.77083333333333, 1, 0.45833333333333
62047, 0.79166666666667, 1, 0.4375
62048, 0.79166666666667, 1.025, 0.45833333333333
62049, 0.77083333333333, 1.05, 0.45833333333333
62050, 0.79166666666667, 1.05, 0.4375
62051, 0.79166666666667, 1.075, 0.45833333333333
62052, 0.77083333333333, 1.1, 0.45833333333333
62053, 0.79166666666667, 1.1, 0.4375
62054, 0.79166666666667, 1.125, 0.45833333333333
62055, 0.77083333333333, 1.15, 0.45833333333333
62056, 0.79166666666667, 1.15, 0.4375
62057, 0.79166666666667, 1.175, 0.45833333333333
62058, 0.77083333333333, 1.2, 0.45833333333333
62059, 0.79166666666667, 1.2, 0.4375
62060, 0.79166666666667, 1.225, 0.45833333333333
62061, 0.77083333333333, 1.25, 0.45833333333333
62062, 0.79166666666667, 1.25, 0.4375
62063, 0.79166666666667, 1.275, 0.45833333333333
62064, 0.77083333333333, 1.3, 0.45833333333333
62065, 0.79166666666667, 1.3, 0.4375
62066, 0.79166666666667, 1.325, 0.45833333333333
62067, 0.79166666666667, 0.2, 0.47916666666667
62068, 0.79166666666667, 0.25, 0.47916666666667
62069, 0.79166666666667, 0.3, 0.47916666666667
62070, 0.79166666666667, 0.35, 0.47916666666667
62071, 0.79166666666667, 0.4, 0.47916666666667
62072, 0.79166666666667, 0.45, 0.47916666666667
62073, 0.79166666666667, 0.5, 0.47916666666667
62074, 0.79166666666667, 0.55, 0.47916666666667
62075, 0.79166666666667, 0.6, 0.47916666666667
62076, 0.79166666666667, 0.65, 0.47916666666667
62077, 0.79166666666667, 0.7, 0.47916666666667
62078, 0.79166666666667, 0.75, 0.47916666666667
62079, 0.79166666666667, 0.8, 0.47916666666667
62080, 0.79166666666667, 0.85, 0.47916666666667
62081, 0.79166666666667, 0.9, 0.47916666666667
62082, 0.79166666666667, 0.95, 0.47916666666667
62083, 0.79166666666667, 1, 0.47916666666667
62084, 0.79166666666667, 1.05, 0.47916666666667
62085, 0.79166666666667, 1.1, 0.47916666666667
62086, 0.79166666666667, 1.15, 0.47916666666667
62087, 0.79166666666667, 1.2, 0.47916666666667
62088, 0.79166666666667, 1.25, 0.47916666666667
62089, 0.79166666666667, 1.3, 0.47916666666667
62090, 0.83333333333333, 0.175, 0.041666666666667
62091, 0.8125, 0.2, 0.041666666666667
62092, 0.83333333333333, 0.2, 0.020833333333333
62093, 0.83333333333333, 0.225, 0.041666666666667
62094, 0.8125, 0.25, 0.041666666666667
62095, 0.83333333333333, 0.25, 0.020833333333333
62096, 0.83333333333333, 0.275, 0.041666666666667
62097, 0.8125, 0.3, 0.041666666666667
62098, 0.83333333333333, 0.3, 0.020833333333333
62099, 0.83333333333333, 0.325, 0.041666666666667
62100, 0.8125, 0.35, 0.041666666666667
62101, 0.83333333333333, 0.35, 0.020833333333333
62102, 0.83333333333333, 0.375, 0.041666666666667
62103, 0.8125, 0.4, 0.041666666666667
62104, 0.83333333333333, 0.4, 0.020833333333333
62105, 0.83333333333333, 0.425, 0.041666666666667
62106, 0.8125, 0.45, 0.041666666666667
62107, 0.83333333333333, 0.45, 0.020833333333333
62108, 0.83333333333333, 0.475, 0.041666666666667
62109, 0.8125, 0.5, 0.041666666666667
62110, 0.83333333333333, 0.5, 0.020833333333333
62111, 0.83333333333333, 0.525, 0.041666666666667
62112, 0.8125, 0.55, 0.041666666666667
62113, 0.83333333333333, 0.55, 0.020833333333333
62114, 0.83333333333333, 0.575, 0.041666666666667
62115, 0.8125, 0.6, 0.041666666666667
62116, 0.83333333333333, 0.6, 0.020833333333333
62117, 0.83333333333333, 0.625, 0.041666666666667
62118, 0.8125, 0.65, 0.041666666666667
62119, 0.83333333333333, 0.65, 0.020833333333333
62120, 0.83333333333333, 0.675, 0.041666666666667
62121, 0.8125, 0.7, 0.041666666666667
62122, 0.83333333333333, 0.7, 0.020833333333333
62123, 0.83333333333333, 0.725, 0.041666666666667
62124, 0.8125, 0.75, 0.041666666666667
62125, 0.83333333333333, 0.75, 0.020833333333333
62126, 0.83333333333333, 0.775, 0.041666666666667
62127, 0.8125, 0.8, 0.041666666666667
62128, 0.83333333333333, 0.8, 0.020833333333333
62129, 0.83333333333333, 0.825, 0.041666666666667
62130, 0.8125, 0.85, 0.041666666666667
62131, 0.83333333333333, 0.85, 0.020833333333333
62132, 0.83333333333333, 0.875, 0.041666666666667
62133, 0.8125, 0.9, 0.041666666666667
62134, 0.83333333333333, 0.9, 0.020833333333333
62135, 0.83333333333333, 0.925, 0.041666666666667
62136, 0.8125, 0.95, 0.041666666666667
62137, 0.83333333333333, 0.95, 0.020833333333333
62138, 0.83333333333333, 0.975, 0.041666666666667
62139, 0.8125, 1, 0.041666666666667
62140, 0.83333333333333, 1, 0.020833333333333
62141, 0.83333333333333, 1.025, 0.041666666666667
62142, 0.8125, 1.05, 0.041666666666667
62143, 0.83333333333333, 1.05, 0.020833333333333
62144, 0.83333333333333, 1.075, 0.041666666666667
62145, 0.8125, 1.1, 0.041666666666667
62146, 0.83333333333333, 1.1, 0.020833333333333
62147, 0.83333333333333, 1.125, 0.041666666666667
62148, 0.8125, 1.15, 0.041666666666667
62149, 0.83333333333333, 1.15, 0.020833333333333
62150, 0.83333333333333, 1.175, 0.041666666666667
62151, 0.8125, 1.2, 0.041666666666667
62152, 0.83333333333333, 1.2, 0.020833333333333
62153, 0.83333333333333, 1.225, 0.041666666666667
62154, 0.8125, 1.25, 0.041666666666667
62155, 0.83333333333333, 1.25, 0.020833333333333
62156, 0.83333333333333, 1.275, 0.041666666666667
62157, 0.8125, 1.3, 0.041666666666667
62158, 0.83333333333333, 1.3, 0.020833333333333
62159, 0.83333333333333, 1.325, 0.041666666666667
62160, 0.83333333333333, 0.175, 0.083333333333333
62161, 0.8125, 0.2, 0.083333333333333
62162, 0.83333333333333, 0.2, 0.0625
62163, 0.83333333333333, 0.225, 0.083333333333333
62164, 0.8125, 0.25, 0.083333333333333
62165, 0.83333333333333, 0.25, 0.0625
62166, 0.83333333333333, 0.275, 0.083333333333333
62167, 0.8125, 0.3, 0.083333333333333
62168, 0.83333333333333, 0.3, 0.0625
62169, 0.83333333333333, 0.325, 0.083333333333333
62170, 0.8125, 0.35, 0.083333333333333
62171, 0.83333333333333, 0.35, 0.0625
62172, 0.83333333333333, 0.375, 0.083333333333333
62173, 0.8125, 0.4, 0.083333333333333
62174, 0.83333333333333, 0.4, 0.0625
62175, 0.83333333333333, 0.425, 0.083333333333333
62176, 0.8125, 0.45, 0.083333333333333
62177, 0.83333333333333, 0.45, 0.0625
62178, 0.83333333333333, 0.475, 0.083333333333333
62179, 0.8125, 0.5, 0.083333333333333
62180, 0.83333333333333, 0.5, 0.0625
62181, 0.83333333333333, 0.525, 0.083333333333333
62182, 0.8125, 0.55, 0.083333333333333
62183, 0.83333333333333, 0.55, 0.0625
62184, 0.83333333333333, 0.575, 0.083333333333333
62185, 0.8125, 0.6, 0.083333333333333
62186, 0.83333333333333, 0.6, 0.0625
62187, 0.83333333333333, 0.625, 0.083333333333333
62188, 0.8125, 0.65, 0.083333333333333
62189, 0.83333333333333, 0.65, 0.0625
62190, 0.83333333333333, 0.675, 0.083333333333333
62191, 0.8125, 0.7, 0.083333333333333
62192, 0.83333333333333, 0.7, 0.0625
62193, 0.83333333333333, 0.725, 0.083333333333333
62194, 0.8125, 0.75, 0.083333333333333
62195, 0.83333333333333, 0.75, 0.0625
62196, 0.83333333333333, 0.775, 0.083333333333333
62197, 0.8125, 0.8, 0.083333333333333
62198, 0.83333333333333, 0.8, 0.0625
62199, 0.83333333333333, 0.825, 0.083333333333333
62200, 0.8125, 0.85, 0.083333333333333
62201, 0.83333333333333, 0.85, 0.0625
62202, 0.83333333333333, 0.875, 0.083333333333333
62203, 0.8125, 0.9, 0.083333333333333
62204, 0.83333333333333, 0.9, 0.0625
62205, 0.83333333333333, 0.925, 0.083333333333333
62206, 0.8125, 0.95, 0.083333333333333
62207, 0.83333333333333, 0.95, 0.0625
62208, 0.83333333333333, 0.975, 0.083333333333333
62209, 0.8125, 1, 0.083333333333333
62210, 0.83333333333333, 1, 0.0625
62211, 0.83333333333333, 1.025, 0.083333333333333
62212, 0.8125, 1.05, 0.083333333333333
62213, 0.83333333333333, 1.05, 0.0625
62214, 0.83333333333333, 1.075, 0.083333333333333
62215, 0.8125, 1.1, 0.083333333333333
62216, 0.83333333333333, 1.1, 0.0625
62217, 0.83333333333333, 1.125, 0.083333333333333
62218, 0.8125, 1.15, 0.083333333333333
62219, 0.83333333333333, 1.15, 0.0625
62220, 0.83333333333333, 1.175, 0.083333333333333
62221, 0.8125, 1.2, 0.083333333333333
62222, 0.83333333333333, 1.2, 0.0625
62223, 0.83333333333333, 1.225, 0.083333333333333
62224, 0.8125, 1.25, 0.083333333333333
62225, 0.83333333333333, 1.25, 0.0625
62226, 0.83333333333333, 1.275, 0.083333333333333
62227, 0.8125, 1.3, 0.083333333333333
62228, 0.83333333333333, 1.3, 0.0625
62229, 0.83333333333333, 1.325, 0.083333333333333
62230, 0.83333333333333, 0.175, 0.125
62231, 0.8125, 0.2, 0.125
62232, 0.83333333333333, 0.2, 0.10416666666667
62233, 0.83333333333333, 0.225, 0.125
62234, 0.8125, 0.25, 0.125
62235, 0.83333333333333, 0.25, 0.10416666666667
62236, 0.83333333333333, 0.275, 0.125
62237, 0.8125, 0.3, 0.125
62238, 0.83333333333333, 0.3, 0.10416666666667
62239, 0.83333333333333, 0.325, 0.125
62240, 0.8125, 0.35, 0.125
62241, 0.83333333333333, 0.35, 0.10416666666667
62242, 0.83333333333333, 0.375, 0.125
62243, 0.8125, 0.4, 0.125
62244, 0.83333333333333, 0.4, 0.10416666666667
62245, 0.83333333333333, 0.425, 0.125
62246, 0.8125, 0.45, 0.125
62247, 0.83333333333333, 0.45, 0.10416666666667
62248, 0.83333333333333, 0.475, 0.125
62249, 0.8125, 0.5, 0.125
62250, 0.83333333333333, 0.5, 0.10416666666667
62251, 0.83333333333333, 0.525, 0.125
62252, 0.8125, 0.55, 0.125
62253, 0.83333333333333, 0.55, 0.10416666666667
62254, 0.83333333333333, 0.575, 0.125
62255, 0.8125, 0.6, 0.125
62256, 0.83333333333333, 0.6, 0.10416666666667
62257, 0.83333333333333, 0.625, 0.125
62258, 0.8125, 0.65, 0.125
62259, 0.83333333333333, 0.65, 0.10416666666667
62260, 0.83333333333333, 0.675, 0.125
62261, 0.8125, 0.7, 0.125
62262, 0.83333333333333, 0.7, 0.10416666666667
62263, 0.83333333333333, 0.725, 0.125
62264, 0.8125, 0.75, 0.125
62265, 0.83333333333333, 0.75, 0.10416666666667
62266, 0.83333333333333, 0.775, 0.125
62267, 0.8125, 0.8, 0.125
62268, 0.83333333333333, 0.8, 0.10416666666667
62269, 0.83333333333333, 0.825, 0.125
62270, 0.8125, 0.85, 0.125
62271, 0.83333333333333, 0.85, 0.10416666666667
62272, 0.83333333333333, 0.875, 0.125
62273, 0.8125, 0.9, 0.125
62274, 0.83333333333333, 0.9, 0.10416666666667
62275, 0.83333333333333, 0.925, 0.125
62276, 0.8125, 0.95, 0.125
62277, 0.83333333333333, 0.95, 0.10416666666667
62278, 0.83333333333333, 0.975, 0.125
62279, 0.8125, 1, 0.125
62280, 0.83333333333333, 1, 0.10416666666667
62281, 0.83333333333333, 1.025, 0.125
62282, 0.8125, 1.05, 0.125
62283, 0.83333333333333, 1.05, 0.10416666666667
62284, 0.83333333333333, 1.075, 0.125
62285, 0.8125, 1.1, 0.125
62286, 0.83333333333333, 1.1, 0.10416666666667
62287, 0.83333333333333, 1.125, 0.125
62288, 0.8125, 1.15, 0.125
62289, 0.83333333333333, 1.15, 0.10416666666667
62290, 0.83333333333333, 1.175, 0.125
62291, 0.8125, 1.2, 0.125
62292, 0.83333333333333, 1.2, 0.10416666666667
62293, 0.83333333333333, 1.225, 0.125
62294, 0.8125, 1.25, 0.125
62295, 0.83333333333333, 1.25, 0.10416666666667
62296, 0.83333333333333, 1.275, 0.125
62297, 0.8125, 1.3, 0.125
62298, 0.83333333333333, 1.3, 0.10416666666667
62299, 0.83333333333333, 1.325, 0.125
62300, 0.83333333333333, 0.175, 0.16666666666667
62301, 0.8125, 0.2, 0.16666666666667
62302, 0.83333333333333, 0.2, 0.14583333333333
62303, 0.83333333333333, 0.225, 0.16666666666667
62304, 0.8125, 0.25, 0.16666666666667
62305, 0.83333333333333, 0.25, 0.14583333333333
62306, 0.83333333333333, 0.275, 0.16666666666667
62307, 0.8125, 0.3, 0.16666666666667
62308, 0.83333333333333, 0.3, 0.14583333333333
62309, 0.83333333333333, 0.325, 0.16666666666667
62310, 0.8125, 0.35, 0.16666666666667
62311, 0.83333333333333, 0.35, 0.14583333333333
62312, 0.83333333333333, 0.375, 0.16666666666667
62313, 0.8125, 0.4, 0.16666666666667
62314, 0.83333333333333, 0.4, 0.14583333333333
62315, 0.83333333333333, 0.425, 0.16666666666667
62316, 0.8125, 0.45, 0.16666666666667
62317, 0.83333333333333, 0.45, 0.14583333333333
62318, 0.83333333333333, 0.475, 0.16666666666667
62319, 0.8125, 0.5, 0.16666666666667
62320, 0.83333333333333, 0.5, 0.14583333333333
62321, 0.83333333333333, 0.525, 0.16666666666667
62322, 0.8125, 0.55, 0.16666666666667
62323, 0.83333333333333, 0.55, 0.14583333333333
62324, 0.83333333333333, 0.575, 0.16666666666667
62325, 0.8125, 0.6, 0.16666666666667
62326, 0.83333333333333, 0.6, 0.14583333333333
62327, 0.83333333333333, 0.625, 0.16666666666667
62328, 0.8125, 0.65, 0.16666666666667
62329, 0.83333333333333, 0.65, 0.14583333333333
62330, 0.83333333333333, 0.675, 0.16666666666667
62331, 0.8125, 0.7, 0.16666666666667
62332, 0.83333333333333, 0.7, 0.14583333333333
62333, 0.83333333333333, 0.725, 0.16666666666667
62334, 0.8125, 0.75, 0.16666666666667
62335, 0.83333333333333, 0.75, 0.14583333333333
62336, 0.83333333333333, 0.775, 0.16666666666667
62337, 0.8125, 0.8, 0.16666666666667
62338, 0.83333333333333, 0.8, 0.14583333333333
62339, 0.83333333333333, 0.825, 0.16666666666667
62340, 0.8125, 0.85, 0.16666666666667
62341, 0.83333333333333, 0.85, 0.14583333333333
62342, 0.83333333333333, 0.875, 0.16666666666667
62343, 0.8125, 0.9, 0.16666666666667
62344, 0.83333333333333, 0.9, 0.14583333333333
62345, 0.83333333333333, 0.925, 0.16666666666667
62346, 0.8125, 0.95, 0.16666666666667
62347, 0.83333333333333, 0.95, 0.14583333333333
62348, 0.83333333333333, 0.975, 0.16666666666667
62349, 0.8125, 1, 0.16666666666667
62350, 0.83333333333333, 1, 0.14583333333333
62351, 0.83333333333333, 1.025, 0.16666666666667
62352, 0.8125, 1.05, 0.16666666666667
62353, 0.83333333333333, 1.05, 0.14583333333333
62354, 0.83333333333333, 1.075, 0.16666666666667
62355, 0.8125, 1.1, 0.16666666666667
62356, 0.83333333333333, 1.1, 0.14583333333333
62357, 0.83333333333333, 1.125, 0.16666666666667
62358, 0.8125, 1.15, 0.16666666666667
62359, 0.83333333333333, 1.15, 0.14583333333333
62360, 0.83333333333333, 1.175, 0.16666666666667
62361, 0.8125, 1.2, 0.16666666666667
62362, 0.83333333333333, 1.2, 0.14583333333333
62363, 0.83333333333333, 1.225, 0.16666666666667
62364, 0.8125, 1.25, 0.16666666666667
62365, 0.83333333333333, 1.25, 0.14583333333333
62366, 0.83333333333333, 1.275, 0.16666666666667
62367, 0.8125, 1.3, 0.16666666666667
62368, 0.83333333333333, 1.3, 0.14583333333333
62369, 0.83333333333333, 1.325, 0.16666666666667
62370, 0.83333333333333, 0.175, 0.20833333333333
62371, 0.8125, 0.2, 0.20833333333333
62372, 0.83333333333333, 0.2, 0.1875
62373, 0.83333333333333, 0.225, 0.20833333333333
62374, 0.8125, 0.25, 0.20833333333333
62375, 0.83333333333333, 0.25, 0.1875
62376, 0.83333333333333, 0.275, 0.20833333333333
62377, 0.8125, 0.3, 0.20833333333333
62378, 0.83333333333333, 0.3, 0.1875
62379, 0.83333333333333, 0.325, 0.20833333333333
62380, 0.8125, 0.35, 0.20833333333333
62381, 0.83333333333333, 0.35, 0.1875
62382, 0.83333333333333, 0.375, 0.20833333333333
62383, 0.8125, 0.4, 0.20833333333333
62384, 0.83333333333333, 0.4, 0.1875
62385, 0.83333333333333, 0.425, 0.20833333333333
62386, 0.8125, 0.45, 0.20833333333333
62387, 0.83333333333333, 0.45, 0.1875
62388, 0.83333333333333, 0.475, 0.20833333333333
62389, 0.8125, 0.5, 0.20833333333333
62390, 0.83333333333333, 0.5, 0.1875
62391, 0.83333333333333, 0.525, 0.20833333333333
62392, 0.8125, 0.55, 0.20833333333333
62393, 0.83333333333333, 0.55, 0.1875
62394, 0.83333333333333, 0.575, 0.20833333333333
62395, 0.8125, 0.6, 0.20833333333333
62396, 0.83333333333333, 0.6, 0.1875
62397, 0.83333333333333, 0.625, 0.20833333333333
62398, 0.8125, 0.65, 0.20833333333333
62399, 0.83333333333333, 0.65, 0.1875
62400, 0.83333333333333, 0.675, 0.20833333333333
62401, 0.8125, 0.7, 0.20833333333333
62402, 0.83333333333333, 0.7, 0.1875
62403, 0.83333333333333, 0.725, 0.20833333333333
62404, 0.8125, 0.75, 0.20833333333333
62405, 0.83333333333333, 0.75, 0.1875
62406, 0.83333333333333, 0.775, 0.20833333333333
62407, 0.8125, 0.8, 0.20833333333333
62408, 0.83333333333333, 0.8, 0.1875
62409, 0.83333333333333, 0.825, 0.20833333333333
62410, 0.8125, 0.85, 0.20833333333333
62411, 0.83333333333333, 0.85, 0.1875
62412, 0.83333333333333, 0.875, 0.20833333333333
62413, 0.8125, 0.9, 0.20833333333333
62414, 0.83333333333333, 0.9, 0.1875
62415, 0.83333333333333, 0.925, 0.20833333333333
62416, 0.8125, 0.95, 0.20833333333333
62417, 0.83333333333333, 0.95, 0.1875
62418, 0.83333333333333, 0.975, 0.20833333333333
62419, 0.8125, 1, 0.20833333333333
62420, 0.83333333333333, 1, 0.1875
62421, 0.83333333333333, 1.025, 0.20833333333333
62422, 0.8125, 1.05, 0.20833333333333
62423, 0.83333333333333, 1.05, 0.1875
62424, 0.83333333333333, 1.075, 0.20833333333333
62425, 0.8125, 1.1, 0.20833333333333
62426, 0.83333333333333, 1.1, 0.1875
62427, 0.83333333333333, 1.125, 0.20833333333333
62428, 0.8125, 1.15, 0.20833333333333
62429, 0.83333333333333, 1.15, 0.1875
62430, 0.83333333333333, 1.175, 0.20833333333333
62431, 0.8125, 1.2, 0.20833333333333
62432, 0.83333333333333, 1.2, 0.1875
62433, 0.83333333333333, 1.225, 0.20833333333333
62434, 0.8125, 1.25, 0.20833333333333
62435, 0.83333333333333, 1.25, 0.1875
62436, 0.83333333333333, 1.275, 0.20833333333333
62437, 0.8125, 1.3, 0.20833333333333
62438, 0.83333333333333, 1.3, 0.1875
62439, 0.83333333333333, 1.325, 0.20833333333333
62440, 0.83333333333333, 0.175, 0.25
62441, 0.8125, 0.2, 0.25
62442, 0.83333333333333, 0.2, 0.22916666666667
62443, 0.83333333333333, 0.225, 0.25
62444, 0.8125, 0.25, 0.25
62445, 0.83333333333333, 0.25, 0.22916666666667
62446, 0.83333333333333, 0.275, 0.25
62447, 0.8125, 0.3, 0.25
62448, 0.83333333333333, 0.3, 0.22916666666667
62449, 0.83333333333333, 0.325, 0.25
62450, 0.8125, 0.35, 0.25
62451, 0.83333333333333, 0.35, 0.22916666666667
62452, 0.83333333333333, 0.375, 0.25
62453, 0.8125, 0.4, 0.25
62454, 0.83333333333333, 0.4, 0.22916666666667
62455, 0.83333333333333, 0.425, 0.25
62456, 0.8125, 0.45, 0.25
62457, 0.83333333333333, 0.45, 0.22916666666667
62458, 0.83333333333333, 0.475, 0.25
62459, 0.8125, 0.5, 0.25
62460, 0.83333333333333, 0.5, 0.22916666666667
62461, 0.83333333333333, 0.525, 0.25
62462, 0.8125, 0.55, 0.25
62463, 0.83333333333333, 0.55, 0.22916666666667
62464, 0.83333333333333, 0.575, 0.25
62465, 0.8125, 0.6, 0.25
62466, 0.83333333333333, 0.6, 0.22916666666667
62467, 0.83333333333333, 0.625, 0.25
62468, 0.8125, 0.65, 0.25
62469, 0.83333333333333, 0.65, 0.22916666666667
62470, 0.83333333333333, 0.675, 0.25
62471, 0.8125, 0.7, 0.25
62472, 0.83333333333333, 0.7, 0.22916666666667
62473, 0.83333333333333, 0.725, 0.25
62474, 0.8125, 0.75, 0.25
62475, 0.83333333333333, 0.75, 0.22916666666667
62476, 0.83333333333333, 0.775, 0.25
62477, 0.8125, 0.8, 0.25
62478, 0.83333333333333, 0.8, 0.22916666666667
62479, 0.83333333333333, 0.825, 0.25
62480, 0.8125, 0.85, 0.25
62481, 0.83333333333333, 0.85, 0.22916666666667
62482, 0.83333333333333, 0.875, 0.25
62483, 0.8125, 0.9, 0.25
62484, 0.83333333333333, 0.9, 0.22916666666667
62485, 0.83333333333333, 0.925, 0.25
62486, 0.8125, 0.95, 0.25
62487, 0.83333333333333, 0.95, 0.22916666666667
62488, 0.83333333333333, 0.975, 0.25
62489, 0.8125, 1, 0.25
62490, 0.83333333333333, 1, 0.22916666666667
62491, 0.83333333333333, 1.025, 0.25
62492, 0.8125, 1.05, 0.25
62493, 0.83333333333333, 1.05, 0.22916666666667
62494, 0.83333333333333, 1.075, 0.25
62495, 0.8125, 1.1, 0.25
62496, 0.83333333333333, 1.1, 0.22916666666667
62497, 0.83333333333333, 1.125, 0.25
62498, 0.8125, 1.15, 0.25
62499, 0.83333333333333, 1.15, 0.22916666666667
62500, 0.83333333333333, 1.175, 0.25
62501, 0.8125, 1.2, 0.25
62502, 0.83333333333333, 1.2, 0.22916666666667
62503, 0.83333333333333, 1.225, 0.25
62504, 0.8125, 1.25, 0.25
62505, 0.83333333333333, 1.25, 0.22916666666667
62506, 0.83333333333333, 1.275, 0.25
62507, 0.8125, 1.3, 0.25
62508, 0.83333333333333, 1.3, 0.22916666666667
62509, 0.83333333333333, 1.325, 0.25
62510, 0.83333333333333, 0.175, 0.29166666666667
62511, 0.8125, 0.2, 0.29166666666667
62512, 0.83333333333333, 0.2, 0.27083333333333
62513, 0.83333333333333, 0.225, 0.29166666666667
62514, 0.8125, 0.25, 0.29166666666667
62515, 0.83333333333333, 0.25, 0.27083333333333
62516, 0.83333333333333, 0.275, 0.29166666666667
62517, 0.8125, 0.3, 0.29166666666667
62518, 0.83333333333333, 0.3, 0.27083333333333
62519, 0.83333333333333, 0.325, 0.29166666666667
62520, 0.8125, 0.35, 0.29166666666667
62521, 0.83333333333333, 0.35, 0.27083333333333
62522, 0.83333333333333, 0.375, 0.29166666666667
62523, 0.8125, 0.4, 0.29166666666667
62524, 0.83333333333333, 0.4, 0.27083333333333
62525, 0.83333333333333, 0.425, 0.29166666666667
62526, 0.8125, 0.45, 0.29166666666667
62527, 0.83333333333333, 0.45, 0.27083333333333
62528, 0.83333333333333, 0.475, 0.29166666666667
62529, 0.8125, 0.5, 0.29166666666667
62530, 0.83333333333333, 0.5, 0.27083333333333
62531, 0.83333333333333, 0.525, 0.29166666666667
62532, 0.8125, 0.55, 0.29166666666667
62533, 0.83333333333333, 0.55, 0.27083333333333
62534, 0.83333333333333, 0.575, 0.29166666666667
62535, 0.8125, 0.6, 0.29166666666667
62536, 0.83333333333333, 0.6, 0.27083333333333
62537, 0.83333333333333, 0.625, 0.29166666666667
62538, 0.8125, 0.65, 0.29166666666667
62539, 0.83333333333333, 0.65, 0.27083333333333
62540, 0.83333333333333, 0.675, 0.29166666666667
62541, 0.8125, 0.7, 0.29166666666667
62542, 0.83333333333333, 0.7, 0.27083333333333
62543, 0.83333333333333, 0.725, 0.29166666666667
62544, 0.8125, 0.75, 0.29166666666667
62545, 0.83333333333333, 0.75, 0.27083333333333
62546, 0.83333333333333, 0.775, 0.29166666666667
62547, 0.8125, 0.8, 0.29166666666667
62548, 0.83333333333333, 0.8, 0.27083333333333
62549, 0.83333333333333, 0.825, 0.29166666666667
62550, 0.8125, 0.85, 0.29166666666667
62551, 0.83333333333333, 0.85, 0.27083333333333
62552, 0.83333333333333, 0.875, 0.29166666666667
62553, 0.8125, 0.9, 0.29166666666667
62554, 0.83333333333333, 0.9, 0.27083333333333
62555, 0.83333333333333, 0.925, 0.29166666666667
62556, 0.8125, 0.95, 0.29166666666667
62557, 0.83333333333333, 0.95, 0.27083333333333
62558, 0.83333333333333, 0.975, 0.29166666666667
62559, 0.8125, 1, 0.29166666666667
62560, 0.83333333333333, 1, 0.27083333333333
62561, 0.83333333333333, 1.025, 0.29166666666667
62562, 0.8125, 1.05, 0.29166666666667
62563, 0.83333333333333, 1.05, 0.27083333333333
62564, 0.83333333333333, 1.075, 0.29166666666667
62565, 0.8125, 1.1, 0.29166666666667
62566, 0.83333333333333, 1.1, 0.27083333333333
62567, 0.83333333333333, 1.125, 0.29166666666667
62568, 0.8125, 1.15, 0.29166666666667
62569, 0.83333333333333, 1.15, 0.27083333333333
62570, 0.83333333333333, 1.175, 0.29166666666667
62571, 0.8125, 1.2, 0.29166666666667
62572, 0.83333333333333, 1.2, 0.27083333333333
62573, 0.83333333333333, 1.225, 0.29166666666667
62574, 0.8125, 1.25, 0.29166666666667
62575, 0.83333333333333, 1.25, 0.27083333333333
62576, 0.83333333333333, 1.275, 0.29166666666667
62577, 0.8125, 1.3, 0.29166666666667
62578, 0.83333333333333, 1.3, 0.27083333333333
62579, 0.83333333333333, 1.325, 0.29166666666667
62580, 0.83333333333333, 0.175, 0.33333333333333
62581, 0.8125, 0.2, 0.33333333333333
62582, 0.83333333333333, 0.2, 0.3125
62583, 0.83333333333333, 0.225, 0.33333333333333
62584, 0.8125, 0.25, 0.33333333333333
62585, 0.83333333333333, 0.25, 0.3125
62586, 0.83333333333333, 0.275, 0.33333333333333
62587, 0.8125, 0.3, 0.33333333333333
62588, 0.83333333333333, 0.3, 0.3125
62589, 0.83333333333333, 0.325, 0.33333333333333
62590, 0.8125, 0.35, 0.33333333333333
62591, 0.83333333333333, 0.35, 0.3125
62592, 0.83333333333333, 0.375, 0.33333333333333
62593, 0.8125, 0.4, 0.33333333333333
62594, 0.83333333333333, 0.4, 0.3125
62595, 0.83333333333333, 0.425, 0.33333333333333
62596, 0.8125, 0.45, 0.33333333333333
62597, 0.83333333333333, 0.45, 0.3125
62598, 0.83333333333333, 0.475, 0.33333333333333
62599, 0.8125, 0.5, 0.33333333333333
62600, 0.83333333333333, 0.5, 0.3125
62601, 0.83333333333333, 0.525, 0.33333333333333
62602, 0.8125, 0.55, 0.33333333333333
62603, 0.83333333333333, 0.55, 0.3125
62604, 0.83333333333333, 0.575, 0.33333333333333
62605, 0.8125, 0.6, 0.33333333333333
62606, 0.83333333333333, 0.6, 0.3125
62607, 0.83333333333333, 0.625, 0.33333333333333
62608, 0.8125, 0.65, 0.33333333333333
62609, 0.83333333333333, 0.65, 0.3125
62610, 0.83333333333333, 0.675, 0.33333333333333
62611, 0.8125, 0.7, 0.33333333333333
62612, 0.83333333333333, 0.7, 0.3125
62613, 0.83333333333333, 0.725, 0.33333333333333
62614, 0.8125, 0.75, 0.33333333333333
62615, 0.83333333333333, 0.75, 0.3125
62616, 0.83333333333333, 0.775, 0.33333333333333
62617, 0.8125, 0.8, 0.33333333333333
62618, 0.83333333333333, 0.8, 0.3125
62619, 0.83333333333333, 0.825, 0.33333333333333
62620, 0.8125, 0.85, 0.33333333333333
62621, 0.83333333333333, 0.85, 0.3125
62622, 0.83333333333333, 0.875, 0.33333333333333
62623, 0.8125, 0.9, 0.33333333333333
62624, 0.83333333333333, 0.9, 0.3125
62625, 0.83333333333333, 0.925, 0.33333333333333
62626, 0.8125, 0.95, 0.33333333333333
62627, 0.83333333333333, 0.95, 0.3125
62628, 0.83333333333333, 0.975, 0.33333333333333
62629, 0.8125, 1, 0.33333333333333
62630, 0.83333333333333, 1, 0.3125
62631, 0.83333333333333, 1.025, 0.33333333333333
62632, 0.8125, 1.05, 0.33333333333333
62633, 0.83333333333333, 1.05, 0.3125
62634, 0.83333333333333, 1.075, 0.33333333333333
62635, 0.8125, 1.1, 0.33333333333333
62636, 0.83333333333333, 1.1, 0.3125
62637, 0.83333333333333, 1.125, 0.33333333333333
62638, 0.8125, 1.15, 0.33333333333333
62639, 0.83333333333333, 1.15, 0.3125
62640, 0.83333333333333, 1.175, 0.33333333333333
62641, 0.8125, 1.2, 0.33333333333333
62642, 0.83333333333333, 1.2, 0.3125
62643, 0.83333333333333, 1.225, 0.33333333333333
62644, 0.8125, 1.25, 0.33333333333333
62645, 0.83333333333333, 1.25, 0.3125
62646, 0.83333333333333, 1.275, 0.33333333333333
62647, 0.8125, 1.3, 0.33333333333333
62648, 0.83333333333333, 1.3, 0.3125
62649, 0.83333333333333, 1.325, 0.33333333333333
62650, 0.83333333333333, 0.175, 0.375
62651, 0.8125, 0.2, 0.375
62652, 0.83333333333333, 0.2, 0.35416666666667
62653, 0.83333333333333, 0.225, 0.375
62654, 0.8125, 0.25, 0.375
62655, 0.83333333333333, 0.25, 0.35416666666667
62656, 0.83333333333333, 0.275, 0.375
62657, 0.8125, 0.3, 0.375
62658, 0.83333333333333, 0.3, 0.35416666666667
62659, 0.83333333333333, 0.325, 0.375
62660, 0.8125, 0.35, 0.375
62661, 0.83333333333333, 0.35, 0.35416666666667
62662, 0.83333333333333, 0.375, 0.375
62663, 0.8125, 0.4, 0.375
62664, 0.83333333333333, 0.4, 0.35416666666667
62665, 0.83333333333333, 0.425, 0.375
62666, 0.8125, 0.45, 0.375
62667, 0.83333333333333, 0.45, 0.35416666666667
62668, 0.83333333333333, 0.475, 0.375
62669, 0.8125, 0.5, 0.375
62670, 0.83333333333333, 0.5, 0.35416666666667
62671, 0.83333333333333, 0.525, 0.375
62672, 0.8125, 0.55, 0.375
62673, 0.83333333333333, 0.55, 0.35416666666667
62674, 0.83333333333333, 0.575, 0.375
62675, 0.8125, 0.6, 0.375
62676, 0.83333333333333, 0.6, 0.35416666666667
62677, 0.83333333333333, 0.625, 0.375
62678, 0.8125, 0.65, 0.375
62679, 0.83333333333333, 0.65, 0.35416666666667
62680, 0.83333333333333, 0.675, 0.375
62681, 0.8125, 0.7, 0.375
62682, 0.83333333333333, 0.7, 0.35416666666667
62683, 0.83333333333333, 0.725, 0.375
62684, 0.8125, 0.75, 0.375
62685, 0.83333333333333, 0.75, 0.35416666666667
62686, 0.83333333333333, 0.775, 0.375
62687, 0.8125, 0.8, 0.375
62688, 0.83333333333333, 0.8, 0.35416666666667
62689, 0.83333333333333, 0.825, 0.375
62690, 0.8125, 0.85, 0.375
62691, 0.83333333333333, 0.85, 0.35416666666667
62692, 0.83333333333333, 0.875, 0.375
62693, 0.8125, 0.9, 0.375
62694, 0.83333333333333, 0.9, 0.35416666666667
62695, 0.83333333333333, 0.925, 0.375
62696, 0.8125, 0.95, 0.375
62697, 0.83333333333333, 0.95, 0.35416666666667
62698, 0.83333333333333, 0.975, 0.375
62699, 0.8125, 1, 0.375
62700, 0.83333333333333, 1, 0.35416666666667
62701, 0.83333333333333, 1.025, 0.375
62702, 0.8125, 1.05, 0.375
62703, 0.83333333333333, 1.05, 0.35416666666667
62704, 0.83333333333333, 1.075, 0.375
62705, 0.8125, 1.1, 0.375
62706, 0.83333333333333, 1.1, 0.35416666666667
62707, 0.83333333333333, 1.125, 0.375
62708, 0.8125, 1.15, 0.375
62709, 0.83333333333333, 1.15, 0.35416666666667
62710, 0.83333333333333, 1.175, 0.375
62711, 0.8125, 1.2, 0.375
62712, 0.83333333333333, 1.2, 0.35416666666667
62713, 0.83333333333333, 1.225, 0.375
62714, 0.8125, 1.25, 0.375
62715, 0.83333333333333, 1.25, 0.35416666666667
62716, 0.83333333333333, 1.275, 0.375
62717, 0.8125, 1.3, 0.375
62718, 0.83333333333333, 1.3, 0.35416666666667
62719, 0.83333333333333, 1.325, 0.375
62720, 0.83333333333333, 0.175, 0.41666666666667
62721, 0.8125, 0.2, 0.41666666666667
62722, 0.83333333333333, 0.2, 0.39583333333333
62723, 0.83333333333333, 0.225, 0.41666666666667
62724, 0.8125, 0.25, 0.41666666666667
62725, 0.83333333333333, 0.25, 0.39583333333333
62726, 0.83333333333333, 0.275, 0.41666666666667
62727, 0.8125, 0.3, 0.41666666666667
62728, 0.83333333333333, 0.3, 0.39583333333333
62729, 0.83333333333333, 0.325, 0.41666666666667
62730, 0.8125, 0.35, 0.41666666666667
62731, 0.83333333333333, 0.35, 0.39583333333333
62732, 0.83333333333333, 0.375, 0.41666666666667
62733, 0.8125, 0.4, 0.41666666666667
62734, 0.83333333333333, 0.4, 0.39583333333333
62735, 0.83333333333333, 0.425, 0.41666666666667
62736, 0.8125, 0.45, 0.41666666666667
62737, 0.83333333333333, 0.45, 0.39583333333333
62738, 0.83333333333333, 0.475, 0.41666666666667
62739, 0.8125, 0.5, 0.41666666666667
62740, 0.83333333333333, 0.5, 0.39583333333333
62741, 0.83333333333333, 0.525, 0.41666666666667
62742, 0.8125, 0.55, 0.41666666666667
62743, 0.83333333333333, 0.55, 0.39583333333333
62744, 0.83333333333333, 0.575, 0.41666666666667
62745, 0.8125, 0.6, 0.41666666666667
62746, 0.83333333333333, 0.6, 0.39583333333333
62747, 0.83333333333333, 0.625, 0.41666666666667
62748, 0.8125, 0.65, 0.41666666666667
62749, 0.83333333333333, 0.65, 0.39583333333333
62750, 0.83333333333333, 0.675, 0.41666666666667
62751, 0.8125, 0.7, 0.41666666666667
62752, 0.83333333333333, 0.7, 0.39583333333333
62753, 0.83333333333333, 0.725, 0.41666666666667
62754, 0.8125, 0.75, 0.41666666666667
62755, 0.83333333333333, 0.75, 0.39583333333333
62756, 0.83333333333333, 0.775, 0.41666666666667
62757, 0.8125, 0.8, 0.41666666666667
62758, 0.83333333333333, 0.8, 0.39583333333333
62759, 0.83333333333333, 0.825, 0.41666666666667
62760, 0.8125, 0.85, 0.41666666666667
62761, 0.83333333333333, 0.85, 0.39583333333333
62762, 0.83333333333333, 0.875, 0.41666666666667
62763, 0.8125, 0.9, 0.41666666666667
62764, 0.83333333333333, 0.9, 0.39583333333333
62765, 0.83333333333333, 0.925, 0.41666666666667
62766, 0.8125, 0.95, 0.41666666666667
62767, 0.83333333333333, 0.95, 0.39583333333333
62768, 0.83333333333333, 0.975, 0.41666666666667
62769, 0.8125, 1, 0.41666666666667
62770, 0.83333333333333, 1, 0.39583333333333
62771, 0.83333333333333, 1.025, 0.41666666666667
62772, 0.8125, 1.05, 0.41666666666667
62773, 0.83333333333333, 1.05, 0.39583333333333
62774, 0.83333333333333, 1.075, 0.41666666666667
62775, 0.8125, 1.1, 0.41666666666667
62776, 0.83333333333333, 1.1, 0.39583333333333
62777, 0.83333333333333, 1.125, 0.41666666666667
62778, 0.8125, 1.15, 0.41666666666667
62779, 0.83333333333333, 1.15, 0.39583333333333
62780, 0.83333333333333, 1.175, 0.41666666666667
62781, 0.8125, 1.2, 0.41666666666667
62782, 0.83333333333333, 1.2, 0.39583333333333
62783, 0.83333333333333, 1.225, 0.41666666666667
62784, 0.8125, 1.25, 0.41666666666667
62785, 0.83333333333333, 1.25, 0.39583333333333
62786, 0.83333333333333, 1.275, 0.41666666666667
62787, 0.8125, 1.3, 0.41666666666667
62788, 0.83333333333333, 1.3, 0.39583333333333
62789, 0.83333333333333, 1.325, 0.41666666666667
62790, 0.83333333333333, 0.175, 0.45833333333333
62791, 0.8125, 0.2, 0.45833333333333
62792, 0.83333333333333, 0.2, 0.4375
62793, 0.83333333333333, 0.225, 0.45833333333333
62794, 0.8125, 0.25, 0.45833333333333
62795, 0.83333333333333, 0.25, 0.4375
62796, 0.83333333333333, 0.275, 0.45833333333333
62797, 0.8125, 0.3, 0.45833333333333
62798, 0.83333333333333, 0.3, 0.4375
62799, 0.83333333333333, 0.325, 0.45833333333333
62800, 0.8125, 0.35, 0.45833333333333
62801, 0.83333333333333, 0.35, 0.4375
62802, 0.83333333333333, 0.375, 0.45833333333333
62803, 0.8125, 0.4, 0.45833333333333
62804, 0.83333333333333, 0.4, 0.4375
62805, 0.83333333333333, 0.425, 0.45833333333333
62806, 0.8125, 0.45, 0.45833333333333
62807, 0.83333333333333, 0.45, 0.4375
62808, 0.83333333333333, 0.475, 0.45833333333333
62809, 0.8125, 0.5, 0.45833333333333
62810, 0.83333333333333, 0.5, 0.4375
62811, 0.83333333333333, 0.525, 0.45833333333333
62812, 0.8125, 0.55, 0.45833333333333
62813, 0.83333333333333, 0.55, 0.4375
62814, 0.83333333333333, 0.575, 0.45833333333333
62815, 0.8125, 0.6, 0.45833333333333
62816, 0.83333333333333, 0.6, 0.4375
62817, 0.83333333333333, 0.625, 0.45833333333333
62818, 0.8125, 0.65, 0.45833333333333
62819, 0.83333333333333, 0.65, 0.4375
62820, 0.83333333333333, 0.675, 0.45833333333333
62821, 0.8125, 0.7, 0.45833333333333
62822, 0.83333333333333, 0.7, 0.4375
62823, 0.83333333333333, 0.725, 0.45833333333333
62824, 0.8125, 0.75, 0.45833333333333
62825, 0.83333333333333, 0.75, 0.4375
62826, 0.83333333333333, 0.775, 0.45833333333333
62827, 0.8125, 0.8, 0.45833333333333
62828, 0.83333333333333, 0.8, 0.4375
62829, 0.83333333333333, 0.825, 0.45833333333333
62830, 0.8125, 0.85, 0.45833333333333
62831, 0.83333333333333, 0.85, 0.4375
62832, 0.83333333333333, 0.875, 0.45833333333333
62833, 0.8125, 0.9, 0.45833333333333
62834, 0.83333333333333, 0.9, 0.4375
62835, 0.83333333333333, 0.925, 0.45833333333333
62836, 0.8125, 0.95, 0.45833333333333
62837, 0.83333333333333, 0.95, 0.4375
62838, 0.83333333333333, 0.975, 0.45833333333333
62839, 0.8125, 1, 0.45833333333333
62840, 0.83333333333333, 1, 0.4375
62841, 0.83333333333333, 1.025, 0.45833333333333
62842, 0.8125, 1.05, 0.45833333333333
62843, 0.83333333333333, 1.05, 0.4375
62844, 0.83333333333333, 1.075, 0.45833333333333
62845, 0.8125, 1.1, 0.45833333333333
62846, 0.83333333333333, 1.1, 0.4375
62847, 0.83333333333333, 1.125, 0.45833333333333
62848, 0.8125, 1.15, 0.45833333333333
62849, 0.83333333333333, 1.15, 0.4375
62850, 0.83333333333333, 1.175, 0.45833333333333
62851, 0.8125, 1.2, 0.45833333333333
62852, 0.83333333333333, 1.2, 0.4375
62853, 0.83333333333333, 1.225, 0.45833333333333
62854, 0.8125, 1.25, 0.45833333333333
62855, 0.83333333333333, 1.25, 0.4375
62856, 0.83333333333333, 1.275, 0.45833333333333
62857, 0.8125, 1.3, 0.45833333333333
62858, 0.83333333333333, 1.3, 0.4375
62859, 0.83333333333333, 1.325, 0.45833333333333
62860, 0.83333333333333, 0.2, 0.47916666666667
62861, 0.83333333333333, 0.25, 0.47916666666667
62862, 0.83333333333333, 0.3, 0.47916666666667
62863, 0.83333333333333, 0.35, 0.47916666666667
62864, 0.83333333333333, 0.4, 0.47916666666667
62865, 0.83333333333333, 0.45, 0.47916666666667
62866, 0.83333333333333, 0.5, 0.47916666666667
62867, 0.83333333333333, 0.55, 0.47916666666667
62868, 0.83333333333333, 0.6, 0.47916666666667
62869, 0.83333333333333, 0.65, 0.47916666666667
62870, 0.83333333333333, 0.7, 0.47916666666667
62871, 0.83333333333333, 0.75, 0.47916666666667
62872, 0.83333333333333, 0.8, 0.47916666666667
62873, 0.83333333333333, 0.85, 0.47916666666667
62874, 0.83333333333333, 0.9, 0.47916666666667
62875, 0.83333333333333, 0.95, 0.47916666666667
62876, 0.83333333333333, 1, 0.47916666666667
62877, 0.83333333333333, 1.05, 0.47916666666667
62878, 0.83333333333333, 1.1, 0.47916666666667
62879, 0.83333333333333, 1.15, 0.47916666666667
62880, 0.83333333333333, 1.2, 0.47916666666667
62881, 0.83333333333333, 1.25, 0.47916666666667
62882, 0.83333333333333, 1.3, 0.47916666666667
62883, 0.875, 0.175, 0.041666666666667
62884, 0.85416666666667, 0.2, 0.041666666666667
62885, 0.875, 0.2, 0.020833333333333
62886, 0.875, 0.225, 0.041666666666667
62887, 0.85416666666667, 0.25, 0.041666666666667
62888, 0.875, 0.25, 0.020833333333333
62889, 0.875, 0.275, 0.041666666666667
62890, 0.85416666666667, 0.3, 0.041666666666667
62891, 0.875, 0.3, 0.020833333333333
62892, 0.875, 0.325, 0.041666666666667
62893, 0.85416666666667, 0.35, 0.041666666666667
62894, 0.875, 0.35, 0.020833333333333
62895, 0.875, 0.375, 0.041666666666667
62896, 0.85416666666667, 0.4, 0.041666666666667
62897, 0.875, 0.4, 0.020833333333333
62898, 0.875, 0.425, 0.041666666666667
62899, 0.85416666666667, 0.45, 0.041666666666667
62900, 0.875, 0.45, 0.020833333333333
62901, 0.875, 0.475, 0.041666666666667
62902, 0.85416666666667, 0.5, 0.041666666666667
62903, 0.875, 0.5, 0.020833333333333
62904, 0.875, 0.525, 0.041666666666667
62905, 0.85416666666667, 0.55, 0.041666666666667
62906, 0.875, 0.55, 0.020833333333333
62907, 0.875, 0.575, 0.041666666666667
62908, 0.85416666666667, 0.6, 0.041666666666667
62909, 0.875, 0.6, 0.020833333333333
62910, 0.875, 0.625, 0.041666666666667
62911, 0.85416666666667, 0.65, 0.041666666666667
62912, 0.875, 0.65, 0.020833333333333
62913, 0.875, 0.675, 0.041666666666667
62914, 0.85416666666667, 0.7, 0.041666666666667
62915, 0.875, 0.7, 0.020833333333333
62916, 0.875, 0.725, 0.041666666666667
62917, 0.85416666666667, 0.75, 0.041666666666667
62918, 0.875, 0.75, 0.020833333333333
62919, 0.875, 0.775, 0.041666666666667
62920, 0.85416666666667, 0.8, 0.041666666666667
62921, 0.875, 0.8, 0.020833333333333
62922, 0.875, 0.825, 0.041666666666667
62923, 0.85416666666667, 0.85, 0.041666666666667
62924, 0.875, 0.85, 0.020833333333333
62925, 0.875, 0.875, 0.041666666666667
62926, 0.85416666666667, 0.9, 0.041666666666667
62927, 0.875, 0.9, 0.020833333333333
62928, 0.875, 0.925, 0.041666666666667
62929, 0.85416666666667, 0.95, 0.041666666666667
62930, 0.875, 0.95, 0.020833333333333
62931, 0.875, 0.975, 0.041666666666667
62932, 0.85416666666667, 1, 0.041666666666667
62933, 0.875, 1, 0.020833333333333
62934, 0.875, 1.025, 0.041666666666667
62935, 0.85416666666667, 1.05, 0.041666666666667
62936, 0.875, 1.05, 0.020833333333333
62937, 0.875, 1.075, 0.041666666666667
62938, 0.85416666666667, 1.1, 0.041666666666667
62939, 0.875, 1.1, 0.020833333333333
62940, 0.875, 1.125, 0.041666666666667
62941, 0.85416666666667, 1.15, 0.041666666666667
62942, 0.875, 1.15, 0.020833333333333
62943, 0.875, 1.175, 0.041666666666667
62944, 0.85416666666667, 1.2, 0.041666666666667
62945, 0.875, 1.2, 0.020833333333333
62946, 0.875, 1.225, 0.041666666666667
62947, 0.85416666666667, 1.25, 0.041666666666667
62948, 0.875, 1.25, 0.020833333333333
62949, 0.875, 1.275, 0.041666666666667
62950, 0.85416666666667, 1.3, 0.041666666666667
62951, 0.875, 1.3, 0.020833333333333
62952, 0.875, 1.325, 0.041666666666667
62953, 0.875, 0.175, 0.083333333333333
62954, 0.85416666666667, 0.2, 0.083333333333333
62955, 0.875, 0.2, 0.0625
62956, 0.875, 0.225, 0.083333333333333
62957, 0.85416666666667, 0.25, 0.083333333333333
62958, 0.875, 0.25, 0.0625
62959, 0.875, 0.275, 0.083333333333333
62960, 0.85416666666667, 0.3, 0.083333333333333
62961, 0.875, 0.3, 0.0625
62962, 0.875, 0.325, 0.083333333333333
62963, 0.85416666666667, 0.35, 0.083333333333333
62964, 0.875, 0.35, 0.0625
62965, 0.875, 0.375, 0.083333333333333
62966, 0.85416666666667, 0.4, 0.083333333333333
62967, 0.875, 0.4, 0.0625
62968, 0.875, 0.425, 0.083333333333333
62969, 0.85416666666667, 0.45, 0.083333333333333
62970, 0.875, 0.45, 0.0625
62971, 0.875, 0.475, 0.083333333333333
62972, 0.85416666666667, 0.5, 0.083333333333333
62973, 0.875, 0.5, 0.0625
62974, 0.875, 0.525, 0.083333333333333
62975, 0.85416666666667, 0.55, 0.083333333333333
62976, 0.875, 0.55, 0.0625
62977, 0.875, 0.575, 0.083333333333333
62978, 0.85416666666667, 0.6, 0.083333333333333
62979, 0.875, 0.6, 0.0625
62980, 0.875, 0.625, 0.083333333333333
62981, 0.85416666666667, 0.65, 0.083333333333333
62982, 0.875, 0.65, 0.0625
62983, 0.875, 0.675, 0.083333333333333
62984, 0.85416666666667, 0.7, 0.083333333333333
62985, 0.875, 0.7, 0.0625
62986, 0.875, 0.725, 0.083333333333333
62987, 0.85416666666667, 0.75, 0.083333333333333
62988, 0.875, 0.75, 0.0625
62989, 0.875, 0.775, 0.083333333333333
62990, 0.85416666666667, 0.8, 0.083333333333333
62991, 0.875, 0.8, 0.0625
62992, 0.875, 0.825, 0.083333333333333
62993, 0.85416666666667, 0.85, 0.083333333333333
62994, 0.875, 0.85, 0.0625
62995, 0.875, 0.875, 0.083333333333333
62996, 0.85416666666667, 0.9, 0.083333333333333
62997, 0.875, 0.9, 0.0625
62998, 0.875, 0.925, 0.083333333333333
62999, 0.85416666666667, 0.95, 0.083333333333333
63000, 0.875, 0.95, 0.0625
63001, 0.875, 0.975, 0.083333333333333
63002, 0.85416666666667, 1, 0.083333333333333
63003, 0.875, 1, 0.0625
63004, 0.875, 1.025, 0.083333333333333
63005, 0.85416666666667, 1.05, 0.083333333333333
63006, 0.875, 1.05, 0.0625
63007, 0.875, 1.075, 0.083333333333333
63008, 0.85416666666667, 1.1, 0.083333333333333
63009, 0.875, 1.1, 0.0625
63010, 0.875, 1.125, 0.083333333333333
63011, 0.85416666666667, 1.15, 0.083333333333333
63012, 0.875, 1.15, 0.0625
63013, 0.875, 1.175, 0.083333333333333
63014, 0.85416666666667, 1.2, 0.083333333333333
63015, 0.875, 1.2, 0.0625
63016, 0.875, 1.225, 0.083333333333333
63017, 0.85416666666667, 1.25, 0.083333333333333
63018, 0.875, 1.25, 0.0625
63019, 0.875, 1.275, 0.083333333333333
63020, 0.85416666666667, 1.3, 0.083333333333333
63021, 0.875, 1.3, 0.0625
63022, 0.875, 1.325, 0.083333333333333
63023, 0.875, 0.175, 0.125
63024, 0.85416666666667, 0.2, 0.125
63025, 0.875, 0.2, 0.10416666666667
63026, 0.875, 0.225, 0.125
63027, 0.85416666666667, 0.25, 0.125
63028, 0.875, 0.25, 0.10416666666667
63029, 0.875, 0.275, 0.125
63030, 0.85416666666667, 0.3, 0.125
63031, 0.875, 0.3, 0.10416666666667
63032, 0.875, 0.325, 0.125
63033, 0.85416666666667, 0.35, 0.125
63034, 0.875, 0.35, 0.10416666666667
63035, 0.875, 0.375, 0.125
63036, 0.85416666666667, 0.4, 0.125
63037, 0.875, 0.4, 0.10416666666667
63038, 0.875, 0.425, 0.125
63039, 0.85416666666667, 0.45, 0.125
63040, 0.875, 0.45, 0.10416666666667
63041, 0.875, 0.475, 0.125
63042, 0.85416666666667, 0.5, 0.125
63043, 0.875, 0.5, 0.10416666666667
63044, 0.875, 0.525, 0.125
63045, 0.85416666666667, 0.55, 0.125
63046, 0.875, 0.55, 0.10416666666667
63047, 0.875, 0.575, 0.125
63048, 0.85416666666667, 0.6, 0.125
63049, 0.875, 0.6, 0.10416666666667
63050, 0.875, 0.625, 0.125
63051, 0.85416666666667, 0.65, 0.125
63052, 0.875, 0.65, 0.10416666666667
63053, 0.875, 0.675, 0.125
63054, 0.85416666666667, 0.7, 0.125
63055, 0.875, 0.7, 0.10416666666667
63056, 0.875, 0.725, 0.125
63057, 0.85416666666667, 0.75, 0.125
63058, 0.875, 0.75, 0.10416666666667
63059, 0.875, 0.775, 0.125
63060, 0.85416666666667, 0.8, 0.125
63061, 0.875, 0.8, 0.10416666666667
63062, 0.875, 0.825, 0.125
63063, 0.85416666666667, 0.85, 0.125
63064, 0.875, 0.85, 0.10416666666667
63065, 0.875, 0.875, 0.125
63066, 0.85416666666667, 0.9, 0.125
63067, 0.875, 0.9, 0.10416666666667
63068, 0.875, 0.925, 0.125
63069, 0.85416666666667, 0.95, 0.125
63070, 0.875, 0.95, 0.10416666666667
63071, 0.875, 0.975, 0.125
63072, 0.85416666666667, 1, 0.125
63073, 0.875, 1, 0.10416666666667
63074, 0.875, 1.025, 0.125
63075, 0.85416666666667, 1.05, 0.125
63076, 0.875, 1.05, 0.10416666666667
63077, 0.875, 1.075, 0.125
63078, 0.85416666666667, 1.1, 0.125
63079, 0.875, 1.1, 0.10416666666667
63080, 0.875, 1.125, 0.125
63081, 0.85416666666667, 1.15, 0.125
63082, 0.875, 1.15, 0.10416666666667
63083, 0.875, 1.175, 0.125
63084, 0.85416666666667, 1.2, 0.125
63085, 0.875, 1.2, 0.10416666666667
63086, 0.875, 1.225, 0.125
63087, 0.85416666666667, 1.25, 0.125
63088, 0.875, 1.25, 0.10416666666667
63089, 0.875, 1.275, 0.125
63090, 0.85416666666667, 1.3, 0.125
63091, 0.875, 1.3, 0.10416666666667
63092, 0.875, 1.325, 0.125
63093, 0.875, 0.175, 0.16666666666667
63094, 0.85416666666667, 0.2, 0.16666666666667
63095, 0.875, 0.2, 0.14583333333333
63096, 0.875, 0.225, 0.16666666666667
63097, 0.85416666666667, 0.25, 0.16666666666667
63098, 0.875, 0.25, 0.14583333333333
63099, 0.875, 0.275, 0.16666666666667
63100, 0.85416666666667, 0.3, 0.16666666666667
63101, 0.875, 0.3, 0.14583333333333
63102, 0.875, 0.325, 0.16666666666667
63103, 0.85416666666667, 0.35, 0.16666666666667
63104, 0.875, 0.35, 0.14583333333333
63105, 0.875, 0.375, 0.16666666666667
63106, 0.85416666666667, 0.4, 0.16666666666667
63107, 0.875, 0.4, 0.14583333333333
63108, 0.875, 0.425, 0.16666666666667
63109, 0.85416666666667, 0.45, 0.16666666666667
63110, 0.875, 0.45, 0.14583333333333
63111, 0.875, 0.475, 0.16666666666667
63112, 0.85416666666667, 0.5, 0.16666666666667
63113, 0.875, 0.5, 0.14583333333333
63114, 0.875, 0.525, 0.16666666666667
63115, 0.85416666666667, 0.55, 0.16666666666667
63116, 0.875, 0.55, 0.14583333333333
63117, 0.875, 0.575, 0.16666666666667
63118, 0.85416666666667, 0.6, 0.16666666666667
63119, 0.875, 0.6, 0.14583333333333
63120, 0.875, 0.625, 0.16666666666667
63121, 0.85416666666667, 0.65, 0.16666666666667
63122, 0.875, 0.65, 0.14583333333333
63123, 0.875, 0.675, 0.16666666666667
63124, 0.85416666666667, 0.7, 0.16666666666667
63125, 0.875, 0.7, 0.14583333333333
63126, 0.875, 0.725, 0.16666666666667
63127, 0.85416666666667, 0.75, 0.16666666666667
63128, 0.875, 0.75, 0.14583333333333
63129, 0.875, 0.775, 0.16666666666667
63130, 0.85416666666667, 0.8, 0.16666666666667
63131, 0.875, 0.8, 0.14583333333333
63132, 0.875, 0.825, 0.16666666666667
63133, 0.85416666666667, 0.85, 0.16666666666667
63134, 0.875, 0.85, 0.14583333333333
63135, 0.875, 0.875, 0.16666666666667
63136, 0.85416666666667, 0.9, 0.16666666666667
63137, 0.875, 0.9, 0.14583333333333
63138, 0.875, 0.925, 0.16666666666667
63139, 0.85416666666667, 0.95, 0.16666666666667
63140, 0.875, 0.95, 0.14583333333333
63141, 0.875, 0.975, 0.16666666666667
63142, 0.85416666666667, 1, 0.16666666666667
63143, 0.875, 1, 0.14583333333333
63144, 0.875, 1.025, 0.16666666666667
63145, 0.85416666666667, 1.05, 0.16666666666667
63146, 0.875, 1.05, 0.14583333333333
63147, 0.875, 1.075, 0.16666666666667
63148, 0.85416666666667, 1.1, 0.16666666666667
63149, 0.875, 1.1, 0.14583333333333
63150, 0.875, 1.125, 0.16666666666667
63151, 0.85416666666667, 1.15, 0.16666666666667
63152, 0.875, 1.15, 0.14583333333333
63153, 0.875, 1.175, 0.16666666666667
63154, 0.85416666666667, 1.2, 0.16666666666667
63155, 0.875, 1.2, 0.14583333333333
63156, 0.875, 1.225, 0.16666666666667
63157, 0.85416666666667, 1.25, 0.16666666666667
63158, 0.875, 1.25, 0.14583333333333
63159, 0.875, 1.275, 0.16666666666667
63160, 0.85416666666667, 1.3, 0.16666666666667
63161, 0.875, 1.3, 0.14583333333333
63162, 0.875, 1.325, 0.16666666666667
63163, 0.875, 0.175, 0.20833333333333
63164, 0.85416666666667, 0.2, 0.20833333333333
63165, 0.875, 0.2, 0.1875
63166, 0.875, 0.225, 0.20833333333333
63167, 0.85416666666667, 0.25, 0.20833333333333
63168, 0.875, 0.25, 0.1875
63169, 0.875, 0.275, 0.20833333333333
63170, 0.85416666666667, 0.3, 0.20833333333333
63171, 0.875, 0.3, 0.1875
63172, 0.875, 0.325, 0.20833333333333
63173, 0.85416666666667, 0.35, 0.20833333333333
63174, 0.875, 0.35, 0.1875
63175, 0.875, 0.375, 0.20833333333333
63176, 0.85416666666667, 0.4, 0.20833333333333
63177, 0.875, 0.4, 0.1875
63178, 0.875, 0.425, 0.20833333333333
63179, 0.85416666666667, 0.45, 0.20833333333333
63180, 0.875, 0.45, 0.1875
63181, 0.875, 0.475, 0.20833333333333
63182, 0.85416666666667, 0.5, 0.20833333333333
63183, 0.875, 0.5, 0.1875
63184, 0.875, 0.525, 0.20833333333333
63185, 0.85416666666667, 0.55, 0.20833333333333
63186, 0.875, 0.55, 0.1875
63187, 0.875, 0.575, 0.20833333333333
63188, 0.85416666666667, 0.6, 0.20833333333333
63189, 0.875, 0.6, 0.1875
63190, 0.875, 0.625, 0.20833333333333
63191, 0.85416666666667, 0.65, 0.20833333333333
63192, 0.875, 0.65, 0.1875
63193, 0.875, 0.675, 0.20833333333333
63194, 0.85416666666667, 0.7, 0.20833333333333
63195, 0.875, 0.7, 0.1875
63196, 0.875, 0.725, 0.20833333333333
63197, 0.85416666666667, 0.75, 0.20833333333333
63198, 0.875, 0.75, 0.1875
63199, 0.875, 0.775, 0.20833333333333
63200, 0.85416666666667, 0.8, 0.20833333333333
63201, 0.875, 0.8, 0.1875
63202, 0.875, 0.825, 0.20833333333333
63203, 0.85416666666667, 0.85, 0.20833333333333
63204, 0.875, 0.85, 0.1875
63205, 0.875, 0.875, 0.20833333333333
63206, 0.85416666666667, 0.9, 0.20833333333333
63207, 0.875, 0.9, 0.1875
63208, 0.875, 0.925, 0.20833333333333
63209, 0.85416666666667, 0.95, 0.20833333333333
63210, 0.875, 0.95, 0.1875
63211, 0.875, 0.975, 0.20833333333333
63212, 0.85416666666667, 1, 0.20833333333333
63213, 0.875, 1, 0.1875
63214, 0.875, 1.025, 0.20833333333333
63215, 0.85416666666667, 1.05, 0.20833333333333
63216, 0.875, 1.05, 0.1875
63217, 0.875, 1.075, 0.20833333333333
63218, 0.85416666666667, 1.1, 0.20833333333333
63219, 0.875, 1.1, 0.1875
63220, 0.875, 1.125, 0.20833333333333
63221, 0.85416666666667, 1.15, 0.20833333333333
63222, 0.875, 1.15, 0.1875
63223, 0.875, 1.175, 0.20833333333333
63224, 0.85416666666667, 1.2, 0.20833333333333
63225, 0.875, 1.2, 0.1875
63226, 0.875, 1.225, 0.20833333333333
63227, 0.85416666666667, 1.25, 0.20833333333333
63228, 0.875, 1.25, 0.1875
63229, 0.875, 1.275, 0.20833333333333
63230, 0.85416666666667, 1.3, 0.20833333333333
63231, 0.875, 1.3, 0.1875
63232, 0.875, 1.325, 0.20833333333333
63233, 0.875, 0.175, 0.25
63234, 0.85416666666667, 0.2, 0.25
63235, 0.875, 0.2, 0.22916666666667
63236, 0.875, 0.225, 0.25
63237, 0.85416666666667, 0.25, 0.25
63238, 0.875, 0.25, 0.22916666666667
63239, 0.875, 0.275, 0.25
63240, 0.85416666666667, 0.3, 0.25
63241, 0.875, 0.3, 0.22916666666667
63242, 0.875, 0.325, 0.25
63243, 0.85416666666667, 0.35, 0.25
63244, 0.875, 0.35, 0.22916666666667
63245, 0.875, 0.375, 0.25
63246, 0.85416666666667, 0.4, 0.25
63247, 0.875, 0.4, 0.22916666666667
63248, 0.875, 0.425, 0.25
63249, 0.85416666666667, 0.45, 0.25
63250, 0.875, 0.45, 0.22916666666667
63251, 0.875, 0.475, 0.25
63252, 0.85416666666667, 0.5, 0.25
63253, 0.875, 0.5, 0.22916666666667
63254, 0.875, 0.525, 0.25
63255, 0.85416666666667, 0.55, 0.25
63256, 0.875, 0.55, 0.22916666666667
63257, 0.875, 0.575, 0.25
63258, 0.85416666666667, 0.6, 0.25
63259, 0.875, 0.6, 0.22916666666667
63260, 0.875, 0.625, 0.25
63261, 0.85416666666667, 0.65, 0.25
63262, 0.875, 0.65, 0.22916666666667
63263, 0.875, 0.675, 0.25
63264, 0.85416666666667, 0.7, 0.25
63265, 0.875, 0.7, 0.22916666666667
63266, 0.875, 0.725, 0.25
63267, 0.85416666666667, 0.75, 0.25
63268, 0.875, 0.75, 0.22916666666667
63269, 0.875, 0.775, 0.25
63270, 0.85416666666667, 0.8, 0.25
63271, 0.875, 0.8, 0.22916666666667
63272, 0.875, 0.825, 0.25
63273, 0.85416666666667, 0.85, 0.25
63274, 0.875, 0.85, 0.22916666666667
63275, 0.875, 0.875, 0.25
63276, 0.85416666666667, 0.9, 0.25
63277, 0.875, 0.9, 0.22916666666667
63278, 0.875, 0.925, 0.25
63279, 0.85416666666667, 0.95, 0.25
63280, 0.875, 0.95, 0.22916666666667
63281, 0.875, 0.975, 0.25
63282, 0.85416666666667, 1, 0.25
63283, 0.875, 1, 0.22916666666667
63284, 0.875, 1.025, 0.25
63285, 0.85416666666667, 1.05, 0.25
63286, 0.875, 1.05, 0.22916666666667
63287, 0.875, 1.075, 0.25
63288, 0.85416666666667, 1.1, 0.25
63289, 0.875, 1.1, 0.22916666666667
63290, 0.875, 1.125, 0.25
63291, 0.85416666666667, 1.15, 0.25
63292, 0.875, 1.15, 0.22916666666667
63293, 0.875, 1.175, 0.25
63294, 0.85416666666667, 1.2, 0.25
63295, 0.875, 1.2, 0.22916666666667
63296, 0.875, 1.225, 0.25
63297, 0.85416666666667, 1.25, 0.25
63298, 0.875, 1.25, 0.22916666666667
63299, 0.875, 1.275, 0.25
63300, 0.85416666666667, 1.3, 0.25
63301, 0.875, 1.3, 0.22916666666667
63302, 0.875, 1.325, 0.25
63303, 0.875, 0.175, 0.29166666666667
63304, 0.85416666666667, 0.2, 0.29166666666667
63305, 0.875, 0.2, 0.27083333333333
63306, 0.875, 0.225, 0.29166666666667
63307, 0.85416666666667, 0.25, 0.29166666666667
63308, 0.875, 0.25, 0.27083333333333
63309, 0.875, 0.275, 0.29166666666667
63310, 0.85416666666667, 0.3, 0.29166666666667
63311, 0.875, 0.3, 0.27083333333333
63312, 0.875, 0.325, 0.29166666666667
63313, 0.85416666666667, 0.35, 0.29166666666667
63314, 0.875, 0.35, 0.27083333333333
63315, 0.875, 0.375, 0.29166666666667
63316, 0.85416666666667, 0.4, 0.29166666666667
63317, 0.875, 0.4, 0.27083333333333
63318, 0.875, 0.425, 0.29166666666667
63319, 0.85416666666667, 0.45, 0.29166666666667
63320, 0.875, 0.45, 0.27083333333333
63321, 0.875, 0.475, 0.29166666666667
63322, 0.85416666666667, 0.5, 0.29166666666667
63323, 0.875, 0.5, 0.27083333333333
63324, 0.875, 0.525, 0.29166666666667
63325, 0.85416666666667, 0.55, 0.29166666666667
63326, 0.875, 0.55, 0.27083333333333
63327, 0.875, 0.575, 0.29166666666667
63328, 0.85416666666667, 0.6, 0.29166666666667
63329, 0.875, 0.6, 0.27083333333333
63330, 0.875, 0.625, 0.29166666666667
63331, 0.85416666666667, 0.65, 0.29166666666667
63332, 0.875, 0.65, 0.27083333333333
63333, 0.875, 0.675, 0.29166666666667
63334, 0.85416666666667, 0.7, 0.29166666666667
63335, 0.875, 0.7, 0.27083333333333
63336, 0.875, 0.725, 0.29166666666667
63337, 0.85416666666667, 0.75, 0.29166666666667
63338, 0.875, 0.75, 0.27083333333333
63339, 0.875, 0.775, 0.29166666666667
63340, 0.85416666666667, 0.8, 0.29166666666667
63341, 0.875, 0.8, 0.27083333333333
63342, 0.875, 0.825, 0.29166666666667
63343, 0.85416666666667, 0.85, 0.29166666666667
63344, 0.875, 0.85, 0.27083333333333
63345, 0.875, 0.875, 0.29166666666667
63346, 0.85416666666667, 0.9, 0.29166666666667
63347, 0.875, 0.9, 0.27083333333333
63348, 0.875, 0.925, 0.29166666666667
63349, 0.85416666666667, 0.95, 0.29166666666667
63350, 0.875, 0.95, 0.27083333333333
63351, 0.875, 0.975, 0.29166666666667
63352, 0.85416666666667, 1, 0.29166666666667
63353, 0.875, 1, 0.27083333333333
63354, 0.875, 1.025, 0.29166666666667
63355, 0.85416666666667, 1.05, 0.29166666666667
63356, 0.875, 1.05, 0.27083333333333
63357, 0.875, 1.075, 0.29166666666667
63358, 0.85416666666667, 1.1, 0.29166666666667
63359, 0.875, 1.1, 0.27083333333333
63360, 0.875, 1.125, 0.29166666666667
63361, 0.85416666666667, 1.15, 0.29166666666667
63362, 0.875, 1.15, 0.27083333333333
63363, 0.875, 1.175, 0.29166666666667
63364, 0.85416666666667, 1.2, 0.29166666666667
63365, 0.875, 1.2, 0.27083333333333
63366, 0.875, 1.225, 0.29166666666667
63367, 0.85416666666667, 1.25, 0.29166666666667
63368, 0.875, 1.25, 0.27083333333333
63369, 0.875, 1.275, 0.29166666666667
63370, 0.85416666666667, 1.3, 0.29166666666667
63371, 0.875, 1.3, 0.27083333333333
63372, 0.875, 1.325, 0.29166666666667
63373, 0.875, 0.175, 0.33333333333333
63374, 0.85416666666667, 0.2, 0.33333333333333
63375, 0.875, 0.2, 0.3125
63376, 0.875, 0.225, 0.33333333333333
63377, 0.85416666666667, 0.25, 0.33333333333333
63378, 0.875, 0.25, 0.3125
63379, 0.875, 0.275, 0.33333333333333
63380, 0.85416666666667, 0.3, 0.33333333333333
63381, 0.875, 0.3, 0.3125
63382, 0.875, 0.325, 0.33333333333333
63383, 0.85416666666667, 0.35, 0.33333333333333
63384, 0.875, 0.35, 0.3125
63385, 0.875, 0.375, 0.33333333333333
63386, 0.85416666666667, 0.4, 0.33333333333333
63387, 0.875, 0.4, 0.3125
63388, 0.875, 0.425, 0.33333333333333
63389, 0.85416666666667, 0.45, 0.33333333333333
63390, 0.875, 0.45, 0.3125
63391, 0.875, 0.475, 0.33333333333333
63392, 0.85416666666667, 0.5, 0.33333333333333
63393, 0.875, 0.5, 0.3125
63394, 0.875, 0.525, 0.33333333333333
63395, 0.85416666666667, 0.55, 0.33333333333333
63396, 0.875, 0.55, 0.3125
63397, 0.875, 0.575, 0.33333333333333
63398, 0.85416666666667, 0.6, 0.33333333333333
63399, 0.875, 0.6, 0.3125
63400, 0.875, 0.625, 0.33333333333333
63401, 0.85416666666667, 0.65, 0.33333333333333
63402, 0.875, 0.65, 0.3125
63403, 0.875, 0.675, 0.33333333333333
63404, 0.85416666666667, 0.7, 0.33333333333333
63405, 0.875, 0.7, 0.3125
63406, 0.875, 0.725, 0.33333333333333
63407, 0.85416666666667, 0.75, 0.33333333333333
63408, 0.875, 0.75, 0.3125
63409, 0.875, 0.775, 0.33333333333333
63410, 0.85416666666667, 0.8, 0.33333333333333
63411, 0.875, 0.8, 0.3125
63412, 0.875, 0.825, 0.33333333333333
63413, 0.85416666666667, 0.85, 0.33333333333333
63414, 0.875, 0.85, 0.3125
63415, 0.875, 0.875, 0.33333333333333
63416, 0.85416666666667, 0.9, 0.33333333333333
63417, 0.875, 0.9, 0.3125
63418, 0.875, 0.925, 0.33333333333333
63419, 0.85416666666667, 0.95, 0.33333333333333
63420, 0.875, 0.95, 0.3125
63421, 0.875, 0.975, 0.33333333333333
63422, 0.85416666666667, 1, 0.33333333333333
63423, 0.875, 1, 0.3125
63424, 0.875, 1.025, 0.33333333333333
63425, 0.85416666666667, 1.05, 0.33333333333333
63426, 0.875, 1.05, 0.3125
63427, 0.875, 1.075, 0.33333333333333
63428, 0.85416666666667, 1.1, 0.33333333333333
63429, 0.875, 1.1, 0.3125
63430, 0.875, 1.125, 0.33333333333333
63431, 0.85416666666667, 1.15, 0.33333333333333
63432, 0.875, 1.15, 0.3125
63433, 0.875, 1.175, 0.33333333333333
63434, 0.85416666666667, 1.2, 0.33333333333333
63435, 0.875, 1.2, 0.3125
63436, 0.875, 1.225, 0.33333333333333
63437, 0.85416666666667, 1.25, 0.33333333333333
63438, 0.875, 1.25, 0.3125
63439, 0.875, 1.275, 0.33333333333333
63440, 0.85416666666667, 1.3, 0.33333333333333
63441, 0.875, 1.3, 0.3125
63442, 0.875, 1.325, 0.33333333333333
63443, 0.875, 0.175, 0.375
63444, 0.85416666666667, 0.2, 0.375
63445, 0.875, 0.2, 0.35416666666667
63446, 0.875, 0.225, 0.375
63447, 0.85416666666667, 0.25, 0.375
63448, 0.875, 0.25, 0.35416666666667
63449, 0.875, 0.275, 0.375
63450, 0.85416666666667, 0.3, 0.375
63451, 0.875, 0.3, 0.35416666666667
63452, 0.875, 0.325, 0.375
63453, 0.85416666666667, 0.35, 0.375
63454, 0.875, 0.35, 0.35416666666667
63455, 0.875, 0.375, 0.375
63456, 0.85416666666667, 0.4, 0.375
63457, 0.875, 0.4, 0.35416666666667
63458, 0.875, 0.425, 0.375
63459, 0.85416666666667, 0.45, 0.375
63460, 0.875, 0.45, 0.35416666666667
63461, 0.875, 0.475, 0.375
63462, 0.85416666666667, 0.5, 0.375
63463, 0.875, 0.5, 0.35416666666667
63464, 0.875, 0.525, 0.375
63465, 0.85416666666667, 0.55, 0.375
63466, 0.875, 0.55, 0.35416666666667
63467, 0.875, 0.575, 0.375
63468, 0.85416666666667, 0.6, 0.375
63469, 0.875, 0.6, 0.35416666666667
63470, 0.875, 0.625, 0.375
63471, 0.85416666666667, 0.65, 0.375
63472, 0.875, 0.65, 0.35416666666667
63473, 0.875, 0.675, 0.375
63474, 0.85416666666667, 0.7, 0.375
63475, 0.875, 0.7, 0.35416666666667
63476, 0.875, 0.725, 0.375
63477, 0.85416666666667, 0.75, 0.375
63478, 0.875, 0.75, 0.35416666666667
63479, 0.875, 0.775, 0.375
63480, 0.85416666666667, 0.8, 0.375
63481, 0.875, 0.8, 0.35416666666667
63482, 0.875, 0.825, 0.375
63483, 0.85416666666667, 0.85, 0.375
63484, 0.875, 0.85, 0.35416666666667
63485, 0.875, 0.875, 0.375
63486, 0.85416666666667, 0.9, 0.375
63487, 0.875, 0.9, 0.35416666666667
63488, 0.875, 0.925, 0.375
63489, 0.85416666666667, 0.95, 0.375
63490, 0.875, 0.95, 0.35416666666667
63491, 0.875, 0.975, 0.375
63492, 0.85416666666667, 1, 0.375
63493, 0.875, 1, 0.35416666666667
63494, 0.875, 1.025, 0.375
63495, 0.85416666666667, 1.05, 0.375
63496, 0.875, 1.05, 0.35416666666667
63497, 0.875, 1.075, 0.375
63498, 0.85416666666667, 1.1, 0.375
63499, 0.875, 1.1, 0.35416666666667
63500, 0.875, 1.125, 0.375
63501, 0.85416666666667, 1.15, 0.375
63502, 0.875, 1.15, 0.35416666666667
63503, 0.875, 1.175, 0.375
63504, 0.85416666666667, 1.2, 0.375
63505, 0.875, 1.2, 0.35416666666667
63506, 0.875, 1.225, 0.375
63507, 0.85416666666667, 1.25, 0.375
63508, 0.875, 1.25, 0.35416666666667
63509, 0.875, 1.275, 0.375
63510, 0.85416666666667, 1.3, 0.375
63511, 0.875, 1.3, 0.35416666666667
63512, 0.875, 1.325, 0.375
63513, 0.875, 0.175, 0.41666666666667
63514, 0.85416666666667, 0.2, 0.41666666666667
63515, 0.875, 0.2, 0.39583333333333
63516, 0.875, 0.225, 0.41666666666667
63517, 0.85416666666667, 0.25, 0.41666666666667
63518, 0.875, 0.25, 0.39583333333333
63519, 0.875, 0.275, 0.41666666666667
63520, 0.85416666666667, 0.3, 0.41666666666667
63521, 0.875, 0.3, 0.39583333333333
63522, 0.875, 0.325, 0.41666666666667
63523, 0.85416666666667, 0.35, 0.41666666666667
63524, 0.875, 0.35, 0.39583333333333
63525, 0.875, 0.375, 0.41666666666667
63526, 0.85416666666667, 0.4, 0.41666666666667
63527, 0.875, 0.4, 0.39583333333333
63528, 0.875, 0.425, 0.41666666666667
63529, 0.85416666666667, 0.45, 0.41666666666667
63530, 0.875, 0.45, 0.39583333333333
63531, 0.875, 0.475, 0.41666666666667
63532, 0.85416666666667, 0.5, 0.41666666666667
63533, 0.875, 0.5, 0.39583333333333
63534, 0.875, 0.525, 0.41666666666667
63535, 0.85416666666667, 0.55, 0.41666666666667
63536, 0.875, 0.55, 0.39583333333333
63537, 0.875, 0.575, 0.41666666666667
63538, 0.85416666666667, 0.6, 0.41666666666667
63539, 0.875, 0.6, 0.39583333333333
63540, 0.875, 0.625, 0.41666666666667
63541, 0.85416666666667, 0.65, 0.41666666666667
63542, 0.875, 0.65, 0.39583333333333
63543, 0.875, 0.675, 0.41666666666667
63544, 0.85416666666667, 0.7, 0.41666666666667
63545, 0.875, 0.7, 0.39583333333333
63546, 0.875, 0.725, 0.41666666666667
63547, 0.85416666666667, 0.75, 0.41666666666667
63548, 0.875, 0.75, 0.39583333333333
63549, 0.875, 0.775, 0.41666666666667
63550, 0.85416666666667, 0.8, 0.41666666666667
63551, 0.875, 0.8, 0.39583333333333
63552, 0.875, 0.825, 0.41666666666667
63553, 0.85416666666667, 0.85, 0.41666666666667
63554, 0.875, 0.85, 0.39583333333333
63555, 0.875, 0.875, 0.41666666666667
63556, 0.85416666666667, 0.9, 0.41666666666667
63557, 0.875, 0.9, 0.39583333333333
63558, 0.875, 0.925, 0.41666666666667
63559, 0.85416666666667, 0.95, 0.41666666666667
63560, 0.875, 0.95, 0.39583333333333
63561, 0.875, 0.975, 0.41666666666667
63562, 0.85416666666667, 1, 0.41666666666667
63563, 0.875, 1, 0.39583333333333
63564, 0.875, 1.025, 0.41666666666667
63565, 0.85416666666667, 1.05, 0.41666666666667
63566, 0.875, 1.05, 0.39583333333333
63567, 0.875, 1.075, 0.41666666666667
63568, 0.85416666666667, 1.1, 0.41666666666667
63569, 0.875, 1.1, 0.39583333333333
63570, 0.875, 1.125, 0.41666666666667
63571, 0.85416666666667, 1.15, 0.41666666666667
63572, 0.875, 1.15, 0.39583333333333
63573, 0.875, 1.175, 0.41666666666667
63574, 0.85416666666667, 1.2, 0.41666666666667
63575, 0.875, 1.2, 0.39583333333333
63576, 0.875, 1.225, 0.41666666666667
63577, 0.85416666666667, 1.25, 0.41666666666667
63578, 0.875, 1.25, 0.39583333333333
63579, 0.875, 1.275, 0.41666666666667
63580, 0.85416666666667, 1.3, 0.41666666666667
63581, 0.875, 1.3, 0.39583333333333
63582, 0.875, 1.325, 0.41666666666667
63583, 0.875, 0.175, 0.45833333333333
63584, 0.85416666666667, 0.2, 0.45833333333333
63585, 0.875, 0.2, 0.4375
63586, 0.875, 0.225, 0.45833333333333
63587, 0.85416666666667, 0.25, 0.45833333333333
63588, 0.875, 0.25, 0.4375
63589, 0.875, 0.275, 0.45833333333333
63590, 0.85416666666667, 0.3, 0.45833333333333
63591, 0.875, 0.3, 0.4375
63592, 0.875, 0.325, 0.45833333333333
63593, 0.85416666666667, 0.35, 0.45833333333333
63594, 0.875, 0.35, 0.4375
63595, 0.875, 0.375, 0.45833333333333
63596, 0.85416666666667, 0.4, 0.45833333333333
63597, 0.875, 0.4, 0.4375
63598, 0.875, 0.425, 0.45833333333333
63599, 0.85416666666667, 0.45, 0.45833333333333
63600, 0.875, 0.45, 0.4375
63601, 0.875, 0.475, 0.45833333333333
63602, 0.85416666666667, 0.5, 0.45833333333333
63603, 0.875, 0.5, 0.4375
63604, 0.875, 0.525, 0.45833333333333
63605, 0.85416666666667, 0.55, 0.45833333333333
63606, 0.875, 0.55, 0.4375
63607, 0.875, 0.575, 0.45833333333333
63608, 0.85416666666667, 0.6, 0.45833333333333
63609, 0.875, 0.6, 0.4375
63610, 0.875, 0.625, 0.45833333333333
63611, 0.85416666666667, 0.65, 0.45833333333333
63612, 0.875, 0.65, 0.4375
63613, 0.875, 0.675, 0.45833333333333
63614, 0.85416666666667, 0.7, 0.45833333333333
63615, 0.875, 0.7, 0.4375
63616, 0.875, 0.725, 0.45833333333333
63617, 0.85416666666667, 0.75, 0.45833333333333
63618, 0.875, 0.75, 0.4375
63619, 0.875, 0.775, 0.45833333333333
63620, 0.85416666666667, 0.8, 0.45833333333333
63621, 0.875, 0.8, 0.4375
63622, 0.875, 0.825, 0.45833333333333
63623, 0.85416666666667, 0.85, 0.45833333333333
63624, 0.875, 0.85, 0.4375
63625, 0.875, 0.875, 0.45833333333333
63626, 0.85416666666667, 0.9, 0.45833333333333
63627, 0.875, 0.9, 0.4375
63628, 0.875, 0.925, 0.45833333333333
63629, 0.85416666666667, 0.95, 0.45833333333333
63630, 0.875, 0.95, 0.4375
63631, 0.875, 0.975, 0.45833333333333
63632, 0.85416666666667, 1, 0.45833333333333
63633, 0.875, 1, 0.4375
63634, 0.875, 1.025, 0.45833333333333
63635, 0.85416666666667, 1.05, 0.45833333333333
63636, 0.875, 1.05, 0.4375
63637, 0.875, 1.075, 0.45833333333333
63638, 0.85416666666667, 1.1, 0.45833333333333
63639, 0.875, 1.1, 0.4375
63640, 0.875, 1.125, 0.45833333333333
63641, 0.85416666666667, 1.15, 0.45833333333333
63642, 0.875, 1.15, 0.4375
63643, 0.875, 1.175, 0.45833333333333
63644, 0.85416666666667, 1.2, 0.45833333333333
63645, 0.875, 1.2, 0.4375
63646, 0.875, 1.225, 0.45833333333333
63647, 0.85416666666667, 1.25, 0.45833333333333
63648, 0.875, 1.25, 0.4375
63649, 0.875, 1.275, 0.45833333333333
63650, 0.85416666666667, 1.3, 0.45833333333333
63651, 0.875, 1.3, 0.4375
63652, 0.875, 1.325, 0.45833333333333
63653, 0.875, 0.2, 0.47916666666667
63654, 0.875, 0.25, 0.47916666666667
63655, 0.875, 0.3, 0.47916666666667
63656, 0.875, 0.35, 0.47916666666667
63657, 0.875, 0.4, 0.47916666666667
63658, 0.875, 0.45, 0.47916666666667
63659, 0.875, 0.5, 0.47916666666667
63660, 0.875, 0.55, 0.47916666666667
63661, 0.875, 0.6, 0.47916666666667
63662, 0.875, 0.65, 0.47916666666667
63663, 0.875, 0.7, 0.47916666666667
63664, 0.875, 0.75, 0.47916666666667
63665, 0.875, 0.8, 0.47916666666667
63666, 0.875, 0.85, 0.47916666666667
63667, 0.875, 0.9, 0.47916666666667
63668, 0.875, 0.95, 0.47916666666667
63669, 0.875, 1, 0.47916666666667
63670, 0.875, 1.05, 0.47916666666667
63671, 0.875, 1.1, 0.47916666666667
63672, 0.875, 1.15, 0.47916666666667
63673, 0.875, 1.2, 0.47916666666667
63674, 0.875, 1.25, 0.47916666666667
63675, 0.875, 1.3, 0.47916666666667
63676, 0.91666666666667, 0.175, 0.041666666666667
63677, 0.89583333333333, 0.2, 0.041666666666667
63678, 0.91666666666667, 0.2, 0.020833333333333
63679, 0.91666666666667, 0.225, 0.041666666666667
63680, 0.89583333333333, 0.25, 0.041666666666667
63681, 0.91666666666667, 0.25, 0.020833333333333
63682, 0.91666666666667, 0.275, 0.041666666666667
63683, 0.89583333333333, 0.3, 0.041666666666667
63684, 0.91666666666667, 0.3, 0.020833333333333
63685, 0.91666666666667, 0.325, 0.041666666666667
63686, 0.89583333333333, 0.35, 0.041666666666667
63687, 0.91666666666667, 0.35, 0.020833333333333
63688, 0.91666666666667, 0.375, 0.041666666666667
63689, 0.89583333333333, 0.4, 0.041666666666667
63690, 0.91666666666667, 0.4, 0.020833333333333
63691, 0.91666666666667, 0.425, 0.041666666666667
63692, 0.89583333333333, 0.45, 0.041666666666667
63693, 0.91666666666667, 0.45, 0.020833333333333
63694, 0.91666666666667, 0.475, 0.041666666666667
63695, 0.89583333333333, 0.5, 0.041666666666667
63696, 0.91666666666667, 0.5, 0.020833333333333
63697, 0.91666666666667, 0.525, 0.041666666666667
63698, 0.89583333333333, 0.55, 0.041666666666667
63699, 0.91666666666667, 0.55, 0.020833333333333
63700, 0.91666666666667, 0.575, 0.041666666666667
63701, 0.89583333333333, 0.6, 0.041666666666667
63702, 0.91666666666667, 0.6, 0.020833333333333
63703, 0.91666666666667, 0.625, 0.041666666666667
63704, 0.89583333333333, 0.65, 0.041666666666667
63705, 0.91666666666667, 0.65, 0.020833333333333
63706, 0.91666666666667, 0.675, 0.041666666666667
63707, 0.89583333333333, 0.7, 0.041666666666667
63708, 0.91666666666667, 0.7, 0.020833333333333
63709, 0.91666666666667, 0.725, 0.041666666666667
63710, 0.89583333333333, 0.75, 0.041666666666667
63711, 0.91666666666667, 0.75, 0.020833333333333
63712, 0.91666666666667, 0.775, 0.041666666666667
63713, 0.89583333333333, 0.8, 0.041666666666667
63714, 0.91666666666667, 0.8, 0.020833333333333
63715, 0.91666666666667, 0.825, 0.041666666666667
63716, 0.89583333333333, 0.85, 0.041666666666667
63717, 0.91666666666667, 0.85, 0.020833333333333
63718, 0.91666666666667, 0.875, 0.041666666666667
63719, 0.89583333333333, 0.9, 0.041666666666667
63720, 0.91666666666667, 0.9, 0.020833333333333
63721, 0.91666666666667, 0.925, 0.041666666666667
63722, 0.89583333333333, 0.95, 0.041666666666667
63723, 0.91666666666667, 0.95, 0.020833333333333
63724, 0.91666666666667, 0.975, 0.041666666666667
63725, 0.89583333333333, 1, 0.041666666666667
63726, 0.91666666666667, 1, 0.020833333333333
63727, 0.91666666666667, 1.025, 0.041666666666667
63728, 0.89583333333333, 1.05, 0.041666666666667
63729, 0.91666666666667, 1.05, 0.020833333333333
63730, 0.91666666666667, 1.075, 0.041666666666667
63731, 0.89583333333333, 1.1, 0.041666666666667
63732, 0.91666666666667, 1.1, 0.020833333333333
63733, 0.91666666666667, 1.125, 0.041666666666667
63734, 0.89583333333333, 1.15, 0.041666666666667
63735, 0.91666666666667, 1.15, 0.020833333333333
63736, 0.91666666666667, 1.175, 0.041666666666667
63737, 0.89583333333333, 1.2, 0.041666666666667
63738, 0.91666666666667, 1.2, 0.020833333333333
63739, 0.91666666666667, 1.225, 0.041666666666667
63740, 0.89583333333333, 1.25, 0.041666666666667
63741, 0.91666666666667, 1.25, 0.020833333333333
63742, 0.91666666666667, 1.275, 0.041666666666667
63743, 0.89583333333333, 1.3, 0.041666666666667
63744, 0.91666666666667, 1.3, 0.020833333333333
63745, 0.91666666666667, 1.325, 0.041666666666667
63746, 0.91666666666667, 0.175, 0.083333333333333
63747, 0.89583333333333, 0.2, 0.083333333333333
63748, 0.91666666666667, 0.2, 0.0625
63749, 0.91666666666667, 0.225, 0.083333333333333
63750, 0.89583333333333, 0.25, 0.083333333333333
63751, 0.91666666666667, 0.25, 0.0625
63752, 0.91666666666667, 0.275, 0.083333333333333
63753, 0.89583333333333, 0.3, 0.083333333333333
63754, 0.91666666666667, 0.3, 0.0625
63755, 0.91666666666667, 0.325, 0.083333333333333
63756, 0.89583333333333, 0.35, 0.083333333333333
63757, 0.91666666666667, 0.35, 0.0625
63758, 0.91666666666667, 0.375, 0.083333333333333
63759, 0.89583333333333, 0.4, 0.083333333333333
63760, 0.91666666666667, 0.4, 0.0625
63761, 0.91666666666667, 0.425, 0.083333333333333
63762, 0.89583333333333, 0.45, 0.083333333333333
63763, 0.91666666666667, 0.45, 0.0625
63764, 0.91666666666667, 0.475, 0.083333333333333
63765, 0.89583333333333, 0.5, 0.083333333333333
63766, 0.91666666666667, 0.5, 0.0625
63767, 0.91666666666667, 0.525, 0.083333333333333
63768, 0.89583333333333, 0.55, 0.083333333333333
63769, 0.91666666666667, 0.55, 0.0625
63770, 0.91666666666667, 0.575, 0.083333333333333
63771, 0.89583333333333, 0.6, 0.083333333333333
63772, 0.91666666666667, 0.6, 0.0625
63773, 0.91666666666667, 0.625, 0.083333333333333
63774, 0.89583333333333, 0.65, 0.083333333333333
63775, 0.91666666666667, 0.65, 0.0625
63776, 0.91666666666667, 0.675, 0.083333333333333
63777, 0.89583333333333, 0.7, 0.083333333333333
63778, 0.91666666666667, 0.7, 0.0625
63779, 0.91666666666667, 0.725, 0.083333333333333
63780, 0.89583333333333, 0.75, 0.083333333333333
63781, 0.91666666666667, 0.75, 0.0625
63782, 0.91666666666667, 0.775, 0.083333333333333
63783, 0.89583333333333, 0.8, 0.083333333333333
63784, 0.91666666666667, 0.8, 0.0625
63785, 0.91666666666667, 0.825, 0.083333333333333
63786, 0.89583333333333, 0.85, 0.083333333333333
63787, 0.91666666666667, 0.85, 0.0625
63788, 0.91666666666667, 0.875, 0.083333333333333
63789, 0.89583333333333, 0.9, 0.083333333333333
63790, 0.91666666666667, 0.9, 0.0625
63791, 0.91666666666667, 0.925, 0.083333333333333
63792, 0.89583333333333, 0.95, 0.083333333333333
63793, 0.91666666666667, 0.95, 0.0625
63794, 0.91666666666667, 0.975, 0.083333333333333
63795, 0.89583333333333, 1, 0.083333333333333
63796, 0.91666666666667, 1, 0.0625
63797, 0.91666666666667, 1.025, 0.083333333333333
63798, 0.89583333333333, 1.05, 0.083333333333333
63799, 0.91666666666667, 1.05, 0.0625
63800, 0.91666666666667, 1.075, 0.083333333333333
63801, 0.89583333333333, 1.1, 0.083333333333333
63802, 0.91666666666667, 1.1, 0.0625
63803, 0.91666666666667, 1.125, 0.083333333333333
63804, 0.89583333333333, 1.15, 0.083333333333333
63805, 0.91666666666667, 1.15, 0.0625
63806, 0.91666666666667, 1.175, 0.083333333333333
63807, 0.89583333333333, 1.2, 0.083333333333333
63808, 0.91666666666667, 1.2, 0.0625
63809, 0.91666666666667, 1.225, 0.083333333333333
63810, 0.89583333333333, 1.25, 0.083333333333333
63811, 0.91666666666667, 1.25, 0.0625
63812, 0.91666666666667, 1.275, 0.083333333333333
63813, 0.89583333333333, 1.3, 0.083333333333333
63814, 0.91666666666667, 1.3, 0.0625
63815, 0.91666666666667, 1.325, 0.083333333333333
63816, 0.91666666666667, 0.175, 0.125
63817, 0.89583333333333, 0.2, 0.125
63818, 0.91666666666667, 0.2, 0.10416666666667
63819, 0.91666666666667, 0.225, 0.125
63820, 0.89583333333333, 0.25, 0.125
63821, 0.91666666666667, 0.25, 0.10416666666667
63822, 0.91666666666667, 0.275, 0.125
63823, 0.89583333333333, 0.3, 0.125
63824, 0.91666666666667, 0.3, 0.10416666666667
63825, 0.91666666666667, 0.325, 0.125
63826, 0.89583333333333, 0.35, 0.125
63827, 0.91666666666667, 0.35, 0.10416666666667
63828, 0.91666666666667, 0.375, 0.125
63829, 0.89583333333333, 0.4, 0.125
63830, 0.91666666666667, 0.4, 0.10416666666667
63831, 0.91666666666667, 0.425, 0.125
63832, 0.89583333333333, 0.45, 0.125
63833, 0.91666666666667, 0.45, 0.10416666666667
63834, 0.91666666666667, 0.475, 0.125
63835, 0.89583333333333, 0.5, 0.125
63836, 0.91666666666667, 0.5, 0.10416666666667
63837, 0.91666666666667, 0.525, 0.125
63838, 0.89583333333333, 0.55, 0.125
63839, 0.91666666666667, 0.55, 0.10416666666667
63840, 0.91666666666667, 0.575, 0.125
63841, 0.89583333333333, 0.6, 0.125
63842, 0.91666666666667, 0.6, 0.10416666666667
63843, 0.91666666666667, 0.625, 0.125
63844, 0.89583333333333, 0.65, 0.125
63845, 0.91666666666667, 0.65, 0.10416666666667
63846, 0.91666666666667, 0.675, 0.125
63847, 0.89583333333333, 0.7, 0.125
63848, 0.91666666666667, 0.7, 0.10416666666667
63849, 0.91666666666667, 0.725, 0.125
63850, 0.89583333333333, 0.75, 0.125
63851, 0.91666666666667, 0.75, 0.10416666666667
63852, 0.91666666666667, 0.775, 0.125
63853, 0.89583333333333, 0.8, 0.125
63854, 0.91666666666667, 0.8, 0.10416666666667
63855, 0.91666666666667, 0.825, 0.125
63856, 0.89583333333333, 0.85, 0.125
63857, 0.91666666666667, 0.85, 0.10416666666667
63858, 0.91666666666667, 0.875, 0.125
63859, 0.89583333333333, 0.9, 0.125
63860, 0.91666666666667, 0.9, 0.10416666666667
63861, 0.91666666666667, 0.925, 0.125
63862, 0.89583333333333, 0.95, 0.125
63863, 0.91666666666667, 0.95, 0.10416666666667
63864, 0.91666666666667, 0.975, 0.125
63865, 0.89583333333333, 1, 0.125
63866, 0.91666666666667, 1, 0.10416666666667
63867, 0.91666666666667, 1.025, 0.125
63868, 0.89583333333333, 1.05, 0.125
63869, 0.91666666666667, 1.05, 0.10416666666667
63870, 0.91666666666667, 1.075, 0.125
63871, 0.89583333333333, 1.1, 0.125
63872, 0.91666666666667, 1.1, 0.10416666666667
63873, 0.91666666666667, 1.125, 0.125
63874, 0.89583333333333, 1.15, 0.125
63875, 0.91666666666667, 1.15, 0.10416666666667
63876, 0.91666666666667, 1.175, 0.125
63877, 0.89583333333333, 1.2, 0.125
63878, 0.91666666666667, 1.2, 0.10416666666667
63879, 0.91666666666667, 1.225, 0.125
63880, 0.89583333333333, 1.25, 0.125
63881, 0.91666666666667, 1.25, 0.10416666666667
63882, 0.91666666666667, 1.275, 0.125
63883, 0.89583333333333, 1.3, 0.125
63884, 0.91666666666667, 1.3, 0.10416666666667
63885, 0.91666666666667, 1.325, 0.125
63886, 0.91666666666667, 0.175, 0.16666666666667
63887, 0.89583333333333, 0.2, 0.16666666666667
63888, 0.91666666666667, 0.2, 0.14583333333333
63889, 0.91666666666667, 0.225, 0.16666666666667
63890, 0.89583333333333, 0.25, 0.16666666666667
63891, 0.91666666666667, 0.25, 0.14583333333333
63892, 0.91666666666667, 0.275, 0.16666666666667
63893, 0.89583333333333, 0.3, 0.16666666666667
63894, 0.91666666666667, 0.3, 0.14583333333333
63895, 0.91666666666667, 0.325, 0.16666666666667
63896, 0.89583333333333, 0.35, 0.16666666666667
63897, 0.91666666666667, 0.35, 0.14583333333333
63898, 0.91666666666667, 0.375, 0.16666666666667
63899, 0.89583333333333, 0.4, 0.16666666666667
63900, 0.91666666666667, 0.4, 0.14583333333333
63901, 0.91666666666667, 0.425, 0.16666666666667
63902, 0.89583333333333, 0.45, 0.16666666666667
63903, 0.91666666666667, 0.45, 0.14583333333333
63904, 0.91666666666667, 0.475, 0.16666666666667
63905, 0.89583333333333, 0.5, 0.16666666666667
63906, 0.91666666666667, 0.5, 0.14583333333333
63907, 0.91666666666667, 0.525, 0.16666666666667
63908, 0.89583333333333, 0.55, 0.16666666666667
63909, 0.91666666666667, 0.55, 0.14583333333333
63910, 0.91666666666667, 0.575, 0.16666666666667
63911, 0.89583333333333, 0.6, 0.16666666666667
63912, 0.91666666666667, 0.6, 0.14583333333333
63913, 0.91666666666667, 0.625, 0.16666666666667
63914, 0.89583333333333, 0.65, 0.16666666666667
63915, 0.91666666666667, 0.65, 0.14583333333333
63916, 0.91666666666667, 0.675, 0.16666666666667
63917, 0.89583333333333, 0.7, 0.16666666666667
63918, 0.91666666666667, 0.7, 0.14583333333333
63919, 0.91666666666667, 0.725, 0.16666666666667
63920, 0.89583333333333, 0.75, 0.16666666666667
63921, 0.91666666666667, 0.75, 0.14583333333333
63922, 0.91666666666667, 0.775, 0.16666666666667
63923, 0.89583333333333, 0.8, 0.16666666666667
63924, 0.91666666666667, 0.8, 0.14583333333333
63925, 0.91666666666667, 0.825, 0.16666666666667
63926, 0.89583333333333, 0.85, 0.16666666666667
63927, 0.91666666666667, 0.85, 0.14583333333333
63928, 0.91666666666667, 0.875, 0.16666666666667
63929, 0.89583333333333, 0.9, 0.16666666666667
63930, 0.91666666666667, 0.9, 0.14583333333333
63931, 0.91666666666667, 0.925, 0.16666666666667
63932, 0.89583333333333, 0.95, 0.16666666666667
63933, 0.91666666666667, 0.95, 0.14583333333333
63934, 0.91666666666667, 0.975, 0.16666666666667
63935, 0.89583333333333, 1, 0.16666666666667
63936, 0.91666666666667, 1, 0.14583333333333
63937, 0.91666666666667, 1.025, 0.16666666666667
63938, 0.89583333333333, 1.05, 0.16666666666667
63939, 0.91666666666667, 1.05, 0.14583333333333
63940, 0.91666666666667, 1.075, 0.16666666666667
63941, 0.89583333333333, 1.1, 0.16666666666667
63942, 0.91666666666667, 1.1, 0.14583333333333
63943, 0.91666666666667, 1.125, 0.16666666666667
63944, 0.89583333333333, 1.15, 0.16666666666667
63945, 0.91666666666667, 1.15, 0.14583333333333
63946, 0.91666666666667, 1.175, 0.16666666666667
63947, 0.89583333333333, 1.2, 0.16666666666667
63948, 0.91666666666667, 1.2, 0.14583333333333
63949, 0.91666666666667, 1.225, 0.16666666666667
63950, 0.89583333333333, 1.25, 0.16666666666667
63951, 0.91666666666667, 1.25, 0.14583333333333
63952, 0.91666666666667, 1.275, 0.16666666666667
63953, 0.89583333333333, 1.3, 0.16666666666667
63954, 0.91666666666667, 1.3, 0.14583333333333
63955, 0.91666666666667, 1.325, 0.16666666666667
63956, 0.91666666666667, 0.175, 0.20833333333333
63957, 0.89583333333333, 0.2, 0.20833333333333
63958, 0.91666666666667, 0.2, 0.1875
63959, 0.91666666666667, 0.225, 0.20833333333333
63960, 0.89583333333333, 0.25, 0.20833333333333
63961, 0.91666666666667, 0.25, 0.1875
63962, 0.91666666666667, 0.275, 0.20833333333333
63963, 0.89583333333333, 0.3, 0.20833333333333
63964, 0.91666666666667, 0.3, 0.1875
63965, 0.91666666666667, 0.325, 0.20833333333333
63966, 0.89583333333333, 0.35, 0.20833333333333
63967, 0.91666666666667, 0.35, 0.1875
63968, 0.91666666666667, 0.375, 0.20833333333333
63969, 0.89583333333333, 0.4, 0.20833333333333
63970, 0.91666666666667, 0.4, 0.1875
63971, 0.91666666666667, 0.425, 0.20833333333333
63972, 0.89583333333333, 0.45, 0.20833333333333
63973, 0.91666666666667, 0.45, 0.1875
63974, 0.91666666666667, 0.475, 0.20833333333333
63975, 0.89583333333333, 0.5, 0.20833333333333
63976, 0.91666666666667, 0.5, 0.1875
63977, 0.91666666666667, 0.525, 0.20833333333333
63978, 0.89583333333333, 0.55, 0.20833333333333
63979, 0.91666666666667, 0.55, 0.1875
63980, 0.91666666666667, 0.575, 0.20833333333333
63981, 0.89583333333333, 0.6, 0.20833333333333
63982, 0.91666666666667, 0.6, 0.1875
63983, 0.91666666666667, 0.625, 0.20833333333333
63984, 0.89583333333333, 0.65, 0.20833333333333
63985, 0.91666666666667, 0.65, 0.1875
63986, 0.91666666666667, 0.675, 0.20833333333333
63987, 0.89583333333333, 0.7, 0.20833333333333
63988, 0.91666666666667, 0.7, 0.1875
63989, 0.91666666666667, 0.725, 0.20833333333333
63990, 0.89583333333333, 0.75, 0.20833333333333
63991, 0.91666666666667, 0.75, 0.1875
63992, 0.91666666666667, 0.775, 0.20833333333333
63993, 0.89583333333333, 0.8, 0.20833333333333
63994, 0.91666666666667, 0.8, 0.1875
63995, 0.91666666666667, 0.825, 0.20833333333333
63996, 0.89583333333333, 0.85, 0.20833333333333
63997, 0.91666666666667, 0.85, 0.1875
63998, 0.91666666666667, 0.875, 0.20833333333333
63999, 0.89583333333333, 0.9, 0.20833333333333
64000, 0.91666666666667, 0.9, 0.1875
64001, 0.91666666666667, 0.925, 0.20833333333333
64002, 0.89583333333333, 0.95, 0.20833333333333
64003, 0.91666666666667, 0.95, 0.1875
64004, 0.91666666666667, 0.975, 0.20833333333333
64005, 0.89583333333333, 1, 0.20833333333333
64006, 0.91666666666667, 1, 0.1875
64007, 0.91666666666667, 1.025, 0.20833333333333
64008, 0.89583333333333, 1.05, 0.20833333333333
64009, 0.91666666666667, 1.05, 0.1875
64010, 0.91666666666667, 1.075, 0.20833333333333
64011, 0.89583333333333, 1.1, 0.20833333333333
64012, 0.91666666666667, 1.1, 0.1875
64013, 0.91666666666667, 1.125, 0.20833333333333
64014, 0.89583333333333, 1.15, 0.20833333333333
64015, 0.91666666666667, 1.15, 0.1875
64016, 0.91666666666667, 1.175, 0.20833333333333
64017, 0.89583333333333, 1.2, 0.20833333333333
64018, 0.91666666666667, 1.2, 0.1875
64019, 0.91666666666667, 1.225, 0.20833333333333
64020, 0.89583333333333, 1.25, 0.20833333333333
64021, 0.91666666666667, 1.25, 0.1875
64022, 0.91666666666667, 1.275, 0.20833333333333
64023, 0.89583333333333, 1.3, 0.20833333333333
64024, 0.91666666666667, 1.3, 0.1875
64025, 0.91666666666667, 1.325, 0.20833333333333
64026, 0.91666666666667, 0.175, 0.25
64027, 0.89583333333333, 0.2, 0.25
64028, 0.91666666666667, 0.2, 0.22916666666667
64029, 0.91666666666667, 0.225, 0.25
64030, 0.89583333333333, 0.25, 0.25
64031, 0.91666666666667, 0.25, 0.22916666666667
64032, 0.91666666666667, 0.275, 0.25
64033, 0.89583333333333, 0.3, 0.25
64034, 0.91666666666667, 0.3, 0.22916666666667
64035, 0.91666666666667, 0.325, 0.25
64036, 0.89583333333333, 0.35, 0.25
64037, 0.91666666666667, 0.35, 0.22916666666667
64038, 0.91666666666667, 0.375, 0.25
64039, 0.89583333333333, 0.4, 0.25
64040, 0.91666666666667, 0.4, 0.22916666666667
64041, 0.91666666666667, 0.425, 0.25
64042, 0.89583333333333, 0.45, 0.25
64043, 0.91666666666667, 0.45, 0.22916666666667
64044, 0.91666666666667, 0.475, 0.25
64045, 0.89583333333333, 0.5, 0.25
64046, 0.91666666666667, 0.5, 0.22916666666667
64047, 0.91666666666667, 0.525, 0.25
64048, 0.89583333333333, 0.55, 0.25
64049, 0.91666666666667, 0.55, 0.22916666666667
64050, 0.91666666666667, 0.575, 0.25
64051, 0.89583333333333, 0.6, 0.25
64052, 0.91666666666667, 0.6, 0.22916666666667
64053, 0.91666666666667, 0.625, 0.25
64054, 0.89583333333333, 0.65, 0.25
64055, 0.91666666666667, 0.65, 0.22916666666667
64056, 0.91666666666667, 0.675, 0.25
64057, 0.89583333333333, 0.7, 0.25
64058, 0.91666666666667, 0.7, 0.22916666666667
64059, 0.91666666666667, 0.725, 0.25
64060, 0.89583333333333, 0.75, 0.25
64061, 0.91666666666667, 0.75, 0.22916666666667
64062, 0.91666666666667, 0.775, 0.25
64063, 0.89583333333333, 0.8, 0.25
64064, 0.91666666666667, 0.8, 0.22916666666667
64065, 0.91666666666667, 0.825, 0.25
64066, 0.89583333333333, 0.85, 0.25
64067, 0.91666666666667, 0.85, 0.22916666666667
64068, 0.91666666666667, 0.875, 0.25
64069, 0.89583333333333, 0.9, 0.25
64070, 0.91666666666667, 0.9, 0.22916666666667
64071, 0.91666666666667, 0.925, 0.25
64072, 0.89583333333333, 0.95, 0.25
64073, 0.91666666666667, 0.95, 0.22916666666667
64074, 0.91666666666667, 0.975, 0.25
64075, 0.89583333333333, 1, 0.25
64076, 0.91666666666667, 1, 0.22916666666667
64077, 0.91666666666667, 1.025, 0.25
64078, 0.89583333333333, 1.05, 0.25
64079, 0.91666666666667, 1.05, 0.22916666666667
64080, 0.91666666666667, 1.075, 0.25
64081, 0.89583333333333, 1.1, 0.25
64082, 0.91666666666667, 1.1, 0.22916666666667
64083, 0.91666666666667, 1.125, 0.25
64084, 0.89583333333333, 1.15, 0.25
64085, 0.91666666666667, 1.15, 0.22916666666667
64086, 0.91666666666667, 1.175, 0.25
64087, 0.89583333333333, 1.2, 0.25
64088, 0.91666666666667, 1.2, 0.22916666666667
64089, 0.91666666666667, 1.225, 0.25
64090, 0.89583333333333, 1.25, 0.25
64091, 0.91666666666667, 1.25, 0.22916666666667
64092, 0.91666666666667, 1.275, 0.25
64093, 0.89583333333333, 1.3, 0.25
64094, 0.91666666666667, 1.3, 0.22916666666667
64095, 0.91666666666667, 1.325, 0.25
64096, 0.91666666666667, 0.175, 0.29166666666667
64097, 0.89583333333333, 0.2, 0.29166666666667
64098, 0.91666666666667, 0.2, 0.27083333333333
64099, 0.91666666666667, 0.225, 0.29166666666667
64100, 0.89583333333333, 0.25, 0.29166666666667
64101, 0.91666666666667, 0.25, 0.27083333333333
64102, 0.91666666666667, 0.275, 0.29166666666667
64103, 0.89583333333333, 0.3, 0.29166666666667
64104, 0.91666666666667, 0.3, 0.27083333333333
64105, 0.91666666666667, 0.325, 0.29166666666667
64106, 0.89583333333333, 0.35, 0.29166666666667
64107, 0.91666666666667, 0.35, 0.27083333333333
64108, 0.91666666666667, 0.375, 0.29166666666667
64109, 0.89583333333333, 0.4, 0.29166666666667
64110, 0.91666666666667, 0.4, 0.27083333333333
64111, 0.91666666666667, 0.425, 0.29166666666667
64112, 0.89583333333333, 0.45, 0.29166666666667
64113, 0.91666666666667, 0.45, 0.27083333333333
64114, 0.91666666666667, 0.475, 0.29166666666667
64115, 0.89583333333333, 0.5, 0.29166666666667
64116, 0.91666666666667, 0.5, 0.27083333333333
64117, 0.91666666666667, 0.525, 0.29166666666667
64118, 0.89583333333333, 0.55, 0.29166666666667
64119, 0.91666666666667, 0.55, 0.27083333333333
64120, 0.91666666666667, 0.575, 0.29166666666667
64121, 0.89583333333333, 0.6, 0.29166666666667
64122, 0.91666666666667, 0.6, 0.27083333333333
64123, 0.91666666666667, 0.625, 0.29166666666667
64124, 0.89583333333333, 0.65, 0.29166666666667
64125, 0.91666666666667, 0.65, 0.27083333333333
64126, 0.91666666666667, 0.675, 0.29166666666667
64127, 0.89583333333333, 0.7, 0.29166666666667
64128, 0.91666666666667, 0.7, 0.27083333333333
64129, 0.91666666666667, 0.725, 0.29166666666667
64130, 0.89583333333333, 0.75, 0.29166666666667
64131, 0.91666666666667, 0.75, 0.27083333333333
64132, 0.91666666666667, 0.775, 0.29166666666667
64133, 0.89583333333333, 0.8, 0.29166666666667
64134, 0.91666666666667, 0.8, 0.27083333333333
64135, 0.91666666666667, 0.825, 0.29166666666667
64136, 0.89583333333333, 0.85, 0.29166666666667
64137, 0.91666666666667, 0.85, 0.27083333333333
64138, 0.91666666666667, 0.875, 0.29166666666667
64139, 0.89583333333333, 0.9, 0.29166666666667
64140, 0.91666666666667, 0.9, 0.27083333333333
64141, 0.91666666666667, 0.925, 0.29166666666667
64142, 0.89583333333333, 0.95, 0.29166666666667
