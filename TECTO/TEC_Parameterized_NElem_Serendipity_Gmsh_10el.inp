37786, 33697, 104951, 104955, 33701, 33698, 104952, 104956, 33702, 106082, 106094, 106095, 33863, 106085, 106097, 106098, 
33865, 33857, 106083, 106096, 33866
37787, 33698, 104952, 104956, 33702, 33699, 104953, 104957, 33703, 106085, 106097, 106098, 33865, 106088, 106100, 106101, 
33867, 33859, 106086, 106099, 33868
37788, 33699, 104953, 104957, 33703, 33700, 104954, 104958, 33704, 106088, 106100, 106101, 33867, 106091, 106103, 106104, 
33869, 33861, 106089, 106102, 33870
37789, 33700, 104954, 104958, 33704, 3492, 34108, 34109, 3493, 106091, 106103, 106104, 33869, 34375, 34376, 34377, 
3516, 33862, 106092, 106105, 33871
37790, 1425, 16267, 16268, 1426, 33701, 104955, 104959, 33705, 16535, 16536, 16537, 1449, 106095, 106107, 106108, 
33872, 33864, 106093, 106106, 33873
37791, 33701, 104955, 104959, 33705, 33702, 104956, 104960, 33706, 106095, 106107, 106108, 33872, 106098, 106110, 106111, 
33874, 33866, 106096, 106109, 33875
37792, 33702, 104956, 104960, 33706, 33703, 104957, 104961, 33707, 106098, 106110, 106111, 33874, 106101, 106113, 106114, 
33876, 33868, 106099, 106112, 33877
37793, 33703, 104957, 104961, 33707, 33704, 104958, 104962, 33708, 106101, 106113, 106114, 33876, 106104, 106116, 106117, 
33878, 33870, 106102, 106115, 33879
37794, 33704, 104958, 104962, 33708, 3493, 34109, 34110, 3494, 106104, 106116, 106117, 33878, 34377, 34378, 34379, 
3517, 33871, 106105, 106118, 33880
37795, 1426, 16268, 16269, 1427, 33705, 104959, 104963, 33709, 16537, 16538, 16539, 1450, 106108, 106120, 106121, 
33881, 33873, 106106, 106119, 33882
37796, 33705, 104959, 104963, 33709, 33706, 104960, 104964, 33710, 106108, 106120, 106121, 33881, 106111, 106123, 106124, 
33883, 33875, 106109, 106122, 33884
37797, 33706, 104960, 104964, 33710, 33707, 104961, 104965, 33711, 106111, 106123, 106124, 33883, 106114, 106126, 106127, 
33885, 33877, 106112, 106125, 33886
37798, 33707, 104961, 104965, 33711, 33708, 104962, 104966, 33712, 106114, 106126, 106127, 33885, 106117, 106129, 106130, 
33887, 33879, 106115, 106128, 33888
37799, 33708, 104962, 104966, 33712, 3494, 34110, 34111, 3495, 106117, 106129, 106130, 33887, 34379, 34380, 34381, 
3518, 33880, 106118, 106131, 33889
37800, 1427, 16269, 16270, 1428, 33709, 104963, 104967, 33713, 16539, 16540, 16541, 1451, 106121, 106133, 106134, 
33890, 33882, 106119, 106132, 33891
37801, 33709, 104963, 104967, 33713, 33710, 104964, 104968, 33714, 106121, 106133, 106134, 33890, 106124, 106136, 106137, 
33892, 33884, 106122, 106135, 33893
37802, 33710, 104964, 104968, 33714, 33711, 104965, 104969, 33715, 106124, 106136, 106137, 33892, 106127, 106139, 106140, 
33894, 33886, 106125, 106138, 33895
37803, 33711, 104965, 104969, 33715, 33712, 104966, 104970, 33716, 106127, 106139, 106140, 33894, 106130, 106142, 106143, 
33896, 33888, 106128, 106141, 33897
37804, 33712, 104966, 104970, 33716, 3495, 34111, 34112, 3496, 106130, 106142, 106143, 33896, 34381, 34382, 34383, 
3519, 33889, 106131, 106144, 33898
37805, 1428, 16270, 16271, 1429, 33713, 104967, 104971, 33717, 16541, 16542, 16543, 1452, 106134, 106146, 106147, 
33899, 33891, 106132, 106145, 33900
37806, 33713, 104967, 104971, 33717, 33714, 104968, 104972, 33718, 106134, 106146, 106147, 33899, 106137, 106149, 106150, 
33901, 33893, 106135, 106148, 33902
37807, 33714, 104968, 104972, 33718, 33715, 104969, 104973, 33719, 106137, 106149, 106150, 33901, 106140, 106152, 106153, 
33903, 33895, 106138, 106151, 33904
37808, 33715, 104969, 104973, 33719, 33716, 104970, 104974, 33720, 106140, 106152, 106153, 33903, 106143, 106155, 106156, 
33905, 33897, 106141, 106154, 33906
37809, 33716, 104970, 104974, 33720, 3496, 34112, 34113, 3497, 106143, 106155, 106156, 33905, 34383, 34384, 34385, 
3520, 33898, 106144, 106157, 33907
37810, 1429, 16271, 16272, 1430, 33717, 104971, 104975, 33721, 16543, 16544, 16545, 1453, 106147, 106159, 106160, 
33908, 33900, 106145, 106158, 33909
37811, 33717, 104971, 104975, 33721, 33718, 104972, 104976, 33722, 106147, 106159, 106160, 33908, 106150, 106162, 106163, 
33910, 33902, 106148, 106161, 33911
37812, 33718, 104972, 104976, 33722, 33719, 104973, 104977, 33723, 106150, 106162, 106163, 33910, 106153, 106165, 106166, 
33912, 33904, 106151, 106164, 33913
37813, 33719, 104973, 104977, 33723, 33720, 104974, 104978, 33724, 106153, 106165, 106166, 33912, 106156, 106168, 106169, 
33914, 33906, 106154, 106167, 33915
37814, 33720, 104974, 104978, 33724, 3497, 34113, 34114, 3498, 106156, 106168, 106169, 33914, 34385, 34386, 34387, 
3521, 33907, 106157, 106170, 33916
37815, 1430, 16272, 16273, 1431, 33721, 104975, 104979, 33725, 16545, 16546, 16547, 1454, 106160, 106172, 106173, 
33917, 33909, 106158, 106171, 33918
37816, 33721, 104975, 104979, 33725, 33722, 104976, 104980, 33726, 106160, 106172, 106173, 33917, 106163, 106175, 106176, 
33919, 33911, 106161, 106174, 33920
37817, 33722, 104976, 104980, 33726, 33723, 104977, 104981, 33727, 106163, 106175, 106176, 33919, 106166, 106178, 106179, 
33921, 33913, 106164, 106177, 33922
37818, 33723, 104977, 104981, 33727, 33724, 104978, 104982, 33728, 106166, 106178, 106179, 33921, 106169, 106181, 106182, 
33923, 33915, 106167, 106180, 33924
37819, 33724, 104978, 104982, 33728, 3498, 34114, 34115, 3499, 106169, 106181, 106182, 33923, 34387, 34388, 34389, 
3522, 33916, 106170, 106183, 33925
37820, 1431, 16273, 16274, 1432, 33725, 104979, 104983, 33729, 16547, 16548, 16549, 1455, 106173, 106185, 106186, 
33926, 33918, 106171, 106184, 33927
37821, 33725, 104979, 104983, 33729, 33726, 104980, 104984, 33730, 106173, 106185, 106186, 33926, 106176, 106188, 106189, 
33928, 33920, 106174, 106187, 33929
37822, 33726, 104980, 104984, 33730, 33727, 104981, 104985, 33731, 106176, 106188, 106189, 33928, 106179, 106191, 106192, 
33930, 33922, 106177, 106190, 33931
37823, 33727, 104981, 104985, 33731, 33728, 104982, 104986, 33732, 106179, 106191, 106192, 33930, 106182, 106194, 106195, 
33932, 33924, 106180, 106193, 33933
37824, 33728, 104982, 104986, 33732, 3499, 34115, 34116, 3500, 106182, 106194, 106195, 33932, 34389, 34390, 34391, 
3523, 33925, 106183, 106196, 33934
37825, 1432, 16274, 16275, 1433, 33729, 104983, 104987, 33733, 16549, 16550, 16551, 1456, 106186, 106198, 106199, 
33935, 33927, 106184, 106197, 33936
37826, 33729, 104983, 104987, 33733, 33730, 104984, 104988, 33734, 106186, 106198, 106199, 33935, 106189, 106201, 106202, 
33937, 33929, 106187, 106200, 33938
37827, 33730, 104984, 104988, 33734, 33731, 104985, 104989, 33735, 106189, 106201, 106202, 33937, 106192, 106204, 106205, 
33939, 33931, 106190, 106203, 33940
37828, 33731, 104985, 104989, 33735, 33732, 104986, 104990, 33736, 106192, 106204, 106205, 33939, 106195, 106207, 106208, 
33941, 33933, 106193, 106206, 33942
37829, 33732, 104986, 104990, 33736, 3500, 34116, 34117, 3501, 106195, 106207, 106208, 33941, 34391, 34392, 34393, 
3524, 33934, 106196, 106209, 33943
37830, 1433, 16275, 1486, 32, 33733, 104987, 33948, 3470, 16551, 16552, 1497, 1457, 106199, 106210, 33992, 
33944, 33936, 106197, 33993, 3474
37831, 33733, 104987, 33948, 3470, 33734, 104988, 33949, 3471, 106199, 106210, 33992, 33944, 106202, 106211, 33994, 
33945, 33938, 106200, 33995, 3475
37832, 33734, 104988, 33949, 3471, 33735, 104989, 33950, 3472, 106202, 106211, 33994, 33945, 106205, 106212, 33996, 
33946, 33940, 106203, 33997, 3476
37833, 33735, 104989, 33950, 3472, 33736, 104990, 33951, 3473, 106205, 106212, 33996, 33946, 106208, 106213, 33998, 
33947, 33942, 106206, 33999, 3477
37834, 33736, 104990, 33951, 3473, 3501, 34117, 3526, 84, 106208, 106213, 33998, 33947, 34393, 34394, 3537, 
3525, 33943, 106209, 34000, 3478
37835, 1242, 1243, 16276, 16253, 33048, 33052, 104991, 104899, 1254, 16553, 16554, 16506, 33101, 106215, 106216, 
105912, 33093, 33102, 106214, 105911
37836, 33048, 33052, 104991, 104899, 33049, 33053, 104992, 104900, 33101, 106215, 106216, 105912, 33103, 106218, 106219, 
105915, 33095, 33104, 106217, 105914
37837, 33049, 33053, 104992, 104900, 33050, 33054, 104993, 104901, 33103, 106218, 106219, 105915, 33105, 106221, 106222, 
105918, 33097, 33106, 106220, 105917
37838, 33050, 33054, 104993, 104901, 33051, 33055, 104994, 104902, 33105, 106221, 106222, 105918, 33107, 106224, 106225, 
105921, 33099, 33108, 106223, 105920
37839, 33051, 33055, 104994, 104902, 3391, 3392, 34118, 34095, 33107, 106224, 106225, 105921, 3403, 34395, 34396, 
34348, 33100, 33109, 106226, 105923
37840, 16253, 16276, 16277, 16254, 104899, 104991, 104995, 104903, 16554, 16555, 16556, 16508, 106216, 106228, 106229, 
105925, 105911, 106214, 106227, 105924
37841, 104899, 104991, 104995, 104903, 104900, 104992, 104996, 104904, 106216, 106228, 106229, 105925, 106219, 106231, 106232, 
105928, 105914, 106217, 106230, 105927
37842, 104900, 104992, 104996, 104904, 104901, 104993, 104997, 104905, 106219, 106231, 106232, 105928, 106222, 106234, 106235, 
105931, 105917, 106220, 106233, 105930
37843, 104901, 104993, 104997, 104905, 104902, 104994, 104998, 104906, 106222, 106234, 106235, 105931, 106225, 106237, 106238, 
105934, 105920, 106223, 106236, 105933
37844, 104902, 104994, 104998, 104906, 34095, 34118, 34119, 34096, 106225, 106237, 106238, 105934, 34396, 34397, 34398, 
34350, 105923, 106226, 106239, 105936
37845, 16254, 16277, 16278, 16255, 104903, 104995, 104999, 104907, 16556, 16557, 16558, 16510, 106229, 106241, 106242, 
105938, 105924, 106227, 106240, 105937
37846, 104903, 104995, 104999, 104907, 104904, 104996, 105000, 104908, 106229, 106241, 106242, 105938, 106232, 106244, 106245, 
105941, 105927, 106230, 106243, 105940
37847, 104904, 104996, 105000, 104908, 104905, 104997, 105001, 104909, 106232, 106244, 106245, 105941, 106235, 106247, 106248, 
105944, 105930, 106233, 106246, 105943
37848, 104905, 104997, 105001, 104909, 104906, 104998, 105002, 104910, 106235, 106247, 106248, 105944, 106238, 106250, 106251, 
105947, 105933, 106236, 106249, 105946
37849, 104906, 104998, 105002, 104910, 34096, 34119, 34120, 34097, 106238, 106250, 106251, 105947, 34398, 34399, 34400, 
34352, 105936, 106239, 106252, 105949
37850, 16255, 16278, 16279, 16256, 104907, 104999, 105003, 104911, 16558, 16559, 16560, 16512, 106242, 106254, 106255, 
105951, 105937, 106240, 106253, 105950
37851, 104907, 104999, 105003, 104911, 104908, 105000, 105004, 104912, 106242, 106254, 106255, 105951, 106245, 106257, 106258, 
105954, 105940, 106243, 106256, 105953
37852, 104908, 105000, 105004, 104912, 104909, 105001, 105005, 104913, 106245, 106257, 106258, 105954, 106248, 106260, 106261, 
105957, 105943, 106246, 106259, 105956
37853, 104909, 105001, 105005, 104913, 104910, 105002, 105006, 104914, 106248, 106260, 106261, 105957, 106251, 106263, 106264, 
105960, 105946, 106249, 106262, 105959
37854, 104910, 105002, 105006, 104914, 34097, 34120, 34121, 34098, 106251, 106263, 106264, 105960, 34400, 34401, 34402, 
34354, 105949, 106252, 106265, 105962
37855, 16256, 16279, 16280, 16257, 104911, 105003, 105007, 104915, 16560, 16561, 16562, 16514, 106255, 106267, 106268, 
105964, 105950, 106253, 106266, 105963
37856, 104911, 105003, 105007, 104915, 104912, 105004, 105008, 104916, 106255, 106267, 106268, 105964, 106258, 106270, 106271, 
105967, 105953, 106256, 106269, 105966
37857, 104912, 105004, 105008, 104916, 104913, 105005, 105009, 104917, 106258, 106270, 106271, 105967, 106261, 106273, 106274, 
105970, 105956, 106259, 106272, 105969
37858, 104913, 105005, 105009, 104917, 104914, 105006, 105010, 104918, 106261, 106273, 106274, 105970, 106264, 106276, 106277, 
105973, 105959, 106262, 106275, 105972
37859, 104914, 105006, 105010, 104918, 34098, 34121, 34122, 34099, 106264, 106276, 106277, 105973, 34402, 34403, 34404, 
34356, 105962, 106265, 106278, 105975
37860, 16257, 16280, 16281, 16258, 104915, 105007, 105011, 104919, 16562, 16563, 16564, 16516, 106268, 106280, 106281, 
105977, 105963, 106266, 106279, 105976
37861, 104915, 105007, 105011, 104919, 104916, 105008, 105012, 104920, 106268, 106280, 106281, 105977, 106271, 106283, 106284, 
105980, 105966, 106269, 106282, 105979
37862, 104916, 105008, 105012, 104920, 104917, 105009, 105013, 104921, 106271, 106283, 106284, 105980, 106274, 106286, 106287, 
105983, 105969, 106272, 106285, 105982
37863, 104917, 105009, 105013, 104921, 104918, 105010, 105014, 104922, 106274, 106286, 106287, 105983, 106277, 106289, 106290, 
105986, 105972, 106275, 106288, 105985
37864, 104918, 105010, 105014, 104922, 34099, 34122, 34123, 34100, 106277, 106289, 106290, 105986, 34404, 34405, 34406, 
34358, 105975, 106278, 106291, 105988
37865, 16258, 16281, 16282, 16259, 104919, 105011, 105015, 104923, 16564, 16565, 16566, 16518, 106281, 106293, 106294, 
105990, 105976, 106279, 106292, 105989
37866, 104919, 105011, 105015, 104923, 104920, 105012, 105016, 104924, 106281, 106293, 106294, 105990, 106284, 106296, 106297, 
105993, 105979, 106282, 106295, 105992
37867, 104920, 105012, 105016, 104924, 104921, 105013, 105017, 104925, 106284, 106296, 106297, 105993, 106287, 106299, 106300, 
105996, 105982, 106285, 106298, 105995
37868, 104921, 105013, 105017, 104925, 104922, 105014, 105018, 104926, 106287, 106299, 106300, 105996, 106290, 106302, 106303, 
105999, 105985, 106288, 106301, 105998
37869, 104922, 105014, 105018, 104926, 34100, 34123, 34124, 34101, 106290, 106302, 106303, 105999, 34406, 34407, 34408, 
34360, 105988, 106291, 106304, 106001
37870, 16259, 16282, 16283, 16260, 104923, 105015, 105019, 104927, 16566, 16567, 16568, 16520, 106294, 106306, 106307, 
106003, 105989, 106292, 106305, 106002
37871, 104923, 105015, 105019, 104927, 104924, 105016, 105020, 104928, 106294, 106306, 106307, 106003, 106297, 106309, 106310, 
106006, 105992, 106295, 106308, 106005
37872, 104924, 105016, 105020, 104928, 104925, 105017, 105021, 104929, 106297, 106309, 106310, 106006, 106300, 106312, 106313, 
106009, 105995, 106298, 106311, 106008
37873, 104925, 105017, 105021, 104929, 104926, 105018, 105022, 104930, 106300, 106312, 106313, 106009, 106303, 106315, 106316, 
106012, 105998, 106301, 106314, 106011
37874, 104926, 105018, 105022, 104930, 34101, 34124, 34125, 34102, 106303, 106315, 106316, 106012, 34408, 34409, 34410, 
34362, 106001, 106304, 106317, 106014
37875, 16260, 16283, 16284, 16261, 104927, 105019, 105023, 104931, 16568, 16569, 16570, 16522, 106307, 106319, 106320, 
106016, 106002, 106305, 106318, 106015
37876, 104927, 105019, 105023, 104931, 104928, 105020, 105024, 104932, 106307, 106319, 106320, 106016, 106310, 106322, 106323, 
106019, 106005, 106308, 106321, 106018
37877, 104928, 105020, 105024, 104932, 104929, 105021, 105025, 104933, 106310, 106322, 106323, 106019, 106313, 106325, 106326, 
106022, 106008, 106311, 106324, 106021
37878, 104929, 105021, 105025, 104933, 104930, 105022, 105026, 104934, 106313, 106325, 106326, 106022, 106316, 106328, 106329, 
106025, 106011, 106314, 106327, 106024
37879, 104930, 105022, 105026, 104934, 34102, 34125, 34126, 34103, 106316, 106328, 106329, 106025, 34410, 34411, 34412, 
34364, 106014, 106317, 106330, 106027
37880, 16261, 16284, 16285, 16262, 104931, 105023, 105027, 104935, 16570, 16571, 16572, 16524, 106320, 106332, 106333, 
106029, 106015, 106318, 106331, 106028
37881, 104931, 105023, 105027, 104935, 104932, 105024, 105028, 104936, 106320, 106332, 106333, 106029, 106323, 106335, 106336, 
106032, 106018, 106321, 106334, 106031
37882, 104932, 105024, 105028, 104936, 104933, 105025, 105029, 104937, 106323, 106335, 106336, 106032, 106326, 106338, 106339, 
106035, 106021, 106324, 106337, 106034
37883, 104933, 105025, 105029, 104937, 104934, 105026, 105030, 104938, 106326, 106338, 106339, 106035, 106329, 106341, 106342, 
106038, 106024, 106327, 106340, 106037
37884, 104934, 105026, 105030, 104938, 34103, 34126, 34127, 34104, 106329, 106341, 106342, 106038, 34412, 34413, 34414, 
34366, 106027, 106330, 106343, 106040
37885, 16262, 16285, 16286, 16263, 104935, 105027, 105031, 104939, 16572, 16573, 16574, 16526, 106333, 106345, 106346, 
106042, 106028, 106331, 106344, 106041
37886, 104935, 105027, 105031, 104939, 104936, 105028, 105032, 104940, 106333, 106345, 106346, 106042, 106336, 106348, 106349, 
106045, 106031, 106334, 106347, 106044
37887, 104936, 105028, 105032, 104940, 104937, 105029, 105033, 104941, 106336, 106348, 106349, 106045, 106339, 106351, 106352, 
106048, 106034, 106337, 106350, 106047
37888, 104937, 105029, 105033, 104941, 104938, 105030, 105034, 104942, 106339, 106351, 106352, 106048, 106342, 106354, 106355, 
106051, 106037, 106340, 106353, 106050
37889, 104938, 105030, 105034, 104942, 34104, 34127, 34128, 34105, 106342, 106354, 106355, 106051, 34414, 34415, 34416, 
34368, 106040, 106343, 106356, 106053
37890, 16263, 16286, 16287, 16264, 104939, 105031, 105035, 104943, 16574, 16575, 16576, 16528, 106346, 106358, 106359, 
106055, 106041, 106344, 106357, 106054
37891, 104939, 105031, 105035, 104943, 104940, 105032, 105036, 104944, 106346, 106358, 106359, 106055, 106349, 106361, 106362, 
106058, 106044, 106347, 106360, 106057
37892, 104940, 105032, 105036, 104944, 104941, 105033, 105037, 104945, 106349, 106361, 106362, 106058, 106352, 106364, 106365, 
106061, 106047, 106350, 106363, 106060
37893, 104941, 105033, 105037, 104945, 104942, 105034, 105038, 104946, 106352, 106364, 106365, 106061, 106355, 106367, 106368, 
106064, 106050, 106353, 106366, 106063
37894, 104942, 105034, 105038, 104946, 34105, 34128, 34129, 34106, 106355, 106367, 106368, 106064, 34416, 34417, 34418, 
34370, 106053, 106356, 106369, 106066
37895, 16264, 16287, 16288, 16265, 104943, 105035, 105039, 104947, 16576, 16577, 16578, 16530, 106359, 106371, 106372, 
106068, 106054, 106357, 106370, 106067
37896, 104943, 105035, 105039, 104947, 104944, 105036, 105040, 104948, 106359, 106371, 106372, 106068, 106362, 106374, 106375, 
106071, 106057, 106360, 106373, 106070
37897, 104944, 105036, 105040, 104948, 104945, 105037, 105041, 104949, 106362, 106374, 106375, 106071, 106365, 106377, 106378, 
106074, 106060, 106363, 106376, 106073
37898, 104945, 105037, 105041, 104949, 104946, 105038, 105042, 104950, 106365, 106377, 106378, 106074, 106368, 106380, 106381, 
106077, 106063, 106366, 106379, 106076
37899, 104946, 105038, 105042, 104950, 34106, 34129, 34130, 34107, 106368, 106380, 106381, 106077, 34418, 34419, 34420, 
34372, 106066, 106369, 106382, 106079
37900, 16265, 16288, 16289, 16266, 104947, 105039, 105043, 104951, 16578, 16579, 16580, 16532, 106372, 106384, 106385, 
106081, 106067, 106370, 106383, 106080
37901, 104947, 105039, 105043, 104951, 104948, 105040, 105044, 104952, 106372, 106384, 106385, 106081, 106375, 106387, 106388, 
106084, 106070, 106373, 106386, 106083
37902, 104948, 105040, 105044, 104952, 104949, 105041, 105045, 104953, 106375, 106387, 106388, 106084, 106378, 106390, 106391, 
106087, 106073, 106376, 106389, 106086
37903, 104949, 105041, 105045, 104953, 104950, 105042, 105046, 104954, 106378, 106390, 106391, 106087, 106381, 106393, 106394, 
106090, 106076, 106379, 106392, 106089
37904, 104950, 105042, 105046, 104954, 34107, 34130, 34131, 34108, 106381, 106393, 106394, 106090, 34420, 34421, 34422, 
34374, 106079, 106382, 106395, 106092
37905, 16266, 16289, 16290, 16267, 104951, 105043, 105047, 104955, 16580, 16581, 16582, 16534, 106385, 106397, 106398, 
106094, 106080, 106383, 106396, 106093
37906, 104951, 105043, 105047, 104955, 104952, 105044, 105048, 104956, 106385, 106397, 106398, 106094, 106388, 106400, 106401, 
106097, 106083, 106386, 106399, 106096
37907, 104952, 105044, 105048, 104956, 104953, 105045, 105049, 104957, 106388, 106400, 106401, 106097, 106391, 106403, 106404, 
106100, 106086, 106389, 106402, 106099
37908, 104953, 105045, 105049, 104957, 104954, 105046, 105050, 104958, 106391, 106403, 106404, 106100, 106394, 106406, 106407, 
106103, 106089, 106392, 106405, 106102
37909, 104954, 105046, 105050, 104958, 34108, 34131, 34132, 34109, 106394, 106406, 106407, 106103, 34422, 34423, 34424, 
34376, 106092, 106395, 106408, 106105
37910, 16267, 16290, 16291, 16268, 104955, 105047, 105051, 104959, 16582, 16583, 16584, 16536, 106398, 106410, 106411, 
106107, 106093, 106396, 106409, 106106
37911, 104955, 105047, 105051, 104959, 104956, 105048, 105052, 104960, 106398, 106410, 106411, 106107, 106401, 106413, 106414, 
106110, 106096, 106399, 106412, 106109
37912, 104956, 105048, 105052, 104960, 104957, 105049, 105053, 104961, 106401, 106413, 106414, 106110, 106404, 106416, 106417, 
106113, 106099, 106402, 106415, 106112
37913, 104957, 105049, 105053, 104961, 104958, 105050, 105054, 104962, 106404, 106416, 106417, 106113, 106407, 106419, 106420, 
106116, 106102, 106405, 106418, 106115
37914, 104958, 105050, 105054, 104962, 34109, 34132, 34133, 34110, 106407, 106419, 106420, 106116, 34424, 34425, 34426, 
34378, 106105, 106408, 106421, 106118
37915, 16268, 16291, 16292, 16269, 104959, 105051, 105055, 104963, 16584, 16585, 16586, 16538, 106411, 106423, 106424, 
106120, 106106, 106409, 106422, 106119
37916, 104959, 105051, 105055, 104963, 104960, 105052, 105056, 104964, 106411, 106423, 106424, 106120, 106414, 106426, 106427, 
106123, 106109, 106412, 106425, 106122
37917, 104960, 105052, 105056, 104964, 104961, 105053, 105057, 104965, 106414, 106426, 106427, 106123, 106417, 106429, 106430, 
106126, 106112, 106415, 106428, 106125
37918, 104961, 105053, 105057, 104965, 104962, 105054, 105058, 104966, 106417, 106429, 106430, 106126, 106420, 106432, 106433, 
106129, 106115, 106418, 106431, 106128
37919, 104962, 105054, 105058, 104966, 34110, 34133, 34134, 34111, 106420, 106432, 106433, 106129, 34426, 34427, 34428, 
34380, 106118, 106421, 106434, 106131
37920, 16269, 16292, 16293, 16270, 104963, 105055, 105059, 104967, 16586, 16587, 16588, 16540, 106424, 106436, 106437, 
106133, 106119, 106422, 106435, 106132
37921, 104963, 105055, 105059, 104967, 104964, 105056, 105060, 104968, 106424, 106436, 106437, 106133, 106427, 106439, 106440, 
106136, 106122, 106425, 106438, 106135
37922, 104964, 105056, 105060, 104968, 104965, 105057, 105061, 104969, 106427, 106439, 106440, 106136, 106430, 106442, 106443, 
106139, 106125, 106428, 106441, 106138
37923, 104965, 105057, 105061, 104969, 104966, 105058, 105062, 104970, 106430, 106442, 106443, 106139, 106433, 106445, 106446, 
106142, 106128, 106431, 106444, 106141
37924, 104966, 105058, 105062, 104970, 34111, 34134, 34135, 34112, 106433, 106445, 106446, 106142, 34428, 34429, 34430, 
34382, 106131, 106434, 106447, 106144
37925, 16270, 16293, 16294, 16271, 104967, 105059, 105063, 104971, 16588, 16589, 16590, 16542, 106437, 106449, 106450, 
106146, 106132, 106435, 106448, 106145
37926, 104967, 105059, 105063, 104971, 104968, 105060, 105064, 104972, 106437, 106449, 106450, 106146, 106440, 106452, 106453, 
106149, 106135, 106438, 106451, 106148
37927, 104968, 105060, 105064, 104972, 104969, 105061, 105065, 104973, 106440, 106452, 106453, 106149, 106443, 106455, 106456, 
106152, 106138, 106441, 106454, 106151
37928, 104969, 105061, 105065, 104973, 104970, 105062, 105066, 104974, 106443, 106455, 106456, 106152, 106446, 106458, 106459, 
106155, 106141, 106444, 106457, 106154
37929, 104970, 105062, 105066, 104974, 34112, 34135, 34136, 34113, 106446, 106458, 106459, 106155, 34430, 34431, 34432, 
34384, 106144, 106447, 106460, 106157
37930, 16271, 16294, 16295, 16272, 104971, 105063, 105067, 104975, 16590, 16591, 16592, 16544, 106450, 106462, 106463, 
106159, 106145, 106448, 106461, 106158
37931, 104971, 105063, 105067, 104975, 104972, 105064, 105068, 104976, 106450, 106462, 106463, 106159, 106453, 106465, 106466, 
106162, 106148, 106451, 106464, 106161
37932, 104972, 105064, 105068, 104976, 104973, 105065, 105069, 104977, 106453, 106465, 106466, 106162, 106456, 106468, 106469, 
106165, 106151, 106454, 106467, 106164
37933, 104973, 105065, 105069, 104977, 104974, 105066, 105070, 104978, 106456, 106468, 106469, 106165, 106459, 106471, 106472, 
106168, 106154, 106457, 106470, 106167
37934, 104974, 105066, 105070, 104978, 34113, 34136, 34137, 34114, 106459, 106471, 106472, 106168, 34432, 34433, 34434, 
34386, 106157, 106460, 106473, 106170
37935, 16272, 16295, 16296, 16273, 104975, 105067, 105071, 104979, 16592, 16593, 16594, 16546, 106463, 106475, 106476, 
106172, 106158, 106461, 106474, 106171
37936, 104975, 105067, 105071, 104979, 104976, 105068, 105072, 104980, 106463, 106475, 106476, 106172, 106466, 106478, 106479, 
106175, 106161, 106464, 106477, 106174
37937, 104976, 105068, 105072, 104980, 104977, 105069, 105073, 104981, 106466, 106478, 106479, 106175, 106469, 106481, 106482, 
106178, 106164, 106467, 106480, 106177
37938, 104977, 105069, 105073, 104981, 104978, 105070, 105074, 104982, 106469, 106481, 106482, 106178, 106472, 106484, 106485, 
106181, 106167, 106470, 106483, 106180
37939, 104978, 105070, 105074, 104982, 34114, 34137, 34138, 34115, 106472, 106484, 106485, 106181, 34434, 34435, 34436, 
34388, 106170, 106473, 106486, 106183
37940, 16273, 16296, 16297, 16274, 104979, 105071, 105075, 104983, 16594, 16595, 16596, 16548, 106476, 106488, 106489, 
106185, 106171, 106474, 106487, 106184
37941, 104979, 105071, 105075, 104983, 104980, 105072, 105076, 104984, 106476, 106488, 106489, 106185, 106479, 106491, 106492, 
106188, 106174, 106477, 106490, 106187
37942, 104980, 105072, 105076, 104984, 104981, 105073, 105077, 104985, 106479, 106491, 106492, 106188, 106482, 106494, 106495, 
106191, 106177, 106480, 106493, 106190
37943, 104981, 105073, 105077, 104985, 104982, 105074, 105078, 104986, 106482, 106494, 106495, 106191, 106485, 106497, 106498, 
106194, 106180, 106483, 106496, 106193
37944, 104982, 105074, 105078, 104986, 34115, 34138, 34139, 34116, 106485, 106497, 106498, 106194, 34436, 34437, 34438, 
34390, 106183, 106486, 106499, 106196
37945, 16274, 16297, 16298, 16275, 104983, 105075, 105079, 104987, 16596, 16597, 16598, 16550, 106489, 106501, 106502, 
106198, 106184, 106487, 106500, 106197
37946, 104983, 105075, 105079, 104987, 104984, 105076, 105080, 104988, 106489, 106501, 106502, 106198, 106492, 106504, 106505, 
106201, 106187, 106490, 106503, 106200
37947, 104984, 105076, 105080, 104988, 104985, 105077, 105081, 104989, 106492, 106504, 106505, 106201, 106495, 106507, 106508, 
106204, 106190, 106493, 106506, 106203
37948, 104985, 105077, 105081, 104989, 104986, 105078, 105082, 104990, 106495, 106507, 106508, 106204, 106498, 106510, 106511, 
106207, 106193, 106496, 106509, 106206
37949, 104986, 105078, 105082, 104990, 34116, 34139, 34140, 34117, 106498, 106510, 106511, 106207, 34438, 34439, 34440, 
34392, 106196, 106499, 106512, 106209
37950, 16275, 16298, 1487, 1486, 104987, 105079, 33952, 33948, 16598, 16599, 1498, 16552, 106502, 106513, 34001, 
106210, 106197, 106500, 34002, 33993
37951, 104987, 105079, 33952, 33948, 104988, 105080, 33953, 33949, 106502, 106513, 34001, 106210, 106505, 106514, 34003, 
106211, 106200, 106503, 34004, 33995
37952, 104988, 105080, 33953, 33949, 104989, 105081, 33954, 33950, 106505, 106514, 34003, 106211, 106508, 106515, 34005, 
106212, 106203, 106506, 34006, 33997
37953, 104989, 105081, 33954, 33950, 104990, 105082, 33955, 33951, 106508, 106515, 34005, 106212, 106511, 106516, 34007, 
106213, 106206, 106509, 34008, 33999
37954, 104990, 105082, 33955, 33951, 34117, 34140, 3527, 3526, 106511, 106516, 34007, 106213, 34440, 34441, 3538, 
34394, 106209, 106512, 34009, 34000
37955, 1243, 1244, 16299, 16276, 33052, 33056, 105083, 104991, 1255, 16600, 16601, 16553, 33110, 106518, 106519, 
106215, 33102, 33111, 106517, 106214
37956, 33052, 33056, 105083, 104991, 33053, 33057, 105084, 104992, 33110, 106518, 106519, 106215, 33112, 106521, 106522, 
106218, 33104, 33113, 106520, 106217
37957, 33053, 33057, 105084, 104992, 33054, 33058, 105085, 104993, 33112, 106521, 106522, 106218, 33114, 106524, 106525, 
106221, 33106, 33115, 106523, 106220
37958, 33054, 33058, 105085, 104993, 33055, 33059, 105086, 104994, 33114, 106524, 106525, 106221, 33116, 106527, 106528, 
106224, 33108, 33117, 106526, 106223
37959, 33055, 33059, 105086, 104994, 3392, 3393, 34141, 34118, 33116, 106527, 106528, 106224, 3404, 34442, 34443, 
34395, 33109, 33118, 106529, 106226
37960, 16276, 16299, 16300, 16277, 104991, 105083, 105087, 104995, 16601, 16602, 16603, 16555, 106519, 106531, 106532, 
106228, 106214, 106517, 106530, 106227
37961, 104991, 105083, 105087, 104995, 104992, 105084, 105088, 104996, 106519, 106531, 106532, 106228, 106522, 106534, 106535, 
106231, 106217, 106520, 106533, 106230
37962, 104992, 105084, 105088, 104996, 104993, 105085, 105089, 104997, 106522, 106534, 106535, 106231, 106525, 106537, 106538, 
106234, 106220, 106523, 106536, 106233
37963, 104993, 105085, 105089, 104997, 104994, 105086, 105090, 104998, 106525, 106537, 106538, 106234, 106528, 106540, 106541, 
106237, 106223, 106526, 106539, 106236
37964, 104994, 105086, 105090, 104998, 34118, 34141, 34142, 34119, 106528, 106540, 106541, 106237, 34443, 34444, 34445, 
34397, 106226, 106529, 106542, 106239
37965, 16277, 16300, 16301, 16278, 104995, 105087, 105091, 104999, 16603, 16604, 16605, 16557, 106532, 106544, 106545, 
106241, 106227, 106530, 106543, 106240
37966, 104995, 105087, 105091, 104999, 104996, 105088, 105092, 105000, 106532, 106544, 106545, 106241, 106535, 106547, 106548, 
106244, 106230, 106533, 106546, 106243
37967, 104996, 105088, 105092, 105000, 104997, 105089, 105093, 105001, 106535, 106547, 106548, 106244, 106538, 106550, 106551, 
106247, 106233, 106536, 106549, 106246
37968, 104997, 105089, 105093, 105001, 104998, 105090, 105094, 105002, 106538, 106550, 106551, 106247, 106541, 106553, 106554, 
106250, 106236, 106539, 106552, 106249
37969, 104998, 105090, 105094, 105002, 34119, 34142, 34143, 34120, 106541, 106553, 106554, 106250, 34445, 34446, 34447, 
34399, 106239, 106542, 106555, 106252
37970, 16278, 16301, 16302, 16279, 104999, 105091, 105095, 105003, 16605, 16606, 16607, 16559, 106545, 106557, 106558, 
106254, 106240, 106543, 106556, 106253
37971, 104999, 105091, 105095, 105003, 105000, 105092, 105096, 105004, 106545, 106557, 106558, 106254, 106548, 106560, 106561, 
106257, 106243, 106546, 106559, 106256
37972, 105000, 105092, 105096, 105004, 105001, 105093, 105097, 105005, 106548, 106560, 106561, 106257, 106551, 106563, 106564, 
106260, 106246, 106549, 106562, 106259
37973, 105001, 105093, 105097, 105005, 105002, 105094, 105098, 105006, 106551, 106563, 106564, 106260, 106554, 106566, 106567, 
106263, 106249, 106552, 106565, 106262
37974, 105002, 105094, 105098, 105006, 34120, 34143, 34144, 34121, 106554, 106566, 106567, 106263, 34447, 34448, 34449, 
34401, 106252, 106555, 106568, 106265
37975, 16279, 16302, 16303, 16280, 105003, 105095, 105099, 105007, 16607, 16608, 16609, 16561, 106558, 106570, 106571, 
106267, 106253, 106556, 106569, 106266
37976, 105003, 105095, 105099, 105007, 105004, 105096, 105100, 105008, 106558, 106570, 106571, 106267, 106561, 106573, 106574, 
106270, 106256, 106559, 106572, 106269
37977, 105004, 105096, 105100, 105008, 105005, 105097, 105101, 105009, 106561, 106573, 106574, 106270, 106564, 106576, 106577, 
106273, 106259, 106562, 106575, 106272
37978, 105005, 105097, 105101, 105009, 105006, 105098, 105102, 105010, 106564, 106576, 106577, 106273, 106567, 106579, 106580, 
106276, 106262, 106565, 106578, 106275
37979, 105006, 105098, 105102, 105010, 34121, 34144, 34145, 34122, 106567, 106579, 106580, 106276, 34449, 34450, 34451, 
34403, 106265, 106568, 106581, 106278
37980, 16280, 16303, 16304, 16281, 105007, 105099, 105103, 105011, 16609, 16610, 16611, 16563, 106571, 106583, 106584, 
106280, 106266, 106569, 106582, 106279
37981, 105007, 105099, 105103, 105011, 105008, 105100, 105104, 105012, 106571, 106583, 106584, 106280, 106574, 106586, 106587, 
106283, 106269, 106572, 106585, 106282
37982, 105008, 105100, 105104, 105012, 105009, 105101, 105105, 105013, 106574, 106586, 106587, 106283, 106577, 106589, 106590, 
106286, 106272, 106575, 106588, 106285
37983, 105009, 105101, 105105, 105013, 105010, 105102, 105106, 105014, 106577, 106589, 106590, 106286, 106580, 106592, 106593, 
106289, 106275, 106578, 106591, 106288
37984, 105010, 105102, 105106, 105014, 34122, 34145, 34146, 34123, 106580, 106592, 106593, 106289, 34451, 34452, 34453, 
34405, 106278, 106581, 106594, 106291
37985, 16281, 16304, 16305, 16282, 105011, 105103, 105107, 105015, 16611, 16612, 16613, 16565, 106584, 106596, 106597, 
106293, 106279, 106582, 106595, 106292
37986, 105011, 105103, 105107, 105015, 105012, 105104, 105108, 105016, 106584, 106596, 106597, 106293, 106587, 106599, 106600, 
106296, 106282, 106585, 106598, 106295
37987, 105012, 105104, 105108, 105016, 105013, 105105, 105109, 105017, 106587, 106599, 106600, 106296, 106590, 106602, 106603, 
106299, 106285, 106588, 106601, 106298
37988, 105013, 105105, 105109, 105017, 105014, 105106, 105110, 105018, 106590, 106602, 106603, 106299, 106593, 106605, 106606, 
106302, 106288, 106591, 106604, 106301
37989, 105014, 105106, 105110, 105018, 34123, 34146, 34147, 34124, 106593, 106605, 106606, 106302, 34453, 34454, 34455, 
34407, 106291, 106594, 106607, 106304
37990, 16282, 16305, 16306, 16283, 105015, 105107, 105111, 105019, 16613, 16614, 16615, 16567, 106597, 106609, 106610, 
106306, 106292, 106595, 106608, 106305
37991, 105015, 105107, 105111, 105019, 105016, 105108, 105112, 105020, 106597, 106609, 106610, 106306, 106600, 106612, 106613, 
106309, 106295, 106598, 106611, 106308
37992, 105016, 105108, 105112, 105020, 105017, 105109, 105113, 105021, 106600, 106612, 106613, 106309, 106603, 106615, 106616, 
106312, 106298, 106601, 106614, 106311
37993, 105017, 105109, 105113, 105021, 105018, 105110, 105114, 105022, 106603, 106615, 106616, 106312, 106606, 106618, 106619, 
106315, 106301, 106604, 106617, 106314
37994, 105018, 105110, 105114, 105022, 34124, 34147, 34148, 34125, 106606, 106618, 106619, 106315, 34455, 34456, 34457, 
34409, 106304, 106607, 106620, 106317
37995, 16283, 16306, 16307, 16284, 105019, 105111, 105115, 105023, 16615, 16616, 16617, 16569, 106610, 106622, 106623, 
106319, 106305, 106608, 106621, 106318
37996, 105019, 105111, 105115, 105023, 105020, 105112, 105116, 105024, 106610, 106622, 106623, 106319, 106613, 106625, 106626, 
106322, 106308, 106611, 106624, 106321
37997, 105020, 105112, 105116, 105024, 105021, 105113, 105117, 105025, 106613, 106625, 106626, 106322, 106616, 106628, 106629, 
106325, 106311, 106614, 106627, 106324
37998, 105021, 105113, 105117, 105025, 105022, 105114, 105118, 105026, 106616, 106628, 106629, 106325, 106619, 106631, 106632, 
106328, 106314, 106617, 106630, 106327
37999, 105022, 105114, 105118, 105026, 34125, 34148, 34149, 34126, 106619, 106631, 106632, 106328, 34457, 34458, 34459, 
34411, 106317, 106620, 106633, 106330
38000, 16284, 16307, 16308, 16285, 105023, 105115, 105119, 105027, 16617, 16618, 16619, 16571, 106623, 106635, 106636, 
106332, 106318, 106621, 106634, 106331
38001, 105023, 105115, 105119, 105027, 105024, 105116, 105120, 105028, 106623, 106635, 106636, 106332, 106626, 106638, 106639, 
106335, 106321, 106624, 106637, 106334
38002, 105024, 105116, 105120, 105028, 105025, 105117, 105121, 105029, 106626, 106638, 106639, 106335, 106629, 106641, 106642, 
106338, 106324, 106627, 106640, 106337
38003, 105025, 105117, 105121, 105029, 105026, 105118, 105122, 105030, 106629, 106641, 106642, 106338, 106632, 106644, 106645, 
106341, 106327, 106630, 106643, 106340
38004, 105026, 105118, 105122, 105030, 34126, 34149, 34150, 34127, 106632, 106644, 106645, 106341, 34459, 34460, 34461, 
34413, 106330, 106633, 106646, 106343
38005, 16285, 16308, 16309, 16286, 105027, 105119, 105123, 105031, 16619, 16620, 16621, 16573, 106636, 106648, 106649, 
106345, 106331, 106634, 106647, 106344
38006, 105027, 105119, 105123, 105031, 105028, 105120, 105124, 105032, 106636, 106648, 106649, 106345, 106639, 106651, 106652, 
106348, 106334, 106637, 106650, 106347
38007, 105028, 105120, 105124, 105032, 105029, 105121, 105125, 105033, 106639, 106651, 106652, 106348, 106642, 106654, 106655, 
106351, 106337, 106640, 106653, 106350
38008, 105029, 105121, 105125, 105033, 105030, 105122, 105126, 105034, 106642, 106654, 106655, 106351, 106645, 106657, 106658, 
106354, 106340, 106643, 106656, 106353
38009, 105030, 105122, 105126, 105034, 34127, 34150, 34151, 34128, 106645, 106657, 106658, 106354, 34461, 34462, 34463, 
34415, 106343, 106646, 106659, 106356
38010, 16286, 16309, 16310, 16287, 105031, 105123, 105127, 105035, 16621, 16622, 16623, 16575, 106649, 106661, 106662, 
106358, 106344, 106647, 106660, 106357
38011, 105031, 105123, 105127, 105035, 105032, 105124, 105128, 105036, 106649, 106661, 106662, 106358, 106652, 106664, 106665, 
106361, 106347, 106650, 106663, 106360
38012, 105032, 105124, 105128, 105036, 105033, 105125, 105129, 105037, 106652, 106664, 106665, 106361, 106655, 106667, 106668, 
106364, 106350, 106653, 106666, 106363
38013, 105033, 105125, 105129, 105037, 105034, 105126, 105130, 105038, 106655, 106667, 106668, 106364, 106658, 106670, 106671, 
106367, 106353, 106656, 106669, 106366
38014, 105034, 105126, 105130, 105038, 34128, 34151, 34152, 34129, 106658, 106670, 106671, 106367, 34463, 34464, 34465, 
34417, 106356, 106659, 106672, 106369
38015, 16287, 16310, 16311, 16288, 105035, 105127, 105131, 105039, 16623, 16624, 16625, 16577, 106662, 106674, 106675, 
106371, 106357, 106660, 106673, 106370
38016, 105035, 105127, 105131, 105039, 105036, 105128, 105132, 105040, 106662, 106674, 106675, 106371, 106665, 106677, 106678, 
106374, 106360, 106663, 106676, 106373
38017, 105036, 105128, 105132, 105040, 105037, 105129, 105133, 105041, 106665, 106677, 106678, 106374, 106668, 106680, 106681, 
106377, 106363, 106666, 106679, 106376
38018, 105037, 105129, 105133, 105041, 105038, 105130, 105134, 105042, 106668, 106680, 106681, 106377, 106671, 106683, 106684, 
106380, 106366, 106669, 106682, 106379
38019, 105038, 105130, 105134, 105042, 34129, 34152, 34153, 34130, 106671, 106683, 106684, 106380, 34465, 34466, 34467, 
34419, 106369, 106672, 106685, 106382
38020, 16288, 16311, 16312, 16289, 105039, 105131, 105135, 105043, 16625, 16626, 16627, 16579, 106675, 106687, 106688, 
106384, 106370, 106673, 106686, 106383
38021, 105039, 105131, 105135, 105043, 105040, 105132, 105136, 105044, 106675, 106687, 106688, 106384, 106678, 106690, 106691, 
106387, 106373, 106676, 106689, 106386
38022, 105040, 105132, 105136, 105044, 105041, 105133, 105137, 105045, 106678, 106690, 106691, 106387, 106681, 106693, 106694, 
106390, 106376, 106679, 106692, 106389
38023, 105041, 105133, 105137, 105045, 105042, 105134, 105138, 105046, 106681, 106693, 106694, 106390, 106684, 106696, 106697, 
106393, 106379, 106682, 106695, 106392
38024, 105042, 105134, 105138, 105046, 34130, 34153, 34154, 34131, 106684, 106696, 106697, 106393, 34467, 34468, 34469, 
34421, 106382, 106685, 106698, 106395
38025, 16289, 16312, 16313, 16290, 105043, 105135, 105139, 105047, 16627, 16628, 16629, 16581, 106688, 106700, 106701, 
106397, 106383, 106686, 106699, 106396
38026, 105043, 105135, 105139, 105047, 105044, 105136, 105140, 105048, 106688, 106700, 106701, 106397, 106691, 106703, 106704, 
106400, 106386, 106689, 106702, 106399
38027, 105044, 105136, 105140, 105048, 105045, 105137, 105141, 105049, 106691, 106703, 106704, 106400, 106694, 106706, 106707, 
106403, 106389, 106692, 106705, 106402
38028, 105045, 105137, 105141, 105049, 105046, 105138, 105142, 105050, 106694, 106706, 106707, 106403, 106697, 106709, 106710, 
106406, 106392, 106695, 106708, 106405
38029, 105046, 105138, 105142, 105050, 34131, 34154, 34155, 34132, 106697, 106709, 106710, 106406, 34469, 34470, 34471, 
34423, 106395, 106698, 106711, 106408
38030, 16290, 16313, 16314, 16291, 105047, 105139, 105143, 105051, 16629, 16630, 16631, 16583, 106701, 106713, 106714, 
106410, 106396, 106699, 106712, 106409
38031, 105047, 105139, 105143, 105051, 105048, 105140, 105144, 105052, 106701, 106713, 106714, 106410, 106704, 106716, 106717, 
106413, 106399, 106702, 106715, 106412
38032, 105048, 105140, 105144, 105052, 105049, 105141, 105145, 105053, 106704, 106716, 106717, 106413, 106707, 106719, 106720, 
106416, 106402, 106705, 106718, 106415
38033, 105049, 105141, 105145, 105053, 105050, 105142, 105146, 105054, 106707, 106719, 106720, 106416, 106710, 106722, 106723, 
106419, 106405, 106708, 106721, 106418
38034, 105050, 105142, 105146, 105054, 34132, 34155, 34156, 34133, 106710, 106722, 106723, 106419, 34471, 34472, 34473, 
34425, 106408, 106711, 106724, 106421
38035, 16291, 16314, 16315, 16292, 105051, 105143, 105147, 105055, 16631, 16632, 16633, 16585, 106714, 106726, 106727, 
106423, 106409, 106712, 106725, 106422
38036, 105051, 105143, 105147, 105055, 105052, 105144, 105148, 105056, 106714, 106726, 106727, 106423, 106717, 106729, 106730, 
106426, 106412, 106715, 106728, 106425
38037, 105052, 105144, 105148, 105056, 105053, 105145, 105149, 105057, 106717, 106729, 106730, 106426, 106720, 106732, 106733, 
106429, 106415, 106718, 106731, 106428
38038, 105053, 105145, 105149, 105057, 105054, 105146, 105150, 105058, 106720, 106732, 106733, 106429, 106723, 106735, 106736, 
106432, 106418, 106721, 106734, 106431
38039, 105054, 105146, 105150, 105058, 34133, 34156, 34157, 34134, 106723, 106735, 106736, 106432, 34473, 34474, 34475, 
34427, 106421, 106724, 106737, 106434
38040, 16292, 16315, 16316, 16293, 105055, 105147, 105151, 105059, 16633, 16634, 16635, 16587, 106727, 106739, 106740, 
106436, 106422, 106725, 106738, 106435
38041, 105055, 105147, 105151, 105059, 105056, 105148, 105152, 105060, 106727, 106739, 106740, 106436, 106730, 106742, 106743, 
106439, 106425, 106728, 106741, 106438
38042, 105056, 105148, 105152, 105060, 105057, 105149, 105153, 105061, 106730, 106742, 106743, 106439, 106733, 106745, 106746, 
106442, 106428, 106731, 106744, 106441
38043, 105057, 105149, 105153, 105061, 105058, 105150, 105154, 105062, 106733, 106745, 106746, 106442, 106736, 106748, 106749, 
106445, 106431, 106734, 106747, 106444
38044, 105058, 105150, 105154, 105062, 34134, 34157, 34158, 34135, 106736, 106748, 106749, 106445, 34475, 34476, 34477, 
34429, 106434, 106737, 106750, 106447
38045, 16293, 16316, 16317, 16294, 105059, 105151, 105155, 105063, 16635, 16636, 16637, 16589, 106740, 106752, 106753, 
106449, 106435, 106738, 106751, 106448
38046, 105059, 105151, 105155, 105063, 105060, 105152, 105156, 105064, 106740, 106752, 106753, 106449, 106743, 106755, 106756, 
106452, 106438, 106741, 106754, 106451
38047, 105060, 105152, 105156, 105064, 105061, 105153, 105157, 105065, 106743, 106755, 106756, 106452, 106746, 106758, 106759, 
106455, 106441, 106744, 106757, 106454
38048, 105061, 105153, 105157, 105065, 105062, 105154, 105158, 105066, 106746, 106758, 106759, 106455, 106749, 106761, 106762, 
106458, 106444, 106747, 106760, 106457
38049, 105062, 105154, 105158, 105066, 34135, 34158, 34159, 34136, 106749, 106761, 106762, 106458, 34477, 34478, 34479, 
34431, 106447, 106750, 106763, 106460
38050, 16294, 16317, 16318, 16295, 105063, 105155, 105159, 105067, 16637, 16638, 16639, 16591, 106753, 106765, 106766, 
106462, 106448, 106751, 106764, 106461
38051, 105063, 105155, 105159, 105067, 105064, 105156, 105160, 105068, 106753, 106765, 106766, 106462, 106756, 106768, 106769, 
106465, 106451, 106754, 106767, 106464
38052, 105064, 105156, 105160, 105068, 105065, 105157, 105161, 105069, 106756, 106768, 106769, 106465, 106759, 106771, 106772, 
106468, 106454, 106757, 106770, 106467
38053, 105065, 105157, 105161, 105069, 105066, 105158, 105162, 105070, 106759, 106771, 106772, 106468, 106762, 106774, 106775, 
106471, 106457, 106760, 106773, 106470
38054, 105066, 105158, 105162, 105070, 34136, 34159, 34160, 34137, 106762, 106774, 106775, 106471, 34479, 34480, 34481, 
34433, 106460, 106763, 106776, 106473
38055, 16295, 16318, 16319, 16296, 105067, 105159, 105163, 105071, 16639, 16640, 16641, 16593, 106766, 106778, 106779, 
106475, 106461, 106764, 106777, 106474
38056, 105067, 105159, 105163, 105071, 105068, 105160, 105164, 105072, 106766, 106778, 106779, 106475, 106769, 106781, 106782, 
106478, 106464, 106767, 106780, 106477
38057, 105068, 105160, 105164, 105072, 105069, 105161, 105165, 105073, 106769, 106781, 106782, 106478, 106772, 106784, 106785, 
106481, 106467, 106770, 106783, 106480
38058, 105069, 105161, 105165, 105073, 105070, 105162, 105166, 105074, 106772, 106784, 106785, 106481, 106775, 106787, 106788, 
106484, 106470, 106773, 106786, 106483
38059, 105070, 105162, 105166, 105074, 34137, 34160, 34161, 34138, 106775, 106787, 106788, 106484, 34481, 34482, 34483, 
34435, 106473, 106776, 106789, 106486
38060, 16296, 16319, 16320, 16297, 105071, 105163, 105167, 105075, 16641, 16642, 16643, 16595, 106779, 106791, 106792, 
106488, 106474, 106777, 106790, 106487
38061, 105071, 105163, 105167, 105075, 105072, 105164, 105168, 105076, 106779, 106791, 106792, 106488, 106782, 106794, 106795, 
106491, 106477, 106780, 106793, 106490
38062, 105072, 105164, 105168, 105076, 105073, 105165, 105169, 105077, 106782, 106794, 106795, 106491, 106785, 106797, 106798, 
106494, 106480, 106783, 106796, 106493
38063, 105073, 105165, 105169, 105077, 105074, 105166, 105170, 105078, 106785, 106797, 106798, 106494, 106788, 106800, 106801, 
106497, 106483, 106786, 106799, 106496
38064, 105074, 105166, 105170, 105078, 34138, 34161, 34162, 34139, 106788, 106800, 106801, 106497, 34483, 34484, 34485, 
34437, 106486, 106789, 106802, 106499
38065, 16297, 16320, 16321, 16298, 105075, 105167, 105171, 105079, 16643, 16644, 16645, 16597, 106792, 106804, 106805, 
106501, 106487, 106790, 106803, 106500
38066, 105075, 105167, 105171, 105079, 105076, 105168, 105172, 105080, 106792, 106804, 106805, 106501, 106795, 106807, 106808, 
106504, 106490, 106793, 106806, 106503
38067, 105076, 105168, 105172, 105080, 105077, 105169, 105173, 105081, 106795, 106807, 106808, 106504, 106798, 106810, 106811, 
106507, 106493, 106796, 106809, 106506
38068, 105077, 105169, 105173, 105081, 105078, 105170, 105174, 105082, 106798, 106810, 106811, 106507, 106801, 106813, 106814, 
106510, 106496, 106799, 106812, 106509
38069, 105078, 105170, 105174, 105082, 34139, 34162, 34163, 34140, 106801, 106813, 106814, 106510, 34485, 34486, 34487, 
34439, 106499, 106802, 106815, 106512
38070, 16298, 16321, 1488, 1487, 105079, 105171, 33956, 33952, 16645, 16646, 1499, 16599, 106805, 106816, 34010, 
106513, 106500, 106803, 34011, 34002
38071, 105079, 105171, 33956, 33952, 105080, 105172, 33957, 33953, 106805, 106816, 34010, 106513, 106808, 106817, 34012, 
106514, 106503, 106806, 34013, 34004
38072, 105080, 105172, 33957, 33953, 105081, 105173, 33958, 33954, 106808, 106817, 34012, 106514, 106811, 106818, 34014, 
106515, 106506, 106809, 34015, 34006
38073, 105081, 105173, 33958, 33954, 105082, 105174, 33959, 33955, 106811, 106818, 34014, 106515, 106814, 106819, 34016, 
106516, 106509, 106812, 34017, 34008
38074, 105082, 105174, 33959, 33955, 34140, 34163, 3528, 3527, 106814, 106819, 34016, 106516, 34487, 34488, 3539, 
34441, 106512, 106815, 34018, 34009
38075, 1244, 1245, 16322, 16299, 33056, 33060, 105175, 105083, 1256, 16647, 16648, 16600, 33119, 106821, 106822, 
106518, 33111, 33120, 106820, 106517
38076, 33056, 33060, 105175, 105083, 33057, 33061, 105176, 105084, 33119, 106821, 106822, 106518, 33121, 106824, 106825, 
106521, 33113, 33122, 106823, 106520
38077, 33057, 33061, 105176, 105084, 33058, 33062, 105177, 105085, 33121, 106824, 106825, 106521, 33123, 106827, 106828, 
106524, 33115, 33124, 106826, 106523
38078, 33058, 33062, 105177, 105085, 33059, 33063, 105178, 105086, 33123, 106827, 106828, 106524, 33125, 106830, 106831, 
106527, 33117, 33126, 106829, 106526
38079, 33059, 33063, 105178, 105086, 3393, 3394, 34164, 34141, 33125, 106830, 106831, 106527, 3405, 34489, 34490, 
34442, 33118, 33127, 106832, 106529
38080, 16299, 16322, 16323, 16300, 105083, 105175, 105179, 105087, 16648, 16649, 16650, 16602, 106822, 106834, 106835, 
106531, 106517, 106820, 106833, 106530
38081, 105083, 105175, 105179, 105087, 105084, 105176, 105180, 105088, 106822, 106834, 106835, 106531, 106825, 106837, 106838, 
106534, 106520, 106823, 106836, 106533
38082, 105084, 105176, 105180, 105088, 105085, 105177, 105181, 105089, 106825, 106837, 106838, 106534, 106828, 106840, 106841, 
106537, 106523, 106826, 106839, 106536
38083, 105085, 105177, 105181, 105089, 105086, 105178, 105182, 105090, 106828, 106840, 106841, 106537, 106831, 106843, 106844, 
106540, 106526, 106829, 106842, 106539
38084, 105086, 105178, 105182, 105090, 34141, 34164, 34165, 34142, 106831, 106843, 106844, 106540, 34490, 34491, 34492, 
34444, 106529, 106832, 106845, 106542
38085, 16300, 16323, 16324, 16301, 105087, 105179, 105183, 105091, 16650, 16651, 16652, 16604, 106835, 106847, 106848, 
106544, 106530, 106833, 106846, 106543
38086, 105087, 105179, 105183, 105091, 105088, 105180, 105184, 105092, 106835, 106847, 106848, 106544, 106838, 106850, 106851, 
106547, 106533, 106836, 106849, 106546
38087, 105088, 105180, 105184, 105092, 105089, 105181, 105185, 105093, 106838, 106850, 106851, 106547, 106841, 106853, 106854, 
106550, 106536, 106839, 106852, 106549
38088, 105089, 105181, 105185, 105093, 105090, 105182, 105186, 105094, 106841, 106853, 106854, 106550, 106844, 106856, 106857, 
106553, 106539, 106842, 106855, 106552
38089, 105090, 105182, 105186, 105094, 34142, 34165, 34166, 34143, 106844, 106856, 106857, 106553, 34492, 34493, 34494, 
34446, 106542, 106845, 106858, 106555
38090, 16301, 16324, 16325, 16302, 105091, 105183, 105187, 105095, 16652, 16653, 16654, 16606, 106848, 106860, 106861, 
106557, 106543, 106846, 106859, 106556
38091, 105091, 105183, 105187, 105095, 105092, 105184, 105188, 105096, 106848, 106860, 106861, 106557, 106851, 106863, 106864, 
106560, 106546, 106849, 106862, 106559
38092, 105092, 105184, 105188, 105096, 105093, 105185, 105189, 105097, 106851, 106863, 106864, 106560, 106854, 106866, 106867, 
106563, 106549, 106852, 106865, 106562
38093, 105093, 105185, 105189, 105097, 105094, 105186, 105190, 105098, 106854, 106866, 106867, 106563, 106857, 106869, 106870, 
106566, 106552, 106855, 106868, 106565
38094, 105094, 105186, 105190, 105098, 34143, 34166, 34167, 34144, 106857, 106869, 106870, 106566, 34494, 34495, 34496, 
34448, 106555, 106858, 106871, 106568
38095, 16302, 16325, 16326, 16303, 105095, 105187, 105191, 105099, 16654, 16655, 16656, 16608, 106861, 106873, 106874, 
106570, 106556, 106859, 106872, 106569
38096, 105095, 105187, 105191, 105099, 105096, 105188, 105192, 105100, 106861, 106873, 106874, 106570, 106864, 106876, 106877, 
106573, 106559, 106862, 106875, 106572
38097, 105096, 105188, 105192, 105100, 105097, 105189, 105193, 105101, 106864, 106876, 106877, 106573, 106867, 106879, 106880, 
106576, 106562, 106865, 106878, 106575
38098, 105097, 105189, 105193, 105101, 105098, 105190, 105194, 105102, 106867, 106879, 106880, 106576, 106870, 106882, 106883, 
106579, 106565, 106868, 106881, 106578
38099, 105098, 105190, 105194, 105102, 34144, 34167, 34168, 34145, 106870, 106882, 106883, 106579, 34496, 34497, 34498, 
34450, 106568, 106871, 106884, 106581
38100, 16303, 16326, 16327, 16304, 105099, 105191, 105195, 105103, 16656, 16657, 16658, 16610, 106874, 106886, 106887, 
106583, 106569, 106872, 106885, 106582
38101, 105099, 105191, 105195, 105103, 105100, 105192, 105196, 105104, 106874, 106886, 106887, 106583, 106877, 106889, 106890, 
106586, 106572, 106875, 106888, 106585
38102, 105100, 105192, 105196, 105104, 105101, 105193, 105197, 105105, 106877, 106889, 106890, 106586, 106880, 106892, 106893, 
106589, 106575, 106878, 106891, 106588
38103, 105101, 105193, 105197, 105105, 105102, 105194, 105198, 105106, 106880, 106892, 106893, 106589, 106883, 106895, 106896, 
106592, 106578, 106881, 106894, 106591
38104, 105102, 105194, 105198, 105106, 34145, 34168, 34169, 34146, 106883, 106895, 106896, 106592, 34498, 34499, 34500, 
34452, 106581, 106884, 106897, 106594
38105, 16304, 16327, 16328, 16305, 105103, 105195, 105199, 105107, 16658, 16659, 16660, 16612, 106887, 106899, 106900, 
106596, 106582, 106885, 106898, 106595
38106, 105103, 105195, 105199, 105107, 105104, 105196, 105200, 105108, 106887, 106899, 106900, 106596, 106890, 106902, 106903, 
106599, 106585, 106888, 106901, 106598
38107, 105104, 105196, 105200, 105108, 105105, 105197, 105201, 105109, 106890, 106902, 106903, 106599, 106893, 106905, 106906, 
106602, 106588, 106891, 106904, 106601
38108, 105105, 105197, 105201, 105109, 105106, 105198, 105202, 105110, 106893, 106905, 106906, 106602, 106896, 106908, 106909, 
106605, 106591, 106894, 106907, 106604
38109, 105106, 105198, 105202, 105110, 34146, 34169, 34170, 34147, 106896, 106908, 106909, 106605, 34500, 34501, 34502, 
34454, 106594, 106897, 106910, 106607
38110, 16305, 16328, 16329, 16306, 105107, 105199, 105203, 105111, 16660, 16661, 16662, 16614, 106900, 106912, 106913, 
106609, 106595, 106898, 106911, 106608
38111, 105107, 105199, 105203, 105111, 105108, 105200, 105204, 105112, 106900, 106912, 106913, 106609, 106903, 106915, 106916, 
106612, 106598, 106901, 106914, 106611
38112, 105108, 105200, 105204, 105112, 105109, 105201, 105205, 105113, 106903, 106915, 106916, 106612, 106906, 106918, 106919, 
106615, 106601, 106904, 106917, 106614
38113, 105109, 105201, 105205, 105113, 105110, 105202, 105206, 105114, 106906, 106918, 106919, 106615, 106909, 106921, 106922, 
106618, 106604, 106907, 106920, 106617
38114, 105110, 105202, 105206, 105114, 34147, 34170, 34171, 34148, 106909, 106921, 106922, 106618, 34502, 34503, 34504, 
34456, 106607, 106910, 106923, 106620
38115, 16306, 16329, 16330, 16307, 105111, 105203, 105207, 105115, 16662, 16663, 16664, 16616, 106913, 106925, 106926, 
106622, 106608, 106911, 106924, 106621
38116, 105111, 105203, 105207, 105115, 105112, 105204, 105208, 105116, 106913, 106925, 106926, 106622, 106916, 106928, 106929, 
106625, 106611, 106914, 106927, 106624
38117, 105112, 105204, 105208, 105116, 105113, 105205, 105209, 105117, 106916, 106928, 106929, 106625, 106919, 106931, 106932, 
106628, 106614, 106917, 106930, 106627
38118, 105113, 105205, 105209, 105117, 105114, 105206, 105210, 105118, 106919, 106931, 106932, 106628, 106922, 106934, 106935, 
106631, 106617, 106920, 106933, 106630
38119, 105114, 105206, 105210, 105118, 34148, 34171, 34172, 34149, 106922, 106934, 106935, 106631, 34504, 34505, 34506, 
34458, 106620, 106923, 106936, 106633
38120, 16307, 16330, 16331, 16308, 105115, 105207, 105211, 105119, 16664, 16665, 16666, 16618, 106926, 106938, 106939, 
106635, 106621, 106924, 106937, 106634
38121, 105115, 105207, 105211, 105119, 105116, 105208, 105212, 105120, 106926, 106938, 106939, 106635, 106929, 106941, 106942, 
106638, 106624, 106927, 106940, 106637
38122, 105116, 105208, 105212, 105120, 105117, 105209, 105213, 105121, 106929, 106941, 106942, 106638, 106932, 106944, 106945, 
106641, 106627, 106930, 106943, 106640
38123, 105117, 105209, 105213, 105121, 105118, 105210, 105214, 105122, 106932, 106944, 106945, 106641, 106935, 106947, 106948, 
106644, 106630, 106933, 106946, 106643
38124, 105118, 105210, 105214, 105122, 34149, 34172, 34173, 34150, 106935, 106947, 106948, 106644, 34506, 34507, 34508, 
34460, 106633, 106936, 106949, 106646
38125, 16308, 16331, 16332, 16309, 105119, 105211, 105215, 105123, 16666, 16667, 16668, 16620, 106939, 106951, 106952, 
106648, 106634, 106937, 106950, 106647
38126, 105119, 105211, 105215, 105123, 105120, 105212, 105216, 105124, 106939, 106951, 106952, 106648, 106942, 106954, 106955, 
106651, 106637, 106940, 106953, 106650
38127, 105120, 105212, 105216, 105124, 105121, 105213, 105217, 105125, 106942, 106954, 106955, 106651, 106945, 106957, 106958, 
106654, 106640, 106943, 106956, 106653
38128, 105121, 105213, 105217, 105125, 105122, 105214, 105218, 105126, 106945, 106957, 106958, 106654, 106948, 106960, 106961, 
106657, 106643, 106946, 106959, 106656
38129, 105122, 105214, 105218, 105126, 34150, 34173, 34174, 34151, 106948, 106960, 106961, 106657, 34508, 34509, 34510, 
34462, 106646, 106949, 106962, 106659
38130, 16309, 16332, 16333, 16310, 105123, 105215, 105219, 105127, 16668, 16669, 16670, 16622, 106952, 106964, 106965, 
106661, 106647, 106950, 106963, 106660
38131, 105123, 105215, 105219, 105127, 105124, 105216, 105220, 105128, 106952, 106964, 106965, 106661, 106955, 106967, 106968, 
106664, 106650, 106953, 106966, 106663
38132, 105124, 105216, 105220, 105128, 105125, 105217, 105221, 105129, 106955, 106967, 106968, 106664, 106958, 106970, 106971, 
106667, 106653, 106956, 106969, 106666
38133, 105125, 105217, 105221, 105129, 105126, 105218, 105222, 105130, 106958, 106970, 106971, 106667, 106961, 106973, 106974, 
106670, 106656, 106959, 106972, 106669
38134, 105126, 105218, 105222, 105130, 34151, 34174, 34175, 34152, 106961, 106973, 106974, 106670, 34510, 34511, 34512, 
34464, 106659, 106962, 106975, 106672
38135, 16310, 16333, 16334, 16311, 105127, 105219, 105223, 105131, 16670, 16671, 16672, 16624, 106965, 106977, 106978, 
106674, 106660, 106963, 106976, 106673
38136, 105127, 105219, 105223, 105131, 105128, 105220, 105224, 105132, 106965, 106977, 106978, 106674, 106968, 106980, 106981, 
106677, 106663, 106966, 106979, 106676
38137, 105128, 105220, 105224, 105132, 105129, 105221, 105225, 105133, 106968, 106980, 106981, 106677, 106971, 106983, 106984, 
106680, 106666, 106969, 106982, 106679
38138, 105129, 105221, 105225, 105133, 105130, 105222, 105226, 105134, 106971, 106983, 106984, 106680, 106974, 106986, 106987, 
106683, 106669, 106972, 106985, 106682
38139, 105130, 105222, 105226, 105134, 34152, 34175, 34176, 34153, 106974, 106986, 106987, 106683, 34512, 34513, 34514, 
34466, 106672, 106975, 106988, 106685
38140, 16311, 16334, 16335, 16312, 105131, 105223, 105227, 105135, 16672, 16673, 16674, 16626, 106978, 106990, 106991, 
106687, 106673, 106976, 106989, 106686
38141, 105131, 105223, 105227, 105135, 105132, 105224, 105228, 105136, 106978, 106990, 106991, 106687, 106981, 106993, 106994, 
106690, 106676, 106979, 106992, 106689
38142, 105132, 105224, 105228, 105136, 105133, 105225, 105229, 105137, 106981, 106993, 106994, 106690, 106984, 106996, 106997, 
106693, 106679, 106982, 106995, 106692
38143, 105133, 105225, 105229, 105137, 105134, 105226, 105230, 105138, 106984, 106996, 106997, 106693, 106987, 106999, 107000, 
106696, 106682, 106985, 106998, 106695
38144, 105134, 105226, 105230, 105138, 34153, 34176, 34177, 34154, 106987, 106999, 107000, 106696, 34514, 34515, 34516, 
34468, 106685, 106988, 107001, 106698
38145, 16312, 16335, 16336, 16313, 105135, 105227, 105231, 105139, 16674, 16675, 16676, 16628, 106991, 107003, 107004, 
106700, 106686, 106989, 107002, 106699
38146, 105135, 105227, 105231, 105139, 105136, 105228, 105232, 105140, 106991, 107003, 107004, 106700, 106994, 107006, 107007, 
106703, 106689, 106992, 107005, 106702
38147, 105136, 105228, 105232, 105140, 105137, 105229, 105233, 105141, 106994, 107006, 107007, 106703, 106997, 107009, 107010, 
106706, 106692, 106995, 107008, 106705
38148, 105137, 105229, 105233, 105141, 105138, 105230, 105234, 105142, 106997, 107009, 107010, 106706, 107000, 107012, 107013, 
106709, 106695, 106998, 107011, 106708
38149, 105138, 105230, 105234, 105142, 34154, 34177, 34178, 34155, 107000, 107012, 107013, 106709, 34516, 34517, 34518, 
34470, 106698, 107001, 107014, 106711
38150, 16313, 16336, 16337, 16314, 105139, 105231, 105235, 105143, 16676, 16677, 16678, 16630, 107004, 107016, 107017, 
106713, 106699, 107002, 107015, 106712
38151, 105139, 105231, 105235, 105143, 105140, 105232, 105236, 105144, 107004, 107016, 107017, 106713, 107007, 107019, 107020, 
106716, 106702, 107005, 107018, 106715
38152, 105140, 105232, 105236, 105144, 105141, 105233, 105237, 105145, 107007, 107019, 107020, 106716, 107010, 107022, 107023, 
106719, 106705, 107008, 107021, 106718
38153, 105141, 105233, 105237, 105145, 105142, 105234, 105238, 105146, 107010, 107022, 107023, 106719, 107013, 107025, 107026, 
106722, 106708, 107011, 107024, 106721
38154, 105142, 105234, 105238, 105146, 34155, 34178, 34179, 34156, 107013, 107025, 107026, 106722, 34518, 34519, 34520, 
34472, 106711, 107014, 107027, 106724
38155, 16314, 16337, 16338, 16315, 105143, 105235, 105239, 105147, 16678, 16679, 16680, 16632, 107017, 107029, 107030, 
106726, 106712, 107015, 107028, 106725
38156, 105143, 105235, 105239, 105147, 105144, 105236, 105240, 105148, 107017, 107029, 107030, 106726, 107020, 107032, 107033, 
106729, 106715, 107018, 107031, 106728
38157, 105144, 105236, 105240, 105148, 105145, 105237, 105241, 105149, 107020, 107032, 107033, 106729, 107023, 107035, 107036, 
106732, 106718, 107021, 107034, 106731
38158, 105145, 105237, 105241, 105149, 105146, 105238, 105242, 105150, 107023, 107035, 107036, 106732, 107026, 107038, 107039, 
106735, 106721, 107024, 107037, 106734
38159, 105146, 105238, 105242, 105150, 34156, 34179, 34180, 34157, 107026, 107038, 107039, 106735, 34520, 34521, 34522, 
34474, 106724, 107027, 107040, 106737
38160, 16315, 16338, 16339, 16316, 105147, 105239, 105243, 105151, 16680, 16681, 16682, 16634, 107030, 107042, 107043, 
106739, 106725, 107028, 107041, 106738
38161, 105147, 105239, 105243, 105151, 105148, 105240, 105244, 105152, 107030, 107042, 107043, 106739, 107033, 107045, 107046, 
106742, 106728, 107031, 107044, 106741
38162, 105148, 105240, 105244, 105152, 105149, 105241, 105245, 105153, 107033, 107045, 107046, 106742, 107036, 107048, 107049, 
106745, 106731, 107034, 107047, 106744
38163, 105149, 105241, 105245, 105153, 105150, 105242, 105246, 105154, 107036, 107048, 107049, 106745, 107039, 107051, 107052, 
106748, 106734, 107037, 107050, 106747
38164, 105150, 105242, 105246, 105154, 34157, 34180, 34181, 34158, 107039, 107051, 107052, 106748, 34522, 34523, 34524, 
34476, 106737, 107040, 107053, 106750
38165, 16316, 16339, 16340, 16317, 105151, 105243, 105247, 105155, 16682, 16683, 16684, 16636, 107043, 107055, 107056, 
106752, 106738, 107041, 107054, 106751
38166, 105151, 105243, 105247, 105155, 105152, 105244, 105248, 105156, 107043, 107055, 107056, 106752, 107046, 107058, 107059, 
106755, 106741, 107044, 107057, 106754
38167, 105152, 105244, 105248, 105156, 105153, 105245, 105249, 105157, 107046, 107058, 107059, 106755, 107049, 107061, 107062, 
106758, 106744, 107047, 107060, 106757
38168, 105153, 105245, 105249, 105157, 105154, 105246, 105250, 105158, 107049, 107061, 107062, 106758, 107052, 107064, 107065, 
106761, 106747, 107050, 107063, 106760
38169, 105154, 105246, 105250, 105158, 34158, 34181, 34182, 34159, 107052, 107064, 107065, 106761, 34524, 34525, 34526, 
34478, 106750, 107053, 107066, 106763
38170, 16317, 16340, 16341, 16318, 105155, 105247, 105251, 105159, 16684, 16685, 16686, 16638, 107056, 107068, 107069, 
106765, 106751, 107054, 107067, 106764
38171, 105155, 105247, 105251, 105159, 105156, 105248, 105252, 105160, 107056, 107068, 107069, 106765, 107059, 107071, 107072, 
106768, 106754, 107057, 107070, 106767
38172, 105156, 105248, 105252, 105160, 105157, 105249, 105253, 105161, 107059, 107071, 107072, 106768, 107062, 107074, 107075, 
106771, 106757, 107060, 107073, 106770
38173, 105157, 105249, 105253, 105161, 105158, 105250, 105254, 105162, 107062, 107074, 107075, 106771, 107065, 107077, 107078, 
106774, 106760, 107063, 107076, 106773
38174, 105158, 105250, 105254, 105162, 34159, 34182, 34183, 34160, 107065, 107077, 107078, 106774, 34526, 34527, 34528, 
34480, 106763, 107066, 107079, 106776
38175, 16318, 16341, 16342, 16319, 105159, 105251, 105255, 105163, 16686, 16687, 16688, 16640, 107069, 107081, 107082, 
106778, 106764, 107067, 107080, 106777
38176, 105159, 105251, 105255, 105163, 105160, 105252, 105256, 105164, 107069, 107081, 107082, 106778, 107072, 107084, 107085, 
106781, 106767, 107070, 107083, 106780
38177, 105160, 105252, 105256, 105164, 105161, 105253, 105257, 105165, 107072, 107084, 107085, 106781, 107075, 107087, 107088, 
106784, 106770, 107073, 107086, 106783
38178, 105161, 105253, 105257, 105165, 105162, 105254, 105258, 105166, 107075, 107087, 107088, 106784, 107078, 107090, 107091, 
106787, 106773, 107076, 107089, 106786
38179, 105162, 105254, 105258, 105166, 34160, 34183, 34184, 34161, 107078, 107090, 107091, 106787, 34528, 34529, 34530, 
34482, 106776, 107079, 107092, 106789
38180, 16319, 16342, 16343, 16320, 105163, 105255, 105259, 105167, 16688, 16689, 16690, 16642, 107082, 107094, 107095, 
106791, 106777, 107080, 107093, 106790
38181, 105163, 105255, 105259, 105167, 105164, 105256, 105260, 105168, 107082, 107094, 107095, 106791, 107085, 107097, 107098, 
106794, 106780, 107083, 107096, 106793
38182, 105164, 105256, 105260, 105168, 105165, 105257, 105261, 105169, 107085, 107097, 107098, 106794, 107088, 107100, 107101, 
106797, 106783, 107086, 107099, 106796
38183, 105165, 105257, 105261, 105169, 105166, 105258, 105262, 105170, 107088, 107100, 107101, 106797, 107091, 107103, 107104, 
106800, 106786, 107089, 107102, 106799
38184, 105166, 105258, 105262, 105170, 34161, 34184, 34185, 34162, 107091, 107103, 107104, 106800, 34530, 34531, 34532, 
34484, 106789, 107092, 107105, 106802
38185, 16320, 16343, 16344, 16321, 105167, 105259, 105263, 105171, 16690, 16691, 16692, 16644, 107095, 107107, 107108, 
106804, 106790, 107093, 107106, 106803
38186, 105167, 105259, 105263, 105171, 105168, 105260, 105264, 105172, 107095, 107107, 107108, 106804, 107098, 107110, 107111, 
106807, 106793, 107096, 107109, 106806
38187, 105168, 105260, 105264, 105172, 105169, 105261, 105265, 105173, 107098, 107110, 107111, 106807, 107101, 107113, 107114, 
106810, 106796, 107099, 107112, 106809
38188, 105169, 105261, 105265, 105173, 105170, 105262, 105266, 105174, 107101, 107113, 107114, 106810, 107104, 107116, 107117, 
106813, 106799, 107102, 107115, 106812
38189, 105170, 105262, 105266, 105174, 34162, 34185, 34186, 34163, 107104, 107116, 107117, 106813, 34532, 34533, 34534, 
34486, 106802, 107105, 107118, 106815
38190, 16321, 16344, 1489, 1488, 105171, 105263, 33960, 33956, 16692, 16693, 1500, 16646, 107108, 107119, 34019, 
106816, 106803, 107106, 34020, 34011
38191, 105171, 105263, 33960, 33956, 105172, 105264, 33961, 33957, 107108, 107119, 34019, 106816, 107111, 107120, 34021, 
106817, 106806, 107109, 34022, 34013
38192, 105172, 105264, 33961, 33957, 105173, 105265, 33962, 33958, 107111, 107120, 34021, 106817, 107114, 107121, 34023, 
106818, 106809, 107112, 34024, 34015
38193, 105173, 105265, 33962, 33958, 105174, 105266, 33963, 33959, 107114, 107121, 34023, 106818, 107117, 107122, 34025, 
106819, 106812, 107115, 34026, 34017
38194, 105174, 105266, 33963, 33959, 34163, 34186, 3529, 3528, 107117, 107122, 34025, 106819, 34534, 34535, 3540, 
34488, 106815, 107118, 34027, 34018
38195, 1245, 1246, 16345, 16322, 33060, 33064, 105267, 105175, 1257, 16694, 16695, 16647, 33128, 107124, 107125, 
106821, 33120, 33129, 107123, 106820
38196, 33060, 33064, 105267, 105175, 33061, 33065, 105268, 105176, 33128, 107124, 107125, 106821, 33130, 107127, 107128, 
106824, 33122, 33131, 107126, 106823
38197, 33061, 33065, 105268, 105176, 33062, 33066, 105269, 105177, 33130, 107127, 107128, 106824, 33132, 107130, 107131, 
106827, 33124, 33133, 107129, 106826
38198, 33062, 33066, 105269, 105177, 33063, 33067, 105270, 105178, 33132, 107130, 107131, 106827, 33134, 107133, 107134, 
106830, 33126, 33135, 107132, 106829
38199, 33063, 33067, 105270, 105178, 3394, 3395, 34187, 34164, 33134, 107133, 107134, 106830, 3406, 34536, 34537, 
34489, 33127, 33136, 107135, 106832
38200, 16322, 16345, 16346, 16323, 105175, 105267, 105271, 105179, 16695, 16696, 16697, 16649, 107125, 107137, 107138, 
106834, 106820, 107123, 107136, 106833
38201, 105175, 105267, 105271, 105179, 105176, 105268, 105272, 105180, 107125, 107137, 107138, 106834, 107128, 107140, 107141, 
106837, 106823, 107126, 107139, 106836
38202, 105176, 105268, 105272, 105180, 105177, 105269, 105273, 105181, 107128, 107140, 107141, 106837, 107131, 107143, 107144, 
106840, 106826, 107129, 107142, 106839
38203, 105177, 105269, 105273, 105181, 105178, 105270, 105274, 105182, 107131, 107143, 107144, 106840, 107134, 107146, 107147, 
106843, 106829, 107132, 107145, 106842
38204, 105178, 105270, 105274, 105182, 34164, 34187, 34188, 34165, 107134, 107146, 107147, 106843, 34537, 34538, 34539, 
34491, 106832, 107135, 107148, 106845
38205, 16323, 16346, 16347, 16324, 105179, 105271, 105275, 105183, 16697, 16698, 16699, 16651, 107138, 107150, 107151, 
106847, 106833, 107136, 107149, 106846
38206, 105179, 105271, 105275, 105183, 105180, 105272, 105276, 105184, 107138, 107150, 107151, 106847, 107141, 107153, 107154, 
106850, 106836, 107139, 107152, 106849
38207, 105180, 105272, 105276, 105184, 105181, 105273, 105277, 105185, 107141, 107153, 107154, 106850, 107144, 107156, 107157, 
106853, 106839, 107142, 107155, 106852
38208, 105181, 105273, 105277, 105185, 105182, 105274, 105278, 105186, 107144, 107156, 107157, 106853, 107147, 107159, 107160, 
106856, 106842, 107145, 107158, 106855
38209, 105182, 105274, 105278, 105186, 34165, 34188, 34189, 34166, 107147, 107159, 107160, 106856, 34539, 34540, 34541, 
34493, 106845, 107148, 107161, 106858
38210, 16324, 16347, 16348, 16325, 105183, 105275, 105279, 105187, 16699, 16700, 16701, 16653, 107151, 107163, 107164, 
106860, 106846, 107149, 107162, 106859
38211, 105183, 105275, 105279, 105187, 105184, 105276, 105280, 105188, 107151, 107163, 107164, 106860, 107154, 107166, 107167, 
106863, 106849, 107152, 107165, 106862
38212, 105184, 105276, 105280, 105188, 105185, 105277, 105281, 105189, 107154, 107166, 107167, 106863, 107157, 107169, 107170, 
106866, 106852, 107155, 107168, 106865
38213, 105185, 105277, 105281, 105189, 105186, 105278, 105282, 105190, 107157, 107169, 107170, 106866, 107160, 107172, 107173, 
106869, 106855, 107158, 107171, 106868
38214, 105186, 105278, 105282, 105190, 34166, 34189, 34190, 34167, 107160, 107172, 107173, 106869, 34541, 34542, 34543, 
34495, 106858, 107161, 107174, 106871
38215, 16325, 16348, 16349, 16326, 105187, 105279, 105283, 105191, 16701, 16702, 16703, 16655, 107164, 107176, 107177, 
106873, 106859, 107162, 107175, 106872
38216, 105187, 105279, 105283, 105191, 105188, 105280, 105284, 105192, 107164, 107176, 107177, 106873, 107167, 107179, 107180, 
106876, 106862, 107165, 107178, 106875
38217, 105188, 105280, 105284, 105192, 105189, 105281, 105285, 105193, 107167, 107179, 107180, 106876, 107170, 107182, 107183, 
106879, 106865, 107168, 107181, 106878
38218, 105189, 105281, 105285, 105193, 105190, 105282, 105286, 105194, 107170, 107182, 107183, 106879, 107173, 107185, 107186, 
106882, 106868, 107171, 107184, 106881
38219, 105190, 105282, 105286, 105194, 34167, 34190, 34191, 34168, 107173, 107185, 107186, 106882, 34543, 34544, 34545, 
34497, 106871, 107174, 107187, 106884
38220, 16326, 16349, 16350, 16327, 105191, 105283, 105287, 105195, 16703, 16704, 16705, 16657, 107177, 107189, 107190, 
106886, 106872, 107175, 107188, 106885
38221, 105191, 105283, 105287, 105195, 105192, 105284, 105288, 105196, 107177, 107189, 107190, 106886, 107180, 107192, 107193, 
106889, 106875, 107178, 107191, 106888
38222, 105192, 105284, 105288, 105196, 105193, 105285, 105289, 105197, 107180, 107192, 107193, 106889, 107183, 107195, 107196, 
106892, 106878, 107181, 107194, 106891
38223, 105193, 105285, 105289, 105197, 105194, 105286, 105290, 105198, 107183, 107195, 107196, 106892, 107186, 107198, 107199, 
106895, 106881, 107184, 107197, 106894
38224, 105194, 105286, 105290, 105198, 34168, 34191, 34192, 34169, 107186, 107198, 107199, 106895, 34545, 34546, 34547, 
34499, 106884, 107187, 107200, 106897
38225, 16327, 16350, 16351, 16328, 105195, 105287, 105291, 105199, 16705, 16706, 16707, 16659, 107190, 107202, 107203, 
106899, 106885, 107188, 107201, 106898
38226, 105195, 105287, 105291, 105199, 105196, 105288, 105292, 105200, 107190, 107202, 107203, 106899, 107193, 107205, 107206, 
106902, 106888, 107191, 107204, 106901
38227, 105196, 105288, 105292, 105200, 105197, 105289, 105293, 105201, 107193, 107205, 107206, 106902, 107196, 107208, 107209, 
106905, 106891, 107194, 107207, 106904
38228, 105197, 105289, 105293, 105201, 105198, 105290, 105294, 105202, 107196, 107208, 107209, 106905, 107199, 107211, 107212, 
106908, 106894, 107197, 107210, 106907
38229, 105198, 105290, 105294, 105202, 34169, 34192, 34193, 34170, 107199, 107211, 107212, 106908, 34547, 34548, 34549, 
34501, 106897, 107200, 107213, 106910
38230, 16328, 16351, 16352, 16329, 105199, 105291, 105295, 105203, 16707, 16708, 16709, 16661, 107203, 107215, 107216, 
106912, 106898, 107201, 107214, 106911
38231, 105199, 105291, 105295, 105203, 105200, 105292, 105296, 105204, 107203, 107215, 107216, 106912, 107206, 107218, 107219, 
106915, 106901, 107204, 107217, 106914
38232, 105200, 105292, 105296, 105204, 105201, 105293, 105297, 105205, 107206, 107218, 107219, 106915, 107209, 107221, 107222, 
106918, 106904, 107207, 107220, 106917
38233, 105201, 105293, 105297, 105205, 105202, 105294, 105298, 105206, 107209, 107221, 107222, 106918, 107212, 107224, 107225, 
106921, 106907, 107210, 107223, 106920
38234, 105202, 105294, 105298, 105206, 34170, 34193, 34194, 34171, 107212, 107224, 107225, 106921, 34549, 34550, 34551, 
34503, 106910, 107213, 107226, 106923
38235, 16329, 16352, 16353, 16330, 105203, 105295, 105299, 105207, 16709, 16710, 16711, 16663, 107216, 107228, 107229, 
106925, 106911, 107214, 107227, 106924
38236, 105203, 105295, 105299, 105207, 105204, 105296, 105300, 105208, 107216, 107228, 107229, 106925, 107219, 107231, 107232, 
106928, 106914, 107217, 107230, 106927
38237, 105204, 105296, 105300, 105208, 105205, 105297, 105301, 105209, 107219, 107231, 107232, 106928, 107222, 107234, 107235, 
106931, 106917, 107220, 107233, 106930
38238, 105205, 105297, 105301, 105209, 105206, 105298, 105302, 105210, 107222, 107234, 107235, 106931, 107225, 107237, 107238, 
106934, 106920, 107223, 107236, 106933
38239, 105206, 105298, 105302, 105210, 34171, 34194, 34195, 34172, 107225, 107237, 107238, 106934, 34551, 34552, 34553, 
34505, 106923, 107226, 107239, 106936
38240, 16330, 16353, 16354, 16331, 105207, 105299, 105303, 105211, 16711, 16712, 16713, 16665, 107229, 107241, 107242, 
106938, 106924, 107227, 107240, 106937
38241, 105207, 105299, 105303, 105211, 105208, 105300, 105304, 105212, 107229, 107241, 107242, 106938, 107232, 107244, 107245, 
106941, 106927, 107230, 107243, 106940
38242, 105208, 105300, 105304, 105212, 105209, 105301, 105305, 105213, 107232, 107244, 107245, 106941, 107235, 107247, 107248, 
106944, 106930, 107233, 107246, 106943
38243, 105209, 105301, 105305, 105213, 105210, 105302, 105306, 105214, 107235, 107247, 107248, 106944, 107238, 107250, 107251, 
106947, 106933, 107236, 107249, 106946
38244, 105210, 105302, 105306, 105214, 34172, 34195, 34196, 34173, 107238, 107250, 107251, 106947, 34553, 34554, 34555, 
34507, 106936, 107239, 107252, 106949
38245, 16331, 16354, 16355, 16332, 105211, 105303, 105307, 105215, 16713, 16714, 16715, 16667, 107242, 107254, 107255, 
106951, 106937, 107240, 107253, 106950
38246, 105211, 105303, 105307, 105215, 105212, 105304, 105308, 105216, 107242, 107254, 107255, 106951, 107245, 107257, 107258, 
106954, 106940, 107243, 107256, 106953
38247, 105212, 105304, 105308, 105216, 105213, 105305, 105309, 105217, 107245, 107257, 107258, 106954, 107248, 107260, 107261, 
106957, 106943, 107246, 107259, 106956
38248, 105213, 105305, 105309, 105217, 105214, 105306, 105310, 105218, 107248, 107260, 107261, 106957, 107251, 107263, 107264, 
106960, 106946, 107249, 107262, 106959
38249, 105214, 105306, 105310, 105218, 34173, 34196, 34197, 34174, 107251, 107263, 107264, 106960, 34555, 34556, 34557, 
34509, 106949, 107252, 107265, 106962
38250, 16332, 16355, 16356, 16333, 105215, 105307, 105311, 105219, 16715, 16716, 16717, 16669, 107255, 107267, 107268, 
106964, 106950, 107253, 107266, 106963
38251, 105215, 105307, 105311, 105219, 105216, 105308, 105312, 105220, 107255, 107267, 107268, 106964, 107258, 107270, 107271, 
106967, 106953, 107256, 107269, 106966
38252, 105216, 105308, 105312, 105220, 105217, 105309, 105313, 105221, 107258, 107270, 107271, 106967, 107261, 107273, 107274, 
106970, 106956, 107259, 107272, 106969
38253, 105217, 105309, 105313, 105221, 105218, 105310, 105314, 105222, 107261, 107273, 107274, 106970, 107264, 107276, 107277, 
106973, 106959, 107262, 107275, 106972
38254, 105218, 105310, 105314, 105222, 34174, 34197, 34198, 34175, 107264, 107276, 107277, 106973, 34557, 34558, 34559, 
34511, 106962, 107265, 107278, 106975
38255, 16333, 16356, 16357, 16334, 105219, 105311, 105315, 105223, 16717, 16718, 16719, 16671, 107268, 107280, 107281, 
106977, 106963, 107266, 107279, 106976
38256, 105219, 105311, 105315, 105223, 105220, 105312, 105316, 105224, 107268, 107280, 107281, 106977, 107271, 107283, 107284, 
106980, 106966, 107269, 107282, 106979
38257, 105220, 105312, 105316, 105224, 105221, 105313, 105317, 105225, 107271, 107283, 107284, 106980, 107274, 107286, 107287, 
106983, 106969, 107272, 107285, 106982
38258, 105221, 105313, 105317, 105225, 105222, 105314, 105318, 105226, 107274, 107286, 107287, 106983, 107277, 107289, 107290, 
106986, 106972, 107275, 107288, 106985
38259, 105222, 105314, 105318, 105226, 34175, 34198, 34199, 34176, 107277, 107289, 107290, 106986, 34559, 34560, 34561, 
34513, 106975, 107278, 107291, 106988
38260, 16334, 16357, 16358, 16335, 105223, 105315, 105319, 105227, 16719, 16720, 16721, 16673, 107281, 107293, 107294, 
106990, 106976, 107279, 107292, 106989
38261, 105223, 105315, 105319, 105227, 105224, 105316, 105320, 105228, 107281, 107293, 107294, 106990, 107284, 107296, 107297, 
106993, 106979, 107282, 107295, 106992
38262, 105224, 105316, 105320, 105228, 105225, 105317, 105321, 105229, 107284, 107296, 107297, 106993, 107287, 107299, 107300, 
106996, 106982, 107285, 107298, 106995
38263, 105225, 105317, 105321, 105229, 105226, 105318, 105322, 105230, 107287, 107299, 107300, 106996, 107290, 107302, 107303, 
106999, 106985, 107288, 107301, 106998
38264, 105226, 105318, 105322, 105230, 34176, 34199, 34200, 34177, 107290, 107302, 107303, 106999, 34561, 34562, 34563, 
34515, 106988, 107291, 107304, 107001
38265, 16335, 16358, 16359, 16336, 105227, 105319, 105323, 105231, 16721, 16722, 16723, 16675, 107294, 107306, 107307, 
107003, 106989, 107292, 107305, 107002
38266, 105227, 105319, 105323, 105231, 105228, 105320, 105324, 105232, 107294, 107306, 107307, 107003, 107297, 107309, 107310, 
107006, 106992, 107295, 107308, 107005
38267, 105228, 105320, 105324, 105232, 105229, 105321, 105325, 105233, 107297, 107309, 107310, 107006, 107300, 107312, 107313, 
107009, 106995, 107298, 107311, 107008
38268, 105229, 105321, 105325, 105233, 105230, 105322, 105326, 105234, 107300, 107312, 107313, 107009, 107303, 107315, 107316, 
107012, 106998, 107301, 107314, 107011
38269, 105230, 105322, 105326, 105234, 34177, 34200, 34201, 34178, 107303, 107315, 107316, 107012, 34563, 34564, 34565, 
34517, 107001, 107304, 107317, 107014
38270, 16336, 16359, 16360, 16337, 105231, 105323, 105327, 105235, 16723, 16724, 16725, 16677, 107307, 107319, 107320, 
107016, 107002, 107305, 107318, 107015
38271, 105231, 105323, 105327, 105235, 105232, 105324, 105328, 105236, 107307, 107319, 107320, 107016, 107310, 107322, 107323, 
107019, 107005, 107308, 107321, 107018
38272, 105232, 105324, 105328, 105236, 105233, 105325, 105329, 105237, 107310, 107322, 107323, 107019, 107313, 107325, 107326, 
107022, 107008, 107311, 107324, 107021
38273, 105233, 105325, 105329, 105237, 105234, 105326, 105330, 105238, 107313, 107325, 107326, 107022, 107316, 107328, 107329, 
107025, 107011, 107314, 107327, 107024
38274, 105234, 105326, 105330, 105238, 34178, 34201, 34202, 34179, 107316, 107328, 107329, 107025, 34565, 34566, 34567, 
34519, 107014, 107317, 107330, 107027
38275, 16337, 16360, 16361, 16338, 105235, 105327, 105331, 105239, 16725, 16726, 16727, 16679, 107320, 107332, 107333, 
107029, 107015, 107318, 107331, 107028
38276, 105235, 105327, 105331, 105239, 105236, 105328, 105332, 105240, 107320, 107332, 107333, 107029, 107323, 107335, 107336, 
107032, 107018, 107321, 107334, 107031
38277, 105236, 105328, 105332, 105240, 105237, 105329, 105333, 105241, 107323, 107335, 107336, 107032, 107326, 107338, 107339, 
107035, 107021, 107324, 107337, 107034
38278, 105237, 105329, 105333, 105241, 105238, 105330, 105334, 105242, 107326, 107338, 107339, 107035, 107329, 107341, 107342, 
107038, 107024, 107327, 107340, 107037
38279, 105238, 105330, 105334, 105242, 34179, 34202, 34203, 34180, 107329, 107341, 107342, 107038, 34567, 34568, 34569, 
34521, 107027, 107330, 107343, 107040
38280, 16338, 16361, 16362, 16339, 105239, 105331, 105335, 105243, 16727, 16728, 16729, 16681, 107333, 107345, 107346, 
107042, 107028, 107331, 107344, 107041
38281, 105239, 105331, 105335, 105243, 105240, 105332, 105336, 105244, 107333, 107345, 107346, 107042, 107336, 107348, 107349, 
107045, 107031, 107334, 107347, 107044
38282, 105240, 105332, 105336, 105244, 105241, 105333, 105337, 105245, 107336, 107348, 107349, 107045, 107339, 107351, 107352, 
107048, 107034, 107337, 107350, 107047
38283, 105241, 105333, 105337, 105245, 105242, 105334, 105338, 105246, 107339, 107351, 107352, 107048, 107342, 107354, 107355, 
107051, 107037, 107340, 107353, 107050
38284, 105242, 105334, 105338, 105246, 34180, 34203, 34204, 34181, 107342, 107354, 107355, 107051, 34569, 34570, 34571, 
34523, 107040, 107343, 107356, 107053
38285, 16339, 16362, 16363, 16340, 105243, 105335, 105339, 105247, 16729, 16730, 16731, 16683, 107346, 107358, 107359, 
107055, 107041, 107344, 107357, 107054
38286, 105243, 105335, 105339, 105247, 105244, 105336, 105340, 105248, 107346, 107358, 107359, 107055, 107349, 107361, 107362, 
107058, 107044, 107347, 107360, 107057
38287, 105244, 105336, 105340, 105248, 105245, 105337, 105341, 105249, 107349, 107361, 107362, 107058, 107352, 107364, 107365, 
107061, 107047, 107350, 107363, 107060
38288, 105245, 105337, 105341, 105249, 105246, 105338, 105342, 105250, 107352, 107364, 107365, 107061, 107355, 107367, 107368, 
107064, 107050, 107353, 107366, 107063
38289, 105246, 105338, 105342, 105250, 34181, 34204, 34205, 34182, 107355, 107367, 107368, 107064, 34571, 34572, 34573, 
34525, 107053, 107356, 107369, 107066
38290, 16340, 16363, 16364, 16341, 105247, 105339, 105343, 105251, 16731, 16732, 16733, 16685, 107359, 107371, 107372, 
107068, 107054, 107357, 107370, 107067
38291, 105247, 105339, 105343, 105251, 105248, 105340, 105344, 105252, 107359, 107371, 107372, 107068, 107362, 107374, 107375, 
107071, 107057, 107360, 107373, 107070
38292, 105248, 105340, 105344, 105252, 105249, 105341, 105345, 105253, 107362, 107374, 107375, 107071, 107365, 107377, 107378, 
107074, 107060, 107363, 107376, 107073
38293, 105249, 105341, 105345, 105253, 105250, 105342, 105346, 105254, 107365, 107377, 107378, 107074, 107368, 107380, 107381, 
107077, 107063, 107366, 107379, 107076
38294, 105250, 105342, 105346, 105254, 34182, 34205, 34206, 34183, 107368, 107380, 107381, 107077, 34573, 34574, 34575, 
34527, 107066, 107369, 107382, 107079
38295, 16341, 16364, 16365, 16342, 105251, 105343, 105347, 105255, 16733, 16734, 16735, 16687, 107372, 107384, 107385, 
107081, 107067, 107370, 107383, 107080
38296, 105251, 105343, 105347, 105255, 105252, 105344, 105348, 105256, 107372, 107384, 107385, 107081, 107375, 107387, 107388, 
107084, 107070, 107373, 107386, 107083
38297, 105252, 105344, 105348, 105256, 105253, 105345, 105349, 105257, 107375, 107387, 107388, 107084, 107378, 107390, 107391, 
107087, 107073, 107376, 107389, 107086
38298, 105253, 105345, 105349, 105257, 105254, 105346, 105350, 105258, 107378, 107390, 107391, 107087, 107381, 107393, 107394, 
107090, 107076, 107379, 107392, 107089
38299, 105254, 105346, 105350, 105258, 34183, 34206, 34207, 34184, 107381, 107393, 107394, 107090, 34575, 34576, 34577, 
34529, 107079, 107382, 107395, 107092
38300, 16342, 16365, 16366, 16343, 105255, 105347, 105351, 105259, 16735, 16736, 16737, 16689, 107385, 107397, 107398, 
107094, 107080, 107383, 107396, 107093
38301, 105255, 105347, 105351, 105259, 105256, 105348, 105352, 105260, 107385, 107397, 107398, 107094, 107388, 107400, 107401, 
107097, 107083, 107386, 107399, 107096
38302, 105256, 105348, 105352, 105260, 105257, 105349, 105353, 105261, 107388, 107400, 107401, 107097, 107391, 107403, 107404, 
107100, 107086, 107389, 107402, 107099
38303, 105257, 105349, 105353, 105261, 105258, 105350, 105354, 105262, 107391, 107403, 107404, 107100, 107394, 107406, 107407, 
107103, 107089, 107392, 107405, 107102
38304, 105258, 105350, 105354, 105262, 34184, 34207, 34208, 34185, 107394, 107406, 107407, 107103, 34577, 34578, 34579, 
34531, 107092, 107395, 107408, 107105
38305, 16343, 16366, 16367, 16344, 105259, 105351, 105355, 105263, 16737, 16738, 16739, 16691, 107398, 107410, 107411, 
107107, 107093, 107396, 107409, 107106
38306, 105259, 105351, 105355, 105263, 105260, 105352, 105356, 105264, 107398, 107410, 107411, 107107, 107401, 107413, 107414, 
107110, 107096, 107399, 107412, 107109
38307, 105260, 105352, 105356, 105264, 105261, 105353, 105357, 105265, 107401, 107413, 107414, 107110, 107404, 107416, 107417, 
107113, 107099, 107402, 107415, 107112
38308, 105261, 105353, 105357, 105265, 105262, 105354, 105358, 105266, 107404, 107416, 107417, 107113, 107407, 107419, 107420, 
107116, 107102, 107405, 107418, 107115
38309, 105262, 105354, 105358, 105266, 34185, 34208, 34209, 34186, 107407, 107419, 107420, 107116, 34579, 34580, 34581, 
34533, 107105, 107408, 107421, 107118
38310, 16344, 16367, 1490, 1489, 105263, 105355, 33964, 33960, 16739, 16740, 1501, 16693, 107411, 107422, 34028, 
107119, 107106, 107409, 34029, 34020
38311, 105263, 105355, 33964, 33960, 105264, 105356, 33965, 33961, 107411, 107422, 34028, 107119, 107414, 107423, 34030, 
107120, 107109, 107412, 34031, 34022
38312, 105264, 105356, 33965, 33961, 105265, 105357, 33966, 33962, 107414, 107423, 34030, 107120, 107417, 107424, 34032, 
107121, 107112, 107415, 34033, 34024
38313, 105265, 105357, 33966, 33962, 105266, 105358, 33967, 33963, 107417, 107424, 34032, 107121, 107420, 107425, 34034, 
107122, 107115, 107418, 34035, 34026
38314, 105266, 105358, 33967, 33963, 34186, 34209, 3530, 3529, 107420, 107425, 34034, 107122, 34581, 34582, 3541, 
34535, 107118, 107421, 34036, 34027
38315, 1246, 1247, 16368, 16345, 33064, 33068, 105359, 105267, 1258, 16741, 16742, 16694, 33137, 107427, 107428, 
107124, 33129, 33138, 107426, 107123
38316, 33064, 33068, 105359, 105267, 33065, 33069, 105360, 105268, 33137, 107427, 107428, 107124, 33139, 107430, 107431, 
107127, 33131, 33140, 107429, 107126
38317, 33065, 33069, 105360, 105268, 33066, 33070, 105361, 105269, 33139, 107430, 107431, 107127, 33141, 107433, 107434, 
107130, 33133, 33142, 107432, 107129
38318, 33066, 33070, 105361, 105269, 33067, 33071, 105362, 105270, 33141, 107433, 107434, 107130, 33143, 107436, 107437, 
107133, 33135, 33144, 107435, 107132
38319, 33067, 33071, 105362, 105270, 3395, 3396, 34210, 34187, 33143, 107436, 107437, 107133, 3407, 34583, 34584, 
34536, 33136, 33145, 107438, 107135
38320, 16345, 16368, 16369, 16346, 105267, 105359, 105363, 105271, 16742, 16743, 16744, 16696, 107428, 107440, 107441, 
107137, 107123, 107426, 107439, 107136
38321, 105267, 105359, 105363, 105271, 105268, 105360, 105364, 105272, 107428, 107440, 107441, 107137, 107431, 107443, 107444, 
107140, 107126, 107429, 107442, 107139
38322, 105268, 105360, 105364, 105272, 105269, 105361, 105365, 105273, 107431, 107443, 107444, 107140, 107434, 107446, 107447, 
107143, 107129, 107432, 107445, 107142
38323, 105269, 105361, 105365, 105273, 105270, 105362, 105366, 105274, 107434, 107446, 107447, 107143, 107437, 107449, 107450, 
107146, 107132, 107435, 107448, 107145
38324, 105270, 105362, 105366, 105274, 34187, 34210, 34211, 34188, 107437, 107449, 107450, 107146, 34584, 34585, 34586, 
34538, 107135, 107438, 107451, 107148
38325, 16346, 16369, 16370, 16347, 105271, 105363, 105367, 105275, 16744, 16745, 16746, 16698, 107441, 107453, 107454, 
107150, 107136, 107439, 107452, 107149
38326, 105271, 105363, 105367, 105275, 105272, 105364, 105368, 105276, 107441, 107453, 107454, 107150, 107444, 107456, 107457, 
107153, 107139, 107442, 107455, 107152
38327, 105272, 105364, 105368, 105276, 105273, 105365, 105369, 105277, 107444, 107456, 107457, 107153, 107447, 107459, 107460, 
107156, 107142, 107445, 107458, 107155
38328, 105273, 105365, 105369, 105277, 105274, 105366, 105370, 105278, 107447, 107459, 107460, 107156, 107450, 107462, 107463, 
107159, 107145, 107448, 107461, 107158
38329, 105274, 105366, 105370, 105278, 34188, 34211, 34212, 34189, 107450, 107462, 107463, 107159, 34586, 34587, 34588, 
34540, 107148, 107451, 107464, 107161
38330, 16347, 16370, 16371, 16348, 105275, 105367, 105371, 105279, 16746, 16747, 16748, 16700, 107454, 107466, 107467, 
107163, 107149, 107452, 107465, 107162
38331, 105275, 105367, 105371, 105279, 105276, 105368, 105372, 105280, 107454, 107466, 107467, 107163, 107457, 107469, 107470, 
107166, 107152, 107455, 107468, 107165
38332, 105276, 105368, 105372, 105280, 105277, 105369, 105373, 105281, 107457, 107469, 107470, 107166, 107460, 107472, 107473, 
107169, 107155, 107458, 107471, 107168
38333, 105277, 105369, 105373, 105281, 105278, 105370, 105374, 105282, 107460, 107472, 107473, 107169, 107463, 107475, 107476, 
107172, 107158, 107461, 107474, 107171
38334, 105278, 105370, 105374, 105282, 34189, 34212, 34213, 34190, 107463, 107475, 107476, 107172, 34588, 34589, 34590, 
34542, 107161, 107464, 107477, 107174
38335, 16348, 16371, 16372, 16349, 105279, 105371, 105375, 105283, 16748, 16749, 16750, 16702, 107467, 107479, 107480, 
107176, 107162, 107465, 107478, 107175
38336, 105279, 105371, 105375, 105283, 105280, 105372, 105376, 105284, 107467, 107479, 107480, 107176, 107470, 107482, 107483, 
107179, 107165, 107468, 107481, 107178
38337, 105280, 105372, 105376, 105284, 105281, 105373, 105377, 105285, 107470, 107482, 107483, 107179, 107473, 107485, 107486, 
107182, 107168, 107471, 107484, 107181
38338, 105281, 105373, 105377, 105285, 105282, 105374, 105378, 105286, 107473, 107485, 107486, 107182, 107476, 107488, 107489, 
107185, 107171, 107474, 107487, 107184
38339, 105282, 105374, 105378, 105286, 34190, 34213, 34214, 34191, 107476, 107488, 107489, 107185, 34590, 34591, 34592, 
34544, 107174, 107477, 107490, 107187
38340, 16349, 16372, 16373, 16350, 105283, 105375, 105379, 105287, 16750, 16751, 16752, 16704, 107480, 107492, 107493, 
107189, 107175, 107478, 107491, 107188
38341, 105283, 105375, 105379, 105287, 105284, 105376, 105380, 105288, 107480, 107492, 107493, 107189, 107483, 107495, 107496, 
107192, 107178, 107481, 107494, 107191
38342, 105284, 105376, 105380, 105288, 105285, 105377, 105381, 105289, 107483, 107495, 107496, 107192, 107486, 107498, 107499, 
107195, 107181, 107484, 107497, 107194
38343, 105285, 105377, 105381, 105289, 105286, 105378, 105382, 105290, 107486, 107498, 107499, 107195, 107489, 107501, 107502, 
107198, 107184, 107487, 107500, 107197
38344, 105286, 105378, 105382, 105290, 34191, 34214, 34215, 34192, 107489, 107501, 107502, 107198, 34592, 34593, 34594, 
34546, 107187, 107490, 107503, 107200
38345, 16350, 16373, 16374, 16351, 105287, 105379, 105383, 105291, 16752, 16753, 16754, 16706, 107493, 107505, 107506, 
107202, 107188, 107491, 107504, 107201
38346, 105287, 105379, 105383, 105291, 105288, 105380, 105384, 105292, 107493, 107505, 107506, 107202, 107496, 107508, 107509, 
107205, 107191, 107494, 107507, 107204
38347, 105288, 105380, 105384, 105292, 105289, 105381, 105385, 105293, 107496, 107508, 107509, 107205, 107499, 107511, 107512, 
107208, 107194, 107497, 107510, 107207
38348, 105289, 105381, 105385, 105293, 105290, 105382, 105386, 105294, 107499, 107511, 107512, 107208, 107502, 107514, 107515, 
107211, 107197, 107500, 107513, 107210
38349, 105290, 105382, 105386, 105294, 34192, 34215, 34216, 34193, 107502, 107514, 107515, 107211, 34594, 34595, 34596, 
34548, 107200, 107503, 107516, 107213
38350, 16351, 16374, 16375, 16352, 105291, 105383, 105387, 105295, 16754, 16755, 16756, 16708, 107506, 107518, 107519, 
107215, 107201, 107504, 107517, 107214
38351, 105291, 105383, 105387, 105295, 105292, 105384, 105388, 105296, 107506, 107518, 107519, 107215, 107509, 107521, 107522, 
107218, 107204, 107507, 107520, 107217
38352, 105292, 105384, 105388, 105296, 105293, 105385, 105389, 105297, 107509, 107521, 107522, 107218, 107512, 107524, 107525, 
107221, 107207, 107510, 107523, 107220
38353, 105293, 105385, 105389, 105297, 105294, 105386, 105390, 105298, 107512, 107524, 107525, 107221, 107515, 107527, 107528, 
107224, 107210, 107513, 107526, 107223
38354, 105294, 105386, 105390, 105298, 34193, 34216, 34217, 34194, 107515, 107527, 107528, 107224, 34596, 34597, 34598, 
34550, 107213, 107516, 107529, 107226
38355, 16352, 16375, 16376, 16353, 105295, 105387, 105391, 105299, 16756, 16757, 16758, 16710, 107519, 107531, 107532, 
107228, 107214, 107517, 107530, 107227
38356, 105295, 105387, 105391, 105299, 105296, 105388, 105392, 105300, 107519, 107531, 107532, 107228, 107522, 107534, 107535, 
107231, 107217, 107520, 107533, 107230
38357, 105296, 105388, 105392, 105300, 105297, 105389, 105393, 105301, 107522, 107534, 107535, 107231, 107525, 107537, 107538, 
107234, 107220, 107523, 107536, 107233
38358, 105297, 105389, 105393, 105301, 105298, 105390, 105394, 105302, 107525, 107537, 107538, 107234, 107528, 107540, 107541, 
107237, 107223, 107526, 107539, 107236
38359, 105298, 105390, 105394, 105302, 34194, 34217, 34218, 34195, 107528, 107540, 107541, 107237, 34598, 34599, 34600, 
34552, 107226, 107529, 107542, 107239
38360, 16353, 16376, 16377, 16354, 105299, 105391, 105395, 105303, 16758, 16759, 16760, 16712, 107532, 107544, 107545, 
107241, 107227, 107530, 107543, 107240
38361, 105299, 105391, 105395, 105303, 105300, 105392, 105396, 105304, 107532, 107544, 107545, 107241, 107535, 107547, 107548, 
107244, 107230, 107533, 107546, 107243
38362, 105300, 105392, 105396, 105304, 105301, 105393, 105397, 105305, 107535, 107547, 107548, 107244, 107538, 107550, 107551, 
107247, 107233, 107536, 107549, 107246
38363, 105301, 105393, 105397, 105305, 105302, 105394, 105398, 105306, 107538, 107550, 107551, 107247, 107541, 107553, 107554, 
107250, 107236, 107539, 107552, 107249
38364, 105302, 105394, 105398, 105306, 34195, 34218, 34219, 34196, 107541, 107553, 107554, 107250, 34600, 34601, 34602, 
34554, 107239, 107542, 107555, 107252
38365, 16354, 16377, 16378, 16355, 105303, 105395, 105399, 105307, 16760, 16761, 16762, 16714, 107545, 107557, 107558, 
107254, 107240, 107543, 107556, 107253
38366, 105303, 105395, 105399, 105307, 105304, 105396, 105400, 105308, 107545, 107557, 107558, 107254, 107548, 107560, 107561, 
107257, 107243, 107546, 107559, 107256
38367, 105304, 105396, 105400, 105308, 105305, 105397, 105401, 105309, 107548, 107560, 107561, 107257, 107551, 107563, 107564, 
107260, 107246, 107549, 107562, 107259
38368, 105305, 105397, 105401, 105309, 105306, 105398, 105402, 105310, 107551, 107563, 107564, 107260, 107554, 107566, 107567, 
107263, 107249, 107552, 107565, 107262
38369, 105306, 105398, 105402, 105310, 34196, 34219, 34220, 34197, 107554, 107566, 107567, 107263, 34602, 34603, 34604, 
34556, 107252, 107555, 107568, 107265
38370, 16355, 16378, 16379, 16356, 105307, 105399, 105403, 105311, 16762, 16763, 16764, 16716, 107558, 107570, 107571, 
107267, 107253, 107556, 107569, 107266
38371, 105307, 105399, 105403, 105311, 105308, 105400, 105404, 105312, 107558, 107570, 107571, 107267, 107561, 107573, 107574, 
107270, 107256, 107559, 107572, 107269
38372, 105308, 105400, 105404, 105312, 105309, 105401, 105405, 105313, 107561, 107573, 107574, 107270, 107564, 107576, 107577, 
107273, 107259, 107562, 107575, 107272
38373, 105309, 105401, 105405, 105313, 105310, 105402, 105406, 105314, 107564, 107576, 107577, 107273, 107567, 107579, 107580, 
107276, 107262, 107565, 107578, 107275
38374, 105310, 105402, 105406, 105314, 34197, 34220, 34221, 34198, 107567, 107579, 107580, 107276, 34604, 34605, 34606, 
34558, 107265, 107568, 107581, 107278
38375, 16356, 16379, 16380, 16357, 105311, 105403, 105407, 105315, 16764, 16765, 16766, 16718, 107571, 107583, 107584, 
107280, 107266, 107569, 107582, 107279
38376, 105311, 105403, 105407, 105315, 105312, 105404, 105408, 105316, 107571, 107583, 107584, 107280, 107574, 107586, 107587, 
107283, 107269, 107572, 107585, 107282
38377, 105312, 105404, 105408, 105316, 105313, 105405, 105409, 105317, 107574, 107586, 107587, 107283, 107577, 107589, 107590, 
107286, 107272, 107575, 107588, 107285
38378, 105313, 105405, 105409, 105317, 105314, 105406, 105410, 105318, 107577, 107589, 107590, 107286, 107580, 107592, 107593, 
107289, 107275, 107578, 107591, 107288
38379, 105314, 105406, 105410, 105318, 34198, 34221, 34222, 34199, 107580, 107592, 107593, 107289, 34606, 34607, 34608, 
34560, 107278, 107581, 107594, 107291
38380, 16357, 16380, 16381, 16358, 105315, 105407, 105411, 105319, 16766, 16767, 16768, 16720, 107584, 107596, 107597, 
107293, 107279, 107582, 107595, 107292
38381, 105315, 105407, 105411, 105319, 105316, 105408, 105412, 105320, 107584, 107596, 107597, 107293, 107587, 107599, 107600, 
107296, 107282, 107585, 107598, 107295
38382, 105316, 105408, 105412, 105320, 105317, 105409, 105413, 105321, 107587, 107599, 107600, 107296, 107590, 107602, 107603, 
107299, 107285, 107588, 107601, 107298
38383, 105317, 105409, 105413, 105321, 105318, 105410, 105414, 105322, 107590, 107602, 107603, 107299, 107593, 107605, 107606, 
107302, 107288, 107591, 107604, 107301
38384, 105318, 105410, 105414, 105322, 34199, 34222, 34223, 34200, 107593, 107605, 107606, 107302, 34608, 34609, 34610, 
34562, 107291, 107594, 107607, 107304
38385, 16358, 16381, 16382, 16359, 105319, 105411, 105415, 105323, 16768, 16769, 16770, 16722, 107597, 107609, 107610, 
107306, 107292, 107595, 107608, 107305
38386, 105319, 105411, 105415, 105323, 105320, 105412, 105416, 105324, 107597, 107609, 107610, 107306, 107600, 107612, 107613, 
107309, 107295, 107598, 107611, 107308
38387, 105320, 105412, 105416, 105324, 105321, 105413, 105417, 105325, 107600, 107612, 107613, 107309, 107603, 107615, 107616, 
107312, 107298, 107601, 107614, 107311
38388, 105321, 105413, 105417, 105325, 105322, 105414, 105418, 105326, 107603, 107615, 107616, 107312, 107606, 107618, 107619, 
107315, 107301, 107604, 107617, 107314
38389, 105322, 105414, 105418, 105326, 34200, 34223, 34224, 34201, 107606, 107618, 107619, 107315, 34610, 34611, 34612, 
34564, 107304, 107607, 107620, 107317
38390, 16359, 16382, 16383, 16360, 105323, 105415, 105419, 105327, 16770, 16771, 16772, 16724, 107610, 107622, 107623, 
107319, 107305, 107608, 107621, 107318
38391, 105323, 105415, 105419, 105327, 105324, 105416, 105420, 105328, 107610, 107622, 107623, 107319, 107613, 107625, 107626, 
107322, 107308, 107611, 107624, 107321
38392, 105324, 105416, 105420, 105328, 105325, 105417, 105421, 105329, 107613, 107625, 107626, 107322, 107616, 107628, 107629, 
107325, 107311, 107614, 107627, 107324
38393, 105325, 105417, 105421, 105329, 105326, 105418, 105422, 105330, 107616, 107628, 107629, 107325, 107619, 107631, 107632, 
107328, 107314, 107617, 107630, 107327
38394, 105326, 105418, 105422, 105330, 34201, 34224, 34225, 34202, 107619, 107631, 107632, 107328, 34612, 34613, 34614, 
34566, 107317, 107620, 107633, 107330
38395, 16360, 16383, 16384, 16361, 105327, 105419, 105423, 105331, 16772, 16773, 16774, 16726, 107623, 107635, 107636, 
107332, 107318, 107621, 107634, 107331
38396, 105327, 105419, 105423, 105331, 105328, 105420, 105424, 105332, 107623, 107635, 107636, 107332, 107626, 107638, 107639, 
107335, 107321, 107624, 107637, 107334
38397, 105328, 105420, 105424, 105332, 105329, 105421, 105425, 105333, 107626, 107638, 107639, 107335, 107629, 107641, 107642, 
107338, 107324, 107627, 107640, 107337
38398, 105329, 105421, 105425, 105333, 105330, 105422, 105426, 105334, 107629, 107641, 107642, 107338, 107632, 107644, 107645, 
107341, 107327, 107630, 107643, 107340
38399, 105330, 105422, 105426, 105334, 34202, 34225, 34226, 34203, 107632, 107644, 107645, 107341, 34614, 34615, 34616, 
34568, 107330, 107633, 107646, 107343
38400, 16361, 16384, 16385, 16362, 105331, 105423, 105427, 105335, 16774, 16775, 16776, 16728, 107636, 107648, 107649, 
107345, 107331, 107634, 107647, 107344
