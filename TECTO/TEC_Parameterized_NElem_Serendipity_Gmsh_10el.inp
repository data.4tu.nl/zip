118280, 2.25, -0.12, 0.29166666666667
118281, 2.25, -0.16, 0.29166666666667
118282, 2.25, -0.04, 0.33333333333333
118283, 2.25, -0.08, 0.33333333333333
118284, 2.25, -0.12, 0.33333333333333
118285, 2.25, -0.16, 0.33333333333333
118286, 2.25, -0.04, 0.375
118287, 2.25, -0.08, 0.375
118288, 2.25, -0.12, 0.375
118289, 2.25, -0.16, 0.375
118290, 2.25, -0.04, 0.41666666666667
118291, 2.25, -0.08, 0.41666666666667
118292, 2.25, -0.12, 0.41666666666667
118293, 2.25, -0.16, 0.41666666666667
118294, 2.25, -0.04, 0.45833333333333
118295, 2.25, -0.08, 0.45833333333333
118296, 2.25, -0.12, 0.45833333333333
118297, 2.25, -0.16, 0.45833333333333
******* E L E M E N T S *************
*ELEMENT, type=T3D3, ELSET=Line1
97, 2, 108, 97
98, 97, 109, 98
99, 98, 110, 99
100, 99, 111, 100
101, 100, 112, 101
102, 101, 113, 102
103, 102, 114, 103
104, 103, 115, 104
105, 104, 116, 105
106, 105, 117, 106
107, 106, 118, 107
108, 107, 119, 1
*ELEMENT, type=T3D3, ELSET=Line2
109, 1, 122, 120
110, 120, 123, 121
111, 121, 124, 3
*ELEMENT, type=T3D3, ELSET=Line3
112, 4, 136, 125
113, 125, 137, 126
114, 126, 138, 127
115, 127, 139, 128
116, 128, 140, 129
117, 129, 141, 130
118, 130, 142, 131
119, 131, 143, 132
120, 132, 144, 133
121, 133, 145, 134
122, 134, 146, 135
123, 135, 147, 3
*ELEMENT, type=T3D3, ELSET=Line4
124, 2, 150, 148
125, 148, 151, 149
126, 149, 152, 4
*ELEMENT, type=T3D3, ELSET=Line5
127, 6, 164, 153
128, 153, 165, 154
129, 154, 166, 155
130, 155, 167, 156
131, 156, 168, 157
132, 157, 169, 158
133, 158, 170, 159
134, 159, 171, 160
135, 160, 172, 161
136, 161, 173, 162
137, 162, 174, 163
138, 163, 175, 5
*ELEMENT, type=T3D3, ELSET=Line6
139, 5, 178, 176
140, 176, 179, 177
141, 177, 180, 7
*ELEMENT, type=T3D3, ELSET=Line7
142, 8, 192, 181
143, 181, 193, 182
144, 182, 194, 183
145, 183, 195, 184
146, 184, 196, 185
147, 185, 197, 186
148, 186, 198, 187
149, 187, 199, 188
150, 188, 200, 189
151, 189, 201, 190
152, 190, 202, 191
153, 191, 203, 7
*ELEMENT, type=T3D3, ELSET=Line8
154, 6, 206, 204
155, 204, 207, 205
156, 205, 208, 8
*ELEMENT, type=T3D3, ELSET=Line9
157, 2, 232, 209
158, 209, 233, 210
159, 210, 234, 211
160, 211, 235, 212
161, 212, 236, 213
162, 213, 237, 214
163, 214, 238, 215
164, 215, 239, 216
165, 216, 240, 217
166, 217, 241, 218
167, 218, 242, 219
168, 219, 243, 220
169, 220, 244, 221
170, 221, 245, 222
171, 222, 246, 223
172, 223, 247, 224
173, 224, 248, 225
174, 225, 249, 226
175, 226, 250, 227
176, 227, 251, 228
177, 228, 252, 229
178, 229, 253, 230
179, 230, 254, 231
180, 231, 255, 6
*ELEMENT, type=T3D3, ELSET=Line10
181, 1, 279, 256
182, 256, 280, 257
183, 257, 281, 258
184, 258, 282, 259
185, 259, 283, 260
186, 260, 284, 261
187, 261, 285, 262
188, 262, 286, 263
189, 263, 287, 264
190, 264, 288, 265
191, 265, 289, 266
192, 266, 290, 267
193, 267, 291, 268
194, 268, 292, 269
195, 269, 293, 270
196, 270, 294, 271
197, 271, 295, 272
198, 272, 296, 273
199, 273, 297, 274
200, 274, 298, 275
201, 275, 299, 276
202, 276, 300, 277
203, 277, 301, 278
204, 278, 302, 5
*ELEMENT, type=T3D3, ELSET=Line11
205, 4, 326, 303
206, 303, 327, 304
207, 304, 328, 305
208, 305, 329, 306
209, 306, 330, 307
210, 307, 331, 308
211, 308, 332, 309
212, 309, 333, 310
213, 310, 334, 311
214, 311, 335, 312
215, 312, 336, 313
216, 313, 337, 314
217, 314, 338, 315
218, 315, 339, 316
219, 316, 340, 317
220, 317, 341, 318
221, 318, 342, 319
222, 319, 343, 320
223, 320, 344, 321
224, 321, 345, 322
225, 322, 346, 323
226, 323, 347, 324
227, 324, 348, 325
228, 325, 349, 8
*ELEMENT, type=T3D3, ELSET=Line12
229, 3, 373, 350
230, 350, 374, 351
231, 351, 375, 352
232, 352, 376, 353
233, 353, 377, 354
234, 354, 378, 355
235, 355, 379, 356
236, 356, 380, 357
237, 357, 381, 358
238, 358, 382, 359
239, 359, 383, 360
240, 360, 384, 361
241, 361, 385, 362
242, 362, 386, 363
243, 363, 387, 364
244, 364, 388, 365
245, 365, 389, 366
246, 366, 390, 367
247, 367, 391, 368
248, 368, 392, 369
249, 369, 393, 370
250, 370, 394, 371
251, 371, 395, 372
252, 372, 396, 7
*ELEMENT, type=T3D3, ELSET=Line13
253, 8, 397, 9
*ELEMENT, type=T3D3, ELSET=Line14
254, 4, 398, 10
*ELEMENT, type=T3D3, ELSET=Line15
255, 10, 422, 399
256, 399, 423, 400
257, 400, 424, 401
258, 401, 425, 402
259, 402, 426, 403
260, 403, 427, 404
261, 404, 428, 405
262, 405, 429, 406
263, 406, 430, 407
264, 407, 431, 408
265, 408, 432, 409
266, 409, 433, 410
267, 410, 434, 411
268, 411, 435, 412
269, 412, 436, 413
270, 413, 437, 414
271, 414, 438, 415
272, 415, 439, 416
273, 416, 440, 417
274, 417, 441, 418
275, 418, 442, 419
276, 419, 443, 420
277, 420, 444, 421
278, 421, 445, 9
*ELEMENT, type=T3D3, ELSET=Line16
279, 7, 446, 11
*ELEMENT, type=T3D3, ELSET=Line17
280, 9, 458, 447
281, 447, 459, 448
282, 448, 460, 449
283, 449, 461, 450
284, 450, 462, 451
285, 451, 463, 452
286, 452, 464, 453
287, 453, 465, 454
288, 454, 466, 455
289, 455, 467, 456
290, 456, 468, 457
291, 457, 469, 11
*ELEMENT, type=T3D3, ELSET=Line18
292, 3, 470, 12
*ELEMENT, type=T3D3, ELSET=Line19
293, 12, 494, 471
294, 471, 495, 472
295, 472, 496, 473
296, 473, 497, 474
297, 474, 498, 475
298, 475, 499, 476
299, 476, 500, 477
300, 477, 501, 478
301, 478, 502, 479
302, 479, 503, 480
303, 480, 504, 481
304, 481, 505, 482
305, 482, 506, 483
306, 483, 507, 484
307, 484, 508, 485
308, 485, 509, 486
309, 486, 510, 487
310, 487, 511, 488
311, 488, 512, 489
312, 489, 513, 490
313, 490, 514, 491
314, 491, 515, 492
315, 492, 516, 493
316, 493, 517, 11
*ELEMENT, type=T3D3, ELSET=Line20
317, 10, 529, 518
318, 518, 530, 519
319, 519, 531, 520
320, 520, 532, 521
321, 521, 533, 522
322, 522, 534, 523
323, 523, 535, 524
324, 524, 536, 525
325, 525, 537, 526
326, 526, 538, 527
327, 527, 539, 528
328, 528, 540, 12
*ELEMENT, type=T3D3, ELSET=Line21
329, 9, 564, 541
330, 541, 565, 542
331, 542, 566, 543
332, 543, 567, 544
333, 544, 568, 545
334, 545, 569, 546
335, 546, 570, 547
336, 547, 571, 548
337, 548, 572, 549
338, 549, 573, 550
339, 550, 574, 551
340, 551, 575, 552
341, 552, 576, 553
342, 553, 577, 554
343, 554, 578, 555
344, 555, 579, 556
345, 556, 580, 557
346, 557, 581, 558
347, 558, 582, 559
348, 559, 583, 560
349, 560, 584, 561
350, 561, 585, 562
351, 562, 586, 563
352, 563, 587, 13
*ELEMENT, type=T3D3, ELSET=Line22
353, 10, 611, 588
354, 588, 612, 589
355, 589, 613, 590
356, 590, 614, 591
357, 591, 615, 592
358, 592, 616, 593
359, 593, 617, 594
360, 594, 618, 595
361, 595, 619, 596
362, 596, 620, 597
363, 597, 621, 598
364, 598, 622, 599
365, 599, 623, 600
366, 600, 624, 601
367, 601, 625, 602
368, 602, 626, 603
369, 603, 627, 604
370, 604, 628, 605
371, 605, 629, 606
372, 606, 630, 607
373, 607, 631, 608
374, 608, 632, 609
375, 609, 633, 610
376, 610, 634, 14
*ELEMENT, type=T3D3, ELSET=Line23
377, 14, 658, 635
378, 635, 659, 636
379, 636, 660, 637
380, 637, 661, 638
381, 638, 662, 639
382, 639, 663, 640
383, 640, 664, 641
384, 641, 665, 642
385, 642, 666, 643
386, 643, 667, 644
387, 644, 668, 645
388, 645, 669, 646
389, 646, 670, 647
390, 647, 671, 648
391, 648, 672, 649
392, 649, 673, 650
393, 650, 674, 651
394, 651, 675, 652
395, 652, 676, 653
396, 653, 677, 654
397, 654, 678, 655
398, 655, 679, 656
399, 656, 680, 657
400, 657, 681, 13
*ELEMENT, type=T3D3, ELSET=Line24
401, 11, 705, 682
402, 682, 706, 683
403, 683, 707, 684
404, 684, 708, 685
405, 685, 709, 686
406, 686, 710, 687
407, 687, 711, 688
408, 688, 712, 689
409, 689, 713, 690
410, 690, 714, 691
411, 691, 715, 692
412, 692, 716, 693
413, 693, 717, 694
414, 694, 718, 695
415, 695, 719, 696
416, 696, 720, 697
417, 697, 721, 698
418, 698, 722, 699
419, 699, 723, 700
420, 700, 724, 701
421, 701, 725, 702
422, 702, 726, 703
423, 703, 727, 704
424, 704, 728, 15
*ELEMENT, type=T3D3, ELSET=Line25
425, 13, 740, 729
426, 729, 741, 730
427, 730, 742, 731
428, 731, 743, 732
429, 732, 744, 733
430, 733, 745, 734
431, 734, 746, 735
432, 735, 747, 736
433, 736, 748, 737
434, 737, 749, 738
435, 738, 750, 739
436, 739, 751, 15
*ELEMENT, type=T3D3, ELSET=Line26
437, 12, 775, 752
438, 752, 776, 753
439, 753, 777, 754
440, 754, 778, 755
441, 755, 779, 756
442, 756, 780, 757
443, 757, 781, 758
444, 758, 782, 759
445, 759, 783, 760
446, 760, 784, 761
447, 761, 785, 762
448, 762, 786, 763
449, 763, 787, 764
450, 764, 788, 765
451, 765, 789, 766
452, 766, 790, 767
453, 767, 791, 768
454, 768, 792, 769
455, 769, 793, 770
456, 770, 794, 771
457, 771, 795, 772
458, 772, 796, 773
459, 773, 797, 774
460, 774, 798, 16
*ELEMENT, type=T3D3, ELSET=Line27
461, 16, 822, 799
462, 799, 823, 800
463, 800, 824, 801
464, 801, 825, 802
465, 802, 826, 803
466, 803, 827, 804
467, 804, 828, 805
468, 805, 829, 806
469, 806, 830, 807
470, 807, 831, 808
471, 808, 832, 809
472, 809, 833, 810
473, 810, 834, 811
474, 811, 835, 812
475, 812, 836, 813
476, 813, 837, 814
477, 814, 838, 815
478, 815, 839, 816
479, 816, 840, 817
480, 817, 841, 818
481, 818, 842, 819
482, 819, 843, 820
483, 820, 844, 821
484, 821, 845, 15
*ELEMENT, type=T3D3, ELSET=Line28
485, 14, 857, 846
486, 846, 858, 847
487, 847, 859, 848
488, 848, 860, 849
489, 849, 861, 850
490, 850, 862, 851
491, 851, 863, 852
492, 852, 864, 853
493, 853, 865, 854
494, 854, 866, 855
495, 855, 867, 856
496, 856, 868, 16
*ELEMENT, type=T3D3, ELSET=Line29
497, 13, 869, 17
*ELEMENT, type=T3D3, ELSET=Line30
498, 14, 870, 18
*ELEMENT, type=T3D3, ELSET=Line31
499, 18, 894, 871
500, 871, 895, 872
501, 872, 896, 873
502, 873, 897, 874
503, 874, 898, 875
504, 875, 899, 876
505, 876, 900, 877
506, 877, 901, 878
507, 878, 902, 879
508, 879, 903, 880
509, 880, 904, 881
510, 881, 905, 882
511, 882, 906, 883
512, 883, 907, 884
513, 884, 908, 885
514, 885, 909, 886
515, 886, 910, 887
516, 887, 911, 888
517, 888, 912, 889
518, 889, 913, 890
519, 890, 914, 891
520, 891, 915, 892
521, 892, 916, 893
522, 893, 917, 17
*ELEMENT, type=T3D3, ELSET=Line32
523, 15, 918, 19
*ELEMENT, type=T3D3, ELSET=Line33
524, 17, 930, 919
525, 919, 931, 920
526, 920, 932, 921
527, 921, 933, 922
528, 922, 934, 923
529, 923, 935, 924
530, 924, 936, 925
531, 925, 937, 926
532, 926, 938, 927
533, 927, 939, 928
534, 928, 940, 929
535, 929, 941, 19
*ELEMENT, type=T3D3, ELSET=Line34
536, 16, 942, 20
*ELEMENT, type=T3D3, ELSET=Line35
537, 20, 966, 943
538, 943, 967, 944
539, 944, 968, 945
540, 945, 969, 946
541, 946, 970, 947
542, 947, 971, 948
543, 948, 972, 949
544, 949, 973, 950
545, 950, 974, 951
546, 951, 975, 952
547, 952, 976, 953
548, 953, 977, 954
549, 954, 978, 955
550, 955, 979, 956
551, 956, 980, 957
552, 957, 981, 958
553, 958, 982, 959
554, 959, 983, 960
555, 960, 984, 961
556, 961, 985, 962
557, 962, 986, 963
558, 963, 987, 964
559, 964, 988, 965
560, 965, 989, 19
*ELEMENT, type=T3D3, ELSET=Line36
561, 18, 1001, 990
562, 990, 1002, 991
563, 991, 1003, 992
564, 992, 1004, 993
565, 993, 1005, 994
566, 994, 1006, 995
567, 995, 1007, 996
568, 996, 1008, 997
569, 997, 1009, 998
570, 998, 1010, 999
571, 999, 1011, 1000
572, 1000, 1012, 20
*ELEMENT, type=T3D3, ELSET=Line37
573, 17, 1015, 1013
574, 1013, 1016, 1014
575, 1014, 1017, 21
*ELEMENT, type=T3D3, ELSET=Line38
576, 18, 1020, 1018
577, 1018, 1021, 1019
578, 1019, 1022, 22
*ELEMENT, type=T3D3, ELSET=Line39
579, 22, 1046, 1023
580, 1023, 1047, 1024
581, 1024, 1048, 1025
582, 1025, 1049, 1026
583, 1026, 1050, 1027
584, 1027, 1051, 1028
585, 1028, 1052, 1029
586, 1029, 1053, 1030
587, 1030, 1054, 1031
588, 1031, 1055, 1032
589, 1032, 1056, 1033
590, 1033, 1057, 1034
591, 1034, 1058, 1035
592, 1035, 1059, 1036
593, 1036, 1060, 1037
594, 1037, 1061, 1038
595, 1038, 1062, 1039
596, 1039, 1063, 1040
597, 1040, 1064, 1041
598, 1041, 1065, 1042
599, 1042, 1066, 1043
600, 1043, 1067, 1044
601, 1044, 1068, 1045
602, 1045, 1069, 21
*ELEMENT, type=T3D3, ELSET=Line40
603, 19, 1072, 1070
604, 1070, 1073, 1071
605, 1071, 1074, 23
*ELEMENT, type=T3D3, ELSET=Line41
606, 21, 1086, 1075
607, 1075, 1087, 1076
608, 1076, 1088, 1077
609, 1077, 1089, 1078
610, 1078, 1090, 1079
611, 1079, 1091, 1080
612, 1080, 1092, 1081
613, 1081, 1093, 1082
614, 1082, 1094, 1083
615, 1083, 1095, 1084
616, 1084, 1096, 1085
617, 1085, 1097, 23
*ELEMENT, type=T3D3, ELSET=Line42
618, 20, 1100, 1098
619, 1098, 1101, 1099
620, 1099, 1102, 24
*ELEMENT, type=T3D3, ELSET=Line43
621, 24, 1126, 1103
622, 1103, 1127, 1104
623, 1104, 1128, 1105
624, 1105, 1129, 1106
625, 1106, 1130, 1107
626, 1107, 1131, 1108
627, 1108, 1132, 1109
628, 1109, 1133, 1110
629, 1110, 1134, 1111
630, 1111, 1135, 1112
631, 1112, 1136, 1113
632, 1113, 1137, 1114
633, 1114, 1138, 1115
634, 1115, 1139, 1116
635, 1116, 1140, 1117
636, 1117, 1141, 1118
637, 1118, 1142, 1119
638, 1119, 1143, 1120
639, 1120, 1144, 1121
640, 1121, 1145, 1122
641, 1122, 1146, 1123
642, 1123, 1147, 1124
643, 1124, 1148, 1125
644, 1125, 1149, 23
*ELEMENT, type=T3D3, ELSET=Line44
645, 22, 1161, 1150
646, 1150, 1162, 1151
647, 1151, 1163, 1152
648, 1152, 1164, 1153
649, 1153, 1165, 1154
650, 1154, 1166, 1155
651, 1155, 1167, 1156
652, 1156, 1168, 1157
653, 1157, 1169, 1158
654, 1158, 1170, 1159
655, 1159, 1171, 1160
656, 1160, 1172, 24
*ELEMENT, type=T3D3, ELSET=Line45
657, 19, 1177, 1173
658, 1173, 1178, 1174
659, 1174, 1179, 1175
660, 1175, 1180, 1176
661, 1176, 1181, 25
*ELEMENT, type=T3D3, ELSET=Line46
662, 23, 1186, 1182
663, 1182, 1187, 1183
664, 1183, 1188, 1184
665, 1184, 1189, 1185
666, 1185, 1190, 26
*ELEMENT, type=T3D3, ELSET=Line47
667, 25, 1193, 1191
668, 1191, 1194, 1192
669, 1192, 1195, 26
*ELEMENT, type=T3D3, ELSET=Line48
670, 17, 1200, 1196
671, 1196, 1201, 1197
672, 1197, 1202, 1198
673, 1198, 1203, 1199
674, 1199, 1204, 27
*ELEMENT, type=T3D3, ELSET=Line49
675, 21, 1209, 1205
676, 1205, 1210, 1206
677, 1206, 1211, 1207
678, 1207, 1212, 1208
679, 1208, 1213, 28
*ELEMENT, type=T3D3, ELSET=Line50
680, 27, 1216, 1214
681, 1214, 1217, 1215
682, 1215, 1218, 28
*ELEMENT, type=T3D3, ELSET=Line51
683, 27, 1230, 1219
684, 1219, 1231, 1220
685, 1220, 1232, 1221
686, 1221, 1233, 1222
687, 1222, 1234, 1223
688, 1223, 1235, 1224
689, 1224, 1236, 1225
690, 1225, 1237, 1226
691, 1226, 1238, 1227
692, 1227, 1239, 1228
693, 1228, 1240, 1229
694, 1229, 1241, 25
*ELEMENT, type=T3D3, ELSET=Line52
695, 28, 1253, 1242
696, 1242, 1254, 1243
697, 1243, 1255, 1244
698, 1244, 1256, 1245
699, 1245, 1257, 1246
700, 1246, 1258, 1247
701, 1247, 1259, 1248
702, 1248, 1260, 1249
703, 1249, 1261, 1250
704, 1250, 1262, 1251
705, 1251, 1263, 1252
706, 1252, 1264, 26
*ELEMENT, type=T3D3, ELSET=Line53
707, 25, 1288, 1265
708, 1265, 1289, 1266
709, 1266, 1290, 1267
710, 1267, 1291, 1268
711, 1268, 1292, 1269
712, 1269, 1293, 1270
713, 1270, 1294, 1271
714, 1271, 1295, 1272
715, 1272, 1296, 1273
716, 1273, 1297, 1274
717, 1274, 1298, 1275
718, 1275, 1299, 1276
719, 1276, 1300, 1277
720, 1277, 1301, 1278
721, 1278, 1302, 1279
722, 1279, 1303, 1280
723, 1280, 1304, 1281
724, 1281, 1305, 1282
725, 1282, 1306, 1283
726, 1283, 1307, 1284
727, 1284, 1308, 1285
728, 1285, 1309, 1286
729, 1286, 1310, 1287
730, 1287, 1311, 29
*ELEMENT, type=T3D3, ELSET=Line54
731, 26, 1335, 1312
732, 1312, 1336, 1313
733, 1313, 1337, 1314
734, 1314, 1338, 1315
735, 1315, 1339, 1316
736, 1316, 1340, 1317
737, 1317, 1341, 1318
738, 1318, 1342, 1319
739, 1319, 1343, 1320
740, 1320, 1344, 1321
741, 1321, 1345, 1322
742, 1322, 1346, 1323
743, 1323, 1347, 1324
744, 1324, 1348, 1325
745, 1325, 1349, 1326
746, 1326, 1350, 1327
747, 1327, 1351, 1328
748, 1328, 1352, 1329
749, 1329, 1353, 1330
750, 1330, 1354, 1331
751, 1331, 1355, 1332
752, 1332, 1356, 1333
753, 1333, 1357, 1334
754, 1334, 1358, 30
*ELEMENT, type=T3D3, ELSET=Line55
755, 29, 1361, 1359
756, 1359, 1362, 1360
757, 1360, 1363, 30
*ELEMENT, type=T3D3, ELSET=Line56
758, 27, 1387, 1364
759, 1364, 1388, 1365
760, 1365, 1389, 1366
761, 1366, 1390, 1367
762, 1367, 1391, 1368
763, 1368, 1392, 1369
764, 1369, 1393, 1370
765, 1370, 1394, 1371
766, 1371, 1395, 1372
767, 1372, 1396, 1373
768, 1373, 1397, 1374
769, 1374, 1398, 1375
770, 1375, 1399, 1376
771, 1376, 1400, 1377
772, 1377, 1401, 1378
773, 1378, 1402, 1379
774, 1379, 1403, 1380
775, 1380, 1404, 1381
776, 1381, 1405, 1382
777, 1382, 1406, 1383
778, 1383, 1407, 1384
779, 1384, 1408, 1385
780, 1385, 1409, 1386
781, 1386, 1410, 31
*ELEMENT, type=T3D3, ELSET=Line57
782, 28, 1434, 1411
783, 1411, 1435, 1412
784, 1412, 1436, 1413
785, 1413, 1437, 1414
786, 1414, 1438, 1415
787, 1415, 1439, 1416
788, 1416, 1440, 1417
789, 1417, 1441, 1418
790, 1418, 1442, 1419
791, 1419, 1443, 1420
792, 1420, 1444, 1421
793, 1421, 1445, 1422
794, 1422, 1446, 1423
795, 1423, 1447, 1424
796, 1424, 1448, 1425
797, 1425, 1449, 1426
798, 1426, 1450, 1427
799, 1427, 1451, 1428
800, 1428, 1452, 1429
801, 1429, 1453, 1430
802, 1430, 1454, 1431
803, 1431, 1455, 1432
804, 1432, 1456, 1433
805, 1433, 1457, 32
*ELEMENT, type=T3D3, ELSET=Line58
806, 31, 1460, 1458
807, 1458, 1461, 1459
808, 1459, 1462, 32
*ELEMENT, type=T3D3, ELSET=Line59
809, 31, 1474, 1463
810, 1463, 1475, 1464
811, 1464, 1476, 1465
812, 1465, 1477, 1466
813, 1466, 1478, 1467
814, 1467, 1479, 1468
815, 1468, 1480, 1469
816, 1469, 1481, 1470
817, 1470, 1482, 1471
818, 1471, 1483, 1472
819, 1472, 1484, 1473
820, 1473, 1485, 29
*ELEMENT, type=T3D3, ELSET=Line60
821, 32, 1497, 1486
822, 1486, 1498, 1487
823, 1487, 1499, 1488
824, 1488, 1500, 1489
825, 1489, 1501, 1490
826, 1490, 1502, 1491
827, 1491, 1503, 1492
828, 1492, 1504, 1493
829, 1493, 1505, 1494
830, 1494, 1506, 1495
831, 1495, 1507, 1496
832, 1496, 1508, 30
*ELEMENT, type=T3D3, ELSET=Line61
833, 25, 1509, 33
*ELEMENT, type=T3D3, ELSET=Line62
834, 29, 1510, 34
*ELEMENT, type=T3D3, ELSET=Line63
835, 33, 1534, 1511
836, 1511, 1535, 1512
837, 1512, 1536, 1513
838, 1513, 1537, 1514
839, 1514, 1538, 1515
840, 1515, 1539, 1516
841, 1516, 1540, 1517
842, 1517, 1541, 1518
843, 1518, 1542, 1519
844, 1519, 1543, 1520
845, 1520, 1544, 1521
846, 1521, 1545, 1522
847, 1522, 1546, 1523
848, 1523, 1547, 1524
849, 1524, 1548, 1525
850, 1525, 1549, 1526
851, 1526, 1550, 1527
852, 1527, 1551, 1528
853, 1528, 1552, 1529
854, 1529, 1553, 1530
855, 1530, 1554, 1531
856, 1531, 1555, 1532
857, 1532, 1556, 1533
858, 1533, 1557, 34
*ELEMENT, type=T3D3, ELSET=Line64
859, 27, 1558, 35
*ELEMENT, type=T3D3, ELSET=Line65
860, 31, 1559, 36
*ELEMENT, type=T3D3, ELSET=Line66
861, 35, 1583, 1560
862, 1560, 1584, 1561
863, 1561, 1585, 1562
864, 1562, 1586, 1563
865, 1563, 1587, 1564
866, 1564, 1588, 1565
867, 1565, 1589, 1566
868, 1566, 1590, 1567
869, 1567, 1591, 1568
870, 1568, 1592, 1569
871, 1569, 1593, 1570
872, 1570, 1594, 1571
873, 1571, 1595, 1572
874, 1572, 1596, 1573
875, 1573, 1597, 1574
876, 1574, 1598, 1575
877, 1575, 1599, 1576
878, 1576, 1600, 1577
879, 1577, 1601, 1578
880, 1578, 1602, 1579
881, 1579, 1603, 1580
882, 1580, 1604, 1581
883, 1581, 1605, 1582
884, 1582, 1606, 36
*ELEMENT, type=T3D3, ELSET=Line67
885, 35, 1618, 1607
886, 1607, 1619, 1608
887, 1608, 1620, 1609
888, 1609, 1621, 1610
889, 1610, 1622, 1611
890, 1611, 1623, 1612
891, 1612, 1624, 1613
892, 1613, 1625, 1614
893, 1614, 1626, 1615
894, 1615, 1627, 1616
895, 1616, 1628, 1617
896, 1617, 1629, 33
*ELEMENT, type=T3D3, ELSET=Line68
897, 36, 1641, 1630
898, 1630, 1642, 1631
899, 1631, 1643, 1632
900, 1632, 1644, 1633
901, 1633, 1645, 1634
902, 1634, 1646, 1635
903, 1635, 1647, 1636
904, 1636, 1648, 1637
905, 1637, 1649, 1638
906, 1638, 1650, 1639
907, 1639, 1651, 1640
908, 1640, 1652, 34
*ELEMENT, type=T3D3, ELSET=Line69
909, 33, 1676, 1653
910, 1653, 1677, 1654
911, 1654, 1678, 1655
912, 1655, 1679, 1656
913, 1656, 1680, 1657
914, 1657, 1681, 1658
915, 1658, 1682, 1659
916, 1659, 1683, 1660
917, 1660, 1684, 1661
918, 1661, 1685, 1662
919, 1662, 1686, 1663
920, 1663, 1687, 1664
921, 1664, 1688, 1665
922, 1665, 1689, 1666
923, 1666, 1690, 1667
924, 1667, 1691, 1668
925, 1668, 1692, 1669
926, 1669, 1693, 1670
927, 1670, 1694, 1671
928, 1671, 1695, 1672
929, 1672, 1696, 1673
930, 1673, 1697, 1674
931, 1674, 1698, 1675
932, 1675, 1699, 37
*ELEMENT, type=T3D3, ELSET=Line70
933, 34, 1723, 1700
934, 1700, 1724, 1701
935, 1701, 1725, 1702
936, 1702, 1726, 1703
937, 1703, 1727, 1704
938, 1704, 1728, 1705
939, 1705, 1729, 1706
940, 1706, 1730, 1707
941, 1707, 1731, 1708
942, 1708, 1732, 1709
943, 1709, 1733, 1710
944, 1710, 1734, 1711
945, 1711, 1735, 1712
946, 1712, 1736, 1713
947, 1713, 1737, 1714
948, 1714, 1738, 1715
949, 1715, 1739, 1716
950, 1716, 1740, 1717
951, 1717, 1741, 1718
952, 1718, 1742, 1719
953, 1719, 1743, 1720
954, 1720, 1744, 1721
955, 1721, 1745, 1722
956, 1722, 1746, 38
*ELEMENT, type=T3D3, ELSET=Line71
957, 37, 1770, 1747
958, 1747, 1771, 1748
959, 1748, 1772, 1749
960, 1749, 1773, 1750
961, 1750, 1774, 1751
962, 1751, 1775, 1752
963, 1752, 1776, 1753
964, 1753, 1777, 1754
965, 1754, 1778, 1755
966, 1755, 1779, 1756
967, 1756, 1780, 1757
968, 1757, 1781, 1758
969, 1758, 1782, 1759
970, 1759, 1783, 1760
971, 1760, 1784, 1761
972, 1761, 1785, 1762
973, 1762, 1786, 1763
974, 1763, 1787, 1764
975, 1764, 1788, 1765
976, 1765, 1789, 1766
977, 1766, 1790, 1767
978, 1767, 1791, 1768
979, 1768, 1792, 1769
980, 1769, 1793, 38
*ELEMENT, type=T3D3, ELSET=Line72
981, 35, 1817, 1794
982, 1794, 1818, 1795
983, 1795, 1819, 1796
984, 1796, 1820, 1797
985, 1797, 1821, 1798
986, 1798, 1822, 1799
987, 1799, 1823, 1800
988, 1800, 1824, 1801
989, 1801, 1825, 1802
990, 1802, 1826, 1803
991, 1803, 1827, 1804
992, 1804, 1828, 1805
993, 1805, 1829, 1806
994, 1806, 1830, 1807
995, 1807, 1831, 1808
996, 1808, 1832, 1809
997, 1809, 1833, 1810
998, 1810, 1834, 1811
999, 1811, 1835, 1812
1000, 1812, 1836, 1813
1001, 1813, 1837, 1814
1002, 1814, 1838, 1815
1003, 1815, 1839, 1816
1004, 1816, 1840, 39
*ELEMENT, type=T3D3, ELSET=Line73
1005, 36, 1864, 1841
1006, 1841, 1865, 1842
1007, 1842, 1866, 1843
1008, 1843, 1867, 1844
1009, 1844, 1868, 1845
1010, 1845, 1869, 1846
1011, 1846, 1870, 1847
1012, 1847, 1871, 1848
1013, 1848, 1872, 1849
1014, 1849, 1873, 1850
1015, 1850, 1874, 1851
1016, 1851, 1875, 1852
1017, 1852, 1876, 1853
1018, 1853, 1877, 1854
1019, 1854, 1878, 1855
1020, 1855, 1879, 1856
1021, 1856, 1880, 1857
1022, 1857, 1881, 1858
1023, 1858, 1882, 1859
1024, 1859, 1883, 1860
1025, 1860, 1884, 1861
1026, 1861, 1885, 1862
1027, 1862, 1886, 1863
1028, 1863, 1887, 40
*ELEMENT, type=T3D3, ELSET=Line74
1029, 39, 1911, 1888
1030, 1888, 1912, 1889
1031, 1889, 1913, 1890
1032, 1890, 1914, 1891
1033, 1891, 1915, 1892
1034, 1892, 1916, 1893
1035, 1893, 1917, 1894
1036, 1894, 1918, 1895
1037, 1895, 1919, 1896
1038, 1896, 1920, 1897
1039, 1897, 1921, 1898
1040, 1898, 1922, 1899
1041, 1899, 1923, 1900
1042, 1900, 1924, 1901
1043, 1901, 1925, 1902
1044, 1902, 1926, 1903
1045, 1903, 1927, 1904
1046, 1904, 1928, 1905
1047, 1905, 1929, 1906
1048, 1906, 1930, 1907
1049, 1907, 1931, 1908
1050, 1908, 1932, 1909
1051, 1909, 1933, 1910
1052, 1910, 1934, 40
*ELEMENT, type=T3D3, ELSET=Line75
1053, 39, 1946, 1935
1054, 1935, 1947, 1936
1055, 1936, 1948, 1937
1056, 1937, 1949, 1938
1057, 1938, 1950, 1939
1058, 1939, 1951, 1940
1059, 1940, 1952, 1941
1060, 1941, 1953, 1942
1061, 1942, 1954, 1943
1062, 1943, 1955, 1944
1063, 1944, 1956, 1945
1064, 1945, 1957, 37
*ELEMENT, type=T3D3, ELSET=Line76
1065, 40, 1969, 1958
1066, 1958, 1970, 1959
1067, 1959, 1971, 1960
1068, 1960, 1972, 1961
1069, 1961, 1973, 1962
1070, 1962, 1974, 1963
1071, 1963, 1975, 1964
1072, 1964, 1976, 1965
1073, 1965, 1977, 1966
1074, 1966, 1978, 1967
1075, 1967, 1979, 1968
1076, 1968, 1980, 38
*ELEMENT, type=T3D3, ELSET=Line77
1077, 37, 1981, 41
*ELEMENT, type=T3D3, ELSET=Line78
1078, 38, 1982, 42
*ELEMENT, type=T3D3, ELSET=Line79
1079, 41, 2006, 1983
1080, 1983, 2007, 1984
1081, 1984, 2008, 1985
1082, 1985, 2009, 1986
1083, 1986, 2010, 1987
1084, 1987, 2011, 1988
1085, 1988, 2012, 1989
1086, 1989, 2013, 1990
1087, 1990, 2014, 1991
1088, 1991, 2015, 1992
1089, 1992, 2016, 1993
1090, 1993, 2017, 1994
1091, 1994, 2018, 1995
1092, 1995, 2019, 1996
1093, 1996, 2020, 1997
1094, 1997, 2021, 1998
1095, 1998, 2022, 1999
1096, 1999, 2023, 2000
1097, 2000, 2024, 2001
1098, 2001, 2025, 2002
1099, 2002, 2026, 2003
1100, 2003, 2027, 2004
1101, 2004, 2028, 2005
1102, 2005, 2029, 42
*ELEMENT, type=T3D3, ELSET=Line80
1103, 39, 2030, 43
*ELEMENT, type=T3D3, ELSET=Line81
1104, 40, 2031, 44
*ELEMENT, type=T3D3, ELSET=Line82
1105, 43, 2055, 2032
1106, 2032, 2056, 2033
1107, 2033, 2057, 2034
1108, 2034, 2058, 2035
1109, 2035, 2059, 2036
1110, 2036, 2060, 2037
1111, 2037, 2061, 2038
1112, 2038, 2062, 2039
1113, 2039, 2063, 2040
1114, 2040, 2064, 2041
1115, 2041, 2065, 2042
1116, 2042, 2066, 2043
1117, 2043, 2067, 2044
1118, 2044, 2068, 2045
1119, 2045, 2069, 2046
1120, 2046, 2070, 2047
1121, 2047, 2071, 2048
1122, 2048, 2072, 2049
1123, 2049, 2073, 2050
1124, 2050, 2074, 2051
1125, 2051, 2075, 2052
1126, 2052, 2076, 2053
1127, 2053, 2077, 2054
1128, 2054, 2078, 44
*ELEMENT, type=T3D3, ELSET=Line83
1129, 43, 2090, 2079
1130, 2079, 2091, 2080
1131, 2080, 2092, 2081
1132, 2081, 2093, 2082
1133, 2082, 2094, 2083
1134, 2083, 2095, 2084
1135, 2084, 2096, 2085
1136, 2085, 2097, 2086
1137, 2086, 2098, 2087
1138, 2087, 2099, 2088
1139, 2088, 2100, 2089
1140, 2089, 2101, 41
*ELEMENT, type=T3D3, ELSET=Line84
1141, 44, 2113, 2102
1142, 2102, 2114, 2103
1143, 2103, 2115, 2104
1144, 2104, 2116, 2105
1145, 2105, 2117, 2106
1146, 2106, 2118, 2107
1147, 2107, 2119, 2108
1148, 2108, 2120, 2109
1149, 2109, 2121, 2110
1150, 2110, 2122, 2111
1151, 2111, 2123, 2112
1152, 2112, 2124, 42
*ELEMENT, type=T3D3, ELSET=Line85
1153, 41, 2127, 2125
1154, 2125, 2128, 2126
1155, 2126, 2129, 45
*ELEMENT, type=T3D3, ELSET=Line86
1156, 42, 2132, 2130
1157, 2130, 2133, 2131
1158, 2131, 2134, 46
*ELEMENT, type=T3D3, ELSET=Line87
1159, 45, 2158, 2135
1160, 2135, 2159, 2136
1161, 2136, 2160, 2137
1162, 2137, 2161, 2138
1163, 2138, 2162, 2139
1164, 2139, 2163, 2140
1165, 2140, 2164, 2141
1166, 2141, 2165, 2142
1167, 2142, 2166, 2143
1168, 2143, 2167, 2144
1169, 2144, 2168, 2145
1170, 2145, 2169, 2146
1171, 2146, 2170, 2147
1172, 2147, 2171, 2148
1173, 2148, 2172, 2149
1174, 2149, 2173, 2150
1175, 2150, 2174, 2151
1176, 2151, 2175, 2152
1177, 2152, 2176, 2153
1178, 2153, 2177, 2154
1179, 2154, 2178, 2155
1180, 2155, 2179, 2156
1181, 2156, 2180, 2157
1182, 2157, 2181, 46
*ELEMENT, type=T3D3, ELSET=Line88
1183, 43, 2184, 2182
1184, 2182, 2185, 2183
1185, 2183, 2186, 47
*ELEMENT, type=T3D3, ELSET=Line89
1186, 44, 2189, 2187
1187, 2187, 2190, 2188
1188, 2188, 2191, 48
*ELEMENT, type=T3D3, ELSET=Line90
1189, 47, 2215, 2192
1190, 2192, 2216, 2193
1191, 2193, 2217, 2194
1192, 2194, 2218, 2195
1193, 2195, 2219, 2196
1194, 2196, 2220, 2197
1195, 2197, 2221, 2198
1196, 2198, 2222, 2199
1197, 2199, 2223, 2200
1198, 2200, 2224, 2201
1199, 2201, 2225, 2202
1200, 2202, 2226, 2203
1201, 2203, 2227, 2204
1202, 2204, 2228, 2205
1203, 2205, 2229, 2206
1204, 2206, 2230, 2207
1205, 2207, 2231, 2208
1206, 2208, 2232, 2209
1207, 2209, 2233, 2210
1208, 2210, 2234, 2211
1209, 2211, 2235, 2212
1210, 2212, 2236, 2213
1211, 2213, 2237, 2214
1212, 2214, 2238, 48
*ELEMENT, type=T3D3, ELSET=Line91
1213, 47, 2250, 2239
1214, 2239, 2251, 2240
1215, 2240, 2252, 2241
1216, 2241, 2253, 2242
1217, 2242, 2254, 2243
1218, 2243, 2255, 2244
1219, 2244, 2256, 2245
1220, 2245, 2257, 2246
1221, 2246, 2258, 2247
1222, 2247, 2259, 2248
1223, 2248, 2260, 2249
1224, 2249, 2261, 45
*ELEMENT, type=T3D3, ELSET=Line92
1225, 48, 2273, 2262
1226, 2262, 2274, 2263
1227, 2263, 2275, 2264
1228, 2264, 2276, 2265
1229, 2265, 2277, 2266
1230, 2266, 2278, 2267
1231, 2267, 2279, 2268
1232, 2268, 2280, 2269
1233, 2269, 2281, 2270
1234, 2270, 2282, 2271
1235, 2271, 2283, 2272
1236, 2272, 2284, 46
*ELEMENT, type=T3D3, ELSET=Line93
1237, 42, 2285, 49
*ELEMENT, type=T3D3, ELSET=Line94
1238, 46, 2286, 50
*ELEMENT, type=T3D3, ELSET=Line95
1239, 49, 2289, 2287
1240, 2287, 2290, 2288
1241, 2288, 2291, 50
*ELEMENT, type=T3D3, ELSET=Line96
1242, 44, 2292, 51
*ELEMENT, type=T3D3, ELSET=Line97
1243, 48, 2293, 52
*ELEMENT, type=T3D3, ELSET=Line98
1244, 51, 2296, 2294
1245, 2294, 2297, 2295
1246, 2295, 2298, 52
*ELEMENT, type=T3D3, ELSET=Line99
1247, 51, 2310, 2299
1248, 2299, 2311, 2300
1249, 2300, 2312, 2301
1250, 2301, 2313, 2302
1251, 2302, 2314, 2303
1252, 2303, 2315, 2304
1253, 2304, 2316, 2305
1254, 2305, 2317, 2306
1255, 2306, 2318, 2307
1256, 2307, 2319, 2308
1257, 2308, 2320, 2309
1258, 2309, 2321, 49
*ELEMENT, type=T3D3, ELSET=Line100
1259, 52, 2333, 2322
1260, 2322, 2334, 2323
1261, 2323, 2335, 2324
1262, 2324, 2336, 2325
1263, 2325, 2337, 2326
1264, 2326, 2338, 2327
1265, 2327, 2339, 2328
1266, 2328, 2340, 2329
1267, 2329, 2341, 2330
1268, 2330, 2342, 2331
1269, 2331, 2343, 2332
1270, 2332, 2344, 50
*ELEMENT, type=T3D3, ELSET=Line101
1271, 1, 2345, 53
*ELEMENT, type=T3D3, ELSET=Line102
1272, 2, 2346, 54
*ELEMENT, type=T3D3, ELSET=Line103
1273, 54, 2358, 2347
1274, 2347, 2359, 2348
1275, 2348, 2360, 2349
1276, 2349, 2361, 2350
1277, 2350, 2362, 2351
1278, 2351, 2363, 2352
1279, 2352, 2364, 2353
1280, 2353, 2365, 2354
1281, 2354, 2366, 2355
1282, 2355, 2367, 2356
1283, 2356, 2368, 2357
1284, 2357, 2369, 53
*ELEMENT, type=T3D3, ELSET=Line104
1285, 3, 2370, 55
*ELEMENT, type=T3D3, ELSET=Line105
1286, 53, 2373, 2371
1287, 2371, 2374, 2372
1288, 2372, 2375, 55
*ELEMENT, type=T3D3, ELSET=Line106
1289, 4, 2376, 56
*ELEMENT, type=T3D3, ELSET=Line107
1290, 56, 2388, 2377
1291, 2377, 2389, 2378
1292, 2378, 2390, 2379
1293, 2379, 2391, 2380
1294, 2380, 2392, 2381
1295, 2381, 2393, 2382
1296, 2382, 2394, 2383
1297, 2383, 2395, 2384
1298, 2384, 2396, 2385
1299, 2385, 2397, 2386
1300, 2386, 2398, 2387
1301, 2387, 2399, 55
*ELEMENT, type=T3D3, ELSET=Line108
1302, 54, 2402, 2400
1303, 2400, 2403, 2401
1304, 2401, 2404, 56
*ELEMENT, type=T3D3, ELSET=Line125
1305, 11, 2405, 57
*ELEMENT, type=T3D3, ELSET=Line126
1306, 15, 2406, 58
*ELEMENT, type=T3D3, ELSET=Line127
1307, 57, 2430, 2407
1308, 2407, 2431, 2408
1309, 2408, 2432, 2409
1310, 2409, 2433, 2410
1311, 2410, 2434, 2411
1312, 2411, 2435, 2412
1313, 2412, 2436, 2413
1314, 2413, 2437, 2414
1315, 2414, 2438, 2415
1316, 2415, 2439, 2416
1317, 2416, 2440, 2417
1318, 2417, 2441, 2418
1319, 2418, 2442, 2419
1320, 2419, 2443, 2420
1321, 2420, 2444, 2421
1322, 2421, 2445, 2422
1323, 2422, 2446, 2423
1324, 2423, 2447, 2424
1325, 2424, 2448, 2425
1326, 2425, 2449, 2426
1327, 2426, 2450, 2427
1328, 2427, 2451, 2428
1329, 2428, 2452, 2429
1330, 2429, 2453, 58
*ELEMENT, type=T3D3, ELSET=Line128
1331, 9, 2454, 59
*ELEMENT, type=T3D3, ELSET=Line129
1332, 13, 2455, 60
*ELEMENT, type=T3D3, ELSET=Line130
1333, 59, 2479, 2456
1334, 2456, 2480, 2457
1335, 2457, 2481, 2458
1336, 2458, 2482, 2459
1337, 2459, 2483, 2460
1338, 2460, 2484, 2461
1339, 2461, 2485, 2462
1340, 2462, 2486, 2463
1341, 2463, 2487, 2464
1342, 2464, 2488, 2465
1343, 2465, 2489, 2466
1344, 2466, 2490, 2467
1345, 2467, 2491, 2468
1346, 2468, 2492, 2469
1347, 2469, 2493, 2470
1348, 2470, 2494, 2471
1349, 2471, 2495, 2472
1350, 2472, 2496, 2473
1351, 2473, 2497, 2474
1352, 2474, 2498, 2475
1353, 2475, 2499, 2476
1354, 2476, 2500, 2477
1355, 2477, 2501, 2478
1356, 2478, 2502, 60
*ELEMENT, type=T3D3, ELSET=Line131
1357, 59, 2514, 2503
1358, 2503, 2515, 2504
1359, 2504, 2516, 2505
1360, 2505, 2517, 2506
1361, 2506, 2518, 2507
1362, 2507, 2519, 2508
1363, 2508, 2520, 2509
1364, 2509, 2521, 2510
1365, 2510, 2522, 2511
1366, 2511, 2523, 2512
1367, 2512, 2524, 2513
1368, 2513, 2525, 57
*ELEMENT, type=T3D3, ELSET=Line132
1369, 60, 2537, 2526
1370, 2526, 2538, 2527
1371, 2527, 2539, 2528
1372, 2528, 2540, 2529
1373, 2529, 2541, 2530
1374, 2530, 2542, 2531
1375, 2531, 2543, 2532
1376, 2532, 2544, 2533
1377, 2533, 2545, 2534
1378, 2534, 2546, 2535
1379, 2535, 2547, 2536
1380, 2536, 2548, 58
*ELEMENT, type=T3D3, ELSET=Line133
1381, 33, 2549, 61
*ELEMENT, type=T3D3, ELSET=Line134
1382, 37, 2550, 62
*ELEMENT, type=T3D3, ELSET=Line135
1383, 61, 2574, 2551
1384, 2551, 2575, 2552
1385, 2552, 2576, 2553
1386, 2553, 2577, 2554
1387, 2554, 2578, 2555
1388, 2555, 2579, 2556
1389, 2556, 2580, 2557
1390, 2557, 2581, 2558
1391, 2558, 2582, 2559
1392, 2559, 2583, 2560
1393, 2560, 2584, 2561
1394, 2561, 2585, 2562
1395, 2562, 2586, 2563
1396, 2563, 2587, 2564
1397, 2564, 2588, 2565
1398, 2565, 2589, 2566
1399, 2566, 2590, 2567
1400, 2567, 2591, 2568
1401, 2568, 2592, 2569
1402, 2569, 2593, 2570
1403, 2570, 2594, 2571
1404, 2571, 2595, 2572
1405, 2572, 2596, 2573
1406, 2573, 2597, 62
*ELEMENT, type=T3D3, ELSET=Line136
1407, 35, 2598, 63
*ELEMENT, type=T3D3, ELSET=Line137
1408, 39, 2599, 64
*ELEMENT, type=T3D3, ELSET=Line138
1409, 63, 2623, 2600
1410, 2600, 2624, 2601
1411, 2601, 2625, 2602
1412, 2602, 2626, 2603
1413, 2603, 2627, 2604
1414, 2604, 2628, 2605
1415, 2605, 2629, 2606
1416, 2606, 2630, 2607
1417, 2607, 2631, 2608
1418, 2608, 2632, 2609
1419, 2609, 2633, 2610
1420, 2610, 2634, 2611
1421, 2611, 2635, 2612
1422, 2612, 2636, 2613
1423, 2613, 2637, 2614
1424, 2614, 2638, 2615
1425, 2615, 2639, 2616
1426, 2616, 2640, 2617
1427, 2617, 2641, 2618
1428, 2618, 2642, 2619
1429, 2619, 2643, 2620
1430, 2620, 2644, 2621
1431, 2621, 2645, 2622
1432, 2622, 2646, 64
*ELEMENT, type=T3D3, ELSET=Line139
1433, 63, 2658, 2647
1434, 2647, 2659, 2648
1435, 2648, 2660, 2649
1436, 2649, 2661, 2650
1437, 2650, 2662, 2651
1438, 2651, 2663, 2652
1439, 2652, 2664, 2653
1440, 2653, 2665, 2654
1441, 2654, 2666, 2655
1442, 2655, 2667, 2656
1443, 2656, 2668, 2657
1444, 2657, 2669, 61
*ELEMENT, type=T3D3, ELSET=Line140
1445, 64, 2681, 2670
1446, 2670, 2682, 2671
1447, 2671, 2683, 2672
1448, 2672, 2684, 2673
1449, 2673, 2685, 2674
1450, 2674, 2686, 2675
1451, 2675, 2687, 2676
1452, 2676, 2688, 2677
1453, 2677, 2689, 2678
1454, 2678, 2690, 2679
1455, 2679, 2691, 2680
1456, 2680, 2692, 62
*ELEMENT, type=T3D3, ELSET=Line141
1457, 9, 2693, 65
*ELEMENT, type=T3D3, ELSET=Line142
1458, 13, 2694, 66
*ELEMENT, type=T3D3, ELSET=Line143
1459, 65, 2718, 2695
1460, 2695, 2719, 2696
1461, 2696, 2720, 2697
1462, 2697, 2721, 2698
1463, 2698, 2722, 2699
1464, 2699, 2723, 2700
1465, 2700, 2724, 2701
1466, 2701, 2725, 2702
1467, 2702, 2726, 2703
1468, 2703, 2727, 2704
1469, 2704, 2728, 2705
1470, 2705, 2729, 2706
1471, 2706, 2730, 2707
1472, 2707, 2731, 2708
1473, 2708, 2732, 2709
1474, 2709, 2733, 2710
1475, 2710, 2734, 2711
1476, 2711, 2735, 2712
1477, 2712, 2736, 2713
1478, 2713, 2737, 2714
1479, 2714, 2738, 2715
1480, 2715, 2739, 2716
1481, 2716, 2740, 2717
1482, 2717, 2741, 66
*ELEMENT, type=T3D3, ELSET=Line144
1483, 10, 2742, 67
*ELEMENT, type=T3D3, ELSET=Line145
1484, 14, 2743, 68
*ELEMENT, type=T3D3, ELSET=Line146
1485, 67, 2767, 2744
1486, 2744, 2768, 2745
1487, 2745, 2769, 2746
1488, 2746, 2770, 2747
1489, 2747, 2771, 2748
1490, 2748, 2772, 2749
1491, 2749, 2773, 2750
1492, 2750, 2774, 2751
1493, 2751, 2775, 2752
1494, 2752, 2776, 2753
1495, 2753, 2777, 2754
1496, 2754, 2778, 2755
1497, 2755, 2779, 2756
1498, 2756, 2780, 2757
1499, 2757, 2781, 2758
1500, 2758, 2782, 2759
1501, 2759, 2783, 2760
1502, 2760, 2784, 2761
1503, 2761, 2785, 2762
1504, 2762, 2786, 2763
1505, 2763, 2787, 2764
1506, 2764, 2788, 2765
1507, 2765, 2789, 2766
1508, 2766, 2790, 68
*ELEMENT, type=T3D3, ELSET=Line147
1509, 67, 2814, 2791
1510, 2791, 2815, 2792
1511, 2792, 2816, 2793
1512, 2793, 2817, 2794
1513, 2794, 2818, 2795
1514, 2795, 2819, 2796
1515, 2796, 2820, 2797
1516, 2797, 2821, 2798
1517, 2798, 2822, 2799
1518, 2799, 2823, 2800
1519, 2800, 2824, 2801
1520, 2801, 2825, 2802
1521, 2802, 2826, 2803
1522, 2803, 2827, 2804
1523, 2804, 2828, 2805
1524, 2805, 2829, 2806
1525, 2806, 2830, 2807
1526, 2807, 2831, 2808
1527, 2808, 2832, 2809
1528, 2809, 2833, 2810
1529, 2810, 2834, 2811
1530, 2811, 2835, 2812
1531, 2812, 2836, 2813
1532, 2813, 2837, 65
*ELEMENT, type=T3D3, ELSET=Line148
1533, 68, 2861, 2838
1534, 2838, 2862, 2839
1535, 2839, 2863, 2840
1536, 2840, 2864, 2841
1537, 2841, 2865, 2842
1538, 2842, 2866, 2843
1539, 2843, 2867, 2844
1540, 2844, 2868, 2845
1541, 2845, 2869, 2846
1542, 2846, 2870, 2847
1543, 2847, 2871, 2848
1544, 2848, 2872, 2849
1545, 2849, 2873, 2850
1546, 2850, 2874, 2851
1547, 2851, 2875, 2852
1548, 2852, 2876, 2853
1549, 2853, 2877, 2854
1550, 2854, 2878, 2855
1551, 2855, 2879, 2856
1552, 2856, 2880, 2857
1553, 2857, 2881, 2858
1554, 2858, 2882, 2859
1555, 2859, 2883, 2860
1556, 2860, 2884, 66
*ELEMENT, type=T3D3, ELSET=Line149
1557, 35, 2885, 69
*ELEMENT, type=T3D3, ELSET=Line150
1558, 39, 2886, 70
*ELEMENT, type=T3D3, ELSET=Line151
1559, 69, 2910, 2887
1560, 2887, 2911, 2888
1561, 2888, 2912, 2889
1562, 2889, 2913, 2890
1563, 2890, 2914, 2891
1564, 2891, 2915, 2892
1565, 2892, 2916, 2893
1566, 2893, 2917, 2894
1567, 2894, 2918, 2895
1568, 2895, 2919, 2896
1569, 2896, 2920, 2897
1570, 2897, 2921, 2898
1571, 2898, 2922, 2899
1572, 2899, 2923, 2900
1573, 2900, 2924, 2901
1574, 2901, 2925, 2902
1575, 2902, 2926, 2903
1576, 2903, 2927, 2904
1577, 2904, 2928, 2905
1578, 2905, 2929, 2906
1579, 2906, 2930, 2907
1580, 2907, 2931, 2908
1581, 2908, 2932, 2909
1582, 2909, 2933, 70
*ELEMENT, type=T3D3, ELSET=Line152
1583, 36, 2934, 71
*ELEMENT, type=T3D3, ELSET=Line153
1584, 40, 2935, 72
*ELEMENT, type=T3D3, ELSET=Line154
1585, 71, 2959, 2936
1586, 2936, 2960, 2937
1587, 2937, 2961, 2938
1588, 2938, 2962, 2939
1589, 2939, 2963, 2940
1590, 2940, 2964, 2941
1591, 2941, 2965, 2942
1592, 2942, 2966, 2943
1593, 2943, 2967, 2944
1594, 2944, 2968, 2945
1595, 2945, 2969, 2946
1596, 2946, 2970, 2947
1597, 2947, 2971, 2948
1598, 2948, 2972, 2949
1599, 2949, 2973, 2950
1600, 2950, 2974, 2951
1601, 2951, 2975, 2952
1602, 2952, 2976, 2953
1603, 2953, 2977, 2954
1604, 2954, 2978, 2955
1605, 2955, 2979, 2956
1606, 2956, 2980, 2957
1607, 2957, 2981, 2958
1608, 2958, 2982, 72
*ELEMENT, type=T3D3, ELSET=Line155
1609, 69, 3006, 2983
1610, 2983, 3007, 2984
1611, 2984, 3008, 2985
1612, 2985, 3009, 2986
1613, 2986, 3010, 2987
1614, 2987, 3011, 2988
1615, 2988, 3012, 2989
1616, 2989, 3013, 2990
1617, 2990, 3014, 2991
1618, 2991, 3015, 2992
1619, 2992, 3016, 2993
1620, 2993, 3017, 2994
1621, 2994, 3018, 2995
1622, 2995, 3019, 2996
1623, 2996, 3020, 2997
1624, 2997, 3021, 2998
1625, 2998, 3022, 2999
1626, 2999, 3023, 3000
1627, 3000, 3024, 3001
1628, 3001, 3025, 3002
1629, 3002, 3026, 3003
1630, 3003, 3027, 3004
1631, 3004, 3028, 3005
1632, 3005, 3029, 71
*ELEMENT, type=T3D3, ELSET=Line156
1633, 70, 3053, 3030
1634, 3030, 3054, 3031
1635, 3031, 3055, 3032
1636, 3032, 3056, 3033
1637, 3033, 3057, 3034
1638, 3034, 3058, 3035
1639, 3035, 3059, 3036
1640, 3036, 3060, 3037
1641, 3037, 3061, 3038
1642, 3038, 3062, 3039
1643, 3039, 3063, 3040
1644, 3040, 3064, 3041
1645, 3041, 3065, 3042
1646, 3042, 3066, 3043
1647, 3043, 3067, 3044
1648, 3044, 3068, 3045
1649, 3045, 3069, 3046
1650, 3046, 3070, 3047
1651, 3047, 3071, 3048
1652, 3048, 3072, 3049
1653, 3049, 3073, 3050
1654, 3050, 3074, 3051
1655, 3051, 3075, 3052
1656, 3052, 3076, 72
*ELEMENT, type=T3D3, ELSET=Line157
1657, 63, 3077, 73
*ELEMENT, type=T3D3, ELSET=Line158
1658, 69, 3078, 73
*ELEMENT, type=T3D3, ELSET=Line159
1659, 64, 3079, 74
*ELEMENT, type=T3D3, ELSET=Line160
1660, 70, 3080, 74
*ELEMENT, type=T3D3, ELSET=Line161
1661, 73, 3104, 3081
1662, 3081, 3105, 3082
1663, 3082, 3106, 3083
1664, 3083, 3107, 3084
1665, 3084, 3108, 3085
1666, 3085, 3109, 3086
1667, 3086, 3110, 3087
1668, 3087, 3111, 3088
1669, 3088, 3112, 3089
1670, 3089, 3113, 3090
1671, 3090, 3114, 3091
1672, 3091, 3115, 3092
1673, 3092, 3116, 3093
1674, 3093, 3117, 3094
1675, 3094, 3118, 3095
1676, 3095, 3119, 3096
1677, 3096, 3120, 3097
1678, 3097, 3121, 3098
1679, 3098, 3122, 3099
1680, 3099, 3123, 3100
1681, 3100, 3124, 3101
1682, 3101, 3125, 3102
1683, 3102, 3126, 3103
1684, 3103, 3127, 74
*ELEMENT, type=T3D3, ELSET=Line162
1685, 59, 3128, 75
*ELEMENT, type=T3D3, ELSET=Line163
1686, 65, 3129, 75
*ELEMENT, type=T3D3, ELSET=Line164
1687, 60, 3130, 76
*ELEMENT, type=T3D3, ELSET=Line165
1688, 66, 3131, 76
*ELEMENT, type=T3D3, ELSET=Line166
1689, 75, 3155, 3132
1690, 3132, 3156, 3133
1691, 3133, 3157, 3134
1692, 3134, 3158, 3135
1693, 3135, 3159, 3136
1694, 3136, 3160, 3137
1695, 3137, 3161, 3138
1696, 3138, 3162, 3139
1697, 3139, 3163, 3140
1698, 3140, 3164, 3141
1699, 3141, 3165, 3142
1700, 3142, 3166, 3143
1701, 3143, 3167, 3144
1702, 3144, 3168, 3145
1703, 3145, 3169, 3146
1704, 3146, 3170, 3147
1705, 3147, 3171, 3148
1706, 3148, 3172, 3149
1707, 3149, 3173, 3150
1708, 3150, 3174, 3151
1709, 3151, 3175, 3152
1710, 3152, 3176, 3153
1711, 3153, 3177, 3154
1712, 3154, 3178, 76
*ELEMENT, type=T3D3, ELSET=Line167
1713, 21, 3183, 3179
1714, 3179, 3184, 3180
1715, 3180, 3185, 3181
1716, 3181, 3186, 3182
1717, 3182, 3187, 77
*ELEMENT, type=T3D3, ELSET=Line168
1718, 22, 3192, 3188
1719, 3188, 3193, 3189
1720, 3189, 3194, 3190
1721, 3190, 3195, 3191
1722, 3191, 3196, 78
*ELEMENT, type=T3D3, ELSET=Line169
1723, 78, 3220, 3197
1724, 3197, 3221, 3198
1725, 3198, 3222, 3199
1726, 3199, 3223, 3200
1727, 3200, 3224, 3201
1728, 3201, 3225, 3202
1729, 3202, 3226, 3203
1730, 3203, 3227, 3204
1731, 3204, 3228, 3205
1732, 3205, 3229, 3206
1733, 3206, 3230, 3207
1734, 3207, 3231, 3208
1735, 3208, 3232, 3209
1736, 3209, 3233, 3210
1737, 3210, 3234, 3211
1738, 3211, 3235, 3212
1739, 3212, 3236, 3213
1740, 3213, 3237, 3214
1741, 3214, 3238, 3215
1742, 3215, 3239, 3216
1743, 3216, 3240, 3217
1744, 3217, 3241, 3218
1745, 3218, 3242, 3219
1746, 3219, 3243, 77
*ELEMENT, type=T3D3, ELSET=Line170
1747, 23, 3248, 3244
1748, 3244, 3249, 3245
1749, 3245, 3250, 3246
1750, 3246, 3251, 3247
1751, 3247, 3252, 79
*ELEMENT, type=T3D3, ELSET=Line171
1752, 77, 3264, 3253
1753, 3253, 3265, 3254
1754, 3254, 3266, 3255
1755, 3255, 3267, 3256
1756, 3256, 3268, 3257
1757, 3257, 3269, 3258
1758, 3258, 3270, 3259
1759, 3259, 3271, 3260
1760, 3260, 3272, 3261
1761, 3261, 3273, 3262
1762, 3262, 3274, 3263
1763, 3263, 3275, 79
*ELEMENT, type=T3D3, ELSET=Line172
1764, 24, 3280, 3276
1765, 3276, 3281, 3277
1766, 3277, 3282, 3278
1767, 3278, 3283, 3279
1768, 3279, 3284, 80
*ELEMENT, type=T3D3, ELSET=Line173
1769, 80, 3308, 3285
1770, 3285, 3309, 3286
1771, 3286, 3310, 3287
1772, 3287, 3311, 3288
1773, 3288, 3312, 3289
1774, 3289, 3313, 3290
1775, 3290, 3314, 3291
1776, 3291, 3315, 3292
1777, 3292, 3316, 3293
1778, 3293, 3317, 3294
1779, 3294, 3318, 3295
1780, 3295, 3319, 3296
1781, 3296, 3320, 3297
1782, 3297, 3321, 3298
1783, 3298, 3322, 3299
1784, 3299, 3323, 3300
1785, 3300, 3324, 3301
1786, 3301, 3325, 3302
1787, 3302, 3326, 3303
1788, 3303, 3327, 3304
1789, 3304, 3328, 3305
1790, 3305, 3329, 3306
1791, 3306, 3330, 3307
1792, 3307, 3331, 79
*ELEMENT, type=T3D3, ELSET=Line174
1793, 78, 3343, 3332
1794, 3332, 3344, 3333
1795, 3333, 3345, 3334
1796, 3334, 3346, 3335
1797, 3335, 3347, 3336
1798, 3336, 3348, 3337
1799, 3337, 3349, 3338
1800, 3338, 3350, 3339
1801, 3339, 3351, 3340
1802, 3340, 3352, 3341
1803, 3341, 3353, 3342
1804, 3342, 3354, 80
*ELEMENT, type=T3D3, ELSET=Line175
1805, 26, 3359, 3355
1806, 3355, 3360, 3356
1807, 3356, 3361, 3357
1808, 3357, 3362, 3358
1809, 3358, 3363, 81
*ELEMENT, type=T3D3, ELSET=Line176
1810, 79, 3368, 3364
1811, 3364, 3369, 3365
1812, 3365, 3370, 3366
1813, 3366, 3371, 3367
1814, 3367, 3372, 81
*ELEMENT, type=T3D3, ELSET=Line177
1815, 28, 3377, 3373
1816, 3373, 3378, 3374
1817, 3374, 3379, 3375
1818, 3375, 3380, 3376
1819, 3376, 3381, 82
*ELEMENT, type=T3D3, ELSET=Line178
1820, 77, 3386, 3382
1821, 3382, 3387, 3383
1822, 3383, 3388, 3384
1823, 3384, 3389, 3385
1824, 3385, 3390, 82
*ELEMENT, type=T3D3, ELSET=Line179
1825, 82, 3402, 3391
1826, 3391, 3403, 3392
1827, 3392, 3404, 3393
1828, 3393, 3405, 3394
1829, 3394, 3406, 3395
1830, 3395, 3407, 3396
1831, 3396, 3408, 3397
1832, 3397, 3409, 3398
1833, 3398, 3410, 3399
1834, 3399, 3411, 3400
1835, 3400, 3412, 3401
1836, 3401, 3413, 81
*ELEMENT, type=T3D3, ELSET=Line180
1837, 30, 3418, 3414
1838, 3414, 3419, 3415
1839, 3415, 3420, 3416
1840, 3416, 3421, 3417
1841, 3417, 3422, 83
*ELEMENT, type=T3D3, ELSET=Line181
1842, 81, 3446, 3423
1843, 3423, 3447, 3424
1844, 3424, 3448, 3425
1845, 3425, 3449, 3426
1846, 3426, 3450, 3427
1847, 3427, 3451, 3428
1848, 3428, 3452, 3429
1849, 3429, 3453, 3430
1850, 3430, 3454, 3431
1851, 3431, 3455, 3432
1852, 3432, 3456, 3433
1853, 3433, 3457, 3434
1854, 3434, 3458, 3435
1855, 3435, 3459, 3436
1856, 3436, 3460, 3437
1857, 3437, 3461, 3438
1858, 3438, 3462, 3439
1859, 3439, 3463, 3440
1860, 3440, 3464, 3441
1861, 3441, 3465, 3442
1862, 3442, 3466, 3443
1863, 3443, 3467, 3444
1864, 3444, 3468, 3445
1865, 3445, 3469, 83
*ELEMENT, type=T3D3, ELSET=Line182
1866, 32, 3474, 3470
1867, 3470, 3475, 3471
1868, 3471, 3476, 3472
1869, 3472, 3477, 3473
1870, 3473, 3478, 84
*ELEMENT, type=T3D3, ELSET=Line183
1871, 82, 3502, 3479
1872, 3479, 3503, 3480
1873, 3480, 3504, 3481
1874, 3481, 3505, 3482
1875, 3482, 3506, 3483
1876, 3483, 3507, 3484
1877, 3484, 3508, 3485
1878, 3485, 3509, 3486
1879, 3486, 3510, 3487
1880, 3487, 3511, 3488
1881, 3488, 3512, 3489
1882, 3489, 3513, 3490
1883, 3490, 3514, 3491
1884, 3491, 3515, 3492
1885, 3492, 3516, 3493
1886, 3493, 3517, 3494
1887, 3494, 3518, 3495
1888, 3495, 3519, 3496
1889, 3496, 3520, 3497
1890, 3497, 3521, 3498
1891, 3498, 3522, 3499
1892, 3499, 3523, 3500
1893, 3500, 3524, 3501
1894, 3501, 3525, 84
*ELEMENT, type=T3D3, ELSET=Line184
1895, 84, 3537, 3526
1896, 3526, 3538, 3527
1897, 3527, 3539, 3528
1898, 3528, 3540, 3529
1899, 3529, 3541, 3530
1900, 3530, 3542, 3531
1901, 3531, 3543, 3532
1902, 3532, 3544, 3533
1903, 3533, 3545, 3534
1904, 3534, 3546, 3535
1905, 3535, 3547, 3536
1906, 3536, 3548, 83
*ELEMENT, type=T3D3, ELSET=Line185
1907, 6, 3553, 3549
1908, 3549, 3554, 3550
1909, 3550, 3555, 3551
1910, 3551, 3556, 3552
1911, 3552, 3557, 85
*ELEMENT, type=T3D3, ELSET=Line186
1912, 2, 3562, 3558
1913, 3558, 3563, 3559
1914, 3559, 3564, 3560
1915, 3560, 3565, 3561
1916, 3561, 3566, 86
*ELEMENT, type=T3D3, ELSET=Line187
1917, 86, 3590, 3567
1918, 3567, 3591, 3568
1919, 3568, 3592, 3569
1920, 3569, 3593, 3570
1921, 3570, 3594, 3571
1922, 3571, 3595, 3572
1923, 3572, 3596, 3573
1924, 3573, 3597, 3574
1925, 3574, 3598, 3575
1926, 3575, 3599, 3576
1927, 3576, 3600, 3577
1928, 3577, 3601, 3578
1929, 3578, 3602, 3579
1930, 3579, 3603, 3580
1931, 3580, 3604, 3581
1932, 3581, 3605, 3582
1933, 3582, 3606, 3583
1934, 3583, 3607, 3584
1935, 3584, 3608, 3585
1936, 3585, 3609, 3586
1937, 3586, 3610, 3587
1938, 3587, 3611, 3588
1939, 3588, 3612, 3589
1940, 3589, 3613, 85
*ELEMENT, type=T3D3, ELSET=Line188
1941, 5, 3618, 3614
1942, 3614, 3619, 3615
1943, 3615, 3620, 3616
1944, 3616, 3621, 3617
1945, 3617, 3622, 87
*ELEMENT, type=T3D3, ELSET=Line189
1946, 85, 3634, 3623
1947, 3623, 3635, 3624
1948, 3624, 3636, 3625
1949, 3625, 3637, 3626
1950, 3626, 3638, 3627
1951, 3627, 3639, 3628
1952, 3628, 3640, 3629
1953, 3629, 3641, 3630
1954, 3630, 3642, 3631
1955, 3631, 3643, 3632
1956, 3632, 3644, 3633
1957, 3633, 3645, 87
*ELEMENT, type=T3D3, ELSET=Line190
1958, 1, 3650, 3646
1959, 3646, 3651, 3647
1960, 3647, 3652, 3648
1961, 3648, 3653, 3649
1962, 3649, 3654, 88
*ELEMENT, type=T3D3, ELSET=Line191
1963, 88, 3678, 3655
1964, 3655, 3679, 3656
1965, 3656, 3680, 3657
1966, 3657, 3681, 3658
1967, 3658, 3682, 3659
1968, 3659, 3683, 3660
1969, 3660, 3684, 3661
1970, 3661, 3685, 3662
1971, 3662, 3686, 3663
1972, 3663, 3687, 3664
1973, 3664, 3688, 3665
1974, 3665, 3689, 3666
1975, 3666, 3690, 3667
1976, 3667, 3691, 3668
1977, 3668, 3692, 3669
1978, 3669, 3693, 3670
1979, 3670, 3694, 3671
1980, 3671, 3695, 3672
1981, 3672, 3696, 3673
1982, 3673, 3697, 3674
1983, 3674, 3698, 3675
1984, 3675, 3699, 3676
1985, 3676, 3700, 3677
1986, 3677, 3701, 87
*ELEMENT, type=T3D3, ELSET=Line192
1987, 86, 3713, 3702
1988, 3702, 3714, 3703
1989, 3703, 3715, 3704
1990, 3704, 3716, 3705
1991, 3705, 3717, 3706
1992, 3706, 3718, 3707
1993, 3707, 3719, 3708
1994, 3708, 3720, 3709
1995, 3709, 3721, 3710
1996, 3710, 3722, 3711
1997, 3711, 3723, 3712
1998, 3712, 3724, 88
*ELEMENT, type=T3D3, ELSET=Line193
1999, 53, 3729, 3725
2000, 3725, 3730, 3726
2001, 3726, 3731, 3727
2002, 3727, 3732, 3728
2003, 3728, 3733, 89
*ELEMENT, type=T3D3, ELSET=Line194
2004, 88, 3734, 89
*ELEMENT, type=T3D3, ELSET=Line195
2005, 54, 3739, 3735
2006, 3735, 3740, 3736
2007, 3736, 3741, 3737
2008, 3737, 3742, 3738
2009, 3738, 3743, 90
*ELEMENT, type=T3D3, ELSET=Line196
2010, 86, 3744, 90
*ELEMENT, type=T3D3, ELSET=Line197
2011, 90, 3756, 3745
2012, 3745, 3757, 3746
2013, 3746, 3758, 3747
2014, 3747, 3759, 3748
2015, 3748, 3760, 3749
2016, 3749, 3761, 3750
2017, 3750, 3762, 3751
2018, 3751, 3763, 3752
2019, 3752, 3764, 3753
2020, 3753, 3765, 3754
2021, 3754, 3766, 3755
2022, 3755, 3767, 89
*ELEMENT, type=T3D3, ELSET=Line198
2023, 45, 3772, 3768
2024, 3768, 3773, 3769
2025, 3769, 3774, 3770
2026, 3770, 3775, 3771
2027, 3771, 3776, 91
*ELEMENT, type=T3D3, ELSET=Line199
2028, 46, 3781, 3777
2029, 3777, 3782, 3778
2030, 3778, 3783, 3779
2031, 3779, 3784, 3780
2032, 3780, 3785, 92
*ELEMENT, type=T3D3, ELSET=Line200
2033, 91, 3809, 3786
2034, 3786, 3810, 3787
2035, 3787, 3811, 3788
2036, 3788, 3812, 3789
2037, 3789, 3813, 3790
2038, 3790, 3814, 3791
2039, 3791, 3815, 3792
2040, 3792, 3816, 3793
2041, 3793, 3817, 3794
2042, 3794, 3818, 3795
2043, 3795, 3819, 3796
2044, 3796, 3820, 3797
2045, 3797, 3821, 3798
2046, 3798, 3822, 3799
2047, 3799, 3823, 3800
2048, 3800, 3824, 3801
2049, 3801, 3825, 3802
2050, 3802, 3826, 3803
2051, 3803, 3827, 3804
2052, 3804, 3828, 3805
2053, 3805, 3829, 3806
2054, 3806, 3830, 3807
2055, 3807, 3831, 3808
2056, 3808, 3832, 92
*ELEMENT, type=T3D3, ELSET=Line201
2057, 47, 3837, 3833
2058, 3833, 3838, 3834
2059, 3834, 3839, 3835
2060, 3835, 3840, 3836
2061, 3836, 3841, 93
*ELEMENT, type=T3D3, ELSET=Line202
2062, 48, 3846, 3842
2063, 3842, 3847, 3843
2064, 3843, 3848, 3844
2065, 3844, 3849, 3845
2066, 3845, 3850, 94
*ELEMENT, type=T3D3, ELSET=Line203
2067, 93, 3874, 3851
2068, 3851, 3875, 3852
2069, 3852, 3876, 3853
2070, 3853, 3877, 3854
2071, 3854, 3878, 3855
2072, 3855, 3879, 3856
2073, 3856, 3880, 3857
2074, 3857, 3881, 3858
2075, 3858, 3882, 3859
2076, 3859, 3883, 3860
2077, 3860, 3884, 3861
2078, 3861, 3885, 3862
2079, 3862, 3886, 3863
2080, 3863, 3887, 3864
2081, 3864, 3888, 3865
2082, 3865, 3889, 3866
2083, 3866, 3890, 3867
2084, 3867, 3891, 3868
2085, 3868, 3892, 3869
2086, 3869, 3893, 3870
2087, 3870, 3894, 3871
2088, 3871, 3895, 3872
2089, 3872, 3896, 3873
2090, 3873, 3897, 94
*ELEMENT, type=T3D3, ELSET=Line204
2091, 93, 3909, 3898
2092, 3898, 3910, 3899
2093, 3899, 3911, 3900
2094, 3900, 3912, 3901
2095, 3901, 3913, 3902
2096, 3902, 3914, 3903
2097, 3903, 3915, 3904
2098, 3904, 3916, 3905
2099, 3905, 3917, 3906
2100, 3906, 3918, 3907
2101, 3907, 3919, 3908
2102, 3908, 3920, 91
*ELEMENT, type=T3D3, ELSET=Line205
2103, 94, 3932, 3921
2104, 3921, 3933, 3922
2105, 3922, 3934, 3923
2106, 3923, 3935, 3924
2107, 3924, 3936, 3925
2108, 3925, 3937, 3926
2109, 3926, 3938, 3927
2110, 3927, 3939, 3928
2111, 3928, 3940, 3929
2112, 3929, 3941, 3930
2113, 3930, 3942, 3931
2114, 3931, 3943, 92
*ELEMENT, type=T3D3, ELSET=Line206
2115, 50, 3948, 3944
2116, 3944, 3949, 3945
2117, 3945, 3950, 3946
2118, 3946, 3951, 3947
2119, 3947, 3952, 95
*ELEMENT, type=T3D3, ELSET=Line207
2120, 92, 3953, 95
*ELEMENT, type=T3D3, ELSET=Line208
2121, 52, 3958, 3954
2122, 3954, 3959, 3955
2123, 3955, 3960, 3956
2124, 3956, 3961, 3957
2125, 3957, 3962, 96
*ELEMENT, type=T3D3, ELSET=Line209
2126, 94, 3963, 96
*ELEMENT, type=T3D3, ELSET=Line210
2127, 96, 3975, 3964
2128, 3964, 3976, 3965
2129, 3965, 3977, 3966
2130, 3966, 3978, 3967
2131, 3967, 3979, 3968
2132, 3968, 3980, 3969
2133, 3969, 3981, 3970
2134, 3970, 3982, 3971
2135, 3971, 3983, 3972
2136, 3972, 3984, 3973
2137, 3973, 3985, 3974
2138, 3974, 3986, 95
*ELEMENT, type=CPS8, ELSET=Surface1
2139, 2, 97, 3987, 148, 108, 4009, 4010, 150
2140, 148, 3987, 3988, 149, 4010, 4011, 4012, 151
2141, 149, 3988, 125, 4, 4012, 4013, 136, 152
2142, 97, 98, 3989, 3987, 109, 4014, 4015, 4009
2143, 3987, 3989, 3990, 3988, 4015, 4016, 4017, 4011
2144, 3988, 3990, 126, 125, 4017, 4018, 137, 4013
2145, 98, 99, 3991, 3989, 110, 4019, 4020, 4014
2146, 3989, 3991, 3992, 3990, 4020, 4021, 4022, 4016
2147, 3990, 3992, 127, 126, 4022, 4023, 138, 4018
2148, 99, 100, 3993, 3991, 111, 4024, 4025, 4019
2149, 3991, 3993, 3994, 3992, 4025, 4026, 4027, 4021
2150, 3992, 3994, 128, 127, 4027, 4028, 139, 4023
2151, 100, 101, 3995, 3993, 112, 4029, 4030, 4024
2152, 3993, 3995, 3996, 3994, 4030, 4031, 4032, 4026
2153, 3994, 3996, 129, 128, 4032, 4033, 140, 4028
2154, 101, 102, 3997, 3995, 113, 4034, 4035, 4029
2155, 3995, 3997, 3998, 3996, 4035, 4036, 4037, 4031
2156, 3996, 3998, 130, 129, 4037, 4038, 141, 4033
2157, 102, 103, 3999, 3997, 114, 4039, 4040, 4034
2158, 3997, 3999, 4000, 3998, 4040, 4041, 4042, 4036
2159, 3998, 4000, 131, 130, 4042, 4043, 142, 4038
2160, 103, 104, 4001, 3999, 115, 4044, 4045, 4039
2161, 3999, 4001, 4002, 4000, 4045, 4046, 4047, 4041
2162, 4000, 4002, 132, 131, 4047, 4048, 143, 4043
2163, 104, 105, 4003, 4001, 116, 4049, 4050, 4044
2164, 4001, 4003, 4004, 4002, 4050, 4051, 4052, 4046
2165, 4002, 4004, 133, 132, 4052, 4053, 144, 4048
2166, 105, 106, 4005, 4003, 117, 4054, 4055, 4049
2167, 4003, 4005, 4006, 4004, 4055, 4056, 4057, 4051
2168, 4004, 4006, 134, 133, 4057, 4058, 145, 4053
2169, 106, 107, 4007, 4005, 118, 4059, 4060, 4054
2170, 4005, 4007, 4008, 4006, 4060, 4061, 4062, 4056
2171, 4006, 4008, 135, 134, 4062, 4063, 146, 4058
2172, 107, 1, 120, 4007, 119, 122, 4064, 4059
2173, 4007, 120, 121, 4008, 4064, 123, 4065, 4061
2174, 4008, 121, 3, 135, 4065, 124, 147, 4063
*ELEMENT, type=CPS8, ELSET=Surface2
2175, 6, 204, 4066, 153, 206, 4088, 4089, 164
2176, 204, 205, 4067, 4066, 207, 4090, 4091, 4088
2177, 205, 8, 181, 4067, 208, 192, 4092, 4090
2178, 153, 4066, 4068, 154, 4089, 4093, 4094, 165
2179, 4066, 4067, 4069, 4068, 4091, 4095, 4096, 4093
2180, 4067, 181, 182, 4069, 4092, 193, 4097, 4095
2181, 154, 4068, 4070, 155, 4094, 4098, 4099, 166
2182, 4068, 4069, 4071, 4070, 4096, 4100, 4101, 4098
2183, 4069, 182, 183, 4071, 4097, 194, 4102, 4100
2184, 155, 4070, 4072, 156, 4099, 4103, 4104, 167
2185, 4070, 4071, 4073, 4072, 4101, 4105, 4106, 4103
2186, 4071, 183, 184, 4073, 4102, 195, 4107, 4105
2187, 156, 4072, 4074, 157, 4104, 4108, 4109, 168
2188, 4072, 4073, 4075, 4074, 4106, 4110, 4111, 4108
2189, 4073, 184, 185, 4075, 4107, 196, 4112, 4110
2190, 157, 4074, 4076, 158, 4109, 4113, 4114, 169
2191, 4074, 4075, 4077, 4076, 4111, 4115, 4116, 4113
2192, 4075, 185, 186, 4077, 4112, 197, 4117, 4115
2193, 158, 4076, 4078, 159, 4114, 4118, 4119, 170
2194, 4076, 4077, 4079, 4078, 4116, 4120, 4121, 4118
2195, 4077, 186, 187, 4079, 4117, 198, 4122, 4120
2196, 159, 4078, 4080, 160, 4119, 4123, 4124, 171
2197, 4078, 4079, 4081, 4080, 4121, 4125, 4126, 4123
2198, 4079, 187, 188, 4081, 4122, 199, 4127, 4125
2199, 160, 4080, 4082, 161, 4124, 4128, 4129, 172
2200, 4080, 4081, 4083, 4082, 4126, 4130, 4131, 4128
2201, 4081, 188, 189, 4083, 4127, 200, 4132, 4130
2202, 161, 4082, 4084, 162, 4129, 4133, 4134, 173
2203, 4082, 4083, 4085, 4084, 4131, 4135, 4136, 4133
2204, 4083, 189, 190, 4085, 4132, 201, 4137, 4135
2205, 162, 4084, 4086, 163, 4134, 4138, 4139, 174
2206, 4084, 4085, 4087, 4086, 4136, 4140, 4141, 4138
2207, 4085, 190, 191, 4087, 4137, 202, 4142, 4140
2208, 163, 4086, 176, 5, 4139, 4143, 178, 175
2209, 4086, 4087, 177, 176, 4141, 4144, 179, 4143
2210, 4087, 191, 7, 177, 4142, 203, 180, 4144
*ELEMENT, type=CPS8, ELSET=Surface3
2211, 2, 209, 4145, 97, 232, 4398, 4399, 108
2212, 97, 4145, 4146, 98, 4399, 4400, 4401, 109
2213, 98, 4146, 4147, 99, 4401, 4402, 4403, 110
2214, 99, 4147, 4148, 100, 4403, 4404, 4405, 111
2215, 100, 4148, 4149, 101, 4405, 4406, 4407, 112
2216, 101, 4149, 4150, 102, 4407, 4408, 4409, 113
2217, 102, 4150, 4151, 103, 4409, 4410, 4411, 114
2218, 103, 4151, 4152, 104, 4411, 4412, 4413, 115
2219, 104, 4152, 4153, 105, 4413, 4414, 4415, 116
2220, 105, 4153, 4154, 106, 4415, 4416, 4417, 117
2221, 106, 4154, 4155, 107, 4417, 4418, 4419, 118
2222, 107, 4155, 256, 1, 4419, 4420, 279, 119
2223, 209, 210, 4156, 4145, 233, 4421, 4422, 4398
2224, 4145, 4156, 4157, 4146, 4422, 4423, 4424, 4400
2225, 4146, 4157, 4158, 4147, 4424, 4425, 4426, 4402
2226, 4147, 4158, 4159, 4148, 4426, 4427, 4428, 4404
2227, 4148, 4159, 4160, 4149, 4428, 4429, 4430, 4406
2228, 4149, 4160, 4161, 4150, 4430, 4431, 4432, 4408
2229, 4150, 4161, 4162, 4151, 4432, 4433, 4434, 4410
2230, 4151, 4162, 4163, 4152, 4434, 4435, 4436, 4412
2231, 4152, 4163, 4164, 4153, 4436, 4437, 4438, 4414
2232, 4153, 4164, 4165, 4154, 4438, 4439, 4440, 4416
2233, 4154, 4165, 4166, 4155, 4440, 4441, 4442, 4418
2234, 4155, 4166, 257, 256, 4442, 4443, 280, 4420
2235, 210, 211, 4167, 4156, 234, 4444, 4445, 4421
2236, 4156, 4167, 4168, 4157, 4445, 4446, 4447, 4423
2237, 4157, 4168, 4169, 4158, 4447, 4448, 4449, 4425
2238, 4158, 4169, 4170, 4159, 4449, 4450, 4451, 4427
2239, 4159, 4170, 4171, 4160, 4451, 4452, 4453, 4429
2240, 4160, 4171, 4172, 4161, 4453, 4454, 4455, 4431
2241, 4161, 4172, 4173, 4162, 4455, 4456, 4457, 4433
2242, 4162, 4173, 4174, 4163, 4457, 4458, 4459, 4435
2243, 4163, 4174, 4175, 4164, 4459, 4460, 4461, 4437
2244, 4164, 4175, 4176, 4165, 4461, 4462, 4463, 4439
2245, 4165, 4176, 4177, 4166, 4463, 4464, 4465, 4441
2246, 4166, 4177, 258, 257, 4465, 4466, 281, 4443
2247, 211, 212, 4178, 4167, 235, 4467, 4468, 4444
2248, 4167, 4178, 4179, 4168, 4468, 4469, 4470, 4446
2249, 4168, 4179, 4180, 4169, 4470, 4471, 4472, 4448
2250, 4169, 4180, 4181, 4170, 4472, 4473, 4474, 4450
2251, 4170, 4181, 4182, 4171, 4474, 4475, 4476, 4452
2252, 4171, 4182, 4183, 4172, 4476, 4477, 4478, 4454
2253, 4172, 4183, 4184, 4173, 4478, 4479, 4480, 4456
2254, 4173, 4184, 4185, 4174, 4480, 4481, 4482, 4458
2255, 4174, 4185, 4186, 4175, 4482, 4483, 4484, 4460
2256, 4175, 4186, 4187, 4176, 4484, 4485, 4486, 4462
2257, 4176, 4187, 4188, 4177, 4486, 4487, 4488, 4464
2258, 4177, 4188, 259, 258, 4488, 4489, 282, 4466
2259, 212, 213, 4189, 4178, 236, 4490, 4491, 4467
2260, 4178, 4189, 4190, 4179, 4491, 4492, 4493, 4469
2261, 4179, 4190, 4191, 4180, 4493, 4494, 4495, 4471
2262, 4180, 4191, 4192, 4181, 4495, 4496, 4497, 4473
2263, 4181, 4192, 4193, 4182, 4497, 4498, 4499, 4475
2264, 4182, 4193, 4194, 4183, 4499, 4500, 4501, 4477
2265, 4183, 4194, 4195, 4184, 4501, 4502, 4503, 4479
2266, 4184, 4195, 4196, 4185, 4503, 4504, 4505, 4481
2267, 4185, 4196, 4197, 4186, 4505, 4506, 4507, 4483
2268, 4186, 4197, 4198, 4187, 4507, 4508, 4509, 4485
2269, 4187, 4198, 4199, 4188, 4509, 4510, 4511, 4487
2270, 4188, 4199, 260, 259, 4511, 4512, 283, 4489
2271, 213, 214, 4200, 4189, 237, 4513, 4514, 4490
2272, 4189, 4200, 4201, 4190, 4514, 4515, 4516, 4492
2273, 4190, 4201, 4202, 4191, 4516, 4517, 4518, 4494
2274, 4191, 4202, 4203, 4192, 4518, 4519, 4520, 4496
2275, 4192, 4203, 4204, 4193, 4520, 4521, 4522, 4498
2276, 4193, 4204, 4205, 4194, 4522, 4523, 4524, 4500
2277, 4194, 4205, 4206, 4195, 4524, 4525, 4526, 4502
2278, 4195, 4206, 4207, 4196, 4526, 4527, 4528, 4504
2279, 4196, 4207, 4208, 4197, 4528, 4529, 4530, 4506
2280, 4197, 4208, 4209, 4198, 4530, 4531, 4532, 4508
2281, 4198, 4209, 4210, 4199, 4532, 4533, 4534, 4510
2282, 4199, 4210, 261, 260, 4534, 4535, 284, 4512
2283, 214, 215, 4211, 4200, 238, 4536, 4537, 4513
2284, 4200, 4211, 4212, 4201, 4537, 4538, 4539, 4515
2285, 4201, 4212, 4213, 4202, 4539, 4540, 4541, 4517
2286, 4202, 4213, 4214, 4203, 4541, 4542, 4543, 4519
2287, 4203, 4214, 4215, 4204, 4543, 4544, 4545, 4521
2288, 4204, 4215, 4216, 4205, 4545, 4546, 4547, 4523
2289, 4205, 4216, 4217, 4206, 4547, 4548, 4549, 4525
2290, 4206, 4217, 4218, 4207, 4549, 4550, 4551, 4527
2291, 4207, 4218, 4219, 4208, 4551, 4552, 4553, 4529
2292, 4208, 4219, 4220, 4209, 4553, 4554, 4555, 4531
2293, 4209, 4220, 4221, 4210, 4555, 4556, 4557, 4533
2294, 4210, 4221, 262, 261, 4557, 4558, 285, 4535
2295, 215, 216, 4222, 4211, 239, 4559, 4560, 4536
2296, 4211, 4222, 4223, 4212, 4560, 4561, 4562, 4538
2297, 4212, 4223, 4224, 4213, 4562, 4563, 4564, 4540
2298, 4213, 4224, 4225, 4214, 4564, 4565, 4566, 4542
2299, 4214, 4225, 4226, 4215, 4566, 4567, 4568, 4544
2300, 4215, 4226, 4227, 4216, 4568, 4569, 4570, 4546
2301, 4216, 4227, 4228, 4217, 4570, 4571, 4572, 4548
2302, 4217, 4228, 4229, 4218, 4572, 4573, 4574, 4550
2303, 4218, 4229, 4230, 4219, 4574, 4575, 4576, 4552
2304, 4219, 4230, 4231, 4220, 4576, 4577, 4578, 4554
2305, 4220, 4231, 4232, 4221, 4578, 4579, 4580, 4556
2306, 4221, 4232, 263, 262, 4580, 4581, 286, 4558
2307, 216, 217, 4233, 4222, 240, 4582, 4583, 4559
2308, 4222, 4233, 4234, 4223, 4583, 4584, 4585, 4561
2309, 4223, 4234, 4235, 4224, 4585, 4586, 4587, 4563
2310, 4224, 4235, 4236, 4225, 4587, 4588, 4589, 4565
2311, 4225, 4236, 4237, 4226, 4589, 4590, 4591, 4567
2312, 4226, 4237, 4238, 4227, 4591, 4592, 4593, 4569
2313, 4227, 4238, 4239, 4228, 4593, 4594, 4595, 4571
2314, 4228, 4239, 4240, 4229, 4595, 4596, 4597, 4573
2315, 4229, 4240, 4241, 4230, 4597, 4598, 4599, 4575
2316, 4230, 4241, 4242, 4231, 4599, 4600, 4601, 4577
2317, 4231, 4242, 4243, 4232, 4601, 4602, 4603, 4579
2318, 4232, 4243, 264, 263, 4603, 4604, 287, 4581
2319, 217, 218, 4244, 4233, 241, 4605, 4606, 4582
2320, 4233, 4244, 4245, 4234, 4606, 4607, 4608, 4584
2321, 4234, 4245, 4246, 4235, 4608, 4609, 4610, 4586
2322, 4235, 4246, 4247, 4236, 4610, 4611, 4612, 4588
2323, 4236, 4247, 4248, 4237, 4612, 4613, 4614, 4590
2324, 4237, 4248, 4249, 4238, 4614, 4615, 4616, 4592
2325, 4238, 4249, 4250, 4239, 4616, 4617, 4618, 4594
2326, 4239, 4250, 4251, 4240, 4618, 4619, 4620, 4596
2327, 4240, 4251, 4252, 4241, 4620, 4621, 4622, 4598
2328, 4241, 4252, 4253, 4242, 4622, 4623, 4624, 4600
2329, 4242, 4253, 4254, 4243, 4624, 4625, 4626, 4602
2330, 4243, 4254, 265, 264, 4626, 4627, 288, 4604
2331, 218, 219, 4255, 4244, 242, 4628, 4629, 4605
2332, 4244, 4255, 4256, 4245, 4629, 4630, 4631, 4607
2333, 4245, 4256, 4257, 4246, 4631, 4632, 4633, 4609
2334, 4246, 4257, 4258, 4247, 4633, 4634, 4635, 4611
2335, 4247, 4258, 4259, 4248, 4635, 4636, 4637, 4613
2336, 4248, 4259, 4260, 4249, 4637, 4638, 4639, 4615
2337, 4249, 4260, 4261, 4250, 4639, 4640, 4641, 4617
2338, 4250, 4261, 4262, 4251, 4641, 4642, 4643, 4619
2339, 4251, 4262, 4263, 4252, 4643, 4644, 4645, 4621
2340, 4252, 4263, 4264, 4253, 4645, 4646, 4647, 4623
2341, 4253, 4264, 4265, 4254, 4647, 4648, 4649, 4625
2342, 4254, 4265, 266, 265, 4649, 4650, 289, 4627
2343, 219, 220, 4266, 4255, 243, 4651, 4652, 4628
2344, 4255, 4266, 4267, 4256, 4652, 4653, 4654, 4630
2345, 4256, 4267, 4268, 4257, 4654, 4655, 4656, 4632
2346, 4257, 4268, 4269, 4258, 4656, 4657, 4658, 4634
2347, 4258, 4269, 4270, 4259, 4658, 4659, 4660, 4636
2348, 4259, 4270, 4271, 4260, 4660, 4661, 4662, 4638
2349, 4260, 4271, 4272, 4261, 4662, 4663, 4664, 4640
2350, 4261, 4272, 4273, 4262, 4664, 4665, 4666, 4642
2351, 4262, 4273, 4274, 4263, 4666, 4667, 4668, 4644
2352, 4263, 4274, 4275, 4264, 4668, 4669, 4670, 4646
2353, 4264, 4275, 4276, 4265, 4670, 4671, 4672, 4648
2354, 4265, 4276, 267, 266, 4672, 4673, 290, 4650
2355, 220, 221, 4277, 4266, 244, 4674, 4675, 4651
2356, 4266, 4277, 4278, 4267, 4675, 4676, 4677, 4653
2357, 4267, 4278, 4279, 4268, 4677, 4678, 4679, 4655
2358, 4268, 4279, 4280, 4269, 4679, 4680, 4681, 4657
2359, 4269, 4280, 4281, 4270, 4681, 4682, 4683, 4659
2360, 4270, 4281, 4282, 4271, 4683, 4684, 4685, 4661
2361, 4271, 4282, 4283, 4272, 4685, 4686, 4687, 4663
2362, 4272, 4283, 4284, 4273, 4687, 4688, 4689, 4665
2363, 4273, 4284, 4285, 4274, 4689, 4690, 4691, 4667
2364, 4274, 4285, 4286, 4275, 4691, 4692, 4693, 4669
2365, 4275, 4286, 4287, 4276, 4693, 4694, 4695, 4671
2366, 4276, 4287, 268, 267, 4695, 4696, 291, 4673
2367, 221, 222, 4288, 4277, 245, 4697, 4698, 4674
2368, 4277, 4288, 4289, 4278, 4698, 4699, 4700, 4676
2369, 4278, 4289, 4290, 4279, 4700, 4701, 4702, 4678
2370, 4279, 4290, 4291, 4280, 4702, 4703, 4704, 4680
2371, 4280, 4291, 4292, 4281, 4704, 4705, 4706, 4682
2372, 4281, 4292, 4293, 4282, 4706, 4707, 4708, 4684
2373, 4282, 4293, 4294, 4283, 4708, 4709, 4710, 4686
2374, 4283, 4294, 4295, 4284, 4710, 4711, 4712, 4688
2375, 4284, 4295, 4296, 4285, 4712, 4713, 4714, 4690
2376, 4285, 4296, 4297, 4286, 4714, 4715, 4716, 4692
2377, 4286, 4297, 4298, 4287, 4716, 4717, 4718, 4694
2378, 4287, 4298, 269, 268, 4718, 4719, 292, 4696
2379, 222, 223, 4299, 4288, 246, 4720, 4721, 4697
2380, 4288, 4299, 4300, 4289, 4721, 4722, 4723, 4699
2381, 4289, 4300, 4301, 4290, 4723, 4724, 4725, 4701
2382, 4290, 4301, 4302, 4291, 4725, 4726, 4727, 4703
2383, 4291, 4302, 4303, 4292, 4727, 4728, 4729, 4705
2384, 4292, 4303, 4304, 4293, 4729, 4730, 4731, 4707
2385, 4293, 4304, 4305, 4294, 4731, 4732, 4733, 4709
2386, 4294, 4305, 4306, 4295, 4733, 4734, 4735, 4711
2387, 4295, 4306, 4307, 4296, 4735, 4736, 4737, 4713
2388, 4296, 4307, 4308, 4297, 4737, 4738, 4739, 4715
2389, 4297, 4308, 4309, 4298, 4739, 4740, 4741, 4717
2390, 4298, 4309, 270, 269, 4741, 4742, 293, 4719
2391, 223, 224, 4310, 4299, 247, 4743, 4744, 4720
2392, 4299, 4310, 4311, 4300, 4744, 4745, 4746, 4722
2393, 4300, 4311, 4312, 4301, 4746, 4747, 4748, 4724
2394, 4301, 4312, 4313, 4302, 4748, 4749, 4750, 4726
2395, 4302, 4313, 4314, 4303, 4750, 4751, 4752, 4728
2396, 4303, 4314, 4315, 4304, 4752, 4753, 4754, 4730
2397, 4304, 4315, 4316, 4305, 4754, 4755, 4756, 4732
2398, 4305, 4316, 4317, 4306, 4756, 4757, 4758, 4734
2399, 4306, 4317, 4318, 4307, 4758, 4759, 4760, 4736
2400, 4307, 4318, 4319, 4308, 4760, 4761, 4762, 4738
2401, 4308, 4319, 4320, 4309, 4762, 4763, 4764, 4740
2402, 4309, 4320, 271, 270, 4764, 4765, 294, 4742
2403, 224, 225, 4321, 4310, 248, 4766, 4767, 4743
2404, 4310, 4321, 4322, 4311, 4767, 4768, 4769, 4745
2405, 4311, 4322, 4323, 4312, 4769, 4770, 4771, 4747
2406, 4312, 4323, 4324, 4313, 4771, 4772, 4773, 4749
2407, 4313, 4324, 4325, 4314, 4773, 4774, 4775, 4751
2408, 4314, 4325, 4326, 4315, 4775, 4776, 4777, 4753
2409, 4315, 4326, 4327, 4316, 4777, 4778, 4779, 4755
2410, 4316, 4327, 4328, 4317, 4779, 4780, 4781, 4757
2411, 4317, 4328, 4329, 4318, 4781, 4782, 4783, 4759
2412, 4318, 4329, 4330, 4319, 4783, 4784, 4785, 4761
2413, 4319, 4330, 4331, 4320, 4785, 4786, 4787, 4763
2414, 4320, 4331, 272, 271, 4787, 4788, 295, 4765
2415, 225, 226, 4332, 4321, 249, 4789, 4790, 4766
2416, 4321, 4332, 4333, 4322, 4790, 4791, 4792, 4768
2417, 4322, 4333, 4334, 4323, 4792, 4793, 4794, 4770
2418, 4323, 4334, 4335, 4324, 4794, 4795, 4796, 4772
2419, 4324, 4335, 4336, 4325, 4796, 4797, 4798, 4774
2420, 4325, 4336, 4337, 4326, 4798, 4799, 4800, 4776
2421, 4326, 4337, 4338, 4327, 4800, 4801, 4802, 4778
2422, 4327, 4338, 4339, 4328, 4802, 4803, 4804, 4780
2423, 4328, 4339, 4340, 4329, 4804, 4805, 4806, 4782
2424, 4329, 4340, 4341, 4330, 4806, 4807, 4808, 4784
2425, 4330, 4341, 4342, 4331, 4808, 4809, 4810, 4786
2426, 4331, 4342, 273, 272, 4810, 4811, 296, 4788
2427, 226, 227, 4343, 4332, 250, 4812, 4813, 4789
2428, 4332, 4343, 4344, 4333, 4813, 4814, 4815, 4791
2429, 4333, 4344, 4345, 4334, 4815, 4816, 4817, 4793
2430, 4334, 4345, 4346, 4335, 4817, 4818, 4819, 4795
2431, 4335, 4346, 4347, 4336, 4819, 4820, 4821, 4797
2432, 4336, 4347, 4348, 4337, 4821, 4822, 4823, 4799
2433, 4337, 4348, 4349, 4338, 4823, 4824, 4825, 4801
2434, 4338, 4349, 4350, 4339, 4825, 4826, 4827, 4803
2435, 4339, 4350, 4351, 4340, 4827, 4828, 4829, 4805
2436, 4340, 4351, 4352, 4341, 4829, 4830, 4831, 4807
2437, 4341, 4352, 4353, 4342, 4831, 4832, 4833, 4809
2438, 4342, 4353, 274, 273, 4833, 4834, 297, 4811
2439, 227, 228, 4354, 4343, 251, 4835, 4836, 4812
2440, 4343, 4354, 4355, 4344, 4836, 4837, 4838, 4814
2441, 4344, 4355, 4356, 4345, 4838, 4839, 4840, 4816
2442, 4345, 4356, 4357, 4346, 4840, 4841, 4842, 4818
2443, 4346, 4357, 4358, 4347, 4842, 4843, 4844, 4820
2444, 4347, 4358, 4359, 4348, 4844, 4845, 4846, 4822
2445, 4348, 4359, 4360, 4349, 4846, 4847, 4848, 4824
2446, 4349, 4360, 4361, 4350, 4848, 4849, 4850, 4826
2447, 4350, 4361, 4362, 4351, 4850, 4851, 4852, 4828
2448, 4351, 4362, 4363, 4352, 4852, 4853, 4854, 4830
2449, 4352, 4363, 4364, 4353, 4854, 4855, 4856, 4832
2450, 4353, 4364, 275, 274, 4856, 4857, 298, 4834
2451, 228, 229, 4365, 4354, 252, 4858, 4859, 4835
2452, 4354, 4365, 4366, 4355, 4859, 4860, 4861, 4837
2453, 4355, 4366, 4367, 4356, 4861, 4862, 4863, 4839
2454, 4356, 4367, 4368, 4357, 4863, 4864, 4865, 4841
2455, 4357, 4368, 4369, 4358, 4865, 4866, 4867, 4843
2456, 4358, 4369, 4370, 4359, 4867, 4868, 4869, 4845
2457, 4359, 4370, 4371, 4360, 4869, 4870, 4871, 4847
2458, 4360, 4371, 4372, 4361, 4871, 4872, 4873, 4849
2459, 4361, 4372, 4373, 4362, 4873, 4874, 4875, 4851
2460, 4362, 4373, 4374, 4363, 4875, 4876, 4877, 4853
2461, 4363, 4374, 4375, 4364, 4877, 4878, 4879, 4855
2462, 4364, 4375, 276, 275, 4879, 4880, 299, 4857
2463, 229, 230, 4376, 4365, 253, 4881, 4882, 4858
2464, 4365, 4376, 4377, 4366, 4882, 4883, 4884, 4860
2465, 4366, 4377, 4378, 4367, 4884, 4885, 4886, 4862
2466, 4367, 4378, 4379, 4368, 4886, 4887, 4888, 4864
2467, 4368, 4379, 4380, 4369, 4888, 4889, 4890, 4866
2468, 4369, 4380, 4381, 4370, 4890, 4891, 4892, 4868
2469, 4370, 4381, 4382, 4371, 4892, 4893, 4894, 4870
2470, 4371, 4382, 4383, 4372, 4894, 4895, 4896, 4872
2471, 4372, 4383, 4384, 4373, 4896, 4897, 4898, 4874
2472, 4373, 4384, 4385, 4374, 4898, 4899, 4900, 4876
2473, 4374, 4385, 4386, 4375, 4900, 4901, 4902, 4878
2474, 4375, 4386, 277, 276, 4902, 4903, 300, 4880
2475, 230, 231, 4387, 4376, 254, 4904, 4905, 4881
2476, 4376, 4387, 4388, 4377, 4905, 4906, 4907, 4883
2477, 4377, 4388, 4389, 4378, 4907, 4908, 4909, 4885
2478, 4378, 4389, 4390, 4379, 4909, 4910, 4911, 4887
2479, 4379, 4390, 4391, 4380, 4911, 4912, 4913, 4889
2480, 4380, 4391, 4392, 4381, 4913, 4914, 4915, 4891
2481, 4381, 4392, 4393, 4382, 4915, 4916, 4917, 4893
2482, 4382, 4393, 4394, 4383, 4917, 4918, 4919, 4895
2483, 4383, 4394, 4395, 4384, 4919, 4920, 4921, 4897
2484, 4384, 4395, 4396, 4385, 4921, 4922, 4923, 4899
2485, 4385, 4396, 4397, 4386, 4923, 4924, 4925, 4901
2486, 4386, 4397, 278, 277, 4925, 4926, 301, 4903
2487, 231, 6, 153, 4387, 255, 164, 4927, 4904
2488, 4387, 153, 154, 4388, 4927, 165, 4928, 4906
2489, 4388, 154, 155, 4389, 4928, 166, 4929, 4908
2490, 4389, 155, 156, 4390, 4929, 167, 4930, 4910
2491, 4390, 156, 157, 4391, 4930, 168, 4931, 4912
2492, 4391, 157, 158, 4392, 4931, 169, 4932, 4914
2493, 4392, 158, 159, 4393, 4932, 170, 4933, 4916
2494, 4393, 159, 160, 4394, 4933, 171, 4934, 4918
2495, 4394, 160, 161, 4395, 4934, 172, 4935, 4920
2496, 4395, 161, 162, 4396, 4935, 173, 4936, 4922
2497, 4396, 162, 163, 4397, 4936, 174, 4937, 4924
2498, 4397, 163, 5, 278, 4937, 175, 302, 4926
*ELEMENT, type=CPS8, ELSET=Surface4
2499, 4, 125, 4938, 303, 136, 5191, 5192, 326
2500, 125, 126, 4939, 4938, 137, 5193, 5194, 5191
2501, 126, 127, 4940, 4939, 138, 5195, 5196, 5193
2502, 127, 128, 4941, 4940, 139, 5197, 5198, 5195
2503, 128, 129, 4942, 4941, 140, 5199, 5200, 5197
2504, 129, 130, 4943, 4942, 141, 5201, 5202, 5199
2505, 130, 131, 4944, 4943, 142, 5203, 5204, 5201
2506, 131, 132, 4945, 4944, 143, 5205, 5206, 5203
2507, 132, 133, 4946, 4945, 144, 5207, 5208, 5205
2508, 133, 134, 4947, 4946, 145, 5209, 5210, 5207
2509, 134, 135, 4948, 4947, 146, 5211, 5212, 5209
2510, 135, 3, 350, 4948, 147, 373, 5213, 5211
2511, 303, 4938, 4949, 304, 5192, 5214, 5215, 327
2512, 4938, 4939, 4950, 4949, 5194, 5216, 5217, 5214
2513, 4939, 4940, 4951, 4950, 5196, 5218, 5219, 5216
2514, 4940, 4941, 4952, 4951, 5198, 5220, 5221, 5218
2515, 4941, 4942, 4953, 4952, 5200, 5222, 5223, 5220
2516, 4942, 4943, 4954, 4953, 5202, 5224, 5225, 5222
2517, 4943, 4944, 4955, 4954, 5204, 5226, 5227, 5224
2518, 4944, 4945, 4956, 4955, 5206, 5228, 5229, 5226
2519, 4945, 4946, 4957, 4956, 5208, 5230, 5231, 5228
2520, 4946, 4947, 4958, 4957, 5210, 5232, 5233, 5230
2521, 4947, 4948, 4959, 4958, 5212, 5234, 5235, 5232
2522, 4948, 350, 351, 4959, 5213, 374, 5236, 5234
2523, 304, 4949, 4960, 305, 5215, 5237, 5238, 328
2524, 4949, 4950, 4961, 4960, 5217, 5239, 5240, 5237
2525, 4950, 4951, 4962, 4961, 5219, 5241, 5242, 5239
2526, 4951, 4952, 4963, 4962, 5221, 5243, 5244, 5241
2527, 4952, 4953, 4964, 4963, 5223, 5245, 5246, 5243
2528, 4953, 4954, 4965, 4964, 5225, 5247, 5248, 5245
2529, 4954, 4955, 4966, 4965, 5227, 5249, 5250, 5247
2530, 4955, 4956, 4967, 4966, 5229, 5251, 5252, 5249
2531, 4956, 4957, 4968, 4967, 5231, 5253, 5254, 5251
2532, 4957, 4958, 4969, 4968, 5233, 5255, 5256, 5253
2533, 4958, 4959, 4970, 4969, 5235, 5257, 5258, 5255
2534, 4959, 351, 352, 4970, 5236, 375, 5259, 5257
2535, 305, 4960, 4971, 306, 5238, 5260, 5261, 329
2536, 4960, 4961, 4972, 4971, 5240, 5262, 5263, 5260
2537, 4961, 4962, 4973, 4972, 5242, 5264, 5265, 5262
2538, 4962, 4963, 4974, 4973, 5244, 5266, 5267, 5264
2539, 4963, 4964, 4975, 4974, 5246, 5268, 5269, 5266
2540, 4964, 4965, 4976, 4975, 5248, 5270, 5271, 5268
2541, 4965, 4966, 4977, 4976, 5250, 5272, 5273, 5270
2542, 4966, 4967, 4978, 4977, 5252, 5274, 5275, 5272
2543, 4967, 4968, 4979, 4978, 5254, 5276, 5277, 5274
2544, 4968, 4969, 4980, 4979, 5256, 5278, 5279, 5276
2545, 4969, 4970, 4981, 4980, 5258, 5280, 5281, 5278
2546, 4970, 352, 353, 4981, 5259, 376, 5282, 5280
2547, 306, 4971, 4982, 307, 5261, 5283, 5284, 330
2548, 4971, 4972, 4983, 4982, 5263, 5285, 5286, 5283
2549, 4972, 4973, 4984, 4983, 5265, 5287, 5288, 5285
2550, 4973, 4974, 4985, 4984, 5267, 5289, 5290, 5287
2551, 4974, 4975, 4986, 4985, 5269, 5291, 5292, 5289
2552, 4975, 4976, 4987, 4986, 5271, 5293, 5294, 5291
2553, 4976, 4977, 4988, 4987, 5273, 5295, 5296, 5293
2554, 4977, 4978, 4989, 4988, 5275, 5297, 5298, 5295
2555, 4978, 4979, 4990, 4989, 5277, 5299, 5300, 5297
2556, 4979, 4980, 4991, 4990, 5279, 5301, 5302, 5299
2557, 4980, 4981, 4992, 4991, 5281, 5303, 5304, 5301
2558, 4981, 353, 354, 4992, 5282, 377, 5305, 5303
2559, 307, 4982, 4993, 308, 5284, 5306, 5307, 331
2560, 4982, 4983, 4994, 4993, 5286, 5308, 5309, 5306
2561, 4983, 4984, 4995, 4994, 5288, 5310, 5311, 5308
2562, 4984, 4985, 4996, 4995, 5290, 5312, 5313, 5310
2563, 4985, 4986, 4997, 4996, 5292, 5314, 5315, 5312
2564, 4986, 4987, 4998, 4997, 5294, 5316, 5317, 5314
2565, 4987, 4988, 4999, 4998, 5296, 5318, 5319, 5316
2566, 4988, 4989, 5000, 4999, 5298, 5320, 5321, 5318
2567, 4989, 4990, 5001, 5000, 5300, 5322, 5323, 5320
2568, 4990, 4991, 5002, 5001, 5302, 5324, 5325, 5322
2569, 4991, 4992, 5003, 5002, 5304, 5326, 5327, 5324
2570, 4992, 354, 355, 5003, 5305, 378, 5328, 5326
2571, 308, 4993, 5004, 309, 5307, 5329, 5330, 332
2572, 4993, 4994, 5005, 5004, 5309, 5331, 5332, 5329
2573, 4994, 4995, 5006, 5005, 5311, 5333, 5334, 5331
2574, 4995, 4996, 5007, 5006, 5313, 5335, 5336, 5333
2575, 4996, 4997, 5008, 5007, 5315, 5337, 5338, 5335
2576, 4997, 4998, 5009, 5008, 5317, 5339, 5340, 5337
2577, 4998, 4999, 5010, 5009, 5319, 5341, 5342, 5339
2578, 4999, 5000, 5011, 5010, 5321, 5343, 5344, 5341
2579, 5000, 5001, 5012, 5011, 5323, 5345, 5346, 5343
2580, 5001, 5002, 5013, 5012, 5325, 5347, 5348, 5345
2581, 5002, 5003, 5014, 5013, 5327, 5349, 5350, 5347
2582, 5003, 355, 356, 5014, 5328, 379, 5351, 5349
2583, 309, 5004, 5015, 310, 5330, 5352, 5353, 333
2584, 5004, 5005, 5016, 5015, 5332, 5354, 5355, 5352
2585, 5005, 5006, 5017, 5016, 5334, 5356, 5357, 5354
2586, 5006, 5007, 5018, 5017, 5336, 5358, 5359, 5356
2587, 5007, 5008, 5019, 5018, 5338, 5360, 5361, 5358
2588, 5008, 5009, 5020, 5019, 5340, 5362, 5363, 5360
2589, 5009, 5010, 5021, 5020, 5342, 5364, 5365, 5362
2590, 5010, 5011, 5022, 5021, 5344, 5366, 5367, 5364
2591, 5011, 5012, 5023, 5022, 5346, 5368, 5369, 5366
2592, 5012, 5013, 5024, 5023, 5348, 5370, 5371, 5368
2593, 5013, 5014, 5025, 5024, 5350, 5372, 5373, 5370
2594, 5014, 356, 357, 5025, 5351, 380, 5374, 5372
2595, 310, 5015, 5026, 311, 5353, 5375, 5376, 334
2596, 5015, 5016, 5027, 5026, 5355, 5377, 5378, 5375
2597, 5016, 5017, 5028, 5027, 5357, 5379, 5380, 5377
2598, 5017, 5018, 5029, 5028, 5359, 5381, 5382, 5379
2599, 5018, 5019, 5030, 5029, 5361, 5383, 5384, 5381
2600, 5019, 5020, 5031, 5030, 5363, 5385, 5386, 5383
2601, 5020, 5021, 5032, 5031, 5365, 5387, 5388, 5385
2602, 5021, 5022, 5033, 5032, 5367, 5389, 5390, 5387
2603, 5022, 5023, 5034, 5033, 5369, 5391, 5392, 5389
2604, 5023, 5024, 5035, 5034, 5371, 5393, 5394, 5391
2605, 5024, 5025, 5036, 5035, 5373, 5395, 5396, 5393
2606, 5025, 357, 358, 5036, 5374, 381, 5397, 5395
2607, 311, 5026, 5037, 312, 5376, 5398, 5399, 335
2608, 5026, 5027, 5038, 5037, 5378, 5400, 5401, 5398
2609, 5027, 5028, 5039, 5038, 5380, 5402, 5403, 5400
2610, 5028, 5029, 5040, 5039, 5382, 5404, 5405, 5402
2611, 5029, 5030, 5041, 5040, 5384, 5406, 5407, 5404
2612, 5030, 5031, 5042, 5041, 5386, 5408, 5409, 5406
2613, 5031, 5032, 5043, 5042, 5388, 5410, 5411, 5408
2614, 5032, 5033, 5044, 5043, 5390, 5412, 5413, 5410
2615, 5033, 5034, 5045, 5044, 5392, 5414, 5415, 5412
2616, 5034, 5035, 5046, 5045, 5394, 5416, 5417, 5414
2617, 5035, 5036, 5047, 5046, 5396, 5418, 5419, 5416
2618, 5036, 358, 359, 5047, 5397, 382, 5420, 5418
2619, 312, 5037, 5048, 313, 5399, 5421, 5422, 336
2620, 5037, 5038, 5049, 5048, 5401, 5423, 5424, 5421
2621, 5038, 5039, 5050, 5049, 5403, 5425, 5426, 5423
2622, 5039, 5040, 5051, 5050, 5405, 5427, 5428, 5425
2623, 5040, 5041, 5052, 5051, 5407, 5429, 5430, 5427
2624, 5041, 5042, 5053, 5052, 5409, 5431, 5432, 5429
2625, 5042, 5043, 5054, 5053, 5411, 5433, 5434, 5431
2626, 5043, 5044, 5055, 5054, 5413, 5435, 5436, 5433
2627, 5044, 5045, 5056, 5055, 5415, 5437, 5438, 5435
2628, 5045, 5046, 5057, 5056, 5417, 5439, 5440, 5437
2629, 5046, 5047, 5058, 5057, 5419, 5441, 5442, 5439
2630, 5047, 359, 360, 5058, 5420, 383, 5443, 5441
2631, 313, 5048, 5059, 314, 5422, 5444, 5445, 337
2632, 5048, 5049, 5060, 5059, 5424, 5446, 5447, 5444
2633, 5049, 5050, 5061, 5060, 5426, 5448, 5449, 5446
2634, 5050, 5051, 5062, 5061, 5428, 5450, 5451, 5448
2635, 5051, 5052, 5063, 5062, 5430, 5452, 5453, 5450
2636, 5052, 5053, 5064, 5063, 5432, 5454, 5455, 5452
2637, 5053, 5054, 5065, 5064, 5434, 5456, 5457, 5454
2638, 5054, 5055, 5066, 5065, 5436, 5458, 5459, 5456
2639, 5055, 5056, 5067, 5066, 5438, 5460, 5461, 5458
2640, 5056, 5057, 5068, 5067, 5440, 5462, 5463, 5460
2641, 5057, 5058, 5069, 5068, 5442, 5464, 5465, 5462
2642, 5058, 360, 361, 5069, 5443, 384, 5466, 5464
2643, 314, 5059, 5070, 315, 5445, 5467, 5468, 338
2644, 5059, 5060, 5071, 5070, 5447, 5469, 5470, 5467
2645, 5060, 5061, 5072, 5071, 5449, 5471, 5472, 5469
2646, 5061, 5062, 5073, 5072, 5451, 5473, 5474, 5471
2647, 5062, 5063, 5074, 5073, 5453, 5475, 5476, 5473
2648, 5063, 5064, 5075, 5074, 5455, 5477, 5478, 5475
2649, 5064, 5065, 5076, 5075, 5457, 5479, 5480, 5477
2650, 5065, 5066, 5077, 5076, 5459, 5481, 5482, 5479
2651, 5066, 5067, 5078, 5077, 5461, 5483, 5484, 5481
2652, 5067, 5068, 5079, 5078, 5463, 5485, 5486, 5483
2653, 5068, 5069, 5080, 5079, 5465, 5487, 5488, 5485
2654, 5069, 361, 362, 5080, 5466, 385, 5489, 5487
2655, 315, 5070, 5081, 316, 5468, 5490, 5491, 339
2656, 5070, 5071, 5082, 5081, 5470, 5492, 5493, 5490
2657, 5071, 5072, 5083, 5082, 5472, 5494, 5495, 5492
2658, 5072, 5073, 5084, 5083, 5474, 5496, 5497, 5494
2659, 5073, 5074, 5085, 5084, 5476, 5498, 5499, 5496
2660, 5074, 5075, 5086, 5085, 5478, 5500, 5501, 5498
2661, 5075, 5076, 5087, 5086, 5480, 5502, 5503, 5500
2662, 5076, 5077, 5088, 5087, 5482, 5504, 5505, 5502
2663, 5077, 5078, 5089, 5088, 5484, 5506, 5507, 5504
2664, 5078, 5079, 5090, 5089, 5486, 5508, 5509, 5506
2665, 5079, 5080, 5091, 5090, 5488, 5510, 5511, 5508
2666, 5080, 362, 363, 5091, 5489, 386, 5512, 5510
2667, 316, 5081, 5092, 317, 5491, 5513, 5514, 340
2668, 5081, 5082, 5093, 5092, 5493, 5515, 5516, 5513
2669, 5082, 5083, 5094, 5093, 5495, 5517, 5518, 5515
2670, 5083, 5084, 5095, 5094, 5497, 5519, 5520, 5517
2671, 5084, 5085, 5096, 5095, 5499, 5521, 5522, 5519
2672, 5085, 5086, 5097, 5096, 5501, 5523, 5524, 5521
2673, 5086, 5087, 5098, 5097, 5503, 5525, 5526, 5523
2674, 5087, 5088, 5099, 5098, 5505, 5527, 5528, 5525
2675, 5088, 5089, 5100, 5099, 5507, 5529, 5530, 5527
2676, 5089, 5090, 5101, 5100, 5509, 5531, 5532, 5529
2677, 5090, 5091, 5102, 5101, 5511, 5533, 5534, 5531
2678, 5091, 363, 364, 5102, 5512, 387, 5535, 5533
2679, 317, 5092, 5103, 318, 5514, 5536, 5537, 341
2680, 5092, 5093, 5104, 5103, 5516, 5538, 5539, 5536
2681, 5093, 5094, 5105, 5104, 5518, 5540, 5541, 5538
2682, 5094, 5095, 5106, 5105, 5520, 5542, 5543, 5540
2683, 5095, 5096, 5107, 5106, 5522, 5544, 5545, 5542
2684, 5096, 5097, 5108, 5107, 5524, 5546, 5547, 5544
2685, 5097, 5098, 5109, 5108, 5526, 5548, 5549, 5546
2686, 5098, 5099, 5110, 5109, 5528, 5550, 5551, 5548
2687, 5099, 5100, 5111, 5110, 5530, 5552, 5553, 5550
2688, 5100, 5101, 5112, 5111, 5532, 5554, 5555, 5552
2689, 5101, 5102, 5113, 5112, 5534, 5556, 5557, 5554
2690, 5102, 364, 365, 5113, 5535, 388, 5558, 5556
2691, 318, 5103, 5114, 319, 5537, 5559, 5560, 342
2692, 5103, 5104, 5115, 5114, 5539, 5561, 5562, 5559
2693, 5104, 5105, 5116, 5115, 5541, 5563, 5564, 5561
2694, 5105, 5106, 5117, 5116, 5543, 5565, 5566, 5563
2695, 5106, 5107, 5118, 5117, 5545, 5567, 5568, 5565
2696, 5107, 5108, 5119, 5118, 5547, 5569, 5570, 5567
2697, 5108, 5109, 5120, 5119, 5549, 5571, 5572, 5569
2698, 5109, 5110, 5121, 5120, 5551, 5573, 5574, 5571
2699, 5110, 5111, 5122, 5121, 5553, 5575, 5576, 5573
2700, 5111, 5112, 5123, 5122, 5555, 5577, 5578, 5575
2701, 5112, 5113, 5124, 5123, 5557, 5579, 5580, 5577
2702, 5113, 365, 366, 5124, 5558, 389, 5581, 5579
2703, 319, 5114, 5125, 320, 5560, 5582, 5583, 343
2704, 5114, 5115, 5126, 5125, 5562, 5584, 5585, 5582
2705, 5115, 5116, 5127, 5126, 5564, 5586, 5587, 5584
2706, 5116, 5117, 5128, 5127, 5566, 5588, 5589, 5586
2707, 5117, 5118, 5129, 5128, 5568, 5590, 5591, 5588
2708, 5118, 5119, 5130, 5129, 5570, 5592, 5593, 5590
2709, 5119, 5120, 5131, 5130, 5572, 5594, 5595, 5592
2710, 5120, 5121, 5132, 5131, 5574, 5596, 5597, 5594
2711, 5121, 5122, 5133, 5132, 5576, 5598, 5599, 5596
2712, 5122, 5123, 5134, 5133, 5578, 5600, 5601, 5598
2713, 5123, 5124, 5135, 5134, 5580, 5602, 5603, 5600
2714, 5124, 366, 367, 5135, 5581, 390, 5604, 5602
2715, 320, 5125, 5136, 321, 5583, 5605, 5606, 344
2716, 5125, 5126, 5137, 5136, 5585, 5607, 5608, 5605
2717, 5126, 5127, 5138, 5137, 5587, 5609, 5610, 5607
2718, 5127, 5128, 5139, 5138, 5589, 5611, 5612, 5609
2719, 5128, 5129, 5140, 5139, 5591, 5613, 5614, 5611
2720, 5129, 5130, 5141, 5140, 5593, 5615, 5616, 5613
2721, 5130, 5131, 5142, 5141, 5595, 5617, 5618, 5615
2722, 5131, 5132, 5143, 5142, 5597, 5619, 5620, 5617
2723, 5132, 5133, 5144, 5143, 5599, 5621, 5622, 5619
2724, 5133, 5134, 5145, 5144, 5601, 5623, 5624, 5621
2725, 5134, 5135, 5146, 5145, 5603, 5625, 5626, 5623
2726, 5135, 367, 368, 5146, 5604, 391, 5627, 5625
2727, 321, 5136, 5147, 322, 5606, 5628, 5629, 345
2728, 5136, 5137, 5148, 5147, 5608, 5630, 5631, 5628
2729, 5137, 5138, 5149, 5148, 5610, 5632, 5633, 5630
2730, 5138, 5139, 5150, 5149, 5612, 5634, 5635, 5632
2731, 5139, 5140, 5151, 5150, 5614, 5636, 5637, 5634
2732, 5140, 5141, 5152, 5151, 5616, 5638, 5639, 5636
2733, 5141, 5142, 5153, 5152, 5618, 5640, 5641, 5638
2734, 5142, 5143, 5154, 5153, 5620, 5642, 5643, 5640
2735, 5143, 5144, 5155, 5154, 5622, 5644, 5645, 5642
2736, 5144, 5145, 5156, 5155, 5624, 5646, 5647, 5644
2737, 5145, 5146, 5157, 5156, 5626, 5648, 5649, 5646
2738, 5146, 368, 369, 5157, 5627, 392, 5650, 5648
2739, 322, 5147, 5158, 323, 5629, 5651, 5652, 346
2740, 5147, 5148, 5159, 5158, 5631, 5653, 5654, 5651
2741, 5148, 5149, 5160, 5159, 5633, 5655, 5656, 5653
2742, 5149, 5150, 5161, 5160, 5635, 5657, 5658, 5655
2743, 5150, 5151, 5162, 5161, 5637, 5659, 5660, 5657
2744, 5151, 5152, 5163, 5162, 5639, 5661, 5662, 5659
2745, 5152, 5153, 5164, 5163, 5641, 5663, 5664, 5661
2746, 5153, 5154, 5165, 5164, 5643, 5665, 5666, 5663
2747, 5154, 5155, 5166, 5165, 5645, 5667, 5668, 5665
2748, 5155, 5156, 5167, 5166, 5647, 5669, 5670, 5667
2749, 5156, 5157, 5168, 5167, 5649, 5671, 5672, 5669
2750, 5157, 369, 370, 5168, 5650, 393, 5673, 5671
2751, 323, 5158, 5169, 324, 5652, 5674, 5675, 347
2752, 5158, 5159, 5170, 5169, 5654, 5676, 5677, 5674
2753, 5159, 5160, 5171, 5170, 5656, 5678, 5679, 5676
2754, 5160, 5161, 5172, 5171, 5658, 5680, 5681, 5678
2755, 5161, 5162, 5173, 5172, 5660, 5682, 5683, 5680
2756, 5162, 5163, 5174, 5173, 5662, 5684, 5685, 5682
2757, 5163, 5164, 5175, 5174, 5664, 5686, 5687, 5684
2758, 5164, 5165, 5176, 5175, 5666, 5688, 5689, 5686
2759, 5165, 5166, 5177, 5176, 5668, 5690, 5691, 5688
2760, 5166, 5167, 5178, 5177, 5670, 5692, 5693, 5690
2761, 5167, 5168, 5179, 5178, 5672, 5694, 5695, 5692
2762, 5168, 370, 371, 5179, 5673, 394, 5696, 5694
2763, 324, 5169, 5180, 325, 5675, 5697, 5698, 348
2764, 5169, 5170, 5181, 5180, 5677, 5699, 5700, 5697
2765, 5170, 5171, 5182, 5181, 5679, 5701, 5702, 5699
2766, 5171, 5172, 5183, 5182, 5681, 5703, 5704, 5701
2767, 5172, 5173, 5184, 5183, 5683, 5705, 5706, 5703
2768, 5173, 5174, 5185, 5184, 5685, 5707, 5708, 5705
2769, 5174, 5175, 5186, 5185, 5687, 5709, 5710, 5707
2770, 5175, 5176, 5187, 5186, 5689, 5711, 5712, 5709
2771, 5176, 5177, 5188, 5187, 5691, 5713, 5714, 5711
2772, 5177, 5178, 5189, 5188, 5693, 5715, 5716, 5713
2773, 5178, 5179, 5190, 5189, 5695, 5717, 5718, 5715
2774, 5179, 371, 372, 5190, 5696, 395, 5719, 5717
2775, 325, 5180, 181, 8, 5698, 5720, 192, 349
2776, 5180, 5181, 182, 181, 5700, 5721, 193, 5720
2777, 5181, 5182, 183, 182, 5702, 5722, 194, 5721
2778, 5182, 5183, 184, 183, 5704, 5723, 195, 5722
2779, 5183, 5184, 185, 184, 5706, 5724, 196, 5723
2780, 5184, 5185, 186, 185, 5708, 5725, 197, 5724
2781, 5185, 5186, 187, 186, 5710, 5726, 198, 5725
2782, 5186, 5187, 188, 187, 5712, 5727, 199, 5726
2783, 5187, 5188, 189, 188, 5714, 5728, 200, 5727
2784, 5188, 5189, 190, 189, 5716, 5729, 201, 5728
2785, 5189, 5190, 191, 190, 5718, 5730, 202, 5729
2786, 5190, 372, 7, 191, 5719, 396, 203, 5730
*ELEMENT, type=CPS8, ELSET=Surface5
2787, 2, 148, 5731, 209, 150, 5777, 5778, 232
2788, 209, 5731, 5732, 210, 5778, 5779, 5780, 233
2789, 210, 5732, 5733, 211, 5780, 5781, 5782, 234
2790, 211, 5733, 5734, 212, 5782, 5783, 5784, 235
2791, 212, 5734, 5735, 213, 5784, 5785, 5786, 236
2792, 213, 5735, 5736, 214, 5786, 5787, 5788, 237
2793, 214, 5736, 5737, 215, 5788, 5789, 5790, 238
2794, 215, 5737, 5738, 216, 5790, 5791, 5792, 239
2795, 216, 5738, 5739, 217, 5792, 5793, 5794, 240
2796, 217, 5739, 5740, 218, 5794, 5795, 5796, 241
2797, 218, 5740, 5741, 219, 5796, 5797, 5798, 242
2798, 219, 5741, 5742, 220, 5798, 5799, 5800, 243
2799, 220, 5742, 5743, 221, 5800, 5801, 5802, 244
2800, 221, 5743, 5744, 222, 5802, 5803, 5804, 245
2801, 222, 5744, 5745, 223, 5804, 5805, 5806, 246
2802, 223, 5745, 5746, 224, 5806, 5807, 5808, 247
2803, 224, 5746, 5747, 225, 5808, 5809, 5810, 248
2804, 225, 5747, 5748, 226, 5810, 5811, 5812, 249
2805, 226, 5748, 5749, 227, 5812, 5813, 5814, 250
2806, 227, 5749, 5750, 228, 5814, 5815, 5816, 251
2807, 228, 5750, 5751, 229, 5816, 5817, 5818, 252
2808, 229, 5751, 5752, 230, 5818, 5819, 5820, 253
2809, 230, 5752, 5753, 231, 5820, 5821, 5822, 254
2810, 231, 5753, 204, 6, 5822, 5823, 206, 255
2811, 148, 149, 5754, 5731, 151, 5824, 5825, 5777
2812, 5731, 5754, 5755, 5732, 5825, 5826, 5827, 5779
2813, 5732, 5755, 5756, 5733, 5827, 5828, 5829, 5781
2814, 5733, 5756, 5757, 5734, 5829, 5830, 5831, 5783
2815, 5734, 5757, 5758, 5735, 5831, 5832, 5833, 5785
2816, 5735, 5758, 5759, 5736, 5833, 5834, 5835, 5787
2817, 5736, 5759, 5760, 5737, 5835, 5836, 5837, 5789
2818, 5737, 5760, 5761, 5738, 5837, 5838, 5839, 5791
2819, 5738, 5761, 5762, 5739, 5839, 5840, 5841, 5793
2820, 5739, 5762, 5763, 5740, 5841, 5842, 5843, 5795
2821, 5740, 5763, 5764, 5741, 5843, 5844, 5845, 5797
2822, 5741, 5764, 5765, 5742, 5845, 5846, 5847, 5799
2823, 5742, 5765, 5766, 5743, 5847, 5848, 5849, 5801
2824, 5743, 5766, 5767, 5744, 5849, 5850, 5851, 5803
2825, 5744, 5767, 5768, 5745, 5851, 5852, 5853, 5805
2826, 5745, 5768, 5769, 5746, 5853, 5854, 5855, 5807
2827, 5746, 5769, 5770, 5747, 5855, 5856, 5857, 5809
2828, 5747, 5770, 5771, 5748, 5857, 5858, 5859, 5811
2829, 5748, 5771, 5772, 5749, 5859, 5860, 5861, 5813
2830, 5749, 5772, 5773, 5750, 5861, 5862, 5863, 5815
2831, 5750, 5773, 5774, 5751, 5863, 5864, 5865, 5817
2832, 5751, 5774, 5775, 5752, 5865, 5866, 5867, 5819
2833, 5752, 5775, 5776, 5753, 5867, 5868, 5869, 5821
2834, 5753, 5776, 205, 204, 5869, 5870, 207, 5823
2835, 149, 4, 303, 5754, 152, 326, 5871, 5824
2836, 5754, 303, 304, 5755, 5871, 327, 5872, 5826
2837, 5755, 304, 305, 5756, 5872, 328, 5873, 5828
2838, 5756, 305, 306, 5757, 5873, 329, 5874, 5830
2839, 5757, 306, 307, 5758, 5874, 330, 5875, 5832
2840, 5758, 307, 308, 5759, 5875, 331, 5876, 5834
2841, 5759, 308, 309, 5760, 5876, 332, 5877, 5836
2842, 5760, 309, 310, 5761, 5877, 333, 5878, 5838
2843, 5761, 310, 311, 5762, 5878, 334, 5879, 5840
2844, 5762, 311, 312, 5763, 5879, 335, 5880, 5842
2845, 5763, 312, 313, 5764, 5880, 336, 5881, 5844
2846, 5764, 313, 314, 5765, 5881, 337, 5882, 5846
2847, 5765, 314, 315, 5766, 5882, 338, 5883, 5848
2848, 5766, 315, 316, 5767, 5883, 339, 5884, 5850
2849, 5767, 316, 317, 5768, 5884, 340, 5885, 5852
2850, 5768, 317, 318, 5769, 5885, 341, 5886, 5854
2851, 5769, 318, 319, 5770, 5886, 342, 5887, 5856
2852, 5770, 319, 320, 5771, 5887, 343, 5888, 5858
2853, 5771, 320, 321, 5772, 5888, 344, 5889, 5860
2854, 5772, 321, 322, 5773, 5889, 345, 5890, 5862
2855, 5773, 322, 323, 5774, 5890, 346, 5891, 5864
2856, 5774, 323, 324, 5775, 5891, 347, 5892, 5866
2857, 5775, 324, 325, 5776, 5892, 348, 5893, 5868
2858, 5776, 325, 8, 205, 5893, 349, 208, 5870
*ELEMENT, type=CPS8, ELSET=Surface6
2859, 1, 256, 5894, 120, 279, 5940, 5941, 122
2860, 256, 257, 5895, 5894, 280, 5942, 5943, 5940
2861, 257, 258, 5896, 5895, 281, 5944, 5945, 5942
2862, 258, 259, 5897, 5896, 282, 5946, 5947, 5944
2863, 259, 260, 5898, 5897, 283, 5948, 5949, 5946
2864, 260, 261, 5899, 5898, 284, 5950, 5951, 5948
2865, 261, 262, 5900, 5899, 285, 5952, 5953, 5950
2866, 262, 263, 5901, 5900, 286, 5954, 5955, 5952
2867, 263, 264, 5902, 5901, 287, 5956, 5957, 5954
2868, 264, 265, 5903, 5902, 288, 5958, 5959, 5956
2869, 265, 266, 5904, 5903, 289, 5960, 5961, 5958
2870, 266, 267, 5905, 5904, 290, 5962, 5963, 5960
2871, 267, 268, 5906, 5905, 291, 5964, 5965, 5962
2872, 268, 269, 5907, 5906, 292, 5966, 5967, 5964
2873, 269, 270, 5908, 5907, 293, 5968, 5969, 5966
2874, 270, 271, 5909, 5908, 294, 5970, 5971, 5968
2875, 271, 272, 5910, 5909, 295, 5972, 5973, 5970
2876, 272, 273, 5911, 5910, 296, 5974, 5975, 5972
2877, 273, 274, 5912, 5911, 297, 5976, 5977, 5974
2878, 274, 275, 5913, 5912, 298, 5978, 5979, 5976
2879, 275, 276, 5914, 5913, 299, 5980, 5981, 5978
2880, 276, 277, 5915, 5914, 300, 5982, 5983, 5980
2881, 277, 278, 5916, 5915, 301, 5984, 5985, 5982
2882, 278, 5, 176, 5916, 302, 178, 5986, 5984
2883, 120, 5894, 5917, 121, 5941, 5987, 5988, 123
2884, 5894, 5895, 5918, 5917, 5943, 5989, 5990, 5987
2885, 5895, 5896, 5919, 5918, 5945, 5991, 5992, 5989
2886, 5896, 5897, 5920, 5919, 5947, 5993, 5994, 5991
2887, 5897, 5898, 5921, 5920, 5949, 5995, 5996, 5993
2888, 5898, 5899, 5922, 5921, 5951, 5997, 5998, 5995
2889, 5899, 5900, 5923, 5922, 5953, 5999, 6000, 5997
2890, 5900, 5901, 5924, 5923, 5955, 6001, 6002, 5999
2891, 5901, 5902, 5925, 5924, 5957, 6003, 6004, 6001
2892, 5902, 5903, 5926, 5925, 5959, 6005, 6006, 6003
2893, 5903, 5904, 5927, 5926, 5961, 6007, 6008, 6005
2894, 5904, 5905, 5928, 5927, 5963, 6009, 6010, 6007
2895, 5905, 5906, 5929, 5928, 5965, 6011, 6012, 6009
2896, 5906, 5907, 5930, 5929, 5967, 6013, 6014, 6011
2897, 5907, 5908, 5931, 5930, 5969, 6015, 6016, 6013
2898, 5908, 5909, 5932, 5931, 5971, 6017, 6018, 6015
2899, 5909, 5910, 5933, 5932, 5973, 6019, 6020, 6017
2900, 5910, 5911, 5934, 5933, 5975, 6021, 6022, 6019
2901, 5911, 5912, 5935, 5934, 5977, 6023, 6024, 6021
2902, 5912, 5913, 5936, 5935, 5979, 6025, 6026, 6023
2903, 5913, 5914, 5937, 5936, 5981, 6027, 6028, 6025
2904, 5914, 5915, 5938, 5937, 5983, 6029, 6030, 6027
2905, 5915, 5916, 5939, 5938, 5985, 6031, 6032, 6029
2906, 5916, 176, 177, 5939, 5986, 179, 6033, 6031
2907, 121, 5917, 350, 3, 5988, 6034, 373, 124
2908, 5917, 5918, 351, 350, 5990, 6035, 374, 6034
2909, 5918, 5919, 352, 351, 5992, 6036, 375, 6035
2910, 5919, 5920, 353, 352, 5994, 6037, 376, 6036
2911, 5920, 5921, 354, 353, 5996, 6038, 377, 6037
2912, 5921, 5922, 355, 354, 5998, 6039, 378, 6038
2913, 5922, 5923, 356, 355, 6000, 6040, 379, 6039
2914, 5923, 5924, 357, 356, 6002, 6041, 380, 6040
2915, 5924, 5925, 358, 357, 6004, 6042, 381, 6041
2916, 5925, 5926, 359, 358, 6006, 6043, 382, 6042
2917, 5926, 5927, 360, 359, 6008, 6044, 383, 6043
2918, 5927, 5928, 361, 360, 6010, 6045, 384, 6044
2919, 5928, 5929, 362, 361, 6012, 6046, 385, 6045
2920, 5929, 5930, 363, 362, 6014, 6047, 386, 6046
2921, 5930, 5931, 364, 363, 6016, 6048, 387, 6047
2922, 5931, 5932, 365, 364, 6018, 6049, 388, 6048
2923, 5932, 5933, 366, 365, 6020, 6050, 389, 6049
2924, 5933, 5934, 367, 366, 6022, 6051, 390, 6050
2925, 5934, 5935, 368, 367, 6024, 6052, 391, 6051
2926, 5935, 5936, 369, 368, 6026, 6053, 392, 6052
2927, 5936, 5937, 370, 369, 6028, 6054, 393, 6053
2928, 5937, 5938, 371, 370, 6030, 6055, 394, 6054
2929, 5938, 5939, 372, 371, 6032, 6056, 395, 6055
2930, 5939, 177, 7, 372, 6033, 180, 396, 6056
*ELEMENT, type=CPS8, ELSET=Surface7
2931, 4, 10, 399, 303, 398, 422, 6057, 326
2932, 303, 399, 400, 304, 6057, 423, 6058, 327
2933, 304, 400, 401, 305, 6058, 424, 6059, 328
2934, 305, 401, 402, 306, 6059, 425, 6060, 329
2935, 306, 402, 403, 307, 6060, 426, 6061, 330
2936, 307, 403, 404, 308, 6061, 427, 6062, 331
2937, 308, 404, 405, 309, 6062, 428, 6063, 332
2938, 309, 405, 406, 310, 6063, 429, 6064, 333
2939, 310, 406, 407, 311, 6064, 430, 6065, 334
2940, 311, 407, 408, 312, 6065, 431, 6066, 335
2941, 312, 408, 409, 313, 6066, 432, 6067, 336
2942, 313, 409, 410, 314, 6067, 433, 6068, 337
2943, 314, 410, 411, 315, 6068, 434, 6069, 338
2944, 315, 411, 412, 316, 6069, 435, 6070, 339
2945, 316, 412, 413, 317, 6070, 436, 6071, 340
2946, 317, 413, 414, 318, 6071, 437, 6072, 341
2947, 318, 414, 415, 319, 6072, 438, 6073, 342
2948, 319, 415, 416, 320, 6073, 439, 6074, 343
2949, 320, 416, 417, 321, 6074, 440, 6075, 344
2950, 321, 417, 418, 322, 6075, 441, 6076, 345
2951, 322, 418, 419, 323, 6076, 442, 6077, 346
2952, 323, 419, 420, 324, 6077, 443, 6078, 347
2953, 324, 420, 421, 325, 6078, 444, 6079, 348
2954, 325, 421, 9, 8, 6079, 445, 397, 349
*ELEMENT, type=CPS8, ELSET=Surface8
2955, 8, 9, 447, 181, 397, 458, 6080, 192
2956, 181, 447, 448, 182, 6080, 459, 6081, 193
2957, 182, 448, 449, 183, 6081, 460, 6082, 194
2958, 183, 449, 450, 184, 6082, 461, 6083, 195
2959, 184, 450, 451, 185, 6083, 462, 6084, 196
2960, 185, 451, 452, 186, 6084, 463, 6085, 197
2961, 186, 452, 453, 187, 6085, 464, 6086, 198
2962, 187, 453, 454, 188, 6086, 465, 6087, 199
2963, 188, 454, 455, 189, 6087, 466, 6088, 200
2964, 189, 455, 456, 190, 6088, 467, 6089, 201
2965, 190, 456, 457, 191, 6089, 468, 6090, 202
2966, 191, 457, 11, 7, 6090, 469, 446, 203
*ELEMENT, type=CPS8, ELSET=Surface9
2967, 3, 350, 471, 12, 373, 6091, 494, 470
2968, 350, 351, 472, 471, 374, 6092, 495, 6091
2969, 351, 352, 473, 472, 375, 6093, 496, 6092
2970, 352, 353, 474, 473, 376, 6094, 497, 6093
2971, 353, 354, 475, 474, 377, 6095, 498, 6094
2972, 354, 355, 476, 475, 378, 6096, 499, 6095
2973, 355, 356, 477, 476, 379, 6097, 500, 6096
2974, 356, 357, 478, 477, 380, 6098, 501, 6097
2975, 357, 358, 479, 478, 381, 6099, 502, 6098
2976, 358, 359, 480, 479, 382, 6100, 503, 6099
2977, 359, 360, 481, 480, 383, 6101, 504, 6100
2978, 360, 361, 482, 481, 384, 6102, 505, 6101
2979, 361, 362, 483, 482, 385, 6103, 506, 6102
2980, 362, 363, 484, 483, 386, 6104, 507, 6103
2981, 363, 364, 485, 484, 387, 6105, 508, 6104
2982, 364, 365, 486, 485, 388, 6106, 509, 6105
2983, 365, 366, 487, 486, 389, 6107, 510, 6106
2984, 366, 367, 488, 487, 390, 6108, 511, 6107
2985, 367, 368, 489, 488, 391, 6109, 512, 6108
2986, 368, 369, 490, 489, 392, 6110, 513, 6109
2987, 369, 370, 491, 490, 393, 6111, 514, 6110
2988, 370, 371, 492, 491, 394, 6112, 515, 6111
2989, 371, 372, 493, 492, 395, 6113, 516, 6112
2990, 372, 7, 11, 493, 396, 446, 517, 6113
*ELEMENT, type=CPS8, ELSET=Surface10
2991, 4, 125, 518, 10, 136, 6114, 529, 398
2992, 125, 126, 519, 518, 137, 6115, 530, 6114
2993, 126, 127, 520, 519, 138, 6116, 531, 6115
2994, 127, 128, 521, 520, 139, 6117, 532, 6116
2995, 128, 129, 522, 521, 140, 6118, 533, 6117
2996, 129, 130, 523, 522, 141, 6119, 534, 6118
2997, 130, 131, 524, 523, 142, 6120, 535, 6119
2998, 131, 132, 525, 524, 143, 6121, 536, 6120
2999, 132, 133, 526, 525, 144, 6122, 537, 6121
3000, 133, 134, 527, 526, 145, 6123, 538, 6122
3001, 134, 135, 528, 527, 146, 6124, 539, 6123
3002, 135, 3, 12, 528, 147, 470, 540, 6124
*ELEMENT, type=CPS8, ELSET=Surface11
3003, 10, 518, 6125, 399, 529, 6378, 6379, 422
3004, 518, 519, 6126, 6125, 530, 6380, 6381, 6378
3005, 519, 520, 6127, 6126, 531, 6382, 6383, 6380
3006, 520, 521, 6128, 6127, 532, 6384, 6385, 6382
3007, 521, 522, 6129, 6128, 533, 6386, 6387, 6384
3008, 522, 523, 6130, 6129, 534, 6388, 6389, 6386
3009, 523, 524, 6131, 6130, 535, 6390, 6391, 6388
3010, 524, 525, 6132, 6131, 536, 6392, 6393, 6390
3011, 525, 526, 6133, 6132, 537, 6394, 6395, 6392
3012, 526, 527, 6134, 6133, 538, 6396, 6397, 6394
3013, 527, 528, 6135, 6134, 539, 6398, 6399, 6396
3014, 528, 12, 471, 6135, 540, 494, 6400, 6398
3015, 399, 6125, 6136, 400, 6379, 6401, 6402, 423
3016, 6125, 6126, 6137, 6136, 6381, 6403, 6404, 6401
3017, 6126, 6127, 6138, 6137, 6383, 6405, 6406, 6403
3018, 6127, 6128, 6139, 6138, 6385, 6407, 6408, 6405
3019, 6128, 6129, 6140, 6139, 6387, 6409, 6410, 6407
3020, 6129, 6130, 6141, 6140, 6389, 6411, 6412, 6409
3021, 6130, 6131, 6142, 6141, 6391, 6413, 6414, 6411
3022, 6131, 6132, 6143, 6142, 6393, 6415, 6416, 6413
3023, 6132, 6133, 6144, 6143, 6395, 6417, 6418, 6415
3024, 6133, 6134, 6145, 6144, 6397, 6419, 6420, 6417
3025, 6134, 6135, 6146, 6145, 6399, 6421, 6422, 6419
3026, 6135, 471, 472, 6146, 6400, 495, 6423, 6421
3027, 400, 6136, 6147, 401, 6402, 6424, 6425, 424
3028, 6136, 6137, 6148, 6147, 6404, 6426, 6427, 6424
3029, 6137, 6138, 6149, 6148, 6406, 6428, 6429, 6426
3030, 6138, 6139, 6150, 6149, 6408, 6430, 6431, 6428
3031, 6139, 6140, 6151, 6150, 6410, 6432, 6433, 6430
3032, 6140, 6141, 6152, 6151, 6412, 6434, 6435, 6432
3033, 6141, 6142, 6153, 6152, 6414, 6436, 6437, 6434
3034, 6142, 6143, 6154, 6153, 6416, 6438, 6439, 6436
3035, 6143, 6144, 6155, 6154, 6418, 6440, 6441, 6438
3036, 6144, 6145, 6156, 6155, 6420, 6442, 6443, 6440
3037, 6145, 6146, 6157, 6156, 6422, 6444, 6445, 6442
3038, 6146, 472, 473, 6157, 6423, 496, 6446, 6444
3039, 401, 6147, 6158, 402, 6425, 6447, 6448, 425
3040, 6147, 6148, 6159, 6158, 6427, 6449, 6450, 6447
3041, 6148, 6149, 6160, 6159, 6429, 6451, 6452, 6449
3042, 6149, 6150, 6161, 6160, 6431, 6453, 6454, 6451
3043, 6150, 6151, 6162, 6161, 6433, 6455, 6456, 6453
3044, 6151, 6152, 6163, 6162, 6435, 6457, 6458, 6455
3045, 6152, 6153, 6164, 6163, 6437, 6459, 6460, 6457
3046, 6153, 6154, 6165, 6164, 6439, 6461, 6462, 6459
3047, 6154, 6155, 6166, 6165, 6441, 6463, 6464, 6461
3048, 6155, 6156, 6167, 6166, 6443, 6465, 6466, 6463
3049, 6156, 6157, 6168, 6167, 6445, 6467, 6468, 6465
3050, 6157, 473, 474, 6168, 6446, 497, 6469, 6467
3051, 402, 6158, 6169, 403, 6448, 6470, 6471, 426
3052, 6158, 6159, 6170, 6169, 6450, 6472, 6473, 6470
3053, 6159, 6160, 6171, 6170, 6452, 6474, 6475, 6472
3054, 6160, 6161, 6172, 6171, 6454, 6476, 6477, 6474
3055, 6161, 6162, 6173, 6172, 6456, 6478, 6479, 6476
3056, 6162, 6163, 6174, 6173, 6458, 6480, 6481, 6478
3057, 6163, 6164, 6175, 6174, 6460, 6482, 6483, 6480
3058, 6164, 6165, 6176, 6175, 6462, 6484, 6485, 6482
3059, 6165, 6166, 6177, 6176, 6464, 6486, 6487, 6484
3060, 6166, 6167, 6178, 6177, 6466, 6488, 6489, 6486
3061, 6167, 6168, 6179, 6178, 6468, 6490, 6491, 6488
3062, 6168, 474, 475, 6179, 6469, 498, 6492, 6490
3063, 403, 6169, 6180, 404, 6471, 6493, 6494, 427
3064, 6169, 6170, 6181, 6180, 6473, 6495, 6496, 6493
3065, 6170, 6171, 6182, 6181, 6475, 6497, 6498, 6495
3066, 6171, 6172, 6183, 6182, 6477, 6499, 6500, 6497
3067, 6172, 6173, 6184, 6183, 6479, 6501, 6502, 6499
3068, 6173, 6174, 6185, 6184, 6481, 6503, 6504, 6501
3069, 6174, 6175, 6186, 6185, 6483, 6505, 6506, 6503
3070, 6175, 6176, 6187, 6186, 6485, 6507, 6508, 6505
3071, 6176, 6177, 6188, 6187, 6487, 6509, 6510, 6507
3072, 6177, 6178, 6189, 6188, 6489, 6511, 6512, 6509
3073, 6178, 6179, 6190, 6189, 6491, 6513, 6514, 6511
3074, 6179, 475, 476, 6190, 6492, 499, 6515, 6513
3075, 404, 6180, 6191, 405, 6494, 6516, 6517, 428
3076, 6180, 6181, 6192, 6191, 6496, 6518, 6519, 6516
3077, 6181, 6182, 6193, 6192, 6498, 6520, 6521, 6518
3078, 6182, 6183, 6194, 6193, 6500, 6522, 6523, 6520
