*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_Serendipity_Gmsh_2el.inp
*NODE
1, 0, 0, 0.5
2, 0, 0, 0
3, 0, 0.05, 0.5
4, 0, 0.05, 0
5, 1, 0, 0.5
6, 1, 0, 0
7, 1, 0.05, 0.5
8, 1, 0.05, 0
9, 1, 0.1, 0
10, 0, 0.1, 0
11, 1, 0.1, 0.5
12, 0, 0.1, 0.5
13, 1, 1.3, 0
14, 0, 1.3, 0
15, 1, 1.3, 0.5
16, 0, 1.3, 0.5
17, 1, 1.35, 0
18, 0, 1.35, 0
19, 1, 1.35, 0.5
20, 0, 1.35, 0.5
21, 1, 1.4, 0
22, 0, 1.4, 0
23, 1, 1.4, 0.5
24, 0, 1.4, 0.5
25, 1.2, 1.35, 0.5
26, 1.2, 1.4, 0.5
27, 1.2, 1.35, 0
28, 1.2, 1.4, 0
29, 2.2, 1.35, 0.5
30, 2.2, 1.4, 0.5
31, 2.2, 1.35, 0
32, 2.2, 1.4, 0
33, 1.2, 1.3, 0.5
34, 2.2, 1.3, 0.5
35, 1.2, 1.3, 0
36, 2.2, 1.3, 0
37, 1.2, 0.1, 0.5
38, 2.2, 0.1, 0.5
39, 1.2, 0.1, 0
40, 2.2, 0.1, 0
41, 1.2, 0.05, 0.5
42, 2.2, 0.05, 0.5
43, 1.2, 0.05, 0
44, 2.2, 0.05, 0
45, 1.2, -8.3266726846887e-17, 0.5
46, 2.2, -8.3266726846887e-17, 0.5
47, 1.2, -8.3266726846887e-17, 0
48, 2.2, -8.3266726846887e-17, 0
49, 2.3, 0.05, 0.5
50, 2.3, -8.3266726846887e-17, 0.5
51, 2.3, 0.05, 0
52, 2.3, -8.3266726846887e-17, 0
53, -0.1, 0, 0.5
54, -0.1, 0, 0
55, -0.1, 0.05, 0.5
56, -0.1, 0.05, 0
57, 1.05, 0.1, 0.5
58, 1.05, 1.3, 0.5
59, 1.05, 0.1, 0
60, 1.05, 1.3, 0
61, 1.15, 1.3, 0.5
62, 1.15, 0.1, 0.5
63, 1.15, 1.3, 0
64, 1.15, 0.1, 0
65, 1, 0.1, -0.1
66, 1, 1.3, -0.1
67, 0, 0.1, -0.1
68, 0, 1.3, -0.1
69, 1.2, 1.3, -0.1
70, 1.2, 0.1, -0.1
71, 2.2, 1.3, -0.1
72, 2.2, 0.1, -0.1
73, 1.15, 1.3, -0.1
74, 1.15, 0.1, -0.1
75, 1.05, 0.1, -0.1
76, 1.05, 1.3, -0.1
77, 0, 0, 0.25
78, 0, 0.025, 0.5
79, 0, 0.05, 0.25
80, 0, 0.025, 0
81, 1, 0, 0.25
82, 1, 0.025, 0.5
83, 1, 0.05, 0.25
84, 1, 0.025, 0
85, 0.5, 0, 0
86, 0.25, 0, 0
87, 0.75, 0, 0
88, 0.5, 0, 0.5
89, 0.25, 0, 0.5
90, 0.75, 0, 0.5
91, 0.5, 0.05, 0
92, 0.25, 0.05, 0
93, 0.75, 0.05, 0
94, 0.5, 0.05, 0.5
95, 0.25, 0.05, 0.5
96, 0.75, 0.05, 0.5
97, 1, 0.075, 0
98, 0, 0.075, 0
99, 0.5, 0.1, 0
100, 0.25, 0.1, 0
101, 0.75, 0.1, 0
102, 1, 0.075, 0.5
103, 1, 0.1, 0.25
104, 0, 0.075, 0.5
105, 0.5, 0.1, 0.5
106, 0.25, 0.1, 0.5
107, 0.75, 0.1, 0.5
108, 0, 0.1, 0.25
109, 1, 0.7, 0
110, 1, 0.4, 0
111, 1, 1, 0
112, 0, 0.7, 0
113, 0, 0.4, 0
114, 0, 1, 0
115, 0.5, 1.3, 0
116, 0.25, 1.3, 0
117, 0.75, 1.3, 0
118, 1, 0.7, 0.5
119, 1, 0.4, 0.5
120, 1, 1, 0.5
121, 1, 1.3, 0.25
122, 0, 0.7, 0.5
123, 0, 0.4, 0.5
124, 0, 1, 0.5
125, 0.5, 1.3, 0.5
126, 0.25, 1.3, 0.5
127, 0.75, 1.3, 0.5
128, 0, 1.3, 0.25
129, 1, 1.325, 0
130, 0, 1.325, 0
131, 0.5, 1.35, 0
132, 0.25, 1.35, 0
133, 0.75, 1.35, 0
134, 1, 1.325, 0.5
135, 1, 1.35, 0.25
136, 0, 1.325, 0.5
137, 0.5, 1.35, 0.5
138, 0.25, 1.35, 0.5
139, 0.75, 1.35, 0.5
140, 0, 1.35, 0.25
141, 1, 1.375, 0
142, 0, 1.375, 0
143, 0.5, 1.4, 0
144, 0.25, 1.4, 0
145, 0.75, 1.4, 0
146, 1, 1.375, 0.5
147, 1, 1.4, 0.25
148, 0, 1.375, 0.5
149, 0.5, 1.4, 0.5
150, 0.25, 1.4, 0.5
151, 0.75, 1.4, 0.5
152, 0, 1.4, 0.25
153, 1.1, 1.35, 0.5
154, 1.1, 1.4, 0.5
155, 1.2, 1.375, 0.5
156, 1.1, 1.35, 0
157, 1.1, 1.4, 0
158, 1.2, 1.375, 0
159, 1.2, 1.35, 0.25
160, 1.2, 1.4, 0.25
161, 1.7, 1.35, 0.5
162, 1.45, 1.35, 0.5
163, 1.95, 1.35, 0.5
164, 1.7, 1.4, 0.5
165, 1.45, 1.4, 0.5
166, 1.95, 1.4, 0.5
167, 2.2, 1.375, 0.5
168, 1.7, 1.35, 0
169, 1.45, 1.35, 0
170, 1.95, 1.35, 0
171, 1.7, 1.4, 0
172, 1.45, 1.4, 0
173, 1.95, 1.4, 0
174, 2.2, 1.375, 0
175, 2.2, 1.35, 0.25
176, 2.2, 1.4, 0.25
177, 1.2, 1.325, 0.5
178, 2.2, 1.325, 0.5
179, 1.7, 1.3, 0.5
180, 1.45, 1.3, 0.5
181, 1.95, 1.3, 0.5
182, 1.2, 1.325, 0
183, 2.2, 1.325, 0
184, 1.7, 1.3, 0
185, 1.45, 1.3, 0
186, 1.95, 1.3, 0
187, 1.2, 1.3, 0.25
188, 2.2, 1.3, 0.25
189, 1.2, 0.7, 0.5
190, 1.2, 1, 0.5
191, 1.2, 0.4, 0.5
192, 2.2, 0.7, 0.5
193, 2.2, 1, 0.5
194, 2.2, 0.4, 0.5
195, 1.7, 0.1, 0.5
196, 1.45, 0.1, 0.5
197, 1.95, 0.1, 0.5
198, 1.2, 0.7, 0
199, 1.2, 1, 0
200, 1.2, 0.4, 0
201, 2.2, 0.7, 0
202, 2.2, 1, 0
203, 2.2, 0.4, 0
204, 1.7, 0.1, 0
205, 1.45, 0.1, 0
206, 1.95, 0.1, 0
207, 1.2, 0.1, 0.25
208, 2.2, 0.1, 0.25
209, 1.2, 0.075, 0.5
210, 2.2, 0.075, 0.5
211, 1.7, 0.05, 0.5
212, 1.45, 0.05, 0.5
213, 1.95, 0.05, 0.5
214, 1.2, 0.075, 0
215, 2.2, 0.075, 0
216, 1.7, 0.05, 0
217, 1.45, 0.05, 0
218, 1.95, 0.05, 0
219, 1.2, 0.05, 0.25
220, 2.2, 0.05, 0.25
221, 1.2, 0.025, 0.5
222, 2.2, 0.025, 0.5
223, 1.7, 8.3266726846887e-17, 0.5
224, 1.45, 0, 0.5
225, 1.95, 0, 0.5
226, 1.2, 0.025, 0
227, 2.2, 0.025, 0
228, 1.7, 8.3266726846887e-17, 0
229, 1.45, 0, 0
230, 1.95, 0, 0
231, 1.2, -8.3266726846887e-17, 0.25
232, 2.2, -8.3266726846887e-17, 0.25
233, 2.25, 0.05, 0.5
234, 2.25, -8.3266726846887e-17, 0.5
235, 2.3, 0.025, 0.5
236, 2.25, 0.05, 0
237, 2.25, -8.3266726846887e-17, 0
238, 2.3, 0.025, 0
239, 2.3, 0.05, 0.25
240, 2.3, -8.3266726846887e-17, 0.25
241, -0.05, 0, 0.5
242, -0.05, 0, 0
243, -0.1, 0, 0.25
244, -0.05, 0.05, 0.5
245, -0.1, 0.025, 0.5
246, -0.05, 0.05, 0
247, -0.1, 0.05, 0.25
248, -0.1, 0.025, 0
249, 1.025, 0.1, 0.5
250, 1.025, 1.3, 0.5
251, 1.05, 0.7, 0.5
252, 1.05, 0.4, 0.5
253, 1.05, 1, 0.5
254, 1.025, 0.1, 0
255, 1.025, 1.3, 0
256, 1.05, 0.7, 0
257, 1.05, 0.4, 0
258, 1.05, 1, 0
259, 1.05, 0.1, 0.25
260, 1.05, 1.3, 0.25
261, 1.175, 1.3, 0.5
262, 1.175, 0.1, 0.5
263, 1.15, 0.7, 0.5
264, 1.15, 1, 0.5
265, 1.15, 0.4, 0.5
266, 1.175, 1.3, 0
267, 1.175, 0.1, 0
268, 1.15, 0.7, 0
269, 1.15, 1, 0
270, 1.15, 0.4, 0
271, 1.15, 1.3, 0.25
272, 1.15, 0.1, 0.25
273, 1, 0.1, -0.05
274, 1, 1.3, -0.05
275, 1, 0.7, -0.1
276, 1, 0.4, -0.1
277, 1, 1, -0.1
278, 0, 0.1, -0.05
279, 0, 1.3, -0.05
280, 0, 0.7, -0.1
281, 0, 0.4, -0.1
282, 0, 1, -0.1
283, 0.5, 0.1, -0.1
284, 0.25, 0.1, -0.1
285, 0.75, 0.1, -0.1
286, 0.5, 1.3, -0.1
287, 0.25, 1.3, -0.1
288, 0.75, 1.3, -0.1
289, 1.2, 1.3, -0.05
290, 1.2, 0.1, -0.05
291, 1.2, 0.7, -0.1
292, 1.2, 1, -0.1
293, 1.2, 0.4, -0.1
294, 2.2, 1.3, -0.05
295, 2.2, 0.1, -0.05
296, 2.2, 0.7, -0.1
297, 2.2, 1, -0.1
298, 2.2, 0.4, -0.1
299, 1.7, 1.3, -0.1
300, 1.45, 1.3, -0.1
301, 1.95, 1.3, -0.1
302, 1.7, 0.1, -0.1
303, 1.45, 0.1, -0.1
304, 1.95, 0.1, -0.1
305, 1.15, 1.3, -0.05
306, 1.175, 1.3, -0.1
307, 1.15, 0.1, -0.05
308, 1.175, 0.1, -0.1
309, 1.15, 0.7, -0.1
310, 1.15, 1, -0.1
311, 1.15, 0.4, -0.1
312, 1.05, 0.1, -0.05
313, 1.025, 0.1, -0.1
314, 1.05, 1.3, -0.05
315, 1.025, 1.3, -0.1
316, 1.05, 0.7, -0.1
317, 1.05, 0.4, -0.1
318, 1.05, 1, -0.1
319, 0.5, 0, 0.25
320, 0.5, 0.05, 0.25
321, 0.5, 0.025, 0
322, 0.5, 0.025, 0.5
323, 0.5, 0.075, 0
324, 0.5, 0.075, 0.5
325, 0.5, 0.1, 0.25
326, 0.5, 0.7, 0
327, 0.25, 0.7, 0
328, 0.5, 0.4, 0
329, 0.5, 1, 0
330, 0.75, 0.7, 0
331, 1, 0.7, 0.25
332, 0.5, 0.7, 0.5
333, 0.5, 0.4, 0.5
334, 0.25, 0.7, 0.5
335, 0.5, 1, 0.5
336, 0.75, 0.7, 0.5
337, 0, 0.7, 0.25
338, 0.5, 1.3, 0.25
339, 0.5, 1.325, 0
340, 0.5, 1.325, 0.5
341, 0.5, 1.35, 0.25
342, 0.5, 1.375, 0
343, 0.5, 1.375, 0.5
344, 0.5, 1.4, 0.25
345, 1.7, 1.375, 0.5
346, 1.7, 1.375, 0
347, 1.7, 1.35, 0.25
348, 1.7, 1.4, 0.25
349, 1.7, 1.325, 0.5
350, 1.7, 1.325, 0
351, 1.7, 1.3, 0.25
352, 1.7, 0.7, 0.5
353, 1.45, 0.7, 0.5
354, 1.7, 1, 0.5
355, 1.7, 0.4, 0.5
356, 1.95, 0.7, 0.5
357, 1.7, 0.7, 0
358, 1.7, 1, 0
359, 1.45, 0.7, 0
360, 1.7, 0.4, 0
361, 1.95, 0.7, 0
362, 1.2, 0.7, 0.25
363, 2.2, 0.7, 0.25
364, 1.7, 0.1, 0.25
365, 1.7, 0.075, 0.5
366, 1.7, 0.075, 0
367, 1.7, 0.05, 0.25
368, 1.7, 0.025, 0.5
369, 1.7, 0.025, 0
370, 1.7, 0, 0.25
371, 1.025, 0.7, 0.5
372, 1.025, 0.7, 0
373, 1.05, 0.7, 0.25
374, 1.175, 0.7, 0.5
375, 1.175, 0.7, 0
376, 1.15, 0.7, 0.25
377, 1, 0.7, -0.05
378, 0, 0.7, -0.05
379, 0.5, 0.1, -0.05
380, 0.5, 1.3, -0.05
381, 0.5, 0.7, -0.1
382, 0.25, 0.7, -0.1
383, 0.5, 0.4, -0.1
384, 0.5, 1, -0.1
385, 0.75, 0.7, -0.1
386, 1.2, 0.7, -0.05
387, 2.2, 0.7, -0.05
388, 1.7, 1.3, -0.05
389, 1.7, 0.1, -0.05
390, 1.7, 0.7, -0.1
391, 1.7, 1, -0.1
392, 1.45, 0.7, -0.1
393, 1.7, 0.4, -0.1
394, 1.95, 0.7, -0.1
395, 1.15, 0.7, -0.05
396, 1.175, 0.7, -0.1
397, 1.05, 0.7, -0.05
398, 1.025, 0.7, -0.1
399, 0.5, 0.7, 0.25
400, 1.7, 0.7, 0.25
401, 0.5, 0.7, -0.05
402, 1.7, 0.7, -0.05
******* E L E M E N T S *************
*ELEMENT, type=T3D3, ELSET=Line1
77, 2, 77, 1
*ELEMENT, type=T3D3, ELSET=Line2
78, 1, 78, 3
*ELEMENT, type=T3D3, ELSET=Line3
79, 4, 79, 3
*ELEMENT, type=T3D3, ELSET=Line4
80, 2, 80, 4
*ELEMENT, type=T3D3, ELSET=Line5
81, 6, 81, 5
*ELEMENT, type=T3D3, ELSET=Line6
82, 5, 82, 7
*ELEMENT, type=T3D3, ELSET=Line7
83, 8, 83, 7
*ELEMENT, type=T3D3, ELSET=Line8
84, 6, 84, 8
*ELEMENT, type=T3D3, ELSET=Line9
85, 2, 86, 85
86, 85, 87, 6
*ELEMENT, type=T3D3, ELSET=Line10
87, 1, 89, 88
88, 88, 90, 5
*ELEMENT, type=T3D3, ELSET=Line11
89, 4, 92, 91
90, 91, 93, 8
*ELEMENT, type=T3D3, ELSET=Line12
91, 3, 95, 94
92, 94, 96, 7
*ELEMENT, type=T3D3, ELSET=Line13
93, 8, 97, 9
*ELEMENT, type=T3D3, ELSET=Line14
94, 4, 98, 10
*ELEMENT, type=T3D3, ELSET=Line15
95, 10, 100, 99
96, 99, 101, 9
*ELEMENT, type=T3D3, ELSET=Line16
97, 7, 102, 11
*ELEMENT, type=T3D3, ELSET=Line17
98, 9, 103, 11
*ELEMENT, type=T3D3, ELSET=Line18
99, 3, 104, 12
*ELEMENT, type=T3D3, ELSET=Line19
100, 12, 106, 105
101, 105, 107, 11
*ELEMENT, type=T3D3, ELSET=Line20
102, 10, 108, 12
*ELEMENT, type=T3D3, ELSET=Line21
103, 9, 110, 109
104, 109, 111, 13
*ELEMENT, type=T3D3, ELSET=Line22
105, 10, 113, 112
106, 112, 114, 14
*ELEMENT, type=T3D3, ELSET=Line23
107, 14, 116, 115
108, 115, 117, 13
*ELEMENT, type=T3D3, ELSET=Line24
109, 11, 119, 118
110, 118, 120, 15
*ELEMENT, type=T3D3, ELSET=Line25
111, 13, 121, 15
*ELEMENT, type=T3D3, ELSET=Line26
112, 12, 123, 122
113, 122, 124, 16
*ELEMENT, type=T3D3, ELSET=Line27
114, 16, 126, 125
115, 125, 127, 15
*ELEMENT, type=T3D3, ELSET=Line28
116, 14, 128, 16
*ELEMENT, type=T3D3, ELSET=Line29
117, 13, 129, 17
*ELEMENT, type=T3D3, ELSET=Line30
118, 14, 130, 18
*ELEMENT, type=T3D3, ELSET=Line31
119, 18, 132, 131
120, 131, 133, 17
*ELEMENT, type=T3D3, ELSET=Line32
121, 15, 134, 19
*ELEMENT, type=T3D3, ELSET=Line33
122, 17, 135, 19
*ELEMENT, type=T3D3, ELSET=Line34
123, 16, 136, 20
*ELEMENT, type=T3D3, ELSET=Line35
124, 20, 138, 137
125, 137, 139, 19
*ELEMENT, type=T3D3, ELSET=Line36
126, 18, 140, 20
*ELEMENT, type=T3D3, ELSET=Line37
127, 17, 141, 21
*ELEMENT, type=T3D3, ELSET=Line38
128, 18, 142, 22
*ELEMENT, type=T3D3, ELSET=Line39
129, 22, 144, 143
130, 143, 145, 21
*ELEMENT, type=T3D3, ELSET=Line40
131, 19, 146, 23
*ELEMENT, type=T3D3, ELSET=Line41
132, 21, 147, 23
*ELEMENT, type=T3D3, ELSET=Line42
133, 20, 148, 24
*ELEMENT, type=T3D3, ELSET=Line43
134, 24, 150, 149
135, 149, 151, 23
*ELEMENT, type=T3D3, ELSET=Line44
136, 22, 152, 24
*ELEMENT, type=T3D3, ELSET=Line45
137, 19, 153, 25
*ELEMENT, type=T3D3, ELSET=Line46
138, 23, 154, 26
*ELEMENT, type=T3D3, ELSET=Line47
139, 25, 155, 26
*ELEMENT, type=T3D3, ELSET=Line48
140, 17, 156, 27
*ELEMENT, type=T3D3, ELSET=Line49
141, 21, 157, 28
*ELEMENT, type=T3D3, ELSET=Line50
142, 27, 158, 28
*ELEMENT, type=T3D3, ELSET=Line51
143, 27, 159, 25
*ELEMENT, type=T3D3, ELSET=Line52
144, 28, 160, 26
*ELEMENT, type=T3D3, ELSET=Line53
145, 25, 162, 161
146, 161, 163, 29
*ELEMENT, type=T3D3, ELSET=Line54
147, 26, 165, 164
148, 164, 166, 30
*ELEMENT, type=T3D3, ELSET=Line55
149, 29, 167, 30
*ELEMENT, type=T3D3, ELSET=Line56
150, 27, 169, 168
151, 168, 170, 31
*ELEMENT, type=T3D3, ELSET=Line57
152, 28, 172, 171
153, 171, 173, 32
*ELEMENT, type=T3D3, ELSET=Line58
154, 31, 174, 32
*ELEMENT, type=T3D3, ELSET=Line59
155, 31, 175, 29
*ELEMENT, type=T3D3, ELSET=Line60
156, 32, 176, 30
*ELEMENT, type=T3D3, ELSET=Line61
157, 25, 177, 33
*ELEMENT, type=T3D3, ELSET=Line62
158, 29, 178, 34
*ELEMENT, type=T3D3, ELSET=Line63
159, 33, 180, 179
160, 179, 181, 34
*ELEMENT, type=T3D3, ELSET=Line64
161, 27, 182, 35
*ELEMENT, type=T3D3, ELSET=Line65
162, 31, 183, 36
*ELEMENT, type=T3D3, ELSET=Line66
163, 35, 185, 184
164, 184, 186, 36
*ELEMENT, type=T3D3, ELSET=Line67
165, 35, 187, 33
*ELEMENT, type=T3D3, ELSET=Line68
166, 36, 188, 34
*ELEMENT, type=T3D3, ELSET=Line69
167, 33, 190, 189
168, 189, 191, 37
*ELEMENT, type=T3D3, ELSET=Line70
169, 34, 193, 192
170, 192, 194, 38
*ELEMENT, type=T3D3, ELSET=Line71
171, 37, 196, 195
172, 195, 197, 38
*ELEMENT, type=T3D3, ELSET=Line72
173, 35, 199, 198
174, 198, 200, 39
*ELEMENT, type=T3D3, ELSET=Line73
175, 36, 202, 201
176, 201, 203, 40
*ELEMENT, type=T3D3, ELSET=Line74
177, 39, 205, 204
178, 204, 206, 40
*ELEMENT, type=T3D3, ELSET=Line75
179, 39, 207, 37
*ELEMENT, type=T3D3, ELSET=Line76
180, 40, 208, 38
*ELEMENT, type=T3D3, ELSET=Line77
181, 37, 209, 41
*ELEMENT, type=T3D3, ELSET=Line78
182, 38, 210, 42
*ELEMENT, type=T3D3, ELSET=Line79
183, 41, 212, 211
184, 211, 213, 42
*ELEMENT, type=T3D3, ELSET=Line80
185, 39, 214, 43
*ELEMENT, type=T3D3, ELSET=Line81
186, 40, 215, 44
*ELEMENT, type=T3D3, ELSET=Line82
187, 43, 217, 216
188, 216, 218, 44
*ELEMENT, type=T3D3, ELSET=Line83
189, 43, 219, 41
*ELEMENT, type=T3D3, ELSET=Line84
190, 44, 220, 42
*ELEMENT, type=T3D3, ELSET=Line85
191, 41, 221, 45
*ELEMENT, type=T3D3, ELSET=Line86
192, 42, 222, 46
*ELEMENT, type=T3D3, ELSET=Line87
193, 45, 224, 223
194, 223, 225, 46
*ELEMENT, type=T3D3, ELSET=Line88
195, 43, 226, 47
*ELEMENT, type=T3D3, ELSET=Line89
196, 44, 227, 48
*ELEMENT, type=T3D3, ELSET=Line90
197, 47, 229, 228
198, 228, 230, 48
*ELEMENT, type=T3D3, ELSET=Line91
199, 47, 231, 45
*ELEMENT, type=T3D3, ELSET=Line92
200, 48, 232, 46
*ELEMENT, type=T3D3, ELSET=Line93
201, 42, 233, 49
*ELEMENT, type=T3D3, ELSET=Line94
202, 46, 234, 50
*ELEMENT, type=T3D3, ELSET=Line95
203, 49, 235, 50
*ELEMENT, type=T3D3, ELSET=Line96
204, 44, 236, 51
*ELEMENT, type=T3D3, ELSET=Line97
205, 48, 237, 52
*ELEMENT, type=T3D3, ELSET=Line98
206, 51, 238, 52
*ELEMENT, type=T3D3, ELSET=Line99
207, 51, 239, 49
*ELEMENT, type=T3D3, ELSET=Line100
208, 52, 240, 50
*ELEMENT, type=T3D3, ELSET=Line101
209, 1, 241, 53
*ELEMENT, type=T3D3, ELSET=Line102
210, 2, 242, 54
*ELEMENT, type=T3D3, ELSET=Line103
211, 54, 243, 53
*ELEMENT, type=T3D3, ELSET=Line104
212, 3, 244, 55
*ELEMENT, type=T3D3, ELSET=Line105
213, 53, 245, 55
*ELEMENT, type=T3D3, ELSET=Line106
214, 4, 246, 56
*ELEMENT, type=T3D3, ELSET=Line107
215, 56, 247, 55
*ELEMENT, type=T3D3, ELSET=Line108
216, 54, 248, 56
*ELEMENT, type=T3D3, ELSET=Line125
217, 11, 249, 57
*ELEMENT, type=T3D3, ELSET=Line126
218, 15, 250, 58
*ELEMENT, type=T3D3, ELSET=Line127
219, 57, 252, 251
220, 251, 253, 58
*ELEMENT, type=T3D3, ELSET=Line128
221, 9, 254, 59
*ELEMENT, type=T3D3, ELSET=Line129
222, 13, 255, 60
*ELEMENT, type=T3D3, ELSET=Line130
223, 59, 257, 256
224, 256, 258, 60
*ELEMENT, type=T3D3, ELSET=Line131
225, 59, 259, 57
*ELEMENT, type=T3D3, ELSET=Line132
226, 60, 260, 58
*ELEMENT, type=T3D3, ELSET=Line133
227, 33, 261, 61
*ELEMENT, type=T3D3, ELSET=Line134
228, 37, 262, 62
*ELEMENT, type=T3D3, ELSET=Line135
229, 61, 264, 263
230, 263, 265, 62
*ELEMENT, type=T3D3, ELSET=Line136
231, 35, 266, 63
*ELEMENT, type=T3D3, ELSET=Line137
232, 39, 267, 64
*ELEMENT, type=T3D3, ELSET=Line138
233, 63, 269, 268
234, 268, 270, 64
*ELEMENT, type=T3D3, ELSET=Line139
235, 63, 271, 61
*ELEMENT, type=T3D3, ELSET=Line140
236, 64, 272, 62
*ELEMENT, type=T3D3, ELSET=Line141
237, 9, 273, 65
*ELEMENT, type=T3D3, ELSET=Line142
238, 13, 274, 66
*ELEMENT, type=T3D3, ELSET=Line143
239, 65, 276, 275
240, 275, 277, 66
*ELEMENT, type=T3D3, ELSET=Line144
241, 10, 278, 67
*ELEMENT, type=T3D3, ELSET=Line145
242, 14, 279, 68
*ELEMENT, type=T3D3, ELSET=Line146
243, 67, 281, 280
244, 280, 282, 68
*ELEMENT, type=T3D3, ELSET=Line147
245, 67, 284, 283
246, 283, 285, 65
*ELEMENT, type=T3D3, ELSET=Line148
247, 68, 287, 286
248, 286, 288, 66
*ELEMENT, type=T3D3, ELSET=Line149
249, 35, 289, 69
*ELEMENT, type=T3D3, ELSET=Line150
250, 39, 290, 70
*ELEMENT, type=T3D3, ELSET=Line151
251, 69, 292, 291
252, 291, 293, 70
*ELEMENT, type=T3D3, ELSET=Line152
253, 36, 294, 71
*ELEMENT, type=T3D3, ELSET=Line153
254, 40, 295, 72
*ELEMENT, type=T3D3, ELSET=Line154
255, 71, 297, 296
256, 296, 298, 72
*ELEMENT, type=T3D3, ELSET=Line155
257, 69, 300, 299
258, 299, 301, 71
*ELEMENT, type=T3D3, ELSET=Line156
259, 70, 303, 302
260, 302, 304, 72
*ELEMENT, type=T3D3, ELSET=Line157
261, 63, 305, 73
*ELEMENT, type=T3D3, ELSET=Line158
262, 69, 306, 73
*ELEMENT, type=T3D3, ELSET=Line159
263, 64, 307, 74
*ELEMENT, type=T3D3, ELSET=Line160
264, 70, 308, 74
*ELEMENT, type=T3D3, ELSET=Line161
265, 73, 310, 309
266, 309, 311, 74
*ELEMENT, type=T3D3, ELSET=Line162
267, 59, 312, 75
*ELEMENT, type=T3D3, ELSET=Line163
268, 65, 313, 75
*ELEMENT, type=T3D3, ELSET=Line164
269, 60, 314, 76
*ELEMENT, type=T3D3, ELSET=Line165
270, 66, 315, 76
*ELEMENT, type=T3D3, ELSET=Line166
271, 75, 317, 316
272, 316, 318, 76
*ELEMENT, type=CPS8, ELSET=Surface1
273, 2, 1, 3, 4, 77, 78, 79, 80
*ELEMENT, type=CPS8, ELSET=Surface2
274, 6, 8, 7, 5, 84, 83, 82, 81
*ELEMENT, type=CPS8, ELSET=Surface3
275, 2, 85, 88, 1, 86, 319, 89, 77
276, 85, 6, 5, 88, 87, 81, 90, 319
*ELEMENT, type=CPS8, ELSET=Surface4
277, 4, 3, 94, 91, 79, 95, 320, 92
278, 91, 94, 7, 8, 320, 96, 83, 93
*ELEMENT, type=CPS8, ELSET=Surface5
279, 2, 4, 91, 85, 80, 92, 321, 86
280, 85, 91, 8, 6, 321, 93, 84, 87
*ELEMENT, type=CPS8, ELSET=Surface6
281, 1, 88, 94, 3, 89, 322, 95, 78
282, 88, 5, 7, 94, 90, 82, 96, 322
*ELEMENT, type=CPS8, ELSET=Surface7
283, 4, 10, 99, 91, 98, 100, 323, 92
284, 91, 99, 9, 8, 323, 101, 97, 93
*ELEMENT, type=CPS8, ELSET=Surface8
285, 8, 9, 11, 7, 97, 103, 102, 83
*ELEMENT, type=CPS8, ELSET=Surface9
286, 3, 94, 105, 12, 95, 324, 106, 104
287, 94, 7, 11, 105, 96, 102, 107, 324
*ELEMENT, type=CPS8, ELSET=Surface10
288, 4, 3, 12, 10, 79, 104, 108, 98
*ELEMENT, type=CPS8, ELSET=Surface11
289, 10, 12, 105, 99, 108, 106, 325, 100
290, 99, 105, 11, 9, 325, 107, 103, 101
*ELEMENT, type=CPS8, ELSET=Surface12
291, 10, 112, 326, 99, 113, 327, 328, 100
292, 112, 14, 115, 326, 114, 116, 329, 327
293, 99, 326, 109, 9, 328, 330, 110, 101
294, 326, 115, 13, 109, 329, 117, 111, 330
*ELEMENT, type=CPS8, ELSET=Surface13
295, 9, 109, 118, 11, 110, 331, 119, 103
296, 109, 13, 15, 118, 111, 121, 120, 331
*ELEMENT, type=CPS8, ELSET=Surface14
297, 12, 105, 332, 122, 106, 333, 334, 123
298, 122, 332, 125, 16, 334, 335, 126, 124
299, 105, 11, 118, 332, 107, 119, 336, 333
300, 332, 118, 15, 125, 336, 120, 127, 335
*ELEMENT, type=CPS8, ELSET=Surface15
301, 10, 12, 122, 112, 108, 123, 337, 113
302, 112, 122, 16, 14, 337, 124, 128, 114
*ELEMENT, type=CPS8, ELSET=Surface16
303, 14, 16, 125, 115, 128, 126, 338, 116
304, 115, 125, 15, 13, 338, 127, 121, 117
*ELEMENT, type=CPS8, ELSET=Surface17
305, 14, 18, 131, 115, 130, 132, 339, 116
306, 115, 131, 17, 13, 339, 133, 129, 117
*ELEMENT, type=CPS8, ELSET=Surface18
307, 13, 17, 19, 15, 129, 135, 134, 121
*ELEMENT, type=CPS8, ELSET=Surface19
308, 16, 125, 137, 20, 126, 340, 138, 136
309, 125, 15, 19, 137, 127, 134, 139, 340
*ELEMENT, type=CPS8, ELSET=Surface20
310, 14, 16, 20, 18, 128, 136, 140, 130
*ELEMENT, type=CPS8, ELSET=Surface21
311, 18, 20, 137, 131, 140, 138, 341, 132
312, 131, 137, 19, 17, 341, 139, 135, 133
*ELEMENT, type=CPS8, ELSET=Surface22
313, 18, 22, 143, 131, 142, 144, 342, 132
314, 131, 143, 21, 17, 342, 145, 141, 133
*ELEMENT, type=CPS8, ELSET=Surface23
315, 17, 21, 23, 19, 141, 147, 146, 135
*ELEMENT, type=CPS8, ELSET=Surface24
316, 20, 137, 149, 24, 138, 343, 150, 148
317, 137, 19, 23, 149, 139, 146, 151, 343
*ELEMENT, type=CPS8, ELSET=Surface25
318, 18, 20, 24, 22, 140, 148, 152, 142
*ELEMENT, type=CPS8, ELSET=Surface26
319, 22, 24, 149, 143, 152, 150, 344, 144
320, 143, 149, 23, 21, 344, 151, 147, 145
*ELEMENT, type=CPS8, ELSET=Surface27
321, 19, 25, 26, 23, 153, 155, 154, 146
*ELEMENT, type=CPS8, ELSET=Surface28
322, 17, 21, 28, 27, 141, 157, 158, 156
*ELEMENT, type=CPS8, ELSET=Surface29
323, 17, 27, 25, 19, 156, 159, 153, 135
*ELEMENT, type=CPS8, ELSET=Surface30
324, 21, 23, 26, 28, 147, 154, 160, 157
*ELEMENT, type=CPS8, ELSET=Surface31
325, 27, 28, 26, 25, 158, 160, 155, 159
*ELEMENT, type=CPS8, ELSET=Surface32
326, 25, 161, 164, 26, 162, 345, 165, 155
327, 161, 29, 30, 164, 163, 167, 166, 345
*ELEMENT, type=CPS8, ELSET=Surface33
328, 27, 28, 171, 168, 158, 172, 346, 169
329, 168, 171, 32, 31, 346, 173, 174, 170
*ELEMENT, type=CPS8, ELSET=Surface34
330, 27, 168, 161, 25, 169, 347, 162, 159
331, 168, 31, 29, 161, 170, 175, 163, 347
*ELEMENT, type=CPS8, ELSET=Surface35
332, 28, 26, 164, 171, 160, 165, 348, 172
333, 171, 164, 30, 32, 348, 166, 176, 173
*ELEMENT, type=CPS8, ELSET=Surface36
334, 31, 32, 30, 29, 174, 176, 167, 175
*ELEMENT, type=CPS8, ELSET=Surface37
335, 25, 33, 179, 161, 177, 180, 349, 162
336, 161, 179, 34, 29, 349, 181, 178, 163
*ELEMENT, type=CPS8, ELSET=Surface38
337, 27, 168, 184, 35, 169, 350, 185, 182
338, 168, 31, 36, 184, 170, 183, 186, 350
*ELEMENT, type=CPS8, ELSET=Surface39
339, 27, 35, 33, 25, 182, 187, 177, 159
*ELEMENT, type=CPS8, ELSET=Surface40
340, 31, 29, 34, 36, 175, 178, 188, 183
*ELEMENT, type=CPS8, ELSET=Surface41
341, 35, 184, 179, 33, 185, 351, 180, 187
342, 184, 36, 34, 179, 186, 188, 181, 351
*ELEMENT, type=CPS8, ELSET=Surface42
343, 33, 189, 352, 179, 190, 353, 354, 180
344, 189, 37, 195, 352, 191, 196, 355, 353
345, 179, 352, 192, 34, 354, 356, 193, 181
346, 352, 195, 38, 192, 355, 197, 194, 356
*ELEMENT, type=CPS8, ELSET=Surface43
347, 35, 184, 357, 198, 185, 358, 359, 199
348, 198, 357, 204, 39, 359, 360, 205, 200
349, 184, 36, 201, 357, 186, 202, 361, 358
350, 357, 201, 40, 204, 361, 203, 206, 360
*ELEMENT, type=CPS8, ELSET=Surface44
351, 35, 198, 189, 33, 199, 362, 190, 187
352, 198, 39, 37, 189, 200, 207, 191, 362
*ELEMENT, type=CPS8, ELSET=Surface45
353, 36, 34, 192, 201, 188, 193, 363, 202
354, 201, 192, 38, 40, 363, 194, 208, 203
*ELEMENT, type=CPS8, ELSET=Surface46
355, 39, 204, 195, 37, 205, 364, 196, 207
356, 204, 40, 38, 195, 206, 208, 197, 364
*ELEMENT, type=CPS8, ELSET=Surface47
357, 37, 41, 211, 195, 209, 212, 365, 196
358, 195, 211, 42, 38, 365, 213, 210, 197
*ELEMENT, type=CPS8, ELSET=Surface48
359, 39, 204, 216, 43, 205, 366, 217, 214
360, 204, 40, 44, 216, 206, 215, 218, 366
*ELEMENT, type=CPS8, ELSET=Surface49
361, 39, 43, 41, 37, 214, 219, 209, 207
*ELEMENT, type=CPS8, ELSET=Surface50
362, 40, 38, 42, 44, 208, 210, 220, 215
*ELEMENT, type=CPS8, ELSET=Surface51
363, 43, 216, 211, 41, 217, 367, 212, 219
364, 216, 44, 42, 211, 218, 220, 213, 367
*ELEMENT, type=CPS8, ELSET=Surface52
365, 41, 45, 223, 211, 221, 224, 368, 212
366, 211, 223, 46, 42, 368, 225, 222, 213
*ELEMENT, type=CPS8, ELSET=Surface53
367, 43, 216, 228, 47, 217, 369, 229, 226
368, 216, 44, 48, 228, 218, 227, 230, 369
*ELEMENT, type=CPS8, ELSET=Surface54
369, 43, 47, 45, 41, 226, 231, 221, 219
*ELEMENT, type=CPS8, ELSET=Surface55
370, 44, 42, 46, 48, 220, 222, 232, 227
*ELEMENT, type=CPS8, ELSET=Surface56
371, 47, 228, 223, 45, 229, 370, 224, 231
372, 228, 48, 46, 223, 230, 232, 225, 370
*ELEMENT, type=CPS8, ELSET=Surface57
373, 42, 46, 50, 49, 222, 234, 235, 233
*ELEMENT, type=CPS8, ELSET=Surface58
374, 44, 51, 52, 48, 236, 238, 237, 227
*ELEMENT, type=CPS8, ELSET=Surface59
375, 44, 42, 49, 51, 220, 233, 239, 236
*ELEMENT, type=CPS8, ELSET=Surface60
376, 48, 52, 50, 46, 237, 240, 234, 232
*ELEMENT, type=CPS8, ELSET=Surface61
377, 51, 49, 50, 52, 239, 235, 240, 238
*ELEMENT, type=CPS8, ELSET=Surface62
378, 2, 1, 53, 54, 77, 241, 243, 242
*ELEMENT, type=CPS8, ELSET=Surface63
379, 1, 3, 55, 53, 78, 244, 245, 241
*ELEMENT, type=CPS8, ELSET=Surface64
380, 4, 56, 55, 3, 246, 247, 244, 79
*ELEMENT, type=CPS8, ELSET=Surface65
381, 2, 54, 56, 4, 242, 248, 246, 80
*ELEMENT, type=CPS8, ELSET=Surface66
382, 54, 53, 55, 56, 243, 245, 247, 248
*ELEMENT, type=CPS8, ELSET=Surface77
383, 11, 57, 251, 118, 249, 252, 371, 119
384, 118, 251, 58, 15, 371, 253, 250, 120
*ELEMENT, type=CPS8, ELSET=Surface78
385, 9, 109, 256, 59, 110, 372, 257, 254
386, 109, 13, 60, 256, 111, 255, 258, 372
*ELEMENT, type=CPS8, ELSET=Surface79
387, 9, 59, 57, 11, 254, 259, 249, 103
*ELEMENT, type=CPS8, ELSET=Surface80
388, 13, 15, 58, 60, 121, 250, 260, 255
*ELEMENT, type=CPS8, ELSET=Surface81
389, 59, 256, 251, 57, 257, 373, 252, 259
390, 256, 60, 58, 251, 258, 260, 253, 373
*ELEMENT, type=CPS8, ELSET=Surface82
391, 33, 61, 263, 189, 261, 264, 374, 190
392, 189, 263, 62, 37, 374, 265, 262, 191
*ELEMENT, type=CPS8, ELSET=Surface83
393, 35, 198, 268, 63, 199, 375, 269, 266
394, 198, 39, 64, 268, 200, 267, 270, 375
*ELEMENT, type=CPS8, ELSET=Surface84
395, 35, 63, 61, 33, 266, 271, 261, 187
*ELEMENT, type=CPS8, ELSET=Surface85
396, 39, 37, 62, 64, 207, 262, 272, 267
*ELEMENT, type=CPS8, ELSET=Surface86
397, 63, 268, 263, 61, 269, 376, 264, 271
398, 268, 64, 62, 263, 270, 272, 265, 376
*ELEMENT, type=CPS8, ELSET=Surface87
399, 9, 65, 275, 109, 273, 276, 377, 110
400, 109, 275, 66, 13, 377, 277, 274, 111
*ELEMENT, type=CPS8, ELSET=Surface88
401, 10, 112, 280, 67, 113, 378, 281, 278
402, 112, 14, 68, 280, 114, 279, 282, 378
*ELEMENT, type=CPS8, ELSET=Surface89
403, 10, 67, 283, 99, 278, 284, 379, 100
404, 99, 283, 65, 9, 379, 285, 273, 101
*ELEMENT, type=CPS8, ELSET=Surface90
405, 14, 115, 286, 68, 116, 380, 287, 279
406, 115, 13, 66, 286, 117, 274, 288, 380
*ELEMENT, type=CPS8, ELSET=Surface91
407, 67, 280, 381, 283, 281, 382, 383, 284
408, 280, 68, 286, 381, 282, 287, 384, 382
409, 283, 381, 275, 65, 383, 385, 276, 285
410, 381, 286, 66, 275, 384, 288, 277, 385
*ELEMENT, type=CPS8, ELSET=Surface92
411, 35, 69, 291, 198, 289, 292, 386, 199
412, 198, 291, 70, 39, 386, 293, 290, 200
*ELEMENT, type=CPS8, ELSET=Surface93
413, 36, 201, 296, 71, 202, 387, 297, 294
414, 201, 40, 72, 296, 203, 295, 298, 387
*ELEMENT, type=CPS8, ELSET=Surface94
415, 35, 184, 299, 69, 185, 388, 300, 289
416, 184, 36, 71, 299, 186, 294, 301, 388
*ELEMENT, type=CPS8, ELSET=Surface95
417, 39, 70, 302, 204, 290, 303, 389, 205
418, 204, 302, 72, 40, 389, 304, 295, 206
*ELEMENT, type=CPS8, ELSET=Surface96
419, 69, 299, 390, 291, 300, 391, 392, 292
420, 291, 390, 302, 70, 392, 393, 303, 293
421, 299, 71, 296, 390, 301, 297, 394, 391
422, 390, 296, 72, 302, 394, 298, 304, 393
*ELEMENT, type=CPS8, ELSET=Surface97
423, 35, 69, 73, 63, 289, 306, 305, 266
*ELEMENT, type=CPS8, ELSET=Surface98
424, 39, 64, 74, 70, 267, 307, 308, 290
*ELEMENT, type=CPS8, ELSET=Surface99
425, 63, 73, 309, 268, 305, 310, 395, 269
426, 268, 309, 74, 64, 395, 311, 307, 270
*ELEMENT, type=CPS8, ELSET=Surface100
427, 69, 291, 309, 73, 292, 396, 310, 306
428, 291, 70, 74, 309, 293, 308, 311, 396
*ELEMENT, type=CPS8, ELSET=Surface101
429, 9, 65, 75, 59, 273, 313, 312, 254
*ELEMENT, type=CPS8, ELSET=Surface102
430, 13, 60, 76, 66, 255, 314, 315, 274
*ELEMENT, type=CPS8, ELSET=Surface103
431, 59, 75, 316, 256, 312, 317, 397, 257
432, 256, 316, 76, 60, 397, 318, 314, 258
*ELEMENT, type=CPS8, ELSET=Surface104
433, 65, 275, 316, 75, 276, 398, 317, 313
434, 275, 66, 76, 316, 277, 315, 318, 398
*ELEMENT, type=C3D20, ELSET=Volume1
435, 3, 1, 2, 4, 94, 88, 85, 91, 78, 77, 80, 79, 322, 319, 321, 
320, 95, 89, 86, 92
436, 94, 88, 85, 91, 7, 5, 6, 8, 322, 319, 321, 320, 82, 81, 84, 
83, 96, 90, 87, 93
*ELEMENT, type=C3D20, ELSET=Volume2
437, 4, 3, 94, 91, 10, 12, 105, 99, 79, 95, 320, 92, 108, 106, 325, 
100, 98, 104, 324, 323
438, 91, 94, 7, 8, 99, 105, 11, 9, 320, 96, 83, 93, 325, 107, 103, 
101, 323, 324, 102, 97
*ELEMENT, type=C3D20, ELSET=Volume3
439, 10, 12, 105, 99, 112, 122, 332, 326, 108, 106, 325, 100, 337, 334, 399, 
327, 113, 123, 333, 328
440, 112, 122, 332, 326, 14, 16, 125, 115, 337, 334, 399, 327, 128, 126, 338, 
116, 114, 124, 335, 329
441, 99, 105, 11, 9, 326, 332, 118, 109, 325, 107, 103, 101, 399, 336, 331, 
330, 328, 333, 119, 110
442, 326, 332, 118, 109, 115, 125, 15, 13, 399, 336, 331, 330, 338, 127, 121, 
117, 329, 335, 120, 111
*ELEMENT, type=C3D20, ELSET=Volume4
443, 14, 16, 125, 115, 18, 20, 137, 131, 128, 126, 338, 116, 140, 138, 341, 
132, 130, 136, 340, 339
444, 115, 125, 15, 13, 131, 137, 19, 17, 338, 127, 121, 117, 341, 139, 135, 
133, 339, 340, 134, 129
*ELEMENT, type=C3D20, ELSET=Volume5
445, 18, 20, 137, 131, 22, 24, 149, 143, 140, 138, 341, 132, 152, 150, 344, 
144, 142, 148, 343, 342
446, 131, 137, 19, 17, 143, 149, 23, 21, 341, 139, 135, 133, 344, 151, 147, 
145, 342, 343, 146, 141
*ELEMENT, type=C3D20, ELSET=Volume6
447, 17, 21, 23, 19, 27, 28, 26, 25, 141, 147, 146, 135, 158, 160, 155, 
159, 156, 157, 154, 153
*ELEMENT, type=C3D20, ELSET=Volume7
448, 27, 28, 26, 25, 168, 171, 164, 161, 158, 160, 155, 159, 346, 348, 345, 
347, 169, 172, 165, 162
449, 168, 171, 164, 161, 31, 32, 30, 29, 346, 348, 345, 347, 174, 176, 167, 
175, 170, 173, 166, 163
*ELEMENT, type=C3D20, ELSET=Volume8
450, 27, 168, 161, 25, 35, 184, 179, 33, 169, 347, 162, 159, 185, 351, 180, 
187, 182, 350, 349, 177
451, 168, 31, 29, 161, 184, 36, 34, 179, 170, 175, 163, 347, 186, 188, 181, 
351, 350, 183, 178, 349
*ELEMENT, type=C3D20, ELSET=Volume9
452, 35, 184, 179, 33, 198, 357, 352, 189, 185, 351, 180, 187, 359, 400, 353, 
362, 199, 358, 354, 190
453, 198, 357, 352, 189, 39, 204, 195, 37, 359, 400, 353, 362, 205, 364, 196, 
207, 200, 360, 355, 191
454, 184, 36, 34, 179, 357, 201, 192, 352, 186, 188, 181, 351, 361, 363, 356, 
400, 358, 202, 193, 354
455, 357, 201, 192, 352, 204, 40, 38, 195, 361, 363, 356, 400, 206, 208, 197, 
364, 360, 203, 194, 355
*ELEMENT, type=C3D20, ELSET=Volume10
456, 39, 204, 195, 37, 43, 216, 211, 41, 205, 364, 196, 207, 217, 367, 212, 
219, 214, 366, 365, 209
457, 204, 40, 38, 195, 216, 44, 42, 211, 206, 208, 197, 364, 218, 220, 213, 
367, 366, 215, 210, 365
*ELEMENT, type=C3D20, ELSET=Volume11
458, 43, 216, 211, 41, 47, 228, 223, 45, 217, 367, 212, 219, 229, 370, 224, 
231, 226, 369, 368, 221
459, 216, 44, 42, 211, 228, 48, 46, 223, 218, 220, 213, 367, 230, 232, 225, 
370, 369, 227, 222, 368
*ELEMENT, type=C3D20, ELSET=Volume12
460, 44, 42, 46, 48, 51, 49, 50, 52, 220, 222, 232, 227, 239, 235, 240, 
238, 236, 233, 234, 237
*ELEMENT, type=C3D20, ELSET=Volume13
461, 2, 1, 3, 4, 54, 53, 55, 56, 77, 78, 79, 80, 243, 245, 247, 
248, 242, 241, 244, 246
*ELEMENT, type=C3D20, ELSET=Volume14
462, 10, 112, 326, 99, 67, 280, 381, 283, 113, 327, 328, 100, 281, 382, 383, 
284, 278, 378, 401, 379
463, 112, 14, 115, 326, 280, 68, 286, 381, 114, 116, 329, 327, 282, 287, 384, 
382, 378, 279, 380, 401
464, 99, 326, 109, 9, 283, 381, 275, 65, 328, 330, 110, 101, 383, 385, 276, 
285, 379, 401, 377, 273
465, 326, 115, 13, 109, 381, 286, 66, 275, 329, 117, 111, 330, 384, 288, 277, 
385, 401, 380, 274, 377
*ELEMENT, type=C3D20, ELSET=Volume15
466, 35, 184, 357, 198, 69, 299, 390, 291, 185, 358, 359, 199, 300, 391, 392, 
292, 289, 388, 402, 386
467, 198, 357, 204, 39, 291, 390, 302, 70, 359, 360, 205, 200, 392, 393, 303, 
293, 386, 402, 389, 290
468, 184, 36, 201, 357, 299, 71, 296, 390, 186, 202, 361, 358, 301, 297, 394, 
391, 388, 294, 387, 402
469, 357, 201, 40, 204, 390, 296, 72, 302, 361, 203, 206, 360, 394, 298, 304, 
393, 402, 387, 295, 389
*ELEMENT, type=C3D20, ELSET=Volume16
470, 9, 109, 118, 11, 59, 256, 251, 57, 110, 331, 119, 103, 257, 373, 252, 
259, 254, 372, 371, 249
471, 109, 13, 15, 118, 256, 60, 58, 251, 111, 121, 120, 331, 258, 260, 253, 
373, 372, 255, 250, 371
*ELEMENT, type=C3D20, ELSET=Volume17
472, 35, 198, 189, 33, 63, 268, 263, 61, 199, 362, 190, 187, 269, 376, 264, 
271, 266, 375, 374, 261
473, 198, 39, 37, 189, 268, 64, 62, 263, 200, 207, 191, 362, 270, 272, 265, 
376, 375, 267, 262, 374
*ELEMENT, type=C3D20, ELSET=Volume18
474, 35, 198, 268, 63, 69, 291, 309, 73, 199, 375, 269, 266, 292, 396, 310, 
306, 289, 386, 395, 305
475, 198, 39, 64, 268, 291, 70, 74, 309, 200, 267, 270, 375, 293, 308, 311, 
396, 386, 290, 307, 395
*ELEMENT, type=C3D20, ELSET=Volume19
476, 9, 109, 256, 59, 65, 275, 316, 75, 110, 372, 257, 254, 276, 398, 317, 
313, 273, 377, 397, 312
477, 109, 13, 60, 256, 275, 66, 76, 316, 111, 255, 258, 372, 277, 315, 318, 
398, 377, 274, 314, 397
*ELSET,ELSET=Qin
319, 320, 324, 332, 333, 
*ELSET,ELSET=HeatSink
275, 276, 371, 372, 
*ELSET,ELSET=ElectrodeMaxX
377, 
*ELSET,ELSET=ElectrodeMinX
382, 
*ELSET,ELSET=Force
318, 
*ELSET,ELSET=Copper
435, 436, 445, 446, 447, 448, 449, 458, 459, 460, 
461, 
*ELSET,ELSET=SemiconductorN-
439, 440, 441, 442, 462, 463, 464, 465, 470, 471, 
476, 477, 
*ELSET,ELSET=SemiconductorP+
452, 453, 454, 455, 466, 467, 468, 469, 472, 473, 
474, 475, 
*ELSET,ELSET=Solder
437, 438, 443, 444, 450, 451, 456, 457, 
*ELSET,ELSET=Volume
435, 436, 437, 438, 439, 440, 441, 442, 443, 444, 
445, 446, 447, 448, 449, 450, 451, 452, 453, 454, 
455, 456, 457, 458, 459, 460, 461, 462, 463, 464, 
465, 466, 467, 468, 469, 470, 471, 472, 473, 474, 
475, 476, 477, 
*ELSET,ELSET=TO
439, 440, 441, 442, 452, 453, 454, 455, 462, 463, 
464, 465, 466, 467, 468, 469, 470, 471, 472, 473, 
474, 475, 476, 477, 
*NSET,NSET=Qin
21, 22, 23, 24, 26, 28, 30, 32, 143, 144, 
145, 147, 149, 150, 151, 152, 154, 157, 160, 164, 
165, 166, 171, 172, 173, 176, 344, 348, 
*NSET,NSET=HeatSink
1, 2, 5, 6, 45, 46, 47, 48, 77, 81, 
85, 86, 87, 88, 89, 90, 223, 224, 225, 228, 
229, 230, 231, 232, 319, 370, 
*NSET,NSET=ElectrodeMaxX
49, 50, 51, 52, 235, 238, 239, 240, 
*NSET,NSET=ElectrodeMinX
53, 54, 55, 56, 243, 245, 247, 248, 
*NSET,NSET=Force
18, 20, 22, 24, 140, 142, 148, 152, 
*NSET,NSET=Copper
1, 2, 3, 4, 5, 6, 7, 8, 17, 18, 
19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 
29, 30, 31, 32, 41, 42, 43, 44, 45, 46, 
47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 
77, 78, 79, 80, 81, 82, 83, 84, 85, 86, 
87, 88, 89, 90, 91, 92, 93, 94, 95, 96, 
131, 132, 133, 135, 137, 138, 139, 140, 141, 142, 
143, 144, 145, 146, 147, 148, 149, 150, 151, 152, 
153, 154, 155, 156, 157, 158, 159, 160, 161, 162, 
163, 164, 165, 166, 167, 168, 169, 170, 171, 172, 
173, 174, 175, 176, 211, 212, 213, 216, 217, 218, 
219, 220, 221, 222, 223, 224, 225, 226, 227, 228, 
229, 230, 231, 232, 233, 234, 235, 236, 237, 238, 
239, 240, 241, 242, 243, 244, 245, 246, 247, 248, 
319, 320, 321, 322, 341, 342, 343, 344, 345, 346, 
347, 348, 367, 368, 369, 370, 
*NSET,NSET=SemiconductorN-
9, 10, 11, 12, 13, 14, 15, 16, 57, 58, 
59, 60, 65, 66, 67, 68, 75, 76, 99, 100, 
101, 103, 105, 106, 107, 108, 109, 110, 111, 112, 
113, 114, 115, 116, 117, 118, 119, 120, 121, 122, 
123, 124, 125, 126, 127, 128, 249, 250, 251, 252, 
253, 254, 255, 256, 257, 258, 259, 260, 273, 274, 
275, 276, 277, 278, 279, 280, 281, 282, 283, 284, 
285, 286, 287, 288, 312, 313, 314, 315, 316, 317, 
318, 325, 326, 327, 328, 329, 330, 331, 332, 333, 
334, 335, 336, 337, 338, 371, 372, 373, 377, 378, 
379, 380, 381, 382, 383, 384, 385, 397, 398, 399, 
401, 
*NSET,NSET=SemiconductorP+
33, 34, 35, 36, 37, 38, 39, 40, 61, 62, 
63, 64, 69, 70, 71, 72, 73, 74, 179, 180, 
181, 184, 185, 186, 187, 188, 189, 190, 191, 192, 
193, 194, 195, 196, 197, 198, 199, 200, 201, 202, 
203, 204, 205, 206, 207, 208, 261, 262, 263, 264, 
265, 266, 267, 268, 269, 270, 271, 272, 289, 290, 
291, 292, 293, 294, 295, 296, 297, 298, 299, 300, 
301, 302, 303, 304, 305, 306, 307, 308, 309, 310, 
311, 351, 352, 353, 354, 355, 356, 357, 358, 359, 
360, 361, 362, 363, 364, 374, 375, 376, 386, 387, 
388, 389, 390, 391, 392, 393, 394, 395, 396, 400, 
402, 
*NSET,NSET=Solder
3, 4, 7, 8, 9, 10, 11, 12, 13, 14, 
15, 16, 17, 18, 19, 20, 25, 27, 29, 31, 
33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 
43, 44, 79, 83, 91, 92, 93, 94, 95, 96, 
97, 98, 99, 100, 101, 102, 103, 104, 105, 106, 
107, 108, 115, 116, 117, 121, 125, 126, 127, 128, 
129, 130, 131, 132, 133, 134, 135, 136, 137, 138, 
139, 140, 159, 161, 162, 163, 168, 169, 170, 175, 
177, 178, 179, 180, 181, 182, 183, 184, 185, 186, 
187, 188, 195, 196, 197, 204, 205, 206, 207, 208, 
209, 210, 211, 212, 213, 214, 215, 216, 217, 218, 
219, 220, 320, 323, 324, 325, 338, 339, 340, 341, 
347, 349, 350, 351, 364, 365, 366, 367, 
*NSET,NSET=Volume
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 165, 166, 167, 168, 169, 170, 
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 
191, 192, 193, 194, 195, 196, 197, 198, 199, 200, 
201, 202, 203, 204, 205, 206, 207, 208, 209, 210, 
211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 
221, 222, 223, 224, 225, 226, 227, 228, 229, 230, 
231, 232, 233, 234, 235, 236, 237, 238, 239, 240, 
241, 242, 243, 244, 245, 246, 247, 248, 249, 250, 
251, 252, 253, 254, 255, 256, 257, 258, 259, 260, 
261, 262, 263, 264, 265, 266, 267, 268, 269, 270, 
271, 272, 273, 274, 275, 276, 277, 278, 279, 280, 
281, 282, 283, 284, 285, 286, 287, 288, 289, 290, 
291, 292, 293, 294, 295, 296, 297, 298, 299, 300, 
301, 302, 303, 304, 305, 306, 307, 308, 309, 310, 
311, 312, 313, 314, 315, 316, 317, 318, 319, 320, 
321, 322, 323, 324, 325, 326, 327, 328, 329, 330, 
331, 332, 333, 334, 335, 336, 337, 338, 339, 340, 
341, 342, 343, 344, 345, 346, 347, 348, 349, 350, 
351, 352, 353, 354, 355, 356, 357, 358, 359, 360, 
361, 362, 363, 364, 365, 366, 367, 368, 369, 370, 
371, 372, 373, 374, 375, 376, 377, 378, 379, 380, 
381, 382, 383, 384, 385, 386, 387, 388, 389, 390, 
391, 392, 393, 394, 395, 396, 397, 398, 399, 400, 
401, 402, 
*NSET,NSET=TO
9, 10, 11, 12, 13, 14, 15, 16, 33, 34, 
35, 36, 37, 38, 39, 40, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 99, 100, 101, 103, 
105, 106, 107, 108, 109, 110, 111, 112, 113, 114, 
115, 116, 117, 118, 119, 120, 121, 122, 123, 124, 
125, 126, 127, 128, 179, 180, 181, 184, 185, 186, 
187, 188, 189, 190, 191, 192, 193, 194, 195, 196, 
197, 198, 199, 200, 201, 202, 203, 204, 205, 206, 
207, 208, 249, 250, 251, 252, 253, 254, 255, 256, 
257, 258, 259, 260, 261, 262, 263, 264, 265, 266, 
267, 268, 269, 270, 271, 272, 273, 274, 275, 276, 
277, 278, 279, 280, 281, 282, 283, 284, 285, 286, 
287, 288, 289, 290, 291, 292, 293, 294, 295, 296, 
297, 298, 299, 300, 301, 302, 303, 304, 305, 306, 
307, 308, 309, 310, 311, 312, 313, 314, 315, 316, 
317, 318, 325, 326, 327, 328, 329, 330, 331, 332, 
333, 334, 335, 336, 337, 338, 351, 352, 353, 354, 
355, 356, 357, 358, 359, 360, 361, 362, 363, 364, 
371, 372, 373, 374, 375, 376, 377, 378, 379, 380, 
381, 382, 383, 384, 385, 386, 387, 388, 389, 390, 
391, 392, 393, 394, 395, 396, 397, 398, 399, 400, 
401, 402, 
