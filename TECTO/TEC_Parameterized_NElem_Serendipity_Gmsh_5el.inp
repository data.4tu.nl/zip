*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_Serendipity_Gmsh_5el.inp
*NODE
1, 0, 0, 0.5
2, 0, 0, 0
3, 0, 0.05, 0.5
4, 0, 0.05, 0
5, 1, 0, 0.5
6, 1, 0, 0
7, 1, 0.05, 0.5
8, 1, 0.05, 0
9, 1, 0.1, 0
10, 0, 0.1, 0
11, 1, 0.1, 0.5
12, 0, 0.1, 0.5
13, 1, 1.3, 0
14, 0, 1.3, 0
15, 1, 1.3, 0.5
16, 0, 1.3, 0.5
17, 1, 1.35, 0
18, 0, 1.35, 0
19, 1, 1.35, 0.5
20, 0, 1.35, 0.5
21, 1, 1.4, 0
22, 0, 1.4, 0
23, 1, 1.4, 0.5
24, 0, 1.4, 0.5
25, 1.2, 1.35, 0.5
26, 1.2, 1.4, 0.5
27, 1.2, 1.35, 0
28, 1.2, 1.4, 0
29, 2.2, 1.35, 0.5
30, 2.2, 1.4, 0.5
31, 2.2, 1.35, 0
32, 2.2, 1.4, 0
33, 1.2, 1.3, 0.5
34, 2.2, 1.3, 0.5
35, 1.2, 1.3, 0
36, 2.2, 1.3, 0
37, 1.2, 0.1, 0.5
38, 2.2, 0.1, 0.5
39, 1.2, 0.1, 0
40, 2.2, 0.1, 0
41, 1.2, 0.05, 0.5
42, 2.2, 0.05, 0.5
43, 1.2, 0.05, 0
44, 2.2, 0.05, 0
45, 1.2, -8.3266726846887e-17, 0.5
46, 2.2, -8.3266726846887e-17, 0.5
47, 1.2, -8.3266726846887e-17, 0
48, 2.2, -8.3266726846887e-17, 0
49, 2.3, 0.05, 0.5
50, 2.3, -8.3266726846887e-17, 0.5
51, 2.3, 0.05, 0
52, 2.3, -8.3266726846887e-17, 0
53, -0.1, 0, 0.5
54, -0.1, 0, 0
55, -0.1, 0.05, 0.5
56, -0.1, 0.05, 0
57, 1.05, 0.1, 0.5
58, 1.05, 1.3, 0.5
59, 1.05, 0.1, 0
60, 1.05, 1.3, 0
61, 1.15, 1.3, 0.5
62, 1.15, 0.1, 0.5
63, 1.15, 1.3, 0
64, 1.15, 0.1, 0
65, 1, 0.1, -0.1
66, 1, 1.3, -0.1
67, 0, 0.1, -0.1
68, 0, 1.3, -0.1
69, 1.2, 1.3, -0.1
70, 1.2, 0.1, -0.1
71, 2.2, 1.3, -0.1
72, 2.2, 0.1, -0.1
73, 1.15, 1.3, -0.1
74, 1.15, 0.1, -0.1
75, 1.05, 0.1, -0.1
76, 1.05, 1.3, -0.1
77, 0, 0, 0.16666666666667
78, 0, 0, 0.33333333333333
79, 0, 0, 0.083333333333333
80, 0, 0, 0.25
81, 0, 0, 0.41666666666667
82, 0, 0.025, 0.5
83, 0, 0.0125, 0.5
84, 0, 0.0375, 0.5
85, 0, 0.05, 0.16666666666667
86, 0, 0.05, 0.33333333333333
87, 0, 0.05, 0.083333333333333
88, 0, 0.05, 0.25
89, 0, 0.05, 0.41666666666667
90, 0, 0.025, 0
91, 0, 0.0125, 0
92, 0, 0.0375, 0
93, 1, 0, 0.16666666666667
94, 1, 0, 0.33333333333333
95, 1, 0, 0.083333333333333
96, 1, 0, 0.25
97, 1, 0, 0.41666666666667
98, 1, 0.025, 0.5
99, 1, 0.0125, 0.5
100, 1, 0.0375, 0.5
101, 1, 0.05, 0.16666666666667
102, 1, 0.05, 0.33333333333333
103, 1, 0.05, 0.083333333333333
104, 1, 0.05, 0.25
105, 1, 0.05, 0.41666666666667
106, 1, 0.025, 0
107, 1, 0.0125, 0
108, 1, 0.0375, 0
109, 0.2, 0, 0
110, 0.4, 0, 0
111, 0.6, 0, 0
112, 0.8, 0, 0
113, 0.1, 0, 0
114, 0.3, 0, 0
115, 0.5, 0, 0
116, 0.7, 0, 0
117, 0.9, 0, 0
118, 0.2, 0, 0.5
119, 0.4, 0, 0.5
120, 0.6, 0, 0.5
121, 0.8, 0, 0.5
122, 0.1, 0, 0.5
123, 0.3, 0, 0.5
124, 0.5, 0, 0.5
125, 0.7, 0, 0.5
126, 0.9, 0, 0.5
127, 0.2, 0.05, 0
128, 0.4, 0.05, 0
129, 0.6, 0.05, 0
130, 0.8, 0.05, 0
131, 0.1, 0.05, 0
132, 0.3, 0.05, 0
133, 0.5, 0.05, 0
134, 0.7, 0.05, 0
135, 0.9, 0.05, 0
136, 0.2, 0.05, 0.5
137, 0.4, 0.05, 0.5
138, 0.6, 0.05, 0.5
139, 0.8, 0.05, 0.5
140, 0.1, 0.05, 0.5
141, 0.3, 0.05, 0.5
142, 0.5, 0.05, 0.5
143, 0.7, 0.05, 0.5
144, 0.9, 0.05, 0.5
145, 1, 0.075, 0
146, 0, 0.075, 0
147, 0.2, 0.1, 0
148, 0.4, 0.1, 0
149, 0.6, 0.1, 0
150, 0.8, 0.1, 0
151, 0.1, 0.1, 0
152, 0.3, 0.1, 0
153, 0.5, 0.1, 0
154, 0.7, 0.1, 0
155, 0.9, 0.1, 0
156, 1, 0.075, 0.5
157, 1, 0.1, 0.16666666666667
158, 1, 0.1, 0.33333333333333
159, 1, 0.1, 0.083333333333333
160, 1, 0.1, 0.25
161, 1, 0.1, 0.41666666666667
162, 0, 0.075, 0.5
163, 0.2, 0.1, 0.5
164, 0.4, 0.1, 0.5
165, 0.6, 0.1, 0.5
166, 0.8, 0.1, 0.5
167, 0.1, 0.1, 0.5
168, 0.3, 0.1, 0.5
169, 0.5, 0.1, 0.5
170, 0.7, 0.1, 0.5
171, 0.9, 0.1, 0.5
172, 0, 0.1, 0.16666666666667
173, 0, 0.1, 0.33333333333333
174, 0, 0.1, 0.083333333333333
175, 0, 0.1, 0.25
176, 0, 0.1, 0.41666666666667
177, 1, 0.34, 0
178, 1, 0.58, 0
179, 1, 0.82, 0
180, 1, 1.06, 0
181, 1, 0.22, 0
182, 1, 0.46, 0
183, 1, 0.7, 0
184, 1, 0.94, 0
185, 1, 1.18, 0
186, 0, 0.34, 0
187, 0, 0.58, 0
188, 0, 0.82, 0
189, 0, 1.06, 0
190, 0, 0.22, 0
191, 0, 0.46, 0
192, 0, 0.7, 0
193, 0, 0.94, 0
194, 0, 1.18, 0
195, 0.2, 1.3, 0
196, 0.4, 1.3, 0
197, 0.6, 1.3, 0
198, 0.8, 1.3, 0
199, 0.1, 1.3, 0
200, 0.3, 1.3, 0
201, 0.5, 1.3, 0
202, 0.7, 1.3, 0
203, 0.9, 1.3, 0
204, 1, 0.34, 0.5
205, 1, 0.58, 0.5
206, 1, 0.82, 0.5
207, 1, 1.06, 0.5
208, 1, 0.22, 0.5
209, 1, 0.46, 0.5
210, 1, 0.7, 0.5
211, 1, 0.94, 0.5
212, 1, 1.18, 0.5
213, 1, 1.3, 0.16666666666667
214, 1, 1.3, 0.33333333333333
215, 1, 1.3, 0.083333333333333
216, 1, 1.3, 0.25
217, 1, 1.3, 0.41666666666667
218, 0, 0.34, 0.5
219, 0, 0.58, 0.5
220, 0, 0.82, 0.5
221, 0, 1.06, 0.5
222, 0, 0.22, 0.5
223, 0, 0.46, 0.5
224, 0, 0.7, 0.5
225, 0, 0.94, 0.5
226, 0, 1.18, 0.5
227, 0.2, 1.3, 0.5
228, 0.4, 1.3, 0.5
229, 0.6, 1.3, 0.5
230, 0.8, 1.3, 0.5
231, 0.1, 1.3, 0.5
232, 0.3, 1.3, 0.5
233, 0.5, 1.3, 0.5
234, 0.7, 1.3, 0.5
235, 0.9, 1.3, 0.5
236, 0, 1.3, 0.16666666666667
237, 0, 1.3, 0.33333333333333
238, 0, 1.3, 0.083333333333333
239, 0, 1.3, 0.25
240, 0, 1.3, 0.41666666666667
241, 1, 1.325, 0
242, 0, 1.325, 0
243, 0.2, 1.35, 0
244, 0.4, 1.35, 0
245, 0.6, 1.35, 0
246, 0.8, 1.35, 0
247, 0.1, 1.35, 0
248, 0.3, 1.35, 0
249, 0.5, 1.35, 0
250, 0.7, 1.35, 0
251, 0.9, 1.35, 0
252, 1, 1.325, 0.5
253, 1, 1.35, 0.16666666666667
254, 1, 1.35, 0.33333333333333
255, 1, 1.35, 0.083333333333333
256, 1, 1.35, 0.25
257, 1, 1.35, 0.41666666666667
258, 0, 1.325, 0.5
259, 0.2, 1.35, 0.5
260, 0.4, 1.35, 0.5
261, 0.6, 1.35, 0.5
262, 0.8, 1.35, 0.5
263, 0.1, 1.35, 0.5
264, 0.3, 1.35, 0.5
265, 0.5, 1.35, 0.5
266, 0.7, 1.35, 0.5
267, 0.9, 1.35, 0.5
268, 0, 1.35, 0.16666666666667
269, 0, 1.35, 0.33333333333333
270, 0, 1.35, 0.083333333333333
271, 0, 1.35, 0.25
272, 0, 1.35, 0.41666666666667
273, 1, 1.375, 0
274, 1, 1.3625, 0
275, 1, 1.3875, 0
276, 0, 1.375, 0
277, 0, 1.3625, 0
278, 0, 1.3875, 0
279, 0.2, 1.4, 0
280, 0.4, 1.4, 0
281, 0.6, 1.4, 0
282, 0.8, 1.4, 0
283, 0.1, 1.4, 0
284, 0.3, 1.4, 0
285, 0.5, 1.4, 0
286, 0.7, 1.4, 0
287, 0.9, 1.4, 0
288, 1, 1.375, 0.5
289, 1, 1.3625, 0.5
290, 1, 1.3875, 0.5
291, 1, 1.4, 0.16666666666667
292, 1, 1.4, 0.33333333333333
293, 1, 1.4, 0.083333333333333
294, 1, 1.4, 0.25
295, 1, 1.4, 0.41666666666667
296, 0, 1.375, 0.5
297, 0, 1.3625, 0.5
298, 0, 1.3875, 0.5
299, 0.2, 1.4, 0.5
300, 0.4, 1.4, 0.5
301, 0.6, 1.4, 0.5
302, 0.8, 1.4, 0.5
303, 0.1, 1.4, 0.5
304, 0.3, 1.4, 0.5
305, 0.5, 1.4, 0.5
306, 0.7, 1.4, 0.5
307, 0.9, 1.4, 0.5
308, 0, 1.4, 0.16666666666667
309, 0, 1.4, 0.33333333333333
310, 0, 1.4, 0.083333333333333
311, 0, 1.4, 0.25
312, 0, 1.4, 0.41666666666667
313, 1.1, 1.35, 0.5
314, 1.1, 1.4, 0.5
315, 1.2, 1.375, 0.5
316, 1.2, 1.3625, 0.5
317, 1.2, 1.3875, 0.5
318, 1.1, 1.35, 0
319, 1.1, 1.4, 0
320, 1.2, 1.375, 0
321, 1.2, 1.3625, 0
322, 1.2, 1.3875, 0
323, 1.2, 1.35, 0.16666666666667
324, 1.2, 1.35, 0.33333333333333
325, 1.2, 1.35, 0.083333333333333
326, 1.2, 1.35, 0.25
327, 1.2, 1.35, 0.41666666666667
328, 1.2, 1.4, 0.16666666666667
329, 1.2, 1.4, 0.33333333333333
330, 1.2, 1.4, 0.083333333333333
331, 1.2, 1.4, 0.25
332, 1.2, 1.4, 0.41666666666667
333, 1.4, 1.35, 0.5
334, 1.6, 1.35, 0.5
335, 1.8, 1.35, 0.5
336, 2, 1.35, 0.5
337, 1.3, 1.35, 0.5
338, 1.5, 1.35, 0.5
339, 1.7, 1.35, 0.5
340, 1.9, 1.35, 0.5
341, 2.1, 1.35, 0.5
342, 1.4, 1.4, 0.5
343, 1.6, 1.4, 0.5
344, 1.8, 1.4, 0.5
345, 2, 1.4, 0.5
346, 1.3, 1.4, 0.5
347, 1.5, 1.4, 0.5
348, 1.7, 1.4, 0.5
349, 1.9, 1.4, 0.5
350, 2.1, 1.4, 0.5
351, 2.2, 1.375, 0.5
352, 2.2, 1.3625, 0.5
353, 2.2, 1.3875, 0.5
354, 1.4, 1.35, 0
355, 1.6, 1.35, 0
356, 1.8, 1.35, 0
357, 2, 1.35, 0
358, 1.3, 1.35, 0
359, 1.5, 1.35, 0
360, 1.7, 1.35, 0
361, 1.9, 1.35, 0
362, 2.1, 1.35, 0
363, 1.4, 1.4, 0
364, 1.6, 1.4, 0
365, 1.8, 1.4, 0
366, 2, 1.4, 0
367, 1.3, 1.4, 0
368, 1.5, 1.4, 0
369, 1.7, 1.4, 0
370, 1.9, 1.4, 0
371, 2.1, 1.4, 0
372, 2.2, 1.375, 0
373, 2.2, 1.3625, 0
374, 2.2, 1.3875, 0
375, 2.2, 1.35, 0.16666666666667
376, 2.2, 1.35, 0.33333333333333
377, 2.2, 1.35, 0.083333333333333
378, 2.2, 1.35, 0.25
379, 2.2, 1.35, 0.41666666666667
380, 2.2, 1.4, 0.16666666666667
381, 2.2, 1.4, 0.33333333333333
382, 2.2, 1.4, 0.083333333333333
383, 2.2, 1.4, 0.25
384, 2.2, 1.4, 0.41666666666667
385, 1.2, 1.325, 0.5
386, 2.2, 1.325, 0.5
387, 1.4, 1.3, 0.5
388, 1.6, 1.3, 0.5
389, 1.8, 1.3, 0.5
390, 2, 1.3, 0.5
391, 1.3, 1.3, 0.5
392, 1.5, 1.3, 0.5
393, 1.7, 1.3, 0.5
394, 1.9, 1.3, 0.5
395, 2.1, 1.3, 0.5
396, 1.2, 1.325, 0
397, 2.2, 1.325, 0
398, 1.4, 1.3, 0
399, 1.6, 1.3, 0
400, 1.8, 1.3, 0
401, 2, 1.3, 0
402, 1.3, 1.3, 0
403, 1.5, 1.3, 0
404, 1.7, 1.3, 0
405, 1.9, 1.3, 0
406, 2.1, 1.3, 0
407, 1.2, 1.3, 0.16666666666667
408, 1.2, 1.3, 0.33333333333333
409, 1.2, 1.3, 0.083333333333333
410, 1.2, 1.3, 0.25
411, 1.2, 1.3, 0.41666666666667
412, 2.2, 1.3, 0.16666666666667
413, 2.2, 1.3, 0.33333333333333
414, 2.2, 1.3, 0.083333333333333
415, 2.2, 1.3, 0.25
416, 2.2, 1.3, 0.41666666666667
417, 1.2, 1.06, 0.5
418, 1.2, 0.82, 0.5
419, 1.2, 0.58, 0.5
420, 1.2, 0.34, 0.5
421, 1.2, 1.18, 0.5
422, 1.2, 0.94, 0.5
423, 1.2, 0.7, 0.5
424, 1.2, 0.46, 0.5
425, 1.2, 0.22, 0.5
426, 2.2, 1.06, 0.5
427, 2.2, 0.82, 0.5
428, 2.2, 0.58, 0.5
429, 2.2, 0.34, 0.5
430, 2.2, 1.18, 0.5
431, 2.2, 0.94, 0.5
432, 2.2, 0.7, 0.5
433, 2.2, 0.46, 0.5
434, 2.2, 0.22, 0.5
435, 1.4, 0.1, 0.5
436, 1.6, 0.1, 0.5
437, 1.8, 0.1, 0.5
438, 2, 0.1, 0.5
439, 1.3, 0.1, 0.5
440, 1.5, 0.1, 0.5
441, 1.7, 0.1, 0.5
442, 1.9, 0.1, 0.5
443, 2.1, 0.1, 0.5
444, 1.2, 1.06, 0
445, 1.2, 0.82, 0
446, 1.2, 0.58, 0
447, 1.2, 0.34, 0
448, 1.2, 1.18, 0
449, 1.2, 0.94, 0
450, 1.2, 0.7, 0
451, 1.2, 0.46, 0
452, 1.2, 0.22, 0
453, 2.2, 1.06, 0
454, 2.2, 0.82, 0
455, 2.2, 0.58, 0
456, 2.2, 0.34, 0
457, 2.2, 1.18, 0
458, 2.2, 0.94, 0
459, 2.2, 0.7, 0
460, 2.2, 0.46, 0
461, 2.2, 0.22, 0
462, 1.4, 0.1, 0
463, 1.6, 0.1, 0
464, 1.8, 0.1, 0
465, 2, 0.1, 0
466, 1.3, 0.1, 0
467, 1.5, 0.1, 0
468, 1.7, 0.1, 0
469, 1.9, 0.1, 0
470, 2.1, 0.1, 0
471, 1.2, 0.1, 0.16666666666667
472, 1.2, 0.1, 0.33333333333333
473, 1.2, 0.1, 0.083333333333333
474, 1.2, 0.1, 0.25
475, 1.2, 0.1, 0.41666666666667
476, 2.2, 0.1, 0.16666666666667
477, 2.2, 0.1, 0.33333333333333
478, 2.2, 0.1, 0.083333333333333
479, 2.2, 0.1, 0.25
480, 2.2, 0.1, 0.41666666666667
481, 1.2, 0.075, 0.5
482, 2.2, 0.075, 0.5
483, 1.4, 0.05, 0.5
484, 1.6, 0.05, 0.5
485, 1.8, 0.05, 0.5
486, 2, 0.05, 0.5
487, 1.3, 0.05, 0.5
488, 1.5, 0.05, 0.5
489, 1.7, 0.05, 0.5
490, 1.9, 0.05, 0.5
491, 2.1, 0.05, 0.5
492, 1.2, 0.075, 0
493, 2.2, 0.075, 0
494, 1.4, 0.05, 0
495, 1.6, 0.05, 0
496, 1.8, 0.05, 0
497, 2, 0.05, 0
498, 1.3, 0.05, 0
499, 1.5, 0.05, 0
500, 1.7, 0.05, 0
501, 1.9, 0.05, 0
502, 2.1, 0.05, 0
503, 1.2, 0.05, 0.16666666666667
504, 1.2, 0.05, 0.33333333333333
505, 1.2, 0.05, 0.083333333333333
506, 1.2, 0.05, 0.25
507, 1.2, 0.05, 0.41666666666667
508, 2.2, 0.05, 0.16666666666667
509, 2.2, 0.05, 0.33333333333333
510, 2.2, 0.05, 0.083333333333333
511, 2.2, 0.05, 0.25
512, 2.2, 0.05, 0.41666666666667
513, 1.2, 0.025, 0.5
514, 1.2, 0.0375, 0.5
515, 1.2, 0.0125, 0.5
516, 2.2, 0.025, 0.5
517, 2.2, 0.0375, 0.5
518, 2.2, 0.0125, 0.5
519, 1.4, 8.3266726846887e-17, 0.5
520, 1.6, 8.3266726846887e-17, 0.5
521, 1.8, 8.3266726846887e-17, 0.5
522, 2, 8.3266726846887e-17, 0.5
523, 1.3, 0, 0.5
524, 1.5, 0, 0.5
525, 1.7, 0, 0.5
526, 1.9, 0, 0.5
527, 2.1, 0, 0.5
528, 1.2, 0.025, 0
529, 1.2, 0.0375, 0
530, 1.2, 0.0125, 0
531, 2.2, 0.025, 0
532, 2.2, 0.0375, 0
533, 2.2, 0.0125, 0
534, 1.4, 8.3266726846887e-17, 0
535, 1.6, 8.3266726846887e-17, 0
536, 1.8, 8.3266726846887e-17, 0
537, 2, 8.3266726846887e-17, 0
538, 1.3, 0, 0
539, 1.5, 0, 0
540, 1.7, 0, 0
541, 1.9, 0, 0
542, 2.1, 0, 0
543, 1.2, 8.3266726846887e-17, 0.16666666666667
544, 1.2, 8.3266726846887e-17, 0.33333333333333
545, 1.2, -8.3266726846887e-17, 0.083333333333333
546, 1.2, -8.3266726846887e-17, 0.25
547, 1.2, -8.3266726846887e-17, 0.41666666666667
548, 2.2, 8.3266726846887e-17, 0.16666666666667
549, 2.2, 8.3266726846887e-17, 0.33333333333333
550, 2.2, -8.3266726846887e-17, 0.083333333333333
551, 2.2, -8.3266726846887e-17, 0.25
552, 2.2, -8.3266726846887e-17, 0.41666666666667
553, 2.25, 0.05, 0.5
554, 2.25, -8.3266726846887e-17, 0.5
555, 2.3, 0.025, 0.5
556, 2.3, 0.0375, 0.5
557, 2.3, 0.0125, 0.5
558, 2.25, 0.05, 0
559, 2.25, -8.3266726846887e-17, 0
560, 2.3, 0.025, 0
561, 2.3, 0.0375, 0
562, 2.3, 0.0125, 0
563, 2.3, 0.05, 0.16666666666667
564, 2.3, 0.05, 0.33333333333333
565, 2.3, 0.05, 0.083333333333333
566, 2.3, 0.05, 0.25
567, 2.3, 0.05, 0.41666666666667
568, 2.3, 8.3266726846887e-17, 0.16666666666667
569, 2.3, 8.3266726846887e-17, 0.33333333333333
570, 2.3, -8.3266726846887e-17, 0.083333333333333
571, 2.3, -8.3266726846887e-17, 0.25
572, 2.3, -8.3266726846887e-17, 0.41666666666667
573, -0.05, 0, 0.5
574, -0.05, 0, 0
575, -0.1, 0, 0.16666666666667
576, -0.1, 0, 0.33333333333333
577, -0.1, 0, 0.083333333333333
578, -0.1, 0, 0.25
579, -0.1, 0, 0.41666666666667
580, -0.05, 0.05, 0.5
581, -0.1, 0.025, 0.5
582, -0.1, 0.0125, 0.5
583, -0.1, 0.0375, 0.5
584, -0.05, 0.05, 0
585, -0.1, 0.05, 0.16666666666667
586, -0.1, 0.05, 0.33333333333333
587, -0.1, 0.05, 0.083333333333333
588, -0.1, 0.05, 0.25
589, -0.1, 0.05, 0.41666666666667
590, -0.1, 0.025, 0
591, -0.1, 0.0125, 0
592, -0.1, 0.0375, 0
593, 1.025, 0.1, 0.5
594, 1.025, 1.3, 0.5
595, 1.05, 0.34, 0.5
596, 1.05, 0.58, 0.5
597, 1.05, 0.82, 0.5
598, 1.05, 1.06, 0.5
599, 1.05, 0.22, 0.5
600, 1.05, 0.46, 0.5
601, 1.05, 0.7, 0.5
602, 1.05, 0.94, 0.5
603, 1.05, 1.18, 0.5
604, 1.025, 0.1, 0
605, 1.025, 1.3, 0
606, 1.05, 0.34, 0
607, 1.05, 0.58, 0
608, 1.05, 0.82, 0
609, 1.05, 1.06, 0
610, 1.05, 0.22, 0
611, 1.05, 0.46, 0
612, 1.05, 0.7, 0
613, 1.05, 0.94, 0
614, 1.05, 1.18, 0
615, 1.05, 0.1, 0.16666666666667
616, 1.05, 0.1, 0.33333333333333
617, 1.05, 0.1, 0.083333333333333
618, 1.05, 0.1, 0.25
619, 1.05, 0.1, 0.41666666666667
620, 1.05, 1.3, 0.16666666666667
621, 1.05, 1.3, 0.33333333333333
622, 1.05, 1.3, 0.083333333333333
623, 1.05, 1.3, 0.25
624, 1.05, 1.3, 0.41666666666667
625, 1.175, 1.3, 0.5
626, 1.175, 0.1, 0.5
627, 1.15, 1.06, 0.5
628, 1.15, 0.82, 0.5
629, 1.15, 0.58, 0.5
630, 1.15, 0.34, 0.5
631, 1.15, 1.18, 0.5
632, 1.15, 0.94, 0.5
633, 1.15, 0.7, 0.5
634, 1.15, 0.46, 0.5
635, 1.15, 0.22, 0.5
636, 1.175, 1.3, 0
637, 1.175, 0.1, 0
638, 1.15, 1.06, 0
639, 1.15, 0.82, 0
640, 1.15, 0.58, 0
641, 1.15, 0.34, 0
642, 1.15, 1.18, 0
643, 1.15, 0.94, 0
644, 1.15, 0.7, 0
645, 1.15, 0.46, 0
646, 1.15, 0.22, 0
647, 1.15, 1.3, 0.16666666666667
648, 1.15, 1.3, 0.33333333333333
649, 1.15, 1.3, 0.083333333333333
650, 1.15, 1.3, 0.25
651, 1.15, 1.3, 0.41666666666667
652, 1.15, 0.1, 0.16666666666667
653, 1.15, 0.1, 0.33333333333333
654, 1.15, 0.1, 0.083333333333333
655, 1.15, 0.1, 0.25
656, 1.15, 0.1, 0.41666666666667
657, 1, 0.1, -0.05
658, 1, 0.1, -0.025
659, 1, 0.1, -0.075
660, 1, 1.3, -0.05
661, 1, 1.3, -0.025
662, 1, 1.3, -0.075
663, 1, 0.34, -0.1
664, 1, 0.58, -0.1
665, 1, 0.82, -0.1
666, 1, 1.06, -0.1
667, 1, 0.22, -0.1
668, 1, 0.46, -0.1
669, 1, 0.7, -0.1
670, 1, 0.94, -0.1
671, 1, 1.18, -0.1
672, 0, 0.1, -0.05
673, 0, 0.1, -0.025
674, 0, 0.1, -0.075
675, 0, 1.3, -0.05
676, 0, 1.3, -0.025
677, 0, 1.3, -0.075
678, 0, 0.34, -0.1
679, 0, 0.58, -0.1
680, 0, 0.82, -0.1
681, 0, 1.06, -0.1
682, 0, 0.22, -0.1
683, 0, 0.46, -0.1
684, 0, 0.7, -0.1
685, 0, 0.94, -0.1
686, 0, 1.18, -0.1
687, 0.2, 0.1, -0.1
688, 0.4, 0.1, -0.1
689, 0.6, 0.1, -0.1
690, 0.8, 0.1, -0.1
691, 0.1, 0.1, -0.1
692, 0.3, 0.1, -0.1
693, 0.5, 0.1, -0.1
694, 0.7, 0.1, -0.1
695, 0.9, 0.1, -0.1
696, 0.2, 1.3, -0.1
697, 0.4, 1.3, -0.1
698, 0.6, 1.3, -0.1
699, 0.8, 1.3, -0.1
700, 0.1, 1.3, -0.1
701, 0.3, 1.3, -0.1
702, 0.5, 1.3, -0.1
703, 0.7, 1.3, -0.1
704, 0.9, 1.3, -0.1
705, 1.2, 1.3, -0.05
706, 1.2, 1.3, -0.025
707, 1.2, 1.3, -0.075
708, 1.2, 0.1, -0.05
709, 1.2, 0.1, -0.025
710, 1.2, 0.1, -0.075
711, 1.2, 1.06, -0.1
712, 1.2, 0.82, -0.1
713, 1.2, 0.58, -0.1
714, 1.2, 0.34, -0.1
715, 1.2, 1.18, -0.1
716, 1.2, 0.94, -0.1
717, 1.2, 0.7, -0.1
718, 1.2, 0.46, -0.1
719, 1.2, 0.22, -0.1
720, 2.2, 1.3, -0.05
721, 2.2, 1.3, -0.025
722, 2.2, 1.3, -0.075
723, 2.2, 0.1, -0.05
724, 2.2, 0.1, -0.025
725, 2.2, 0.1, -0.075
726, 2.2, 1.06, -0.1
727, 2.2, 0.82, -0.1
728, 2.2, 0.58, -0.1
729, 2.2, 0.34, -0.1
730, 2.2, 1.18, -0.1
731, 2.2, 0.94, -0.1
732, 2.2, 0.7, -0.1
733, 2.2, 0.46, -0.1
734, 2.2, 0.22, -0.1
735, 1.4, 1.3, -0.1
736, 1.6, 1.3, -0.1
737, 1.8, 1.3, -0.1
738, 2, 1.3, -0.1
739, 1.3, 1.3, -0.1
740, 1.5, 1.3, -0.1
741, 1.7, 1.3, -0.1
742, 1.9, 1.3, -0.1
743, 2.1, 1.3, -0.1
744, 1.4, 0.1, -0.1
745, 1.6, 0.1, -0.1
746, 1.8, 0.1, -0.1
747, 2, 0.1, -0.1
748, 1.3, 0.1, -0.1
749, 1.5, 0.1, -0.1
750, 1.7, 0.1, -0.1
751, 1.9, 0.1, -0.1
752, 2.1, 0.1, -0.1
753, 1.15, 1.3, -0.05
754, 1.15, 1.3, -0.025
755, 1.15, 1.3, -0.075
756, 1.175, 1.3, -0.1
757, 1.15, 0.1, -0.05
758, 1.15, 0.1, -0.025
759, 1.15, 0.1, -0.075
760, 1.175, 0.1, -0.1
761, 1.15, 1.06, -0.1
762, 1.15, 0.82, -0.1
763, 1.15, 0.58, -0.1
764, 1.15, 0.34, -0.1
765, 1.15, 1.18, -0.1
766, 1.15, 0.94, -0.1
767, 1.15, 0.7, -0.1
768, 1.15, 0.46, -0.1
769, 1.15, 0.22, -0.1
770, 1.05, 0.1, -0.05
771, 1.05, 0.1, -0.025
772, 1.05, 0.1, -0.075
773, 1.025, 0.1, -0.1
774, 1.05, 1.3, -0.05
775, 1.05, 1.3, -0.025
776, 1.05, 1.3, -0.075
777, 1.025, 1.3, -0.1
778, 1.05, 0.34, -0.1
779, 1.05, 0.58, -0.1
780, 1.05, 0.82, -0.1
781, 1.05, 1.06, -0.1
782, 1.05, 0.22, -0.1
783, 1.05, 0.46, -0.1
784, 1.05, 0.7, -0.1
785, 1.05, 0.94, -0.1
786, 1.05, 1.18, -0.1
787, 0, 0.025, 0.16666666666667
788, 0, 0.025, 0.33333333333333
789, 0, 0.0125, 0.16666666666667
790, 0, 0.025, 0.083333333333333
791, 0, 0.0375, 0.16666666666667
792, 0, 0.0125, 0.33333333333333
793, 0, 0.025, 0.25
794, 0, 0.0375, 0.33333333333333
795, 0, 0.025, 0.41666666666667
796, 1, 0.025, 0.16666666666667
797, 1, 0.025, 0.33333333333333
798, 1, 0.025, 0.083333333333333
799, 1, 0.0125, 0.16666666666667
800, 1, 0.0375, 0.16666666666667
801, 1, 0.025, 0.25
802, 1, 0.0125, 0.33333333333333
803, 1, 0.0375, 0.33333333333333
804, 1, 0.025, 0.41666666666667
805, 0.2, 0, 0.16666666666667
806, 0.2, 0, 0.33333333333333
807, 0.4, 0, 0.16666666666667
808, 0.4, 0, 0.33333333333333
809, 0.6, 0, 0.16666666666667
810, 0.6, 0, 0.33333333333333
811, 0.8, 0, 0.16666666666667
812, 0.8, 0, 0.33333333333333
813, 0.2, 0, 0.083333333333333
814, 0.1, 0, 0.16666666666667
815, 0.2, 0, 0.25
816, 0.1, 0, 0.33333333333333
817, 0.2, 0, 0.41666666666667
818, 0.4, 0, 0.083333333333333
819, 0.3, 0, 0.16666666666667
820, 0.4, 0, 0.25
821, 0.3, 0, 0.33333333333333
822, 0.4, 0, 0.41666666666667
823, 0.6, 0, 0.083333333333333
824, 0.5, 0, 0.16666666666667
825, 0.6, 0, 0.25
826, 0.5, 0, 0.33333333333333
827, 0.6, 0, 0.41666666666667
828, 0.8, 0, 0.083333333333333
829, 0.7, 0, 0.16666666666667
830, 0.8, 0, 0.25
831, 0.7, 0, 0.33333333333333
832, 0.8, 0, 0.41666666666667
833, 0.9, 0, 0.16666666666667
834, 0.9, 0, 0.33333333333333
835, 0.2, 0.05, 0.16666666666667
836, 0.2, 0.05, 0.33333333333333
837, 0.4, 0.05, 0.16666666666667
838, 0.4, 0.05, 0.33333333333333
839, 0.6, 0.05, 0.16666666666667
840, 0.6, 0.05, 0.33333333333333
841, 0.8, 0.05, 0.16666666666667
842, 0.8, 0.05, 0.33333333333333
843, 0.1, 0.05, 0.16666666666667
844, 0.2, 0.05, 0.083333333333333
845, 0.1, 0.05, 0.33333333333333
846, 0.2, 0.05, 0.25
847, 0.2, 0.05, 0.41666666666667
848, 0.3, 0.05, 0.16666666666667
849, 0.4, 0.05, 0.083333333333333
850, 0.3, 0.05, 0.33333333333333
851, 0.4, 0.05, 0.25
852, 0.4, 0.05, 0.41666666666667
853, 0.5, 0.05, 0.16666666666667
854, 0.6, 0.05, 0.083333333333333
855, 0.5, 0.05, 0.33333333333333
856, 0.6, 0.05, 0.25
857, 0.6, 0.05, 0.41666666666667
858, 0.7, 0.05, 0.16666666666667
859, 0.8, 0.05, 0.083333333333333
860, 0.7, 0.05, 0.33333333333333
861, 0.8, 0.05, 0.25
862, 0.8, 0.05, 0.41666666666667
863, 0.9, 0.05, 0.16666666666667
864, 0.9, 0.05, 0.33333333333333
865, 0.2, 0.025, 0
866, 0.4, 0.025, 0
867, 0.6, 0.025, 0
868, 0.8, 0.025, 0
869, 0.1, 0.025, 0
870, 0.2, 0.0125, 0
871, 0.3, 0.025, 0
872, 0.4, 0.0125, 0
873, 0.5, 0.025, 0
874, 0.6, 0.0125, 0
875, 0.7, 0.025, 0
876, 0.8, 0.0125, 0
877, 0.9, 0.025, 0
878, 0.2, 0.0375, 0
879, 0.4, 0.0375, 0
880, 0.6, 0.0375, 0
881, 0.8, 0.0375, 0
882, 0.2, 0.025, 0.5
883, 0.4, 0.025, 0.5
884, 0.6, 0.025, 0.5
885, 0.8, 0.025, 0.5
886, 0.2, 0.0125, 0.5
887, 0.1, 0.025, 0.5
888, 0.4, 0.0125, 0.5
889, 0.3, 0.025, 0.5
890, 0.6, 0.0125, 0.5
891, 0.5, 0.025, 0.5
892, 0.8, 0.0125, 0.5
893, 0.7, 0.025, 0.5
894, 0.9, 0.025, 0.5
895, 0.2, 0.0375, 0.5
896, 0.4, 0.0375, 0.5
897, 0.6, 0.0375, 0.5
898, 0.8, 0.0375, 0.5
899, 0.2, 0.075, 0
900, 0.4, 0.075, 0
901, 0.6, 0.075, 0
902, 0.8, 0.075, 0
903, 1, 0.075, 0.16666666666667
904, 1, 0.075, 0.33333333333333
905, 0.2, 0.075, 0.5
906, 0.4, 0.075, 0.5
907, 0.6, 0.075, 0.5
908, 0.8, 0.075, 0.5
909, 0, 0.075, 0.16666666666667
910, 0, 0.075, 0.33333333333333
911, 0.2, 0.1, 0.16666666666667
912, 0.2, 0.1, 0.33333333333333
913, 0.4, 0.1, 0.16666666666667
914, 0.4, 0.1, 0.33333333333333
915, 0.6, 0.1, 0.16666666666667
916, 0.6, 0.1, 0.33333333333333
917, 0.8, 0.1, 0.16666666666667
918, 0.8, 0.1, 0.33333333333333
919, 0.1, 0.1, 0.16666666666667
920, 0.2, 0.1, 0.083333333333333
921, 0.1, 0.1, 0.33333333333333
922, 0.2, 0.1, 0.25
923, 0.2, 0.1, 0.41666666666667
924, 0.3, 0.1, 0.16666666666667
925, 0.4, 0.1, 0.083333333333333
926, 0.3, 0.1, 0.33333333333333
927, 0.4, 0.1, 0.25
928, 0.4, 0.1, 0.41666666666667
929, 0.5, 0.1, 0.16666666666667
930, 0.6, 0.1, 0.083333333333333
931, 0.5, 0.1, 0.33333333333333
932, 0.6, 0.1, 0.25
933, 0.6, 0.1, 0.41666666666667
934, 0.7, 0.1, 0.16666666666667
935, 0.8, 0.1, 0.083333333333333
936, 0.7, 0.1, 0.33333333333333
937, 0.8, 0.1, 0.25
938, 0.8, 0.1, 0.41666666666667
939, 0.9, 0.1, 0.16666666666667
940, 0.9, 0.1, 0.33333333333333
941, 0.2, 0.34, 0
942, 0.2, 0.58, 0
943, 0.2, 0.82, 0
944, 0.2, 1.06, 0
945, 0.4, 0.34, 0
946, 0.4, 0.58, 0
947, 0.4, 0.82, 0
948, 0.4, 1.06, 0
949, 0.6, 0.34, 0
950, 0.6, 0.58, 0
951, 0.6, 0.82, 0
952, 0.6, 1.06, 0
953, 0.8, 0.34, 0
954, 0.8, 0.58, 0
955, 0.8, 0.82, 0
956, 0.8, 1.06, 0
957, 0.1, 0.34, 0
958, 0.2, 0.22, 0
959, 0.1, 0.58, 0
960, 0.2, 0.46, 0
961, 0.1, 0.82, 0
962, 0.2, 0.7, 0
963, 0.1, 1.06, 0
964, 0.2, 0.94, 0
965, 0.2, 1.18, 0
966, 0.3, 0.34, 0
967, 0.4, 0.22, 0
968, 0.3, 0.58, 0
969, 0.4, 0.46, 0
970, 0.3, 0.82, 0
971, 0.4, 0.7, 0
972, 0.3, 1.06, 0
973, 0.4, 0.94, 0
974, 0.4, 1.18, 0
975, 0.5, 0.34, 0
976, 0.6, 0.22, 0
977, 0.5, 0.58, 0
978, 0.6, 0.46, 0
979, 0.5, 0.82, 0
980, 0.6, 0.7, 0
981, 0.5, 1.06, 0
982, 0.6, 0.94, 0
983, 0.6, 1.18, 0
984, 0.7, 0.34, 0
985, 0.8, 0.22, 0
986, 0.7, 0.58, 0
987, 0.8, 0.46, 0
988, 0.7, 0.82, 0
989, 0.8, 0.7, 0
990, 0.7, 1.06, 0
991, 0.8, 0.94, 0
992, 0.8, 1.18, 0
993, 0.9, 0.34, 0
994, 0.9, 0.58, 0
995, 0.9, 0.82, 0
996, 0.9, 1.06, 0
997, 1, 0.34, 0.16666666666667
998, 1, 0.58, 0.16666666666667
999, 1, 0.82, 0.16666666666667
1000, 1, 1.06, 0.16666666666667
1001, 1, 0.34, 0.33333333333333
1002, 1, 0.58, 0.33333333333333
1003, 1, 0.82, 0.33333333333333
1004, 1, 1.06, 0.33333333333333
1005, 1, 0.34, 0.083333333333333
1006, 1, 0.22, 0.16666666666667
1007, 1, 0.58, 0.083333333333333
1008, 1, 0.46, 0.16666666666667
1009, 1, 0.82, 0.083333333333333
1010, 1, 0.7, 0.16666666666667
1011, 1, 1.06, 0.083333333333333
1012, 1, 0.94, 0.16666666666667
1013, 1, 1.18, 0.16666666666667
1014, 1, 0.34, 0.25
1015, 1, 0.22, 0.33333333333333
1016, 1, 0.58, 0.25
1017, 1, 0.46, 0.33333333333333
1018, 1, 0.82, 0.25
1019, 1, 0.7, 0.33333333333333
1020, 1, 1.06, 0.25
1021, 1, 0.94, 0.33333333333333
1022, 1, 1.18, 0.33333333333333
1023, 1, 0.34, 0.41666666666667
1024, 1, 0.58, 0.41666666666667
1025, 1, 0.82, 0.41666666666667
1026, 1, 1.06, 0.41666666666667
1027, 0.2, 0.34, 0.5
1028, 0.2, 0.58, 0.5
1029, 0.2, 0.82, 0.5
1030, 0.2, 1.06, 0.5
1031, 0.4, 0.34, 0.5
1032, 0.4, 0.58, 0.5
1033, 0.4, 0.82, 0.5
1034, 0.4, 1.06, 0.5
1035, 0.6, 0.34, 0.5
1036, 0.6, 0.58, 0.5
1037, 0.6, 0.82, 0.5
1038, 0.6, 1.06, 0.5
1039, 0.8, 0.34, 0.5
1040, 0.8, 0.58, 0.5
1041, 0.8, 0.82, 0.5
1042, 0.8, 1.06, 0.5
1043, 0.2, 0.22, 0.5
1044, 0.1, 0.34, 0.5
1045, 0.2, 0.46, 0.5
1046, 0.1, 0.58, 0.5
1047, 0.2, 0.7, 0.5
1048, 0.1, 0.82, 0.5
1049, 0.2, 0.94, 0.5
1050, 0.1, 1.06, 0.5
1051, 0.2, 1.18, 0.5
1052, 0.4, 0.22, 0.5
1053, 0.3, 0.34, 0.5
1054, 0.4, 0.46, 0.5
1055, 0.3, 0.58, 0.5
1056, 0.4, 0.7, 0.5
1057, 0.3, 0.82, 0.5
1058, 0.4, 0.94, 0.5
1059, 0.3, 1.06, 0.5
1060, 0.4, 1.18, 0.5
1061, 0.6, 0.22, 0.5
1062, 0.5, 0.34, 0.5
1063, 0.6, 0.46, 0.5
1064, 0.5, 0.58, 0.5
1065, 0.6, 0.7, 0.5
1066, 0.5, 0.82, 0.5
1067, 0.6, 0.94, 0.5
1068, 0.5, 1.06, 0.5
1069, 0.6, 1.18, 0.5
1070, 0.8, 0.22, 0.5
1071, 0.7, 0.34, 0.5
1072, 0.8, 0.46, 0.5
1073, 0.7, 0.58, 0.5
1074, 0.8, 0.7, 0.5
1075, 0.7, 0.82, 0.5
1076, 0.8, 0.94, 0.5
1077, 0.7, 1.06, 0.5
1078, 0.8, 1.18, 0.5
1079, 0.9, 0.34, 0.5
1080, 0.9, 0.58, 0.5
1081, 0.9, 0.82, 0.5
1082, 0.9, 1.06, 0.5
1083, 0, 0.34, 0.16666666666667
1084, 0, 0.58, 0.16666666666667
1085, 0, 0.82, 0.16666666666667
1086, 0, 1.06, 0.16666666666667
1087, 0, 0.34, 0.33333333333333
1088, 0, 0.58, 0.33333333333333
1089, 0, 0.82, 0.33333333333333
1090, 0, 1.06, 0.33333333333333
1091, 0, 0.22, 0.16666666666667
1092, 0, 0.34, 0.083333333333333
1093, 0, 0.46, 0.16666666666667
1094, 0, 0.58, 0.083333333333333
1095, 0, 0.7, 0.16666666666667
1096, 0, 0.82, 0.083333333333333
1097, 0, 0.94, 0.16666666666667
1098, 0, 1.06, 0.083333333333333
1099, 0, 1.18, 0.16666666666667
1100, 0, 0.22, 0.33333333333333
1101, 0, 0.34, 0.25
1102, 0, 0.46, 0.33333333333333
1103, 0, 0.58, 0.25
1104, 0, 0.7, 0.33333333333333
1105, 0, 0.82, 0.25
1106, 0, 0.94, 0.33333333333333
1107, 0, 1.06, 0.25
1108, 0, 1.18, 0.33333333333333
1109, 0, 0.34, 0.41666666666667
1110, 0, 0.58, 0.41666666666667
1111, 0, 0.82, 0.41666666666667
1112, 0, 1.06, 0.41666666666667
1113, 0.2, 1.3, 0.16666666666667
1114, 0.2, 1.3, 0.33333333333333
1115, 0.4, 1.3, 0.16666666666667
1116, 0.4, 1.3, 0.33333333333333
1117, 0.6, 1.3, 0.16666666666667
1118, 0.6, 1.3, 0.33333333333333
1119, 0.8, 1.3, 0.16666666666667
1120, 0.8, 1.3, 0.33333333333333
1121, 0.1, 1.3, 0.16666666666667
1122, 0.2, 1.3, 0.083333333333333
1123, 0.1, 1.3, 0.33333333333333
1124, 0.2, 1.3, 0.25
1125, 0.2, 1.3, 0.41666666666667
1126, 0.3, 1.3, 0.16666666666667
1127, 0.4, 1.3, 0.083333333333333
1128, 0.3, 1.3, 0.33333333333333
1129, 0.4, 1.3, 0.25
1130, 0.4, 1.3, 0.41666666666667
1131, 0.5, 1.3, 0.16666666666667
1132, 0.6, 1.3, 0.083333333333333
1133, 0.5, 1.3, 0.33333333333333
1134, 0.6, 1.3, 0.25
1135, 0.6, 1.3, 0.41666666666667
1136, 0.7, 1.3, 0.16666666666667
1137, 0.8, 1.3, 0.083333333333333
1138, 0.7, 1.3, 0.33333333333333
1139, 0.8, 1.3, 0.25
1140, 0.8, 1.3, 0.41666666666667
1141, 0.9, 1.3, 0.16666666666667
1142, 0.9, 1.3, 0.33333333333333
1143, 0.2, 1.325, 0
1144, 0.4, 1.325, 0
1145, 0.6, 1.325, 0
1146, 0.8, 1.325, 0
1147, 1, 1.325, 0.16666666666667
1148, 1, 1.325, 0.33333333333333
1149, 0.2, 1.325, 0.5
1150, 0.4, 1.325, 0.5
1151, 0.6, 1.325, 0.5
1152, 0.8, 1.325, 0.5
1153, 0, 1.325, 0.16666666666667
1154, 0, 1.325, 0.33333333333333
1155, 0.2, 1.35, 0.16666666666667
1156, 0.2, 1.35, 0.33333333333333
1157, 0.4, 1.35, 0.16666666666667
1158, 0.4, 1.35, 0.33333333333333
1159, 0.6, 1.35, 0.16666666666667
1160, 0.6, 1.35, 0.33333333333333
1161, 0.8, 1.35, 0.16666666666667
1162, 0.8, 1.35, 0.33333333333333
1163, 0.1, 1.35, 0.16666666666667
1164, 0.2, 1.35, 0.083333333333333
1165, 0.1, 1.35, 0.33333333333333
1166, 0.2, 1.35, 0.25
1167, 0.2, 1.35, 0.41666666666667
1168, 0.3, 1.35, 0.16666666666667
1169, 0.4, 1.35, 0.083333333333333
1170, 0.3, 1.35, 0.33333333333333
1171, 0.4, 1.35, 0.25
1172, 0.4, 1.35, 0.41666666666667
1173, 0.5, 1.35, 0.16666666666667
1174, 0.6, 1.35, 0.083333333333333
1175, 0.5, 1.35, 0.33333333333333
1176, 0.6, 1.35, 0.25
1177, 0.6, 1.35, 0.41666666666667
1178, 0.7, 1.35, 0.16666666666667
1179, 0.8, 1.35, 0.083333333333333
1180, 0.7, 1.35, 0.33333333333333
1181, 0.8, 1.35, 0.25
1182, 0.8, 1.35, 0.41666666666667
1183, 0.9, 1.35, 0.16666666666667
1184, 0.9, 1.35, 0.33333333333333
1185, 0.2, 1.375, 0
1186, 0.4, 1.375, 0
1187, 0.6, 1.375, 0
1188, 0.8, 1.375, 0
1189, 0.1, 1.375, 0
1190, 0.2, 1.3625, 0
1191, 0.2, 1.3875, 0
1192, 0.3, 1.375, 0
1193, 0.4, 1.3625, 0
1194, 0.4, 1.3875, 0
1195, 0.5, 1.375, 0
1196, 0.6, 1.3625, 0
1197, 0.6, 1.3875, 0
1198, 0.7, 1.375, 0
1199, 0.8, 1.3625, 0
1200, 0.8, 1.3875, 0
1201, 0.9, 1.375, 0
1202, 1, 1.375, 0.16666666666667
1203, 1, 1.375, 0.33333333333333
1204, 1, 1.375, 0.083333333333333
1205, 1, 1.3625, 0.16666666666667
1206, 1, 1.3875, 0.16666666666667
1207, 1, 1.375, 0.25
1208, 1, 1.3625, 0.33333333333333
1209, 1, 1.3875, 0.33333333333333
1210, 1, 1.375, 0.41666666666667
1211, 0.2, 1.375, 0.5
1212, 0.4, 1.375, 0.5
1213, 0.6, 1.375, 0.5
1214, 0.8, 1.375, 0.5
1215, 0.2, 1.3625, 0.5
1216, 0.1, 1.375, 0.5
1217, 0.2, 1.3875, 0.5
1218, 0.4, 1.3625, 0.5
1219, 0.3, 1.375, 0.5
1220, 0.4, 1.3875, 0.5
1221, 0.6, 1.3625, 0.5
1222, 0.5, 1.375, 0.5
1223, 0.6, 1.3875, 0.5
1224, 0.8, 1.3625, 0.5
1225, 0.7, 1.375, 0.5
1226, 0.8, 1.3875, 0.5
1227, 0.9, 1.375, 0.5
1228, 0, 1.375, 0.16666666666667
1229, 0, 1.375, 0.33333333333333
1230, 0, 1.3625, 0.16666666666667
1231, 0, 1.375, 0.083333333333333
1232, 0, 1.3875, 0.16666666666667
1233, 0, 1.3625, 0.33333333333333
1234, 0, 1.375, 0.25
1235, 0, 1.3875, 0.33333333333333
1236, 0, 1.375, 0.41666666666667
1237, 0.2, 1.4, 0.16666666666667
1238, 0.2, 1.4, 0.33333333333333
1239, 0.4, 1.4, 0.16666666666667
1240, 0.4, 1.4, 0.33333333333333
1241, 0.6, 1.4, 0.16666666666667
1242, 0.6, 1.4, 0.33333333333333
1243, 0.8, 1.4, 0.16666666666667
1244, 0.8, 1.4, 0.33333333333333
1245, 0.1, 1.4, 0.16666666666667
1246, 0.2, 1.4, 0.083333333333333
1247, 0.1, 1.4, 0.33333333333333
1248, 0.2, 1.4, 0.25
1249, 0.2, 1.4, 0.41666666666667
1250, 0.3, 1.4, 0.16666666666667
1251, 0.4, 1.4, 0.083333333333333
1252, 0.3, 1.4, 0.33333333333333
1253, 0.4, 1.4, 0.25
1254, 0.4, 1.4, 0.41666666666667
1255, 0.5, 1.4, 0.16666666666667
1256, 0.6, 1.4, 0.083333333333333
1257, 0.5, 1.4, 0.33333333333333
1258, 0.6, 1.4, 0.25
1259, 0.6, 1.4, 0.41666666666667
1260, 0.7, 1.4, 0.16666666666667
1261, 0.8, 1.4, 0.083333333333333
1262, 0.7, 1.4, 0.33333333333333
1263, 0.8, 1.4, 0.25
1264, 0.8, 1.4, 0.41666666666667
1265, 0.9, 1.4, 0.16666666666667
1266, 0.9, 1.4, 0.33333333333333
1267, 1.1, 1.375, 0.5
1268, 1.1, 1.375, 0
1269, 1.1, 1.35, 0.16666666666667
1270, 1.1, 1.35, 0.33333333333333
1271, 1.1, 1.4, 0.16666666666667
1272, 1.1, 1.4, 0.33333333333333
1273, 1.2, 1.375, 0.16666666666667
1274, 1.2, 1.375, 0.33333333333333
1275, 1.2, 1.375, 0.083333333333333
1276, 1.2, 1.3625, 0.16666666666667
1277, 1.2, 1.3875, 0.16666666666667
1278, 1.2, 1.375, 0.25
1279, 1.2, 1.3625, 0.33333333333333
1280, 1.2, 1.3875, 0.33333333333333
1281, 1.2, 1.375, 0.41666666666667
1282, 1.4, 1.375, 0.5
1283, 1.6, 1.375, 0.5
1284, 1.8, 1.375, 0.5
1285, 2, 1.375, 0.5
1286, 1.4, 1.3625, 0.5
1287, 1.3, 1.375, 0.5
1288, 1.6, 1.3625, 0.5
1289, 1.5, 1.375, 0.5
1290, 1.8, 1.3625, 0.5
1291, 1.7, 1.375, 0.5
1292, 2, 1.3625, 0.5
1293, 1.9, 1.375, 0.5
1294, 2.1, 1.375, 0.5
1295, 1.4, 1.3875, 0.5
1296, 1.6, 1.3875, 0.5
1297, 1.8, 1.3875, 0.5
1298, 2, 1.3875, 0.5
1299, 1.4, 1.375, 0
1300, 1.6, 1.375, 0
1301, 1.8, 1.375, 0
1302, 2, 1.375, 0
1303, 1.3, 1.375, 0
1304, 1.4, 1.3625, 0
1305, 1.5, 1.375, 0
1306, 1.6, 1.3625, 0
1307, 1.7, 1.375, 0
1308, 1.8, 1.3625, 0
1309, 1.9, 1.375, 0
1310, 2, 1.3625, 0
1311, 2.1, 1.375, 0
1312, 1.4, 1.3875, 0
1313, 1.6, 1.3875, 0
1314, 1.8, 1.3875, 0
1315, 2, 1.3875, 0
1316, 1.4, 1.35, 0.16666666666667
1317, 1.6, 1.35, 0.16666666666667
1318, 1.8, 1.35, 0.16666666666667
1319, 2, 1.35, 0.16666666666667
1320, 1.4, 1.35, 0.33333333333333
1321, 1.6, 1.35, 0.33333333333333
1322, 1.8, 1.35, 0.33333333333333
1323, 2, 1.35, 0.33333333333333
1324, 1.4, 1.35, 0.083333333333333
1325, 1.3, 1.35, 0.16666666666667
1326, 1.6, 1.35, 0.083333333333333
1327, 1.5, 1.35, 0.16666666666667
1328, 1.8, 1.35, 0.083333333333333
1329, 1.7, 1.35, 0.16666666666667
1330, 2, 1.35, 0.083333333333333
1331, 1.9, 1.35, 0.16666666666667
1332, 2.1, 1.35, 0.16666666666667
1333, 1.4, 1.35, 0.25
1334, 1.3, 1.35, 0.33333333333333
1335, 1.6, 1.35, 0.25
1336, 1.5, 1.35, 0.33333333333333
1337, 1.8, 1.35, 0.25
1338, 1.7, 1.35, 0.33333333333333
1339, 2, 1.35, 0.25
1340, 1.9, 1.35, 0.33333333333333
1341, 2.1, 1.35, 0.33333333333333
1342, 1.4, 1.35, 0.41666666666667
1343, 1.6, 1.35, 0.41666666666667
1344, 1.8, 1.35, 0.41666666666667
1345, 2, 1.35, 0.41666666666667
1346, 1.4, 1.4, 0.16666666666667
1347, 1.6, 1.4, 0.16666666666667
1348, 1.8, 1.4, 0.16666666666667
1349, 2, 1.4, 0.16666666666667
1350, 1.4, 1.4, 0.33333333333333
1351, 1.6, 1.4, 0.33333333333333
1352, 1.8, 1.4, 0.33333333333333
1353, 2, 1.4, 0.33333333333333
1354, 1.3, 1.4, 0.16666666666667
1355, 1.4, 1.4, 0.083333333333333
1356, 1.5, 1.4, 0.16666666666667
1357, 1.6, 1.4, 0.083333333333333
1358, 1.7, 1.4, 0.16666666666667
1359, 1.8, 1.4, 0.083333333333333
1360, 1.9, 1.4, 0.16666666666667
1361, 2, 1.4, 0.083333333333333
1362, 2.1, 1.4, 0.16666666666667
1363, 1.3, 1.4, 0.33333333333333
1364, 1.4, 1.4, 0.25
1365, 1.5, 1.4, 0.33333333333333
1366, 1.6, 1.4, 0.25
1367, 1.7, 1.4, 0.33333333333333
1368, 1.8, 1.4, 0.25
1369, 1.9, 1.4, 0.33333333333333
1370, 2, 1.4, 0.25
1371, 2.1, 1.4, 0.33333333333333
1372, 1.4, 1.4, 0.41666666666667
1373, 1.6, 1.4, 0.41666666666667
1374, 1.8, 1.4, 0.41666666666667
1375, 2, 1.4, 0.41666666666667
1376, 2.2, 1.375, 0.16666666666667
1377, 2.2, 1.375, 0.33333333333333
1378, 2.2, 1.375, 0.083333333333333
1379, 2.2, 1.3625, 0.16666666666667
1380, 2.2, 1.3875, 0.16666666666667
1381, 2.2, 1.375, 0.25
1382, 2.2, 1.3625, 0.33333333333333
1383, 2.2, 1.3875, 0.33333333333333
1384, 2.2, 1.375, 0.41666666666667
1385, 1.4, 1.325, 0.5
1386, 1.6, 1.325, 0.5
1387, 1.8, 1.325, 0.5
1388, 2, 1.325, 0.5
1389, 1.4, 1.325, 0
1390, 1.6, 1.325, 0
1391, 1.8, 1.325, 0
1392, 2, 1.325, 0
1393, 1.2, 1.325, 0.16666666666667
1394, 1.2, 1.325, 0.33333333333333
1395, 2.2, 1.325, 0.16666666666667
1396, 2.2, 1.325, 0.33333333333333
1397, 1.4, 1.3, 0.16666666666667
1398, 1.6, 1.3, 0.16666666666667
1399, 1.8, 1.3, 0.16666666666667
1400, 2, 1.3, 0.16666666666667
1401, 1.4, 1.3, 0.33333333333333
1402, 1.6, 1.3, 0.33333333333333
1403, 1.8, 1.3, 0.33333333333333
1404, 2, 1.3, 0.33333333333333
1405, 1.4, 1.3, 0.083333333333333
1406, 1.3, 1.3, 0.16666666666667
1407, 1.6, 1.3, 0.083333333333333
1408, 1.5, 1.3, 0.16666666666667
1409, 1.8, 1.3, 0.083333333333333
1410, 1.7, 1.3, 0.16666666666667
1411, 2, 1.3, 0.083333333333333
1412, 1.9, 1.3, 0.16666666666667
1413, 2.1, 1.3, 0.16666666666667
1414, 1.4, 1.3, 0.25
1415, 1.3, 1.3, 0.33333333333333
1416, 1.6, 1.3, 0.25
1417, 1.5, 1.3, 0.33333333333333
1418, 1.8, 1.3, 0.25
1419, 1.7, 1.3, 0.33333333333333
1420, 2, 1.3, 0.25
1421, 1.9, 1.3, 0.33333333333333
1422, 2.1, 1.3, 0.33333333333333
1423, 1.4, 1.3, 0.41666666666667
1424, 1.6, 1.3, 0.41666666666667
1425, 1.8, 1.3, 0.41666666666667
1426, 2, 1.3, 0.41666666666667
1427, 1.4, 1.06, 0.5
1428, 1.4, 0.82, 0.5
1429, 1.4, 0.58, 0.5
1430, 1.4, 0.34, 0.5
1431, 1.6, 1.06, 0.5
1432, 1.6, 0.82, 0.5
1433, 1.6, 0.58, 0.5
1434, 1.6, 0.34, 0.5
1435, 1.8, 1.06, 0.5
1436, 1.8, 0.82, 0.5
1437, 1.8, 0.58, 0.5
1438, 1.8, 0.34, 0.5
1439, 2, 1.06, 0.5
1440, 2, 0.82, 0.5
1441, 2, 0.58, 0.5
1442, 2, 0.34, 0.5
1443, 1.3, 1.06, 0.5
1444, 1.4, 1.18, 0.5
1445, 1.3, 0.82, 0.5
1446, 1.4, 0.94, 0.5
1447, 1.3, 0.58, 0.5
1448, 1.4, 0.7, 0.5
1449, 1.3, 0.34, 0.5
1450, 1.4, 0.46, 0.5
1451, 1.4, 0.22, 0.5
1452, 1.5, 1.06, 0.5
1453, 1.6, 1.18, 0.5
1454, 1.5, 0.82, 0.5
1455, 1.6, 0.94, 0.5
1456, 1.5, 0.58, 0.5
1457, 1.6, 0.7, 0.5
1458, 1.5, 0.34, 0.5
1459, 1.6, 0.46, 0.5
1460, 1.6, 0.22, 0.5
1461, 1.7, 1.06, 0.5
1462, 1.8, 1.18, 0.5
1463, 1.7, 0.82, 0.5
1464, 1.8, 0.94, 0.5
1465, 1.7, 0.58, 0.5
1466, 1.8, 0.7, 0.5
1467, 1.7, 0.34, 0.5
1468, 1.8, 0.46, 0.5
1469, 1.8, 0.22, 0.5
1470, 1.9, 1.06, 0.5
1471, 2, 1.18, 0.5
1472, 1.9, 0.82, 0.5
1473, 2, 0.94, 0.5
1474, 1.9, 0.58, 0.5
1475, 2, 0.7, 0.5
1476, 1.9, 0.34, 0.5
1477, 2, 0.46, 0.5
1478, 2, 0.22, 0.5
1479, 2.1, 1.06, 0.5
1480, 2.1, 0.82, 0.5
1481, 2.1, 0.58, 0.5
1482, 2.1, 0.34, 0.5
1483, 1.4, 1.06, 0
1484, 1.4, 0.82, 0
1485, 1.4, 0.58, 0
1486, 1.4, 0.34, 0
1487, 1.6, 1.06, 0
1488, 1.6, 0.82, 0
1489, 1.6, 0.58, 0
1490, 1.6, 0.34, 0
1491, 1.8, 1.06, 0
1492, 1.8, 0.82, 0
1493, 1.8, 0.58, 0
1494, 1.8, 0.34, 0
1495, 2, 1.06, 0
1496, 2, 0.82, 0
1497, 2, 0.58, 0
1498, 2, 0.34, 0
1499, 1.4, 1.18, 0
1500, 1.3, 1.06, 0
1501, 1.4, 0.94, 0
1502, 1.3, 0.82, 0
1503, 1.4, 0.7, 0
1504, 1.3, 0.58, 0
1505, 1.4, 0.46, 0
1506, 1.3, 0.34, 0
1507, 1.4, 0.22, 0
1508, 1.6, 1.18, 0
1509, 1.5, 1.06, 0
1510, 1.6, 0.94, 0
1511, 1.5, 0.82, 0
1512, 1.6, 0.7, 0
1513, 1.5, 0.58, 0
1514, 1.6, 0.46, 0
1515, 1.5, 0.34, 0
1516, 1.6, 0.22, 0
1517, 1.8, 1.18, 0
1518, 1.7, 1.06, 0
1519, 1.8, 0.94, 0
1520, 1.7, 0.82, 0
1521, 1.8, 0.7, 0
1522, 1.7, 0.58, 0
1523, 1.8, 0.46, 0
1524, 1.7, 0.34, 0
1525, 1.8, 0.22, 0
1526, 2, 1.18, 0
1527, 1.9, 1.06, 0
1528, 2, 0.94, 0
1529, 1.9, 0.82, 0
1530, 2, 0.7, 0
1531, 1.9, 0.58, 0
1532, 2, 0.46, 0
1533, 1.9, 0.34, 0
1534, 2, 0.22, 0
1535, 2.1, 1.06, 0
1536, 2.1, 0.82, 0
1537, 2.1, 0.58, 0
1538, 2.1, 0.34, 0
1539, 1.2, 1.06, 0.16666666666667
1540, 1.2, 0.82, 0.16666666666667
1541, 1.2, 0.58, 0.16666666666667
1542, 1.2, 0.34, 0.16666666666667
1543, 1.2, 1.06, 0.33333333333333
1544, 1.2, 0.82, 0.33333333333333
1545, 1.2, 0.58, 0.33333333333333
1546, 1.2, 0.34, 0.33333333333333
1547, 1.2, 1.06, 0.083333333333333
1548, 1.2, 1.18, 0.16666666666667
1549, 1.2, 0.82, 0.083333333333333
1550, 1.2, 0.94, 0.16666666666667
1551, 1.2, 0.58, 0.083333333333333
1552, 1.2, 0.7, 0.16666666666667
1553, 1.2, 0.34, 0.083333333333333
1554, 1.2, 0.46, 0.16666666666667
1555, 1.2, 0.22, 0.16666666666667
1556, 1.2, 1.06, 0.25
1557, 1.2, 1.18, 0.33333333333333
1558, 1.2, 0.82, 0.25
1559, 1.2, 0.94, 0.33333333333333
1560, 1.2, 0.58, 0.25
1561, 1.2, 0.7, 0.33333333333333
1562, 1.2, 0.34, 0.25
1563, 1.2, 0.46, 0.33333333333333
1564, 1.2, 0.22, 0.33333333333333
1565, 1.2, 1.06, 0.41666666666667
1566, 1.2, 0.82, 0.41666666666667
1567, 1.2, 0.58, 0.41666666666667
1568, 1.2, 0.34, 0.41666666666667
1569, 2.2, 1.06, 0.16666666666667
1570, 2.2, 0.82, 0.16666666666667
1571, 2.2, 0.58, 0.16666666666667
1572, 2.2, 0.34, 0.16666666666667
1573, 2.2, 1.06, 0.33333333333333
1574, 2.2, 0.82, 0.33333333333333
1575, 2.2, 0.58, 0.33333333333333
1576, 2.2, 0.34, 0.33333333333333
1577, 2.2, 1.18, 0.16666666666667
1578, 2.2, 1.06, 0.083333333333333
1579, 2.2, 0.94, 0.16666666666667
1580, 2.2, 0.82, 0.083333333333333
1581, 2.2, 0.7, 0.16666666666667
1582, 2.2, 0.58, 0.083333333333333
1583, 2.2, 0.46, 0.16666666666667
1584, 2.2, 0.34, 0.083333333333333
1585, 2.2, 0.22, 0.16666666666667
1586, 2.2, 1.18, 0.33333333333333
1587, 2.2, 1.06, 0.25
1588, 2.2, 0.94, 0.33333333333333
1589, 2.2, 0.82, 0.25
1590, 2.2, 0.7, 0.33333333333333
1591, 2.2, 0.58, 0.25
1592, 2.2, 0.46, 0.33333333333333
1593, 2.2, 0.34, 0.25
1594, 2.2, 0.22, 0.33333333333333
1595, 2.2, 1.06, 0.41666666666667
1596, 2.2, 0.82, 0.41666666666667
1597, 2.2, 0.58, 0.41666666666667
1598, 2.2, 0.34, 0.41666666666667
1599, 1.4, 0.1, 0.16666666666667
1600, 1.6, 0.1, 0.16666666666667
1601, 1.8, 0.1, 0.16666666666667
1602, 2, 0.1, 0.16666666666667
1603, 1.4, 0.1, 0.33333333333333
1604, 1.6, 0.1, 0.33333333333333
1605, 1.8, 0.1, 0.33333333333333
1606, 2, 0.1, 0.33333333333333
1607, 1.4, 0.1, 0.083333333333333
1608, 1.3, 0.1, 0.16666666666667
1609, 1.6, 0.1, 0.083333333333333
1610, 1.5, 0.1, 0.16666666666667
1611, 1.8, 0.1, 0.083333333333333
1612, 1.7, 0.1, 0.16666666666667
1613, 2, 0.1, 0.083333333333333
1614, 1.9, 0.1, 0.16666666666667
1615, 2.1, 0.1, 0.16666666666667
1616, 1.4, 0.1, 0.25
1617, 1.3, 0.1, 0.33333333333333
1618, 1.6, 0.1, 0.25
1619, 1.5, 0.1, 0.33333333333333
1620, 1.8, 0.1, 0.25
1621, 1.7, 0.1, 0.33333333333333
1622, 2, 0.1, 0.25
1623, 1.9, 0.1, 0.33333333333333
1624, 2.1, 0.1, 0.33333333333333
1625, 1.4, 0.1, 0.41666666666667
1626, 1.6, 0.1, 0.41666666666667
1627, 1.8, 0.1, 0.41666666666667
1628, 2, 0.1, 0.41666666666667
1629, 1.4, 0.075, 0.5
1630, 1.6, 0.075, 0.5
1631, 1.8, 0.075, 0.5
1632, 2, 0.075, 0.5
1633, 1.4, 0.075, 0
1634, 1.6, 0.075, 0
1635, 1.8, 0.075, 0
1636, 2, 0.075, 0
1637, 1.2, 0.075, 0.16666666666667
1638, 1.2, 0.075, 0.33333333333333
1639, 2.2, 0.075, 0.16666666666667
1640, 2.2, 0.075, 0.33333333333333
1641, 1.4, 0.05, 0.16666666666667
1642, 1.6, 0.05, 0.16666666666667
1643, 1.8, 0.05, 0.16666666666667
1644, 2, 0.05, 0.16666666666667
1645, 1.4, 0.05, 0.33333333333333
1646, 1.6, 0.05, 0.33333333333333
1647, 1.8, 0.05, 0.33333333333333
1648, 2, 0.05, 0.33333333333333
1649, 1.4, 0.05, 0.083333333333333
1650, 1.3, 0.05, 0.16666666666667
1651, 1.6, 0.05, 0.083333333333333
1652, 1.5, 0.05, 0.16666666666667
1653, 1.8, 0.05, 0.083333333333333
1654, 1.7, 0.05, 0.16666666666667
1655, 2, 0.05, 0.083333333333333
1656, 1.9, 0.05, 0.16666666666667
1657, 2.1, 0.05, 0.16666666666667
1658, 1.4, 0.05, 0.25
1659, 1.3, 0.05, 0.33333333333333
1660, 1.6, 0.05, 0.25
1661, 1.5, 0.05, 0.33333333333333
1662, 1.8, 0.05, 0.25
1663, 1.7, 0.05, 0.33333333333333
1664, 2, 0.05, 0.25
1665, 1.9, 0.05, 0.33333333333333
1666, 2.1, 0.05, 0.33333333333333
1667, 1.4, 0.05, 0.41666666666667
1668, 1.6, 0.05, 0.41666666666667
1669, 1.8, 0.05, 0.41666666666667
1670, 2, 0.05, 0.41666666666667
1671, 1.4, 0.025, 0.5
1672, 1.6, 0.025, 0.5
1673, 1.8, 0.025, 0.5
1674, 2, 0.025, 0.5
1675, 1.3, 0.025, 0.5
1676, 1.4, 0.0375, 0.5
1677, 1.4, 0.0125, 0.5
1678, 1.5, 0.025, 0.5
1679, 1.6, 0.0375, 0.5
1680, 1.6, 0.0125, 0.5
1681, 1.7, 0.025, 0.5
1682, 1.8, 0.0375, 0.5
1683, 1.8, 0.0125, 0.5
1684, 1.9, 0.025, 0.5
1685, 2, 0.0375, 0.5
1686, 2, 0.0125, 0.5
1687, 2.1, 0.025, 0.5
1688, 1.4, 0.025, 0
1689, 1.6, 0.025, 0
1690, 1.8, 0.025, 0
1691, 2, 0.025, 0
1692, 1.4, 0.0375, 0
1693, 1.3, 0.025, 0
1694, 1.4, 0.0125, 0
1695, 1.6, 0.0375, 0
1696, 1.5, 0.025, 0
1697, 1.6, 0.0125, 0
1698, 1.8, 0.0375, 0
1699, 1.7, 0.025, 0
1700, 1.8, 0.0125, 0
1701, 2, 0.0375, 0
1702, 1.9, 0.025, 0
1703, 2, 0.0125, 0
1704, 2.1, 0.025, 0
1705, 1.2, 0.025, 0.16666666666667
1706, 1.2, 0.025, 0.33333333333333
1707, 1.2, 0.025, 0.083333333333333
1708, 1.2, 0.0375, 0.16666666666667
1709, 1.2, 0.0125, 0.16666666666667
1710, 1.2, 0.025, 0.25
1711, 1.2, 0.0375, 0.33333333333333
1712, 1.2, 0.0125, 0.33333333333333
1713, 1.2, 0.025, 0.41666666666667
1714, 2.2, 0.025, 0.16666666666667
1715, 2.2, 0.025, 0.33333333333333
1716, 2.2, 0.0375, 0.16666666666667
1717, 2.2, 0.025, 0.083333333333333
1718, 2.2, 0.0125, 0.16666666666667
1719, 2.2, 0.0375, 0.33333333333333
1720, 2.2, 0.025, 0.25
1721, 2.2, 0.0125, 0.33333333333333
1722, 2.2, 0.025, 0.41666666666667
1723, 1.4, 8.3266726846887e-17, 0.16666666666667
1724, 1.6, 8.3266726846887e-17, 0.16666666666667
1725, 1.8, 8.3266726846887e-17, 0.16666666666667
1726, 2, 8.3266726846887e-17, 0.16666666666667
1727, 1.4, 8.3266726846887e-17, 0.33333333333333
1728, 1.6, 8.3266726846887e-17, 0.33333333333333
1729, 1.8, 8.3266726846887e-17, 0.33333333333333
1730, 2, 8.3266726846887e-17, 0.33333333333333
1731, 1.4, 0, 0.083333333333333
1732, 1.3, 0, 0.16666666666667
1733, 1.6, 0, 0.083333333333333
1734, 1.5, 0, 0.16666666666667
1735, 1.8, 0, 0.083333333333333
1736, 1.7, 0, 0.16666666666667
1737, 2, 0, 0.083333333333333
1738, 1.9, 0, 0.16666666666667
1739, 2.1, 0, 0.16666666666667
1740, 1.4, 0, 0.25
1741, 1.3, 0, 0.33333333333333
1742, 1.6, 0, 0.25
1743, 1.5, 0, 0.33333333333333
1744, 1.8, 0, 0.25
1745, 1.7, 0, 0.33333333333333
1746, 2, 0, 0.25
1747, 1.9, 0, 0.33333333333333
1748, 2.1, 0, 0.33333333333333
1749, 1.4, 0, 0.41666666666667
1750, 1.6, 0, 0.41666666666667
1751, 1.8, 0, 0.41666666666667
1752, 2, 0, 0.41666666666667
1753, 2.25, 0.025, 0.5
1754, 2.25, 0.025, 0
1755, 2.25, 0.05, 0.16666666666667
1756, 2.25, 0.05, 0.33333333333333
1757, 2.25, -8.3266726846887e-17, 0.16666666666667
1758, 2.25, -8.3266726846887e-17, 0.33333333333333
1759, 2.3, 0.025, 0.16666666666667
1760, 2.3, 0.025, 0.33333333333333
1761, 2.3, 0.0375, 0.16666666666667
1762, 2.3, 0.025, 0.083333333333333
1763, 2.3, 0.0125, 0.16666666666667
1764, 2.3, 0.0375, 0.33333333333333
1765, 2.3, 0.025, 0.25
1766, 2.3, 0.0125, 0.33333333333333
1767, 2.3, 0.025, 0.41666666666667
1768, -0.05, 0, 0.16666666666667
1769, -0.05, 0, 0.33333333333333
1770, -0.05, 0.025, 0.5
1771, -0.05, 0.05, 0.16666666666667
1772, -0.05, 0.05, 0.33333333333333
1773, -0.05, 0.025, 0
1774, -0.1, 0.025, 0.16666666666667
1775, -0.1, 0.025, 0.33333333333333
1776, -0.1, 0.0125, 0.16666666666667
1777, -0.1, 0.025, 0.083333333333333
1778, -0.1, 0.0375, 0.16666666666667
1779, -0.1, 0.0125, 0.33333333333333
1780, -0.1, 0.025, 0.25
1781, -0.1, 0.0375, 0.33333333333333
1782, -0.1, 0.025, 0.41666666666667
1783, 1.025, 0.34, 0.5
1784, 1.025, 0.58, 0.5
1785, 1.025, 0.82, 0.5
1786, 1.025, 1.06, 0.5
1787, 1.025, 0.34, 0
1788, 1.025, 0.58, 0
1789, 1.025, 0.82, 0
1790, 1.025, 1.06, 0
1791, 1.025, 0.1, 0.16666666666667
1792, 1.025, 0.1, 0.33333333333333
1793, 1.025, 1.3, 0.16666666666667
1794, 1.025, 1.3, 0.33333333333333
1795, 1.05, 0.34, 0.16666666666667
1796, 1.05, 0.58, 0.16666666666667
1797, 1.05, 0.82, 0.16666666666667
1798, 1.05, 1.06, 0.16666666666667
1799, 1.05, 0.34, 0.33333333333333
1800, 1.05, 0.58, 0.33333333333333
1801, 1.05, 0.82, 0.33333333333333
1802, 1.05, 1.06, 0.33333333333333
1803, 1.05, 0.34, 0.083333333333333
1804, 1.05, 0.22, 0.16666666666667
1805, 1.05, 0.58, 0.083333333333333
1806, 1.05, 0.46, 0.16666666666667
1807, 1.05, 0.82, 0.083333333333333
1808, 1.05, 0.7, 0.16666666666667
1809, 1.05, 1.06, 0.083333333333333
1810, 1.05, 0.94, 0.16666666666667
1811, 1.05, 1.18, 0.16666666666667
1812, 1.05, 0.34, 0.25
1813, 1.05, 0.22, 0.33333333333333
1814, 1.05, 0.58, 0.25
1815, 1.05, 0.46, 0.33333333333333
1816, 1.05, 0.82, 0.25
1817, 1.05, 0.7, 0.33333333333333
1818, 1.05, 1.06, 0.25
1819, 1.05, 0.94, 0.33333333333333
1820, 1.05, 1.18, 0.33333333333333
1821, 1.05, 0.34, 0.41666666666667
1822, 1.05, 0.58, 0.41666666666667
1823, 1.05, 0.82, 0.41666666666667
1824, 1.05, 1.06, 0.41666666666667
1825, 1.175, 1.06, 0.5
1826, 1.175, 0.82, 0.5
1827, 1.175, 0.58, 0.5
1828, 1.175, 0.34, 0.5
1829, 1.175, 1.06, 0
1830, 1.175, 0.82, 0
1831, 1.175, 0.58, 0
1832, 1.175, 0.34, 0
1833, 1.175, 1.3, 0.16666666666667
1834, 1.175, 1.3, 0.33333333333333
1835, 1.175, 0.1, 0.16666666666667
1836, 1.175, 0.1, 0.33333333333333
1837, 1.15, 1.06, 0.16666666666667
1838, 1.15, 0.82, 0.16666666666667
1839, 1.15, 0.58, 0.16666666666667
1840, 1.15, 0.34, 0.16666666666667
1841, 1.15, 1.06, 0.33333333333333
1842, 1.15, 0.82, 0.33333333333333
1843, 1.15, 0.58, 0.33333333333333
1844, 1.15, 0.34, 0.33333333333333
1845, 1.15, 1.06, 0.083333333333333
1846, 1.15, 1.18, 0.16666666666667
1847, 1.15, 0.82, 0.083333333333333
1848, 1.15, 0.94, 0.16666666666667
1849, 1.15, 0.58, 0.083333333333333
1850, 1.15, 0.7, 0.16666666666667
1851, 1.15, 0.34, 0.083333333333333
1852, 1.15, 0.46, 0.16666666666667
1853, 1.15, 0.22, 0.16666666666667
1854, 1.15, 1.06, 0.25
1855, 1.15, 1.18, 0.33333333333333
1856, 1.15, 0.82, 0.25
1857, 1.15, 0.94, 0.33333333333333
1858, 1.15, 0.58, 0.25
1859, 1.15, 0.7, 0.33333333333333
1860, 1.15, 0.34, 0.25
1861, 1.15, 0.46, 0.33333333333333
1862, 1.15, 0.22, 0.33333333333333
1863, 1.15, 1.06, 0.41666666666667
1864, 1.15, 0.82, 0.41666666666667
1865, 1.15, 0.58, 0.41666666666667
1866, 1.15, 0.34, 0.41666666666667
1867, 1, 0.34, -0.05
1868, 1, 0.58, -0.05
1869, 1, 0.82, -0.05
1870, 1, 1.06, -0.05
1871, 1, 0.22, -0.05
1872, 1, 0.34, -0.025
1873, 1, 0.34, -0.075
1874, 1, 0.46, -0.05
1875, 1, 0.58, -0.025
1876, 1, 0.58, -0.075
1877, 1, 0.7, -0.05
1878, 1, 0.82, -0.025
1879, 1, 0.82, -0.075
1880, 1, 0.94, -0.05
1881, 1, 1.06, -0.025
1882, 1, 1.06, -0.075
1883, 1, 1.18, -0.05
1884, 0, 0.34, -0.05
1885, 0, 0.58, -0.05
1886, 0, 0.82, -0.05
1887, 0, 1.06, -0.05
1888, 0, 0.34, -0.025
1889, 0, 0.22, -0.05
1890, 0, 0.34, -0.075
1891, 0, 0.58, -0.025
1892, 0, 0.46, -0.05
1893, 0, 0.58, -0.075
1894, 0, 0.82, -0.025
1895, 0, 0.7, -0.05
1896, 0, 0.82, -0.075
1897, 0, 1.06, -0.025
1898, 0, 0.94, -0.05
1899, 0, 1.06, -0.075
1900, 0, 1.18, -0.05
1901, 0.2, 0.1, -0.05
1902, 0.4, 0.1, -0.05
1903, 0.6, 0.1, -0.05
1904, 0.8, 0.1, -0.05
1905, 0.1, 0.1, -0.05
1906, 0.2, 0.1, -0.025
1907, 0.2, 0.1, -0.075
1908, 0.3, 0.1, -0.05
1909, 0.4, 0.1, -0.025
1910, 0.4, 0.1, -0.075
1911, 0.5, 0.1, -0.05
1912, 0.6, 0.1, -0.025
1913, 0.6, 0.1, -0.075
1914, 0.7, 0.1, -0.05
1915, 0.8, 0.1, -0.025
1916, 0.8, 0.1, -0.075
1917, 0.9, 0.1, -0.05
1918, 0.2, 1.3, -0.05
1919, 0.4, 1.3, -0.05
1920, 0.6, 1.3, -0.05
1921, 0.8, 1.3, -0.05
1922, 0.2, 1.3, -0.025
1923, 0.1, 1.3, -0.05
1924, 0.2, 1.3, -0.075
1925, 0.4, 1.3, -0.025
1926, 0.3, 1.3, -0.05
1927, 0.4, 1.3, -0.075
1928, 0.6, 1.3, -0.025
1929, 0.5, 1.3, -0.05
1930, 0.6, 1.3, -0.075
1931, 0.8, 1.3, -0.025
1932, 0.7, 1.3, -0.05
1933, 0.8, 1.3, -0.075
1934, 0.9, 1.3, -0.05
1935, 0.2, 0.34, -0.1
1936, 0.2, 0.58, -0.1
1937, 0.2, 0.82, -0.1
1938, 0.2, 1.06, -0.1
1939, 0.4, 0.34, -0.1
1940, 0.4, 0.58, -0.1
1941, 0.4, 0.82, -0.1
1942, 0.4, 1.06, -0.1
1943, 0.6, 0.34, -0.1
1944, 0.6, 0.58, -0.1
1945, 0.6, 0.82, -0.1
1946, 0.6, 1.06, -0.1
1947, 0.8, 0.34, -0.1
1948, 0.8, 0.58, -0.1
1949, 0.8, 0.82, -0.1
1950, 0.8, 1.06, -0.1
1951, 0.1, 0.34, -0.1
1952, 0.2, 0.22, -0.1
1953, 0.1, 0.58, -0.1
1954, 0.2, 0.46, -0.1
1955, 0.1, 0.82, -0.1
1956, 0.2, 0.7, -0.1
1957, 0.1, 1.06, -0.1
1958, 0.2, 0.94, -0.1
1959, 0.2, 1.18, -0.1
1960, 0.3, 0.34, -0.1
1961, 0.4, 0.22, -0.1
1962, 0.3, 0.58, -0.1
1963, 0.4, 0.46, -0.1
1964, 0.3, 0.82, -0.1
1965, 0.4, 0.7, -0.1
1966, 0.3, 1.06, -0.1
1967, 0.4, 0.94, -0.1
1968, 0.4, 1.18, -0.1
1969, 0.5, 0.34, -0.1
1970, 0.6, 0.22, -0.1
1971, 0.5, 0.58, -0.1
1972, 0.6, 0.46, -0.1
1973, 0.5, 0.82, -0.1
1974, 0.6, 0.7, -0.1
1975, 0.5, 1.06, -0.1
1976, 0.6, 0.94, -0.1
1977, 0.6, 1.18, -0.1
1978, 0.7, 0.34, -0.1
1979, 0.8, 0.22, -0.1
1980, 0.7, 0.58, -0.1
1981, 0.8, 0.46, -0.1
1982, 0.7, 0.82, -0.1
1983, 0.8, 0.7, -0.1
1984, 0.7, 1.06, -0.1
1985, 0.8, 0.94, -0.1
1986, 0.8, 1.18, -0.1
1987, 0.9, 0.34, -0.1
1988, 0.9, 0.58, -0.1
1989, 0.9, 0.82, -0.1
1990, 0.9, 1.06, -0.1
1991, 1.2, 1.06, -0.05
1992, 1.2, 0.82, -0.05
1993, 1.2, 0.58, -0.05
1994, 1.2, 0.34, -0.05
1995, 1.2, 1.18, -0.05
1996, 1.2, 1.06, -0.025
1997, 1.2, 1.06, -0.075
1998, 1.2, 0.94, -0.05
1999, 1.2, 0.82, -0.025
2000, 1.2, 0.82, -0.075
2001, 1.2, 0.7, -0.05
2002, 1.2, 0.58, -0.025
2003, 1.2, 0.58, -0.075
2004, 1.2, 0.46, -0.05
2005, 1.2, 0.34, -0.025
2006, 1.2, 0.34, -0.075
2007, 1.2, 0.22, -0.05
2008, 2.2, 1.06, -0.05
2009, 2.2, 0.82, -0.05
2010, 2.2, 0.58, -0.05
2011, 2.2, 0.34, -0.05
2012, 2.2, 1.06, -0.025
2013, 2.2, 1.18, -0.05
2014, 2.2, 1.06, -0.075
2015, 2.2, 0.82, -0.025
2016, 2.2, 0.94, -0.05
2017, 2.2, 0.82, -0.075
2018, 2.2, 0.58, -0.025
2019, 2.2, 0.7, -0.05
2020, 2.2, 0.58, -0.075
2021, 2.2, 0.34, -0.025
2022, 2.2, 0.46, -0.05
2023, 2.2, 0.34, -0.075
2024, 2.2, 0.22, -0.05
2025, 1.4, 1.3, -0.05
2026, 1.6, 1.3, -0.05
2027, 1.8, 1.3, -0.05
2028, 2, 1.3, -0.05
2029, 1.4, 1.3, -0.025
2030, 1.3, 1.3, -0.05
2031, 1.4, 1.3, -0.075
2032, 1.6, 1.3, -0.025
2033, 1.5, 1.3, -0.05
2034, 1.6, 1.3, -0.075
2035, 1.8, 1.3, -0.025
2036, 1.7, 1.3, -0.05
2037, 1.8, 1.3, -0.075
2038, 2, 1.3, -0.025
2039, 1.9, 1.3, -0.05
2040, 2, 1.3, -0.075
2041, 2.1, 1.3, -0.05
2042, 1.4, 0.1, -0.05
2043, 1.6, 0.1, -0.05
2044, 1.8, 0.1, -0.05
2045, 2, 0.1, -0.05
2046, 1.3, 0.1, -0.05
2047, 1.4, 0.1, -0.025
2048, 1.4, 0.1, -0.075
2049, 1.5, 0.1, -0.05
2050, 1.6, 0.1, -0.025
2051, 1.6, 0.1, -0.075
2052, 1.7, 0.1, -0.05
2053, 1.8, 0.1, -0.025
2054, 1.8, 0.1, -0.075
2055, 1.9, 0.1, -0.05
2056, 2, 0.1, -0.025
2057, 2, 0.1, -0.075
2058, 2.1, 0.1, -0.05
2059, 1.4, 1.06, -0.1
2060, 1.4, 0.82, -0.1
2061, 1.4, 0.58, -0.1
2062, 1.4, 0.34, -0.1
2063, 1.6, 1.06, -0.1
2064, 1.6, 0.82, -0.1
2065, 1.6, 0.58, -0.1
2066, 1.6, 0.34, -0.1
2067, 1.8, 1.06, -0.1
2068, 1.8, 0.82, -0.1
2069, 1.8, 0.58, -0.1
2070, 1.8, 0.34, -0.1
2071, 2, 1.06, -0.1
2072, 2, 0.82, -0.1
2073, 2, 0.58, -0.1
2074, 2, 0.34, -0.1
2075, 1.4, 1.18, -0.1
2076, 1.3, 1.06, -0.1
2077, 1.4, 0.94, -0.1
2078, 1.3, 0.82, -0.1
2079, 1.4, 0.7, -0.1
2080, 1.3, 0.58, -0.1
2081, 1.4, 0.46, -0.1
2082, 1.3, 0.34, -0.1
2083, 1.4, 0.22, -0.1
2084, 1.6, 1.18, -0.1
2085, 1.5, 1.06, -0.1
2086, 1.6, 0.94, -0.1
2087, 1.5, 0.82, -0.1
2088, 1.6, 0.7, -0.1
2089, 1.5, 0.58, -0.1
2090, 1.6, 0.46, -0.1
2091, 1.5, 0.34, -0.1
2092, 1.6, 0.22, -0.1
2093, 1.8, 1.18, -0.1
2094, 1.7, 1.06, -0.1
2095, 1.8, 0.94, -0.1
2096, 1.7, 0.82, -0.1
2097, 1.8, 0.7, -0.1
2098, 1.7, 0.58, -0.1
2099, 1.8, 0.46, -0.1
2100, 1.7, 0.34, -0.1
2101, 1.8, 0.22, -0.1
2102, 2, 1.18, -0.1
2103, 1.9, 1.06, -0.1
2104, 2, 0.94, -0.1
2105, 1.9, 0.82, -0.1
2106, 2, 0.7, -0.1
2107, 1.9, 0.58, -0.1
2108, 2, 0.46, -0.1
2109, 1.9, 0.34, -0.1
2110, 2, 0.22, -0.1
2111, 2.1, 1.06, -0.1
2112, 2.1, 0.82, -0.1
2113, 2.1, 0.58, -0.1
2114, 2.1, 0.34, -0.1
2115, 1.175, 1.3, -0.05
2116, 1.175, 0.1, -0.05
2117, 1.15, 1.06, -0.05
2118, 1.15, 0.82, -0.05
2119, 1.15, 0.58, -0.05
2120, 1.15, 0.34, -0.05
2121, 1.15, 1.18, -0.05
2122, 1.15, 1.06, -0.025
2123, 1.15, 1.06, -0.075
2124, 1.15, 0.94, -0.05
2125, 1.15, 0.82, -0.025
2126, 1.15, 0.82, -0.075
2127, 1.15, 0.7, -0.05
2128, 1.15, 0.58, -0.025
2129, 1.15, 0.58, -0.075
2130, 1.15, 0.46, -0.05
2131, 1.15, 0.34, -0.025
2132, 1.15, 0.34, -0.075
2133, 1.15, 0.22, -0.05
2134, 1.175, 1.06, -0.1
2135, 1.175, 0.82, -0.1
2136, 1.175, 0.58, -0.1
2137, 1.175, 0.34, -0.1
2138, 1.025, 0.1, -0.05
2139, 1.025, 1.3, -0.05
2140, 1.05, 0.34, -0.05
2141, 1.05, 0.58, -0.05
2142, 1.05, 0.82, -0.05
2143, 1.05, 1.06, -0.05
2144, 1.05, 0.22, -0.05
2145, 1.05, 0.34, -0.025
2146, 1.05, 0.34, -0.075
2147, 1.05, 0.46, -0.05
2148, 1.05, 0.58, -0.025
2149, 1.05, 0.58, -0.075
2150, 1.05, 0.7, -0.05
2151, 1.05, 0.82, -0.025
2152, 1.05, 0.82, -0.075
2153, 1.05, 0.94, -0.05
2154, 1.05, 1.06, -0.025
2155, 1.05, 1.06, -0.075
2156, 1.05, 1.18, -0.05
2157, 1.025, 0.34, -0.1
2158, 1.025, 0.58, -0.1
2159, 1.025, 0.82, -0.1
2160, 1.025, 1.06, -0.1
2161, 0.2, 0.025, 0.16666666666667
2162, 0.4, 0.025, 0.16666666666667
2163, 0.6, 0.025, 0.16666666666667
2164, 0.8, 0.025, 0.16666666666667
2165, 0.2, 0.025, 0.33333333333333
2166, 0.4, 0.025, 0.33333333333333
2167, 0.6, 0.025, 0.33333333333333
2168, 0.8, 0.025, 0.33333333333333
2169, 0.1, 0.025, 0.16666666666667
2170, 0.2, 0.0125, 0.16666666666667
2171, 0.2, 0.025, 0.083333333333333
2172, 0.3, 0.025, 0.16666666666667
2173, 0.4, 0.0125, 0.16666666666667
2174, 0.4, 0.025, 0.083333333333333
2175, 0.5, 0.025, 0.16666666666667
2176, 0.6, 0.0125, 0.16666666666667
2177, 0.6, 0.025, 0.083333333333333
2178, 0.7, 0.025, 0.16666666666667
2179, 0.8, 0.0125, 0.16666666666667
2180, 0.8, 0.025, 0.083333333333333
2181, 0.9, 0.025, 0.16666666666667
2182, 0.2, 0.0375, 0.16666666666667
2183, 0.4, 0.0375, 0.16666666666667
2184, 0.6, 0.0375, 0.16666666666667
2185, 0.8, 0.0375, 0.16666666666667
2186, 0.1, 0.025, 0.33333333333333
2187, 0.2, 0.0125, 0.33333333333333
2188, 0.2, 0.025, 0.25
2189, 0.3, 0.025, 0.33333333333333
2190, 0.4, 0.0125, 0.33333333333333
2191, 0.4, 0.025, 0.25
2192, 0.5, 0.025, 0.33333333333333
2193, 0.6, 0.0125, 0.33333333333333
2194, 0.6, 0.025, 0.25
2195, 0.7, 0.025, 0.33333333333333
2196, 0.8, 0.0125, 0.33333333333333
2197, 0.8, 0.025, 0.25
2198, 0.9, 0.025, 0.33333333333333
2199, 0.2, 0.0375, 0.33333333333333
2200, 0.4, 0.0375, 0.33333333333333
2201, 0.6, 0.0375, 0.33333333333333
2202, 0.8, 0.0375, 0.33333333333333
2203, 0.2, 0.025, 0.41666666666667
2204, 0.4, 0.025, 0.41666666666667
2205, 0.6, 0.025, 0.41666666666667
2206, 0.8, 0.025, 0.41666666666667
2207, 0.2, 0.075, 0.16666666666667
2208, 0.2, 0.075, 0.33333333333333
2209, 0.4, 0.075, 0.16666666666667
2210, 0.4, 0.075, 0.33333333333333
2211, 0.6, 0.075, 0.16666666666667
2212, 0.6, 0.075, 0.33333333333333
2213, 0.8, 0.075, 0.16666666666667
2214, 0.8, 0.075, 0.33333333333333
2215, 0.2, 0.34, 0.16666666666667
2216, 0.2, 0.58, 0.16666666666667
2217, 0.2, 0.82, 0.16666666666667
2218, 0.2, 1.06, 0.16666666666667
2219, 0.2, 0.34, 0.33333333333333
2220, 0.2, 0.58, 0.33333333333333
2221, 0.2, 0.82, 0.33333333333333
2222, 0.2, 1.06, 0.33333333333333
2223, 0.4, 0.34, 0.16666666666667
2224, 0.4, 0.58, 0.16666666666667
2225, 0.4, 0.82, 0.16666666666667
2226, 0.4, 1.06, 0.16666666666667
2227, 0.4, 0.34, 0.33333333333333
2228, 0.4, 0.58, 0.33333333333333
2229, 0.4, 0.82, 0.33333333333333
2230, 0.4, 1.06, 0.33333333333333
2231, 0.6, 0.34, 0.16666666666667
2232, 0.6, 0.58, 0.16666666666667
2233, 0.6, 0.82, 0.16666666666667
2234, 0.6, 1.06, 0.16666666666667
2235, 0.6, 0.34, 0.33333333333333
2236, 0.6, 0.58, 0.33333333333333
2237, 0.6, 0.82, 0.33333333333333
2238, 0.6, 1.06, 0.33333333333333
2239, 0.8, 0.34, 0.16666666666667
2240, 0.8, 0.58, 0.16666666666667
2241, 0.8, 0.82, 0.16666666666667
2242, 0.8, 1.06, 0.16666666666667
2243, 0.8, 0.34, 0.33333333333333
2244, 0.8, 0.58, 0.33333333333333
2245, 0.8, 0.82, 0.33333333333333
2246, 0.8, 1.06, 0.33333333333333
2247, 0.2, 0.22, 0.16666666666667
2248, 0.1, 0.34, 0.16666666666667
2249, 0.2, 0.34, 0.083333333333333
2250, 0.2, 0.46, 0.16666666666667
2251, 0.1, 0.58, 0.16666666666667
2252, 0.2, 0.58, 0.083333333333333
2253, 0.2, 0.7, 0.16666666666667
2254, 0.1, 0.82, 0.16666666666667
2255, 0.2, 0.82, 0.083333333333333
2256, 0.2, 0.94, 0.16666666666667
2257, 0.1, 1.06, 0.16666666666667
2258, 0.2, 1.06, 0.083333333333333
2259, 0.2, 1.18, 0.16666666666667
2260, 0.2, 0.22, 0.33333333333333
2261, 0.1, 0.34, 0.33333333333333
2262, 0.2, 0.34, 0.25
2263, 0.2, 0.46, 0.33333333333333
2264, 0.1, 0.58, 0.33333333333333
2265, 0.2, 0.58, 0.25
2266, 0.2, 0.7, 0.33333333333333
2267, 0.1, 0.82, 0.33333333333333
2268, 0.2, 0.82, 0.25
2269, 0.2, 0.94, 0.33333333333333
2270, 0.1, 1.06, 0.33333333333333
2271, 0.2, 1.06, 0.25
2272, 0.2, 1.18, 0.33333333333333
2273, 0.2, 0.34, 0.41666666666667
2274, 0.2, 0.58, 0.41666666666667
2275, 0.2, 0.82, 0.41666666666667
2276, 0.2, 1.06, 0.41666666666667
2277, 0.4, 0.22, 0.16666666666667
2278, 0.3, 0.34, 0.16666666666667
2279, 0.4, 0.34, 0.083333333333333
2280, 0.4, 0.46, 0.16666666666667
2281, 0.3, 0.58, 0.16666666666667
2282, 0.4, 0.58, 0.083333333333333
2283, 0.4, 0.7, 0.16666666666667
2284, 0.3, 0.82, 0.16666666666667
2285, 0.4, 0.82, 0.083333333333333
2286, 0.4, 0.94, 0.16666666666667
2287, 0.3, 1.06, 0.16666666666667
2288, 0.4, 1.06, 0.083333333333333
2289, 0.4, 1.18, 0.16666666666667
2290, 0.4, 0.22, 0.33333333333333
2291, 0.3, 0.34, 0.33333333333333
2292, 0.4, 0.34, 0.25
2293, 0.4, 0.46, 0.33333333333333
2294, 0.3, 0.58, 0.33333333333333
2295, 0.4, 0.58, 0.25
2296, 0.4, 0.7, 0.33333333333333
2297, 0.3, 0.82, 0.33333333333333
2298, 0.4, 0.82, 0.25
2299, 0.4, 0.94, 0.33333333333333
2300, 0.3, 1.06, 0.33333333333333
2301, 0.4, 1.06, 0.25
2302, 0.4, 1.18, 0.33333333333333
2303, 0.4, 0.34, 0.41666666666667
2304, 0.4, 0.58, 0.41666666666667
2305, 0.4, 0.82, 0.41666666666667
2306, 0.4, 1.06, 0.41666666666667
2307, 0.6, 0.22, 0.16666666666667
2308, 0.5, 0.34, 0.16666666666667
2309, 0.6, 0.34, 0.083333333333333
2310, 0.6, 0.46, 0.16666666666667
2311, 0.5, 0.58, 0.16666666666667
2312, 0.6, 0.58, 0.083333333333333
2313, 0.6, 0.7, 0.16666666666667
2314, 0.5, 0.82, 0.16666666666667
2315, 0.6, 0.82, 0.083333333333333
2316, 0.6, 0.94, 0.16666666666667
2317, 0.5, 1.06, 0.16666666666667
2318, 0.6, 1.06, 0.083333333333333
2319, 0.6, 1.18, 0.16666666666667
2320, 0.6, 0.22, 0.33333333333333
2321, 0.5, 0.34, 0.33333333333333
2322, 0.6, 0.34, 0.25
2323, 0.6, 0.46, 0.33333333333333
2324, 0.5, 0.58, 0.33333333333333
2325, 0.6, 0.58, 0.25
2326, 0.6, 0.7, 0.33333333333333
2327, 0.5, 0.82, 0.33333333333333
2328, 0.6, 0.82, 0.25
2329, 0.6, 0.94, 0.33333333333333
2330, 0.5, 1.06, 0.33333333333333
2331, 0.6, 1.06, 0.25
2332, 0.6, 1.18, 0.33333333333333
2333, 0.6, 0.34, 0.41666666666667
2334, 0.6, 0.58, 0.41666666666667
2335, 0.6, 0.82, 0.41666666666667
2336, 0.6, 1.06, 0.41666666666667
2337, 0.8, 0.22, 0.16666666666667
2338, 0.7, 0.34, 0.16666666666667
2339, 0.8, 0.34, 0.083333333333333
2340, 0.8, 0.46, 0.16666666666667
2341, 0.7, 0.58, 0.16666666666667
2342, 0.8, 0.58, 0.083333333333333
2343, 0.8, 0.7, 0.16666666666667
2344, 0.7, 0.82, 0.16666666666667
2345, 0.8, 0.82, 0.083333333333333
2346, 0.8, 0.94, 0.16666666666667
2347, 0.7, 1.06, 0.16666666666667
2348, 0.8, 1.06, 0.083333333333333
2349, 0.8, 1.18, 0.16666666666667
2350, 0.8, 0.22, 0.33333333333333
2351, 0.7, 0.34, 0.33333333333333
2352, 0.8, 0.34, 0.25
2353, 0.8, 0.46, 0.33333333333333
2354, 0.7, 0.58, 0.33333333333333
2355, 0.8, 0.58, 0.25
2356, 0.8, 0.7, 0.33333333333333
2357, 0.7, 0.82, 0.33333333333333
2358, 0.8, 0.82, 0.25
2359, 0.8, 0.94, 0.33333333333333
2360, 0.7, 1.06, 0.33333333333333
2361, 0.8, 1.06, 0.25
2362, 0.8, 1.18, 0.33333333333333
2363, 0.8, 0.34, 0.41666666666667
2364, 0.8, 0.58, 0.41666666666667
2365, 0.8, 0.82, 0.41666666666667
2366, 0.8, 1.06, 0.41666666666667
2367, 0.9, 0.34, 0.16666666666667
2368, 0.9, 0.58, 0.16666666666667
2369, 0.9, 0.82, 0.16666666666667
2370, 0.9, 1.06, 0.16666666666667
2371, 0.9, 0.34, 0.33333333333333
2372, 0.9, 0.58, 0.33333333333333
2373, 0.9, 0.82, 0.33333333333333
2374, 0.9, 1.06, 0.33333333333333
2375, 0.2, 1.325, 0.16666666666667
2376, 0.2, 1.325, 0.33333333333333
2377, 0.4, 1.325, 0.16666666666667
2378, 0.4, 1.325, 0.33333333333333
2379, 0.6, 1.325, 0.16666666666667
2380, 0.6, 1.325, 0.33333333333333
2381, 0.8, 1.325, 0.16666666666667
2382, 0.8, 1.325, 0.33333333333333
2383, 0.2, 1.375, 0.16666666666667
2384, 0.2, 1.375, 0.33333333333333
2385, 0.4, 1.375, 0.16666666666667
2386, 0.4, 1.375, 0.33333333333333
2387, 0.6, 1.375, 0.16666666666667
2388, 0.6, 1.375, 0.33333333333333
2389, 0.8, 1.375, 0.16666666666667
2390, 0.8, 1.375, 0.33333333333333
2391, 0.2, 1.3625, 0.16666666666667
2392, 0.1, 1.375, 0.16666666666667
2393, 0.2, 1.375, 0.083333333333333
2394, 0.2, 1.3875, 0.16666666666667
2395, 0.2, 1.3625, 0.33333333333333
2396, 0.1, 1.375, 0.33333333333333
2397, 0.2, 1.375, 0.25
2398, 0.2, 1.3875, 0.33333333333333
2399, 0.2, 1.375, 0.41666666666667
2400, 0.4, 1.3625, 0.16666666666667
2401, 0.3, 1.375, 0.16666666666667
2402, 0.4, 1.375, 0.083333333333333
2403, 0.4, 1.3875, 0.16666666666667
2404, 0.4, 1.3625, 0.33333333333333
2405, 0.3, 1.375, 0.33333333333333
2406, 0.4, 1.375, 0.25
2407, 0.4, 1.3875, 0.33333333333333
2408, 0.4, 1.375, 0.41666666666667
2409, 0.6, 1.3625, 0.16666666666667
2410, 0.5, 1.375, 0.16666666666667
2411, 0.6, 1.375, 0.083333333333333
2412, 0.6, 1.3875, 0.16666666666667
2413, 0.6, 1.3625, 0.33333333333333
2414, 0.5, 1.375, 0.33333333333333
2415, 0.6, 1.375, 0.25
2416, 0.6, 1.3875, 0.33333333333333
2417, 0.6, 1.375, 0.41666666666667
2418, 0.8, 1.3625, 0.16666666666667
2419, 0.7, 1.375, 0.16666666666667
2420, 0.8, 1.375, 0.083333333333333
2421, 0.8, 1.3875, 0.16666666666667
2422, 0.8, 1.3625, 0.33333333333333
2423, 0.7, 1.375, 0.33333333333333
2424, 0.8, 1.375, 0.25
2425, 0.8, 1.3875, 0.33333333333333
2426, 0.8, 1.375, 0.41666666666667
2427, 0.9, 1.375, 0.16666666666667
2428, 0.9, 1.375, 0.33333333333333
2429, 1.1, 1.375, 0.16666666666667
2430, 1.1, 1.375, 0.33333333333333
2431, 1.4, 1.375, 0.16666666666667
2432, 1.6, 1.375, 0.16666666666667
2433, 1.8, 1.375, 0.16666666666667
2434, 2, 1.375, 0.16666666666667
2435, 1.4, 1.375, 0.33333333333333
2436, 1.6, 1.375, 0.33333333333333
2437, 1.8, 1.375, 0.33333333333333
2438, 2, 1.375, 0.33333333333333
2439, 1.3, 1.375, 0.16666666666667
2440, 1.4, 1.375, 0.083333333333333
2441, 1.4, 1.3625, 0.16666666666667
2442, 1.5, 1.375, 0.16666666666667
2443, 1.6, 1.375, 0.083333333333333
2444, 1.6, 1.3625, 0.16666666666667
2445, 1.7, 1.375, 0.16666666666667
2446, 1.8, 1.375, 0.083333333333333
2447, 1.8, 1.3625, 0.16666666666667
2448, 1.9, 1.375, 0.16666666666667
2449, 2, 1.375, 0.083333333333333
2450, 2, 1.3625, 0.16666666666667
2451, 2.1, 1.375, 0.16666666666667
2452, 1.4, 1.3875, 0.16666666666667
2453, 1.6, 1.3875, 0.16666666666667
2454, 1.8, 1.3875, 0.16666666666667
2455, 2, 1.3875, 0.16666666666667
2456, 1.3, 1.375, 0.33333333333333
2457, 1.4, 1.375, 0.25
2458, 1.4, 1.3625, 0.33333333333333
2459, 1.5, 1.375, 0.33333333333333
2460, 1.6, 1.375, 0.25
2461, 1.6, 1.3625, 0.33333333333333
2462, 1.7, 1.375, 0.33333333333333
2463, 1.8, 1.375, 0.25
2464, 1.8, 1.3625, 0.33333333333333
2465, 1.9, 1.375, 0.33333333333333
2466, 2, 1.375, 0.25
2467, 2, 1.3625, 0.33333333333333
2468, 2.1, 1.375, 0.33333333333333
2469, 1.4, 1.3875, 0.33333333333333
2470, 1.6, 1.3875, 0.33333333333333
2471, 1.8, 1.3875, 0.33333333333333
2472, 2, 1.3875, 0.33333333333333
2473, 1.4, 1.375, 0.41666666666667
2474, 1.6, 1.375, 0.41666666666667
2475, 1.8, 1.375, 0.41666666666667
2476, 2, 1.375, 0.41666666666667
2477, 1.4, 1.325, 0.16666666666667
2478, 1.6, 1.325, 0.16666666666667
2479, 1.8, 1.325, 0.16666666666667
2480, 2, 1.325, 0.16666666666667
2481, 1.4, 1.325, 0.33333333333333
2482, 1.6, 1.325, 0.33333333333333
2483, 1.8, 1.325, 0.33333333333333
2484, 2, 1.325, 0.33333333333333
2485, 1.4, 1.06, 0.16666666666667
2486, 1.4, 0.82, 0.16666666666667
2487, 1.4, 0.58, 0.16666666666667
2488, 1.4, 0.34, 0.16666666666667
2489, 1.6, 1.06, 0.16666666666667
2490, 1.6, 0.82, 0.16666666666667
2491, 1.6, 0.58, 0.16666666666667
2492, 1.6, 0.34, 0.16666666666667
2493, 1.8, 1.06, 0.16666666666667
2494, 1.8, 0.82, 0.16666666666667
2495, 1.8, 0.58, 0.16666666666667
2496, 1.8, 0.34, 0.16666666666667
2497, 2, 1.06, 0.16666666666667
2498, 2, 0.82, 0.16666666666667
2499, 2, 0.58, 0.16666666666667
2500, 2, 0.34, 0.16666666666667
2501, 1.4, 1.06, 0.33333333333333
2502, 1.4, 0.82, 0.33333333333333
2503, 1.4, 0.58, 0.33333333333333
2504, 1.4, 0.34, 0.33333333333333
2505, 1.6, 1.06, 0.33333333333333
2506, 1.6, 0.82, 0.33333333333333
2507, 1.6, 0.58, 0.33333333333333
2508, 1.6, 0.34, 0.33333333333333
2509, 1.8, 1.06, 0.33333333333333
2510, 1.8, 0.82, 0.33333333333333
2511, 1.8, 0.58, 0.33333333333333
2512, 1.8, 0.34, 0.33333333333333
2513, 2, 1.06, 0.33333333333333
2514, 2, 0.82, 0.33333333333333
2515, 2, 0.58, 0.33333333333333
2516, 2, 0.34, 0.33333333333333
2517, 1.4, 1.18, 0.16666666666667
2518, 1.4, 1.06, 0.083333333333333
2519, 1.3, 1.06, 0.16666666666667
2520, 1.4, 0.94, 0.16666666666667
2521, 1.4, 0.82, 0.083333333333333
2522, 1.3, 0.82, 0.16666666666667
2523, 1.4, 0.7, 0.16666666666667
2524, 1.4, 0.58, 0.083333333333333
2525, 1.3, 0.58, 0.16666666666667
2526, 1.4, 0.46, 0.16666666666667
2527, 1.4, 0.34, 0.083333333333333
2528, 1.3, 0.34, 0.16666666666667
2529, 1.4, 0.22, 0.16666666666667
2530, 1.6, 1.18, 0.16666666666667
2531, 1.6, 1.06, 0.083333333333333
2532, 1.5, 1.06, 0.16666666666667
2533, 1.6, 0.94, 0.16666666666667
2534, 1.6, 0.82, 0.083333333333333
2535, 1.5, 0.82, 0.16666666666667
2536, 1.6, 0.7, 0.16666666666667
2537, 1.6, 0.58, 0.083333333333333
2538, 1.5, 0.58, 0.16666666666667
2539, 1.6, 0.46, 0.16666666666667
2540, 1.6, 0.34, 0.083333333333333
2541, 1.5, 0.34, 0.16666666666667
2542, 1.6, 0.22, 0.16666666666667
2543, 1.8, 1.18, 0.16666666666667
2544, 1.8, 1.06, 0.083333333333333
2545, 1.7, 1.06, 0.16666666666667
2546, 1.8, 0.94, 0.16666666666667
2547, 1.8, 0.82, 0.083333333333333
2548, 1.7, 0.82, 0.16666666666667
2549, 1.8, 0.7, 0.16666666666667
2550, 1.8, 0.58, 0.083333333333333
2551, 1.7, 0.58, 0.16666666666667
2552, 1.8, 0.46, 0.16666666666667
2553, 1.8, 0.34, 0.083333333333333
2554, 1.7, 0.34, 0.16666666666667
2555, 1.8, 0.22, 0.16666666666667
2556, 2, 1.18, 0.16666666666667
2557, 2, 1.06, 0.083333333333333
2558, 1.9, 1.06, 0.16666666666667
2559, 2, 0.94, 0.16666666666667
2560, 2, 0.82, 0.083333333333333
2561, 1.9, 0.82, 0.16666666666667
2562, 2, 0.7, 0.16666666666667
2563, 2, 0.58, 0.083333333333333
2564, 1.9, 0.58, 0.16666666666667
2565, 2, 0.46, 0.16666666666667
2566, 2, 0.34, 0.083333333333333
2567, 1.9, 0.34, 0.16666666666667
2568, 2, 0.22, 0.16666666666667
2569, 2.1, 1.06, 0.16666666666667
2570, 2.1, 0.82, 0.16666666666667
2571, 2.1, 0.58, 0.16666666666667
2572, 2.1, 0.34, 0.16666666666667
2573, 1.4, 1.18, 0.33333333333333
2574, 1.4, 1.06, 0.25
2575, 1.3, 1.06, 0.33333333333333
2576, 1.4, 0.94, 0.33333333333333
2577, 1.4, 0.82, 0.25
2578, 1.3, 0.82, 0.33333333333333
2579, 1.4, 0.7, 0.33333333333333
2580, 1.4, 0.58, 0.25
2581, 1.3, 0.58, 0.33333333333333
2582, 1.4, 0.46, 0.33333333333333
2583, 1.4, 0.34, 0.25
2584, 1.3, 0.34, 0.33333333333333
2585, 1.4, 0.22, 0.33333333333333
2586, 1.6, 1.18, 0.33333333333333
2587, 1.6, 1.06, 0.25
2588, 1.5, 1.06, 0.33333333333333
2589, 1.6, 0.94, 0.33333333333333
2590, 1.6, 0.82, 0.25
2591, 1.5, 0.82, 0.33333333333333
2592, 1.6, 0.7, 0.33333333333333
2593, 1.6, 0.58, 0.25
2594, 1.5, 0.58, 0.33333333333333
2595, 1.6, 0.46, 0.33333333333333
2596, 1.6, 0.34, 0.25
2597, 1.5, 0.34, 0.33333333333333
2598, 1.6, 0.22, 0.33333333333333
2599, 1.8, 1.18, 0.33333333333333
2600, 1.8, 1.06, 0.25
2601, 1.7, 1.06, 0.33333333333333
2602, 1.8, 0.94, 0.33333333333333
2603, 1.8, 0.82, 0.25
2604, 1.7, 0.82, 0.33333333333333
2605, 1.8, 0.7, 0.33333333333333
2606, 1.8, 0.58, 0.25
2607, 1.7, 0.58, 0.33333333333333
2608, 1.8, 0.46, 0.33333333333333
2609, 1.8, 0.34, 0.25
2610, 1.7, 0.34, 0.33333333333333
2611, 1.8, 0.22, 0.33333333333333
2612, 2, 1.18, 0.33333333333333
2613, 2, 1.06, 0.25
2614, 1.9, 1.06, 0.33333333333333
2615, 2, 0.94, 0.33333333333333
2616, 2, 0.82, 0.25
2617, 1.9, 0.82, 0.33333333333333
2618, 2, 0.7, 0.33333333333333
2619, 2, 0.58, 0.25
2620, 1.9, 0.58, 0.33333333333333
2621, 2, 0.46, 0.33333333333333
2622, 2, 0.34, 0.25
2623, 1.9, 0.34, 0.33333333333333
2624, 2, 0.22, 0.33333333333333
2625, 2.1, 1.06, 0.33333333333333
2626, 2.1, 0.82, 0.33333333333333
2627, 2.1, 0.58, 0.33333333333333
2628, 2.1, 0.34, 0.33333333333333
2629, 1.4, 1.06, 0.41666666666667
2630, 1.4, 0.82, 0.41666666666667
2631, 1.4, 0.58, 0.41666666666667
2632, 1.4, 0.34, 0.41666666666667
2633, 1.6, 1.06, 0.41666666666667
2634, 1.6, 0.82, 0.41666666666667
2635, 1.6, 0.58, 0.41666666666667
2636, 1.6, 0.34, 0.41666666666667
2637, 1.8, 1.06, 0.41666666666667
2638, 1.8, 0.82, 0.41666666666667
2639, 1.8, 0.58, 0.41666666666667
2640, 1.8, 0.34, 0.41666666666667
2641, 2, 1.06, 0.41666666666667
2642, 2, 0.82, 0.41666666666667
2643, 2, 0.58, 0.41666666666667
2644, 2, 0.34, 0.41666666666667
2645, 1.4, 0.075, 0.16666666666667
2646, 1.6, 0.075, 0.16666666666667
2647, 1.8, 0.075, 0.16666666666667
2648, 2, 0.075, 0.16666666666667
2649, 1.4, 0.075, 0.33333333333333
2650, 1.6, 0.075, 0.33333333333333
2651, 1.8, 0.075, 0.33333333333333
2652, 2, 0.075, 0.33333333333333
2653, 1.4, 0.025, 0.16666666666667
2654, 1.6, 0.025, 0.16666666666667
2655, 1.8, 0.025, 0.16666666666667
2656, 2, 0.025, 0.16666666666667
2657, 1.4, 0.025, 0.33333333333333
2658, 1.6, 0.025, 0.33333333333333
2659, 1.8, 0.025, 0.33333333333333
2660, 2, 0.025, 0.33333333333333
2661, 1.4, 0.0375, 0.16666666666667
2662, 1.4, 0.025, 0.083333333333333
2663, 1.3, 0.025, 0.16666666666667
2664, 1.4, 0.0125, 0.16666666666667
2665, 1.6, 0.0375, 0.16666666666667
2666, 1.6, 0.025, 0.083333333333333
2667, 1.5, 0.025, 0.16666666666667
2668, 1.6, 0.0125, 0.16666666666667
2669, 1.8, 0.0375, 0.16666666666667
2670, 1.8, 0.025, 0.083333333333333
2671, 1.7, 0.025, 0.16666666666667
2672, 1.8, 0.0125, 0.16666666666667
2673, 2, 0.0375, 0.16666666666667
2674, 2, 0.025, 0.083333333333333
2675, 1.9, 0.025, 0.16666666666667
2676, 2, 0.0125, 0.16666666666667
2677, 2.1, 0.025, 0.16666666666667
2678, 1.4, 0.0375, 0.33333333333333
2679, 1.4, 0.025, 0.25
2680, 1.3, 0.025, 0.33333333333333
2681, 1.4, 0.0125, 0.33333333333333
2682, 1.6, 0.0375, 0.33333333333333
2683, 1.6, 0.025, 0.25
2684, 1.5, 0.025, 0.33333333333333
2685, 1.6, 0.0125, 0.33333333333333
2686, 1.8, 0.0375, 0.33333333333333
2687, 1.8, 0.025, 0.25
2688, 1.7, 0.025, 0.33333333333333
2689, 1.8, 0.0125, 0.33333333333333
2690, 2, 0.0375, 0.33333333333333
2691, 2, 0.025, 0.25
2692, 1.9, 0.025, 0.33333333333333
2693, 2, 0.0125, 0.33333333333333
2694, 2.1, 0.025, 0.33333333333333
2695, 1.4, 0.025, 0.41666666666667
2696, 1.6, 0.025, 0.41666666666667
2697, 1.8, 0.025, 0.41666666666667
2698, 2, 0.025, 0.41666666666667
2699, 2.25, 0.025, 0.16666666666667
2700, 2.25, 0.025, 0.33333333333333
2701, -0.05, 0.025, 0.16666666666667
2702, -0.05, 0.025, 0.33333333333333
2703, 0.2, 0.34, -0.05
2704, 0.2, 0.58, -0.05
2705, 0.2, 0.82, -0.05
2706, 0.2, 1.06, -0.05
2707, 0.4, 0.34, -0.05
2708, 0.4, 0.58, -0.05
2709, 0.4, 0.82, -0.05
2710, 0.4, 1.06, -0.05
2711, 0.6, 0.34, -0.05
2712, 0.6, 0.58, -0.05
2713, 0.6, 0.82, -0.05
2714, 0.6, 1.06, -0.05
2715, 0.8, 0.34, -0.05
2716, 0.8, 0.58, -0.05
2717, 0.8, 0.82, -0.05
2718, 0.8, 1.06, -0.05
2719, 0.2, 0.34, -0.025
2720, 0.1, 0.34, -0.05
2721, 0.2, 0.22, -0.05
2722, 0.2, 0.34, -0.075
2723, 0.2, 0.58, -0.025
2724, 0.1, 0.58, -0.05
2725, 0.2, 0.46, -0.05
2726, 0.2, 0.58, -0.075
2727, 0.2, 0.82, -0.025
2728, 0.1, 0.82, -0.05
2729, 0.2, 0.7, -0.05
2730, 0.2, 0.82, -0.075
2731, 0.2, 1.06, -0.025
2732, 0.1, 1.06, -0.05
2733, 0.2, 0.94, -0.05
2734, 0.2, 1.06, -0.075
2735, 0.2, 1.18, -0.05
2736, 0.4, 0.34, -0.025
2737, 0.3, 0.34, -0.05
2738, 0.4, 0.22, -0.05
2739, 0.4, 0.34, -0.075
2740, 0.4, 0.58, -0.025
2741, 0.3, 0.58, -0.05
2742, 0.4, 0.46, -0.05
2743, 0.4, 0.58, -0.075
2744, 0.4, 0.82, -0.025
2745, 0.3, 0.82, -0.05
2746, 0.4, 0.7, -0.05
2747, 0.4, 0.82, -0.075
2748, 0.4, 1.06, -0.025
2749, 0.3, 1.06, -0.05
2750, 0.4, 0.94, -0.05
2751, 0.4, 1.06, -0.075
2752, 0.4, 1.18, -0.05
2753, 0.6, 0.34, -0.025
2754, 0.5, 0.34, -0.05
2755, 0.6, 0.22, -0.05
2756, 0.6, 0.34, -0.075
2757, 0.6, 0.58, -0.025
2758, 0.5, 0.58, -0.05
2759, 0.6, 0.46, -0.05
2760, 0.6, 0.58, -0.075
2761, 0.6, 0.82, -0.025
2762, 0.5, 0.82, -0.05
2763, 0.6, 0.7, -0.05
2764, 0.6, 0.82, -0.075
2765, 0.6, 1.06, -0.025
2766, 0.5, 1.06, -0.05
2767, 0.6, 0.94, -0.05
2768, 0.6, 1.06, -0.075
2769, 0.6, 1.18, -0.05
2770, 0.8, 0.34, -0.025
2771, 0.7, 0.34, -0.05
2772, 0.8, 0.22, -0.05
2773, 0.8, 0.34, -0.075
2774, 0.8, 0.58, -0.025
2775, 0.7, 0.58, -0.05
2776, 0.8, 0.46, -0.05
2777, 0.8, 0.58, -0.075
2778, 0.8, 0.82, -0.025
2779, 0.7, 0.82, -0.05
2780, 0.8, 0.7, -0.05
2781, 0.8, 0.82, -0.075
2782, 0.8, 1.06, -0.025
2783, 0.7, 1.06, -0.05
2784, 0.8, 0.94, -0.05
2785, 0.8, 1.06, -0.075
2786, 0.8, 1.18, -0.05
2787, 0.9, 0.34, -0.05
2788, 0.9, 0.58, -0.05
2789, 0.9, 0.82, -0.05
2790, 0.9, 1.06, -0.05
2791, 1.4, 1.06, -0.05
2792, 1.4, 0.82, -0.05
2793, 1.4, 0.58, -0.05
2794, 1.4, 0.34, -0.05
2795, 1.6, 1.06, -0.05
2796, 1.6, 0.82, -0.05
2797, 1.6, 0.58, -0.05
2798, 1.6, 0.34, -0.05
2799, 1.8, 1.06, -0.05
2800, 1.8, 0.82, -0.05
2801, 1.8, 0.58, -0.05
2802, 1.8, 0.34, -0.05
2803, 2, 1.06, -0.05
2804, 2, 0.82, -0.05
2805, 2, 0.58, -0.05
2806, 2, 0.34, -0.05
2807, 1.4, 1.06, -0.025
2808, 1.4, 1.18, -0.05
2809, 1.3, 1.06, -0.05
2810, 1.4, 1.06, -0.075
2811, 1.4, 0.82, -0.025
2812, 1.4, 0.94, -0.05
2813, 1.3, 0.82, -0.05
2814, 1.4, 0.82, -0.075
2815, 1.4, 0.58, -0.025
2816, 1.4, 0.7, -0.05
2817, 1.3, 0.58, -0.05
2818, 1.4, 0.58, -0.075
2819, 1.4, 0.34, -0.025
2820, 1.4, 0.46, -0.05
2821, 1.3, 0.34, -0.05
2822, 1.4, 0.34, -0.075
2823, 1.4, 0.22, -0.05
2824, 1.6, 1.06, -0.025
2825, 1.6, 1.18, -0.05
2826, 1.5, 1.06, -0.05
2827, 1.6, 1.06, -0.075
2828, 1.6, 0.82, -0.025
2829, 1.6, 0.94, -0.05
2830, 1.5, 0.82, -0.05
2831, 1.6, 0.82, -0.075
2832, 1.6, 0.58, -0.025
2833, 1.6, 0.7, -0.05
2834, 1.5, 0.58, -0.05
2835, 1.6, 0.58, -0.075
2836, 1.6, 0.34, -0.025
2837, 1.6, 0.46, -0.05
2838, 1.5, 0.34, -0.05
2839, 1.6, 0.34, -0.075
2840, 1.6, 0.22, -0.05
2841, 1.8, 1.06, -0.025
2842, 1.8, 1.18, -0.05
2843, 1.7, 1.06, -0.05
2844, 1.8, 1.06, -0.075
2845, 1.8, 0.82, -0.025
2846, 1.8, 0.94, -0.05
2847, 1.7, 0.82, -0.05
2848, 1.8, 0.82, -0.075
2849, 1.8, 0.58, -0.025
2850, 1.8, 0.7, -0.05
2851, 1.7, 0.58, -0.05
2852, 1.8, 0.58, -0.075
2853, 1.8, 0.34, -0.025
2854, 1.8, 0.46, -0.05
2855, 1.7, 0.34, -0.05
2856, 1.8, 0.34, -0.075
2857, 1.8, 0.22, -0.05
2858, 2, 1.06, -0.025
2859, 2, 1.18, -0.05
2860, 1.9, 1.06, -0.05
2861, 2, 1.06, -0.075
2862, 2, 0.82, -0.025
2863, 2, 0.94, -0.05
2864, 1.9, 0.82, -0.05
2865, 2, 0.82, -0.075
2866, 2, 0.58, -0.025
2867, 2, 0.7, -0.05
2868, 1.9, 0.58, -0.05
2869, 2, 0.58, -0.075
2870, 2, 0.34, -0.025
2871, 2, 0.46, -0.05
2872, 1.9, 0.34, -0.05
2873, 2, 0.34, -0.075
2874, 2, 0.22, -0.05
2875, 2.1, 1.06, -0.05
2876, 2.1, 0.82, -0.05
2877, 2.1, 0.58, -0.05
2878, 2.1, 0.34, -0.05
2879, 1.025, 0.34, 0.16666666666667
2880, 1.025, 0.58, 0.16666666666667
2881, 1.025, 0.82, 0.16666666666667
2882, 1.025, 1.06, 0.16666666666667
2883, 1.025, 0.34, 0.33333333333333
2884, 1.025, 0.58, 0.33333333333333
2885, 1.025, 0.82, 0.33333333333333
2886, 1.025, 1.06, 0.33333333333333
2887, 1.175, 1.06, 0.16666666666667
2888, 1.175, 0.82, 0.16666666666667
2889, 1.175, 0.58, 0.16666666666667
2890, 1.175, 0.34, 0.16666666666667
2891, 1.175, 1.06, 0.33333333333333
2892, 1.175, 0.82, 0.33333333333333
2893, 1.175, 0.58, 0.33333333333333
2894, 1.175, 0.34, 0.33333333333333
2895, 1.175, 1.06, -0.05
2896, 1.175, 0.82, -0.05
2897, 1.175, 0.58, -0.05
2898, 1.175, 0.34, -0.05
2899, 1.025, 0.34, -0.05
2900, 1.025, 0.58, -0.05
2901, 1.025, 0.82, -0.05
2902, 1.025, 1.06, -0.05
******* E L E M E N T S *************
*ELEMENT, type=T3D3, ELSET=Line1
77, 2, 79, 77
78, 77, 80, 78
79, 78, 81, 1
*ELEMENT, type=T3D3, ELSET=Line2
80, 1, 83, 82
81, 82, 84, 3
*ELEMENT, type=T3D3, ELSET=Line3
82, 4, 87, 85
83, 85, 88, 86
84, 86, 89, 3
*ELEMENT, type=T3D3, ELSET=Line4
85, 2, 91, 90
86, 90, 92, 4
*ELEMENT, type=T3D3, ELSET=Line5
87, 6, 95, 93
88, 93, 96, 94
89, 94, 97, 5
*ELEMENT, type=T3D3, ELSET=Line6
90, 5, 99, 98
91, 98, 100, 7
*ELEMENT, type=T3D3, ELSET=Line7
92, 8, 103, 101
93, 101, 104, 102
94, 102, 105, 7
*ELEMENT, type=T3D3, ELSET=Line8
95, 6, 107, 106
96, 106, 108, 8
*ELEMENT, type=T3D3, ELSET=Line9
97, 2, 113, 109
98, 109, 114, 110
99, 110, 115, 111
100, 111, 116, 112
101, 112, 117, 6
*ELEMENT, type=T3D3, ELSET=Line10
102, 1, 122, 118
103, 118, 123, 119
104, 119, 124, 120
105, 120, 125, 121
106, 121, 126, 5
*ELEMENT, type=T3D3, ELSET=Line11
107, 4, 131, 127
108, 127, 132, 128
109, 128, 133, 129
110, 129, 134, 130
111, 130, 135, 8
*ELEMENT, type=T3D3, ELSET=Line12
112, 3, 140, 136
113, 136, 141, 137
114, 137, 142, 138
115, 138, 143, 139
116, 139, 144, 7
*ELEMENT, type=T3D3, ELSET=Line13
117, 8, 145, 9
*ELEMENT, type=T3D3, ELSET=Line14
118, 4, 146, 10
*ELEMENT, type=T3D3, ELSET=Line15
119, 10, 151, 147
120, 147, 152, 148
121, 148, 153, 149
122, 149, 154, 150
123, 150, 155, 9
*ELEMENT, type=T3D3, ELSET=Line16
124, 7, 156, 11
*ELEMENT, type=T3D3, ELSET=Line17
125, 9, 159, 157
126, 157, 160, 158
127, 158, 161, 11
*ELEMENT, type=T3D3, ELSET=Line18
128, 3, 162, 12
*ELEMENT, type=T3D3, ELSET=Line19
129, 12, 167, 163
130, 163, 168, 164
131, 164, 169, 165
132, 165, 170, 166
133, 166, 171, 11
*ELEMENT, type=T3D3, ELSET=Line20
134, 10, 174, 172
135, 172, 175, 173
136, 173, 176, 12
*ELEMENT, type=T3D3, ELSET=Line21
137, 9, 181, 177
138, 177, 182, 178
139, 178, 183, 179
140, 179, 184, 180
141, 180, 185, 13
*ELEMENT, type=T3D3, ELSET=Line22
142, 10, 190, 186
143, 186, 191, 187
144, 187, 192, 188
145, 188, 193, 189
146, 189, 194, 14
*ELEMENT, type=T3D3, ELSET=Line23
147, 14, 199, 195
148, 195, 200, 196
149, 196, 201, 197
150, 197, 202, 198
151, 198, 203, 13
*ELEMENT, type=T3D3, ELSET=Line24
152, 11, 208, 204
153, 204, 209, 205
154, 205, 210, 206
155, 206, 211, 207
156, 207, 212, 15
*ELEMENT, type=T3D3, ELSET=Line25
157, 13, 215, 213
158, 213, 216, 214
159, 214, 217, 15
*ELEMENT, type=T3D3, ELSET=Line26
160, 12, 222, 218
161, 218, 223, 219
162, 219, 224, 220
163, 220, 225, 221
164, 221, 226, 16
*ELEMENT, type=T3D3, ELSET=Line27
165, 16, 231, 227
166, 227, 232, 228
167, 228, 233, 229
168, 229, 234, 230
169, 230, 235, 15
*ELEMENT, type=T3D3, ELSET=Line28
170, 14, 238, 236
171, 236, 239, 237
172, 237, 240, 16
*ELEMENT, type=T3D3, ELSET=Line29
173, 13, 241, 17
*ELEMENT, type=T3D3, ELSET=Line30
174, 14, 242, 18
*ELEMENT, type=T3D3, ELSET=Line31
175, 18, 247, 243
176, 243, 248, 244
177, 244, 249, 245
178, 245, 250, 246
179, 246, 251, 17
*ELEMENT, type=T3D3, ELSET=Line32
180, 15, 252, 19
*ELEMENT, type=T3D3, ELSET=Line33
181, 17, 255, 253
182, 253, 256, 254
183, 254, 257, 19
*ELEMENT, type=T3D3, ELSET=Line34
184, 16, 258, 20
*ELEMENT, type=T3D3, ELSET=Line35
185, 20, 263, 259
186, 259, 264, 260
187, 260, 265, 261
188, 261, 266, 262
189, 262, 267, 19
*ELEMENT, type=T3D3, ELSET=Line36
190, 18, 270, 268
191, 268, 271, 269
192, 269, 272, 20
*ELEMENT, type=T3D3, ELSET=Line37
193, 17, 274, 273
194, 273, 275, 21
*ELEMENT, type=T3D3, ELSET=Line38
195, 18, 277, 276
196, 276, 278, 22
*ELEMENT, type=T3D3, ELSET=Line39
197, 22, 283, 279
198, 279, 284, 280
199, 280, 285, 281
200, 281, 286, 282
201, 282, 287, 21
*ELEMENT, type=T3D3, ELSET=Line40
202, 19, 289, 288
203, 288, 290, 23
*ELEMENT, type=T3D3, ELSET=Line41
204, 21, 293, 291
205, 291, 294, 292
206, 292, 295, 23
*ELEMENT, type=T3D3, ELSET=Line42
207, 20, 297, 296
208, 296, 298, 24
*ELEMENT, type=T3D3, ELSET=Line43
209, 24, 303, 299
210, 299, 304, 300
211, 300, 305, 301
212, 301, 306, 302
213, 302, 307, 23
*ELEMENT, type=T3D3, ELSET=Line44
214, 22, 310, 308
215, 308, 311, 309
216, 309, 312, 24
*ELEMENT, type=T3D3, ELSET=Line45
217, 19, 313, 25
*ELEMENT, type=T3D3, ELSET=Line46
218, 23, 314, 26
*ELEMENT, type=T3D3, ELSET=Line47
219, 25, 316, 315
220, 315, 317, 26
*ELEMENT, type=T3D3, ELSET=Line48
221, 17, 318, 27
*ELEMENT, type=T3D3, ELSET=Line49
222, 21, 319, 28
*ELEMENT, type=T3D3, ELSET=Line50
223, 27, 321, 320
224, 320, 322, 28
*ELEMENT, type=T3D3, ELSET=Line51
225, 27, 325, 323
226, 323, 326, 324
227, 324, 327, 25
*ELEMENT, type=T3D3, ELSET=Line52
228, 28, 330, 328
229, 328, 331, 329
230, 329, 332, 26
*ELEMENT, type=T3D3, ELSET=Line53
231, 25, 337, 333
232, 333, 338, 334
233, 334, 339, 335
234, 335, 340, 336
235, 336, 341, 29
*ELEMENT, type=T3D3, ELSET=Line54
236, 26, 346, 342
237, 342, 347, 343
238, 343, 348, 344
239, 344, 349, 345
240, 345, 350, 30
*ELEMENT, type=T3D3, ELSET=Line55
241, 29, 352, 351
242, 351, 353, 30
*ELEMENT, type=T3D3, ELSET=Line56
243, 27, 358, 354
244, 354, 359, 355
245, 355, 360, 356
246, 356, 361, 357
247, 357, 362, 31
*ELEMENT, type=T3D3, ELSET=Line57
248, 28, 367, 363
249, 363, 368, 364
250, 364, 369, 365
251, 365, 370, 366
252, 366, 371, 32
*ELEMENT, type=T3D3, ELSET=Line58
253, 31, 373, 372
254, 372, 374, 32
*ELEMENT, type=T3D3, ELSET=Line59
255, 31, 377, 375
256, 375, 378, 376
257, 376, 379, 29
*ELEMENT, type=T3D3, ELSET=Line60
258, 32, 382, 380
259, 380, 383, 381
260, 381, 384, 30
*ELEMENT, type=T3D3, ELSET=Line61
261, 25, 385, 33
*ELEMENT, type=T3D3, ELSET=Line62
262, 29, 386, 34
*ELEMENT, type=T3D3, ELSET=Line63
263, 33, 391, 387
264, 387, 392, 388
265, 388, 393, 389
266, 389, 394, 390
267, 390, 395, 34
*ELEMENT, type=T3D3, ELSET=Line64
268, 27, 396, 35
*ELEMENT, type=T3D3, ELSET=Line65
269, 31, 397, 36
*ELEMENT, type=T3D3, ELSET=Line66
270, 35, 402, 398
271, 398, 403, 399
272, 399, 404, 400
273, 400, 405, 401
274, 401, 406, 36
*ELEMENT, type=T3D3, ELSET=Line67
275, 35, 409, 407
276, 407, 410, 408
277, 408, 411, 33
*ELEMENT, type=T3D3, ELSET=Line68
278, 36, 414, 412
279, 412, 415, 413
280, 413, 416, 34
*ELEMENT, type=T3D3, ELSET=Line69
281, 33, 421, 417
282, 417, 422, 418
283, 418, 423, 419
284, 419, 424, 420
285, 420, 425, 37
*ELEMENT, type=T3D3, ELSET=Line70
286, 34, 430, 426
287, 426, 431, 427
288, 427, 432, 428
289, 428, 433, 429
290, 429, 434, 38
*ELEMENT, type=T3D3, ELSET=Line71
291, 37, 439, 435
292, 435, 440, 436
293, 436, 441, 437
294, 437, 442, 438
295, 438, 443, 38
*ELEMENT, type=T3D3, ELSET=Line72
296, 35, 448, 444
297, 444, 449, 445
298, 445, 450, 446
299, 446, 451, 447
300, 447, 452, 39
*ELEMENT, type=T3D3, ELSET=Line73
301, 36, 457, 453
302, 453, 458, 454
303, 454, 459, 455
304, 455, 460, 456
305, 456, 461, 40
*ELEMENT, type=T3D3, ELSET=Line74
306, 39, 466, 462
307, 462, 467, 463
308, 463, 468, 464
309, 464, 469, 465
310, 465, 470, 40
*ELEMENT, type=T3D3, ELSET=Line75
311, 39, 473, 471
312, 471, 474, 472
313, 472, 475, 37
*ELEMENT, type=T3D3, ELSET=Line76
314, 40, 478, 476
315, 476, 479, 477
316, 477, 480, 38
*ELEMENT, type=T3D3, ELSET=Line77
317, 37, 481, 41
*ELEMENT, type=T3D3, ELSET=Line78
318, 38, 482, 42
*ELEMENT, type=T3D3, ELSET=Line79
319, 41, 487, 483
320, 483, 488, 484
321, 484, 489, 485
322, 485, 490, 486
323, 486, 491, 42
*ELEMENT, type=T3D3, ELSET=Line80
324, 39, 492, 43
*ELEMENT, type=T3D3, ELSET=Line81
325, 40, 493, 44
*ELEMENT, type=T3D3, ELSET=Line82
326, 43, 498, 494
327, 494, 499, 495
328, 495, 500, 496
329, 496, 501, 497
330, 497, 502, 44
*ELEMENT, type=T3D3, ELSET=Line83
331, 43, 505, 503
332, 503, 506, 504
333, 504, 507, 41
*ELEMENT, type=T3D3, ELSET=Line84
334, 44, 510, 508
335, 508, 511, 509
336, 509, 512, 42
*ELEMENT, type=T3D3, ELSET=Line85
337, 41, 514, 513
338, 513, 515, 45
*ELEMENT, type=T3D3, ELSET=Line86
339, 42, 517, 516
340, 516, 518, 46
*ELEMENT, type=T3D3, ELSET=Line87
341, 45, 523, 519
342, 519, 524, 520
343, 520, 525, 521
344, 521, 526, 522
345, 522, 527, 46
*ELEMENT, type=T3D3, ELSET=Line88
346, 43, 529, 528
347, 528, 530, 47
*ELEMENT, type=T3D3, ELSET=Line89
348, 44, 532, 531
349, 531, 533, 48
*ELEMENT, type=T3D3, ELSET=Line90
350, 47, 538, 534
351, 534, 539, 535
352, 535, 540, 536
353, 536, 541, 537
354, 537, 542, 48
*ELEMENT, type=T3D3, ELSET=Line91
355, 47, 545, 543
356, 543, 546, 544
357, 544, 547, 45
*ELEMENT, type=T3D3, ELSET=Line92
358, 48, 550, 548
359, 548, 551, 549
360, 549, 552, 46
*ELEMENT, type=T3D3, ELSET=Line93
361, 42, 553, 49
*ELEMENT, type=T3D3, ELSET=Line94
362, 46, 554, 50
*ELEMENT, type=T3D3, ELSET=Line95
363, 49, 556, 555
364, 555, 557, 50
*ELEMENT, type=T3D3, ELSET=Line96
365, 44, 558, 51
*ELEMENT, type=T3D3, ELSET=Line97
366, 48, 559, 52
*ELEMENT, type=T3D3, ELSET=Line98
367, 51, 561, 560
368, 560, 562, 52
*ELEMENT, type=T3D3, ELSET=Line99
369, 51, 565, 563
370, 563, 566, 564
371, 564, 567, 49
*ELEMENT, type=T3D3, ELSET=Line100
372, 52, 570, 568
373, 568, 571, 569
374, 569, 572, 50
*ELEMENT, type=T3D3, ELSET=Line101
375, 1, 573, 53
*ELEMENT, type=T3D3, ELSET=Line102
376, 2, 574, 54
*ELEMENT, type=T3D3, ELSET=Line103
377, 54, 577, 575
378, 575, 578, 576
379, 576, 579, 53
*ELEMENT, type=T3D3, ELSET=Line104
380, 3, 580, 55
*ELEMENT, type=T3D3, ELSET=Line105
381, 53, 582, 581
382, 581, 583, 55
*ELEMENT, type=T3D3, ELSET=Line106
383, 4, 584, 56
*ELEMENT, type=T3D3, ELSET=Line107
384, 56, 587, 585
385, 585, 588, 586
386, 586, 589, 55
*ELEMENT, type=T3D3, ELSET=Line108
387, 54, 591, 590
388, 590, 592, 56
*ELEMENT, type=T3D3, ELSET=Line125
389, 11, 593, 57
*ELEMENT, type=T3D3, ELSET=Line126
390, 15, 594, 58
*ELEMENT, type=T3D3, ELSET=Line127
391, 57, 599, 595
392, 595, 600, 596
393, 596, 601, 597
394, 597, 602, 598
395, 598, 603, 58
*ELEMENT, type=T3D3, ELSET=Line128
396, 9, 604, 59
*ELEMENT, type=T3D3, ELSET=Line129
397, 13, 605, 60
*ELEMENT, type=T3D3, ELSET=Line130
398, 59, 610, 606
399, 606, 611, 607
400, 607, 612, 608
401, 608, 613, 609
402, 609, 614, 60
*ELEMENT, type=T3D3, ELSET=Line131
403, 59, 617, 615
404, 615, 618, 616
405, 616, 619, 57
*ELEMENT, type=T3D3, ELSET=Line132
406, 60, 622, 620
407, 620, 623, 621
408, 621, 624, 58
*ELEMENT, type=T3D3, ELSET=Line133
409, 33, 625, 61
*ELEMENT, type=T3D3, ELSET=Line134
410, 37, 626, 62
*ELEMENT, type=T3D3, ELSET=Line135
411, 61, 631, 627
412, 627, 632, 628
413, 628, 633, 629
414, 629, 634, 630
415, 630, 635, 62
*ELEMENT, type=T3D3, ELSET=Line136
416, 35, 636, 63
*ELEMENT, type=T3D3, ELSET=Line137
417, 39, 637, 64
*ELEMENT, type=T3D3, ELSET=Line138
418, 63, 642, 638
419, 638, 643, 639
420, 639, 644, 640
421, 640, 645, 641
422, 641, 646, 64
*ELEMENT, type=T3D3, ELSET=Line139
423, 63, 649, 647
424, 647, 650, 648
425, 648, 651, 61
*ELEMENT, type=T3D3, ELSET=Line140
426, 64, 654, 652
427, 652, 655, 653
428, 653, 656, 62
*ELEMENT, type=T3D3, ELSET=Line141
429, 9, 658, 657
430, 657, 659, 65
*ELEMENT, type=T3D3, ELSET=Line142
431, 13, 661, 660
432, 660, 662, 66
*ELEMENT, type=T3D3, ELSET=Line143
433, 65, 667, 663
434, 663, 668, 664
435, 664, 669, 665
436, 665, 670, 666
437, 666, 671, 66
*ELEMENT, type=T3D3, ELSET=Line144
438, 10, 673, 672
439, 672, 674, 67
*ELEMENT, type=T3D3, ELSET=Line145
440, 14, 676, 675
441, 675, 677, 68
*ELEMENT, type=T3D3, ELSET=Line146
442, 67, 682, 678
443, 678, 683, 679
444, 679, 684, 680
445, 680, 685, 681
446, 681, 686, 68
*ELEMENT, type=T3D3, ELSET=Line147
447, 67, 691, 687
448, 687, 692, 688
449, 688, 693, 689
450, 689, 694, 690
451, 690, 695, 65
*ELEMENT, type=T3D3, ELSET=Line148
452, 68, 700, 696
453, 696, 701, 697
454, 697, 702, 698
455, 698, 703, 699
456, 699, 704, 66
*ELEMENT, type=T3D3, ELSET=Line149
457, 35, 706, 705
458, 705, 707, 69
*ELEMENT, type=T3D3, ELSET=Line150
459, 39, 709, 708
460, 708, 710, 70
*ELEMENT, type=T3D3, ELSET=Line151
461, 69, 715, 711
462, 711, 716, 712
463, 712, 717, 713
464, 713, 718, 714
465, 714, 719, 70
*ELEMENT, type=T3D3, ELSET=Line152
466, 36, 721, 720
467, 720, 722, 71
*ELEMENT, type=T3D3, ELSET=Line153
468, 40, 724, 723
469, 723, 725, 72
*ELEMENT, type=T3D3, ELSET=Line154
470, 71, 730, 726
471, 726, 731, 727
472, 727, 732, 728
473, 728, 733, 729
474, 729, 734, 72
*ELEMENT, type=T3D3, ELSET=Line155
475, 69, 739, 735
476, 735, 740, 736
477, 736, 741, 737
478, 737, 742, 738
479, 738, 743, 71
*ELEMENT, type=T3D3, ELSET=Line156
480, 70, 748, 744
481, 744, 749, 745
482, 745, 750, 746
483, 746, 751, 747
484, 747, 752, 72
*ELEMENT, type=T3D3, ELSET=Line157
485, 63, 754, 753
486, 753, 755, 73
*ELEMENT, type=T3D3, ELSET=Line158
487, 69, 756, 73
*ELEMENT, type=T3D3, ELSET=Line159
488, 64, 758, 757
489, 757, 759, 74
*ELEMENT, type=T3D3, ELSET=Line160
490, 70, 760, 74
*ELEMENT, type=T3D3, ELSET=Line161
491, 73, 765, 761
492, 761, 766, 762
493, 762, 767, 763
494, 763, 768, 764
495, 764, 769, 74
*ELEMENT, type=T3D3, ELSET=Line162
496, 59, 771, 770
497, 770, 772, 75
*ELEMENT, type=T3D3, ELSET=Line163
498, 65, 773, 75
*ELEMENT, type=T3D3, ELSET=Line164
499, 60, 775, 774
500, 774, 776, 76
*ELEMENT, type=T3D3, ELSET=Line165
501, 66, 777, 76
*ELEMENT, type=T3D3, ELSET=Line166
502, 75, 782, 778
503, 778, 783, 779
504, 779, 784, 780
505, 780, 785, 781
506, 781, 786, 76
*ELEMENT, type=CPS8, ELSET=Surface1
507, 2, 77, 787, 90, 79, 789, 790, 91
508, 90, 787, 85, 4, 790, 791, 87, 92
509, 77, 78, 788, 787, 80, 792, 793, 789
510, 787, 788, 86, 85, 793, 794, 88, 791
511, 78, 1, 82, 788, 81, 83, 795, 792
512, 788, 82, 3, 86, 795, 84, 89, 794
*ELEMENT, type=CPS8, ELSET=Surface2
513, 6, 106, 796, 93, 107, 798, 799, 95
514, 106, 8, 101, 796, 108, 103, 800, 798
515, 93, 796, 797, 94, 799, 801, 802, 96
516, 796, 101, 102, 797, 800, 104, 803, 801
517, 94, 797, 98, 5, 802, 804, 99, 97
518, 797, 102, 7, 98, 803, 105, 100, 804
*ELEMENT, type=CPS8, ELSET=Surface3
519, 2, 109, 805, 77, 113, 813, 814, 79
520, 77, 805, 806, 78, 814, 815, 816, 80
521, 78, 806, 118, 1, 816, 817, 122, 81
522, 109, 110, 807, 805, 114, 818, 819, 813
523, 805, 807, 808, 806, 819, 820, 821, 815
524, 806, 808, 119, 118, 821, 822, 123, 817
525, 110, 111, 809, 807, 115, 823, 824, 818
526, 807, 809, 810, 808, 824, 825, 826, 820
527, 808, 810, 120, 119, 826, 827, 124, 822
528, 111, 112, 811, 809, 116, 828, 829, 823
529, 809, 811, 812, 810, 829, 830, 831, 825
530, 810, 812, 121, 120, 831, 832, 125, 827
531, 112, 6, 93, 811, 117, 95, 833, 828
532, 811, 93, 94, 812, 833, 96, 834, 830
533, 812, 94, 5, 121, 834, 97, 126, 832
*ELEMENT, type=CPS8, ELSET=Surface4
534, 4, 85, 835, 127, 87, 843, 844, 131
535, 85, 86, 836, 835, 88, 845, 846, 843
536, 86, 3, 136, 836, 89, 140, 847, 845
537, 127, 835, 837, 128, 844, 848, 849, 132
538, 835, 836, 838, 837, 846, 850, 851, 848
539, 836, 136, 137, 838, 847, 141, 852, 850
540, 128, 837, 839, 129, 849, 853, 854, 133
541, 837, 838, 840, 839, 851, 855, 856, 853
542, 838, 137, 138, 840, 852, 142, 857, 855
543, 129, 839, 841, 130, 854, 858, 859, 134
544, 839, 840, 842, 841, 856, 860, 861, 858
545, 840, 138, 139, 842, 857, 143, 862, 860
546, 130, 841, 101, 8, 859, 863, 103, 135
547, 841, 842, 102, 101, 861, 864, 104, 863
548, 842, 139, 7, 102, 862, 144, 105, 864
*ELEMENT, type=CPS8, ELSET=Surface5
549, 2, 90, 865, 109, 91, 869, 870, 113
550, 109, 865, 866, 110, 870, 871, 872, 114
551, 110, 866, 867, 111, 872, 873, 874, 115
552, 111, 867, 868, 112, 874, 875, 876, 116
553, 112, 868, 106, 6, 876, 877, 107, 117
554, 90, 4, 127, 865, 92, 131, 878, 869
555, 865, 127, 128, 866, 878, 132, 879, 871
556, 866, 128, 129, 867, 879, 133, 880, 873
557, 867, 129, 130, 868, 880, 134, 881, 875
558, 868, 130, 8, 106, 881, 135, 108, 877
*ELEMENT, type=CPS8, ELSET=Surface6
559, 1, 118, 882, 82, 122, 886, 887, 83
560, 118, 119, 883, 882, 123, 888, 889, 886
561, 119, 120, 884, 883, 124, 890, 891, 888
562, 120, 121, 885, 884, 125, 892, 893, 890
563, 121, 5, 98, 885, 126, 99, 894, 892
564, 82, 882, 136, 3, 887, 895, 140, 84
565, 882, 883, 137, 136, 889, 896, 141, 895
566, 883, 884, 138, 137, 891, 897, 142, 896
567, 884, 885, 139, 138, 893, 898, 143, 897
568, 885, 98, 7, 139, 894, 100, 144, 898
*ELEMENT, type=CPS8, ELSET=Surface7
569, 4, 10, 147, 127, 146, 151, 899, 131
570, 127, 147, 148, 128, 899, 152, 900, 132
571, 128, 148, 149, 129, 900, 153, 901, 133
572, 129, 149, 150, 130, 901, 154, 902, 134
573, 130, 150, 9, 8, 902, 155, 145, 135
*ELEMENT, type=CPS8, ELSET=Surface8
574, 8, 9, 157, 101, 145, 159, 903, 103
575, 101, 157, 158, 102, 903, 160, 904, 104
576, 102, 158, 11, 7, 904, 161, 156, 105
*ELEMENT, type=CPS8, ELSET=Surface9
577, 3, 136, 163, 12, 140, 905, 167, 162
578, 136, 137, 164, 163, 141, 906, 168, 905
579, 137, 138, 165, 164, 142, 907, 169, 906
580, 138, 139, 166, 165, 143, 908, 170, 907
581, 139, 7, 11, 166, 144, 156, 171, 908
*ELEMENT, type=CPS8, ELSET=Surface10
582, 4, 85, 172, 10, 87, 909, 174, 146
583, 85, 86, 173, 172, 88, 910, 175, 909
584, 86, 3, 12, 173, 89, 162, 176, 910
*ELEMENT, type=CPS8, ELSET=Surface11
585, 10, 172, 911, 147, 174, 919, 920, 151
586, 172, 173, 912, 911, 175, 921, 922, 919
587, 173, 12, 163, 912, 176, 167, 923, 921
588, 147, 911, 913, 148, 920, 924, 925, 152
589, 911, 912, 914, 913, 922, 926, 927, 924
590, 912, 163, 164, 914, 923, 168, 928, 926
591, 148, 913, 915, 149, 925, 929, 930, 153
592, 913, 914, 916, 915, 927, 931, 932, 929
593, 914, 164, 165, 916, 928, 169, 933, 931
594, 149, 915, 917, 150, 930, 934, 935, 154
595, 915, 916, 918, 917, 932, 936, 937, 934
596, 916, 165, 166, 918, 933, 170, 938, 936
597, 150, 917, 157, 9, 935, 939, 159, 155
598, 917, 918, 158, 157, 937, 940, 160, 939
599, 918, 166, 11, 158, 938, 171, 161, 940
*ELEMENT, type=CPS8, ELSET=Surface12
600, 10, 186, 941, 147, 190, 957, 958, 151
601, 186, 187, 942, 941, 191, 959, 960, 957
602, 187, 188, 943, 942, 192, 961, 962, 959
603, 188, 189, 944, 943, 193, 963, 964, 961
604, 189, 14, 195, 944, 194, 199, 965, 963
605, 147, 941, 945, 148, 958, 966, 967, 152
606, 941, 942, 946, 945, 960, 968, 969, 966
607, 942, 943, 947, 946, 962, 970, 971, 968
608, 943, 944, 948, 947, 964, 972, 973, 970
609, 944, 195, 196, 948, 965, 200, 974, 972
610, 148, 945, 949, 149, 967, 975, 976, 153
611, 945, 946, 950, 949, 969, 977, 978, 975
612, 946, 947, 951, 950, 971, 979, 980, 977
613, 947, 948, 952, 951, 973, 981, 982, 979
614, 948, 196, 197, 952, 974, 201, 983, 981
615, 149, 949, 953, 150, 976, 984, 985, 154
616, 949, 950, 954, 953, 978, 986, 987, 984
617, 950, 951, 955, 954, 980, 988, 989, 986
618, 951, 952, 956, 955, 982, 990, 991, 988
619, 952, 197, 198, 956, 983, 202, 992, 990
620, 150, 953, 177, 9, 985, 993, 181, 155
621, 953, 954, 178, 177, 987, 994, 182, 993
622, 954, 955, 179, 178, 989, 995, 183, 994
623, 955, 956, 180, 179, 991, 996, 184, 995
624, 956, 198, 13, 180, 992, 203, 185, 996
*ELEMENT, type=CPS8, ELSET=Surface13
625, 9, 177, 997, 157, 181, 1005, 1006, 159
626, 177, 178, 998, 997, 182, 1007, 1008, 1005
627, 178, 179, 999, 998, 183, 1009, 1010, 1007
628, 179, 180, 1000, 999, 184, 1011, 1012, 1009
629, 180, 13, 213, 1000, 185, 215, 1013, 1011
630, 157, 997, 1001, 158, 1006, 1014, 1015, 160
631, 997, 998, 1002, 1001, 1008, 1016, 1017, 1014
632, 998, 999, 1003, 1002, 1010, 1018, 1019, 1016
633, 999, 1000, 1004, 1003, 1012, 1020, 1021, 1018
634, 1000, 213, 214, 1004, 1013, 216, 1022, 1020
635, 158, 1001, 204, 11, 1015, 1023, 208, 161
636, 1001, 1002, 205, 204, 1017, 1024, 209, 1023
637, 1002, 1003, 206, 205, 1019, 1025, 210, 1024
638, 1003, 1004, 207, 206, 1021, 1026, 211, 1025
639, 1004, 214, 15, 207, 1022, 217, 212, 1026
*ELEMENT, type=CPS8, ELSET=Surface14
640, 12, 163, 1027, 218, 167, 1043, 1044, 222
641, 218, 1027, 1028, 219, 1044, 1045, 1046, 223
642, 219, 1028, 1029, 220, 1046, 1047, 1048, 224
643, 220, 1029, 1030, 221, 1048, 1049, 1050, 225
644, 221, 1030, 227, 16, 1050, 1051, 231, 226
645, 163, 164, 1031, 1027, 168, 1052, 1053, 1043
646, 1027, 1031, 1032, 1028, 1053, 1054, 1055, 1045
647, 1028, 1032, 1033, 1029, 1055, 1056, 1057, 1047
648, 1029, 1033, 1034, 1030, 1057, 1058, 1059, 1049
649, 1030, 1034, 228, 227, 1059, 1060, 232, 1051
650, 164, 165, 1035, 1031, 169, 1061, 1062, 1052
651, 1031, 1035, 1036, 1032, 1062, 1063, 1064, 1054
652, 1032, 1036, 1037, 1033, 1064, 1065, 1066, 1056
653, 1033, 1037, 1038, 1034, 1066, 1067, 1068, 1058
654, 1034, 1038, 229, 228, 1068, 1069, 233, 1060
655, 165, 166, 1039, 1035, 170, 1070, 1071, 1061
656, 1035, 1039, 1040, 1036, 1071, 1072, 1073, 1063
657, 1036, 1040, 1041, 1037, 1073, 1074, 1075, 1065
658, 1037, 1041, 1042, 1038, 1075, 1076, 1077, 1067
659, 1038, 1042, 230, 229, 1077, 1078, 234, 1069
660, 166, 11, 204, 1039, 171, 208, 1079, 1070
661, 1039, 204, 205, 1040, 1079, 209, 1080, 1072
662, 1040, 205, 206, 1041, 1080, 210, 1081, 1074
663, 1041, 206, 207, 1042, 1081, 211, 1082, 1076
664, 1042, 207, 15, 230, 1082, 212, 235, 1078
*ELEMENT, type=CPS8, ELSET=Surface15
665, 10, 172, 1083, 186, 174, 1091, 1092, 190
666, 186, 1083, 1084, 187, 1092, 1093, 1094, 191
667, 187, 1084, 1085, 188, 1094, 1095, 1096, 192
668, 188, 1085, 1086, 189, 1096, 1097, 1098, 193
669, 189, 1086, 236, 14, 1098, 1099, 238, 194
670, 172, 173, 1087, 1083, 175, 1100, 1101, 1091
671, 1083, 1087, 1088, 1084, 1101, 1102, 1103, 1093
672, 1084, 1088, 1089, 1085, 1103, 1104, 1105, 1095
673, 1085, 1089, 1090, 1086, 1105, 1106, 1107, 1097
674, 1086, 1090, 237, 236, 1107, 1108, 239, 1099
675, 173, 12, 218, 1087, 176, 222, 1109, 1100
676, 1087, 218, 219, 1088, 1109, 223, 1110, 1102
677, 1088, 219, 220, 1089, 1110, 224, 1111, 1104
678, 1089, 220, 221, 1090, 1111, 225, 1112, 1106
679, 1090, 221, 16, 237, 1112, 226, 240, 1108
*ELEMENT, type=CPS8, ELSET=Surface16
680, 14, 236, 1113, 195, 238, 1121, 1122, 199
681, 236, 237, 1114, 1113, 239, 1123, 1124, 1121
682, 237, 16, 227, 1114, 240, 231, 1125, 1123
683, 195, 1113, 1115, 196, 1122, 1126, 1127, 200
684, 1113, 1114, 1116, 1115, 1124, 1128, 1129, 1126
685, 1114, 227, 228, 1116, 1125, 232, 1130, 1128
686, 196, 1115, 1117, 197, 1127, 1131, 1132, 201
687, 1115, 1116, 1118, 1117, 1129, 1133, 1134, 1131
688, 1116, 228, 229, 1118, 1130, 233, 1135, 1133
689, 197, 1117, 1119, 198, 1132, 1136, 1137, 202
690, 1117, 1118, 1120, 1119, 1134, 1138, 1139, 1136
691, 1118, 229, 230, 1120, 1135, 234, 1140, 1138
692, 198, 1119, 213, 13, 1137, 1141, 215, 203
693, 1119, 1120, 214, 213, 1139, 1142, 216, 1141
694, 1120, 230, 15, 214, 1140, 235, 217, 1142
*ELEMENT, type=CPS8, ELSET=Surface17
695, 14, 18, 243, 195, 242, 247, 1143, 199
696, 195, 243, 244, 196, 1143, 248, 1144, 200
697, 196, 244, 245, 197, 1144, 249, 1145, 201
698, 197, 245, 246, 198, 1145, 250, 1146, 202
699, 198, 246, 17, 13, 1146, 251, 241, 203
*ELEMENT, type=CPS8, ELSET=Surface18
700, 13, 17, 253, 213, 241, 255, 1147, 215
701, 213, 253, 254, 214, 1147, 256, 1148, 216
702, 214, 254, 19, 15, 1148, 257, 252, 217
*ELEMENT, type=CPS8, ELSET=Surface19
703, 16, 227, 259, 20, 231, 1149, 263, 258
704, 227, 228, 260, 259, 232, 1150, 264, 1149
705, 228, 229, 261, 260, 233, 1151, 265, 1150
706, 229, 230, 262, 261, 234, 1152, 266, 1151
707, 230, 15, 19, 262, 235, 252, 267, 1152
*ELEMENT, type=CPS8, ELSET=Surface20
708, 14, 236, 268, 18, 238, 1153, 270, 242
709, 236, 237, 269, 268, 239, 1154, 271, 1153
710, 237, 16, 20, 269, 240, 258, 272, 1154
*ELEMENT, type=CPS8, ELSET=Surface21
711, 18, 268, 1155, 243, 270, 1163, 1164, 247
712, 268, 269, 1156, 1155, 271, 1165, 1166, 1163
713, 269, 20, 259, 1156, 272, 263, 1167, 1165
714, 243, 1155, 1157, 244, 1164, 1168, 1169, 248
715, 1155, 1156, 1158, 1157, 1166, 1170, 1171, 1168
716, 1156, 259, 260, 1158, 1167, 264, 1172, 1170
717, 244, 1157, 1159, 245, 1169, 1173, 1174, 249
718, 1157, 1158, 1160, 1159, 1171, 1175, 1176, 1173
719, 1158, 260, 261, 1160, 1172, 265, 1177, 1175
720, 245, 1159, 1161, 246, 1174, 1178, 1179, 250
721, 1159, 1160, 1162, 1161, 1176, 1180, 1181, 1178
722, 1160, 261, 262, 1162, 1177, 266, 1182, 1180
723, 246, 1161, 253, 17, 1179, 1183, 255, 251
724, 1161, 1162, 254, 253, 1181, 1184, 256, 1183
725, 1162, 262, 19, 254, 1182, 267, 257, 1184
*ELEMENT, type=CPS8, ELSET=Surface22
