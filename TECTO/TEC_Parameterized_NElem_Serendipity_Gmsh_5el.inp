726, 18, 276, 1185, 243, 277, 1189, 1190, 247
727, 276, 22, 279, 1185, 278, 283, 1191, 1189
728, 243, 1185, 1186, 244, 1190, 1192, 1193, 248
729, 1185, 279, 280, 1186, 1191, 284, 1194, 1192
730, 244, 1186, 1187, 245, 1193, 1195, 1196, 249
731, 1186, 280, 281, 1187, 1194, 285, 1197, 1195
732, 245, 1187, 1188, 246, 1196, 1198, 1199, 250
733, 1187, 281, 282, 1188, 1197, 286, 1200, 1198
734, 246, 1188, 273, 17, 1199, 1201, 274, 251
735, 1188, 282, 21, 273, 1200, 287, 275, 1201
*ELEMENT, type=CPS8, ELSET=Surface23
736, 17, 273, 1202, 253, 274, 1204, 1205, 255
737, 273, 21, 291, 1202, 275, 293, 1206, 1204
738, 253, 1202, 1203, 254, 1205, 1207, 1208, 256
739, 1202, 291, 292, 1203, 1206, 294, 1209, 1207
740, 254, 1203, 288, 19, 1208, 1210, 289, 257
741, 1203, 292, 23, 288, 1209, 295, 290, 1210
*ELEMENT, type=CPS8, ELSET=Surface24
742, 20, 259, 1211, 296, 263, 1215, 1216, 297
743, 296, 1211, 299, 24, 1216, 1217, 303, 298
744, 259, 260, 1212, 1211, 264, 1218, 1219, 1215
745, 1211, 1212, 300, 299, 1219, 1220, 304, 1217
746, 260, 261, 1213, 1212, 265, 1221, 1222, 1218
747, 1212, 1213, 301, 300, 1222, 1223, 305, 1220
748, 261, 262, 1214, 1213, 266, 1224, 1225, 1221
749, 1213, 1214, 302, 301, 1225, 1226, 306, 1223
750, 262, 19, 288, 1214, 267, 289, 1227, 1224
751, 1214, 288, 23, 302, 1227, 290, 307, 1226
*ELEMENT, type=CPS8, ELSET=Surface25
752, 18, 268, 1228, 276, 270, 1230, 1231, 277
753, 276, 1228, 308, 22, 1231, 1232, 310, 278
754, 268, 269, 1229, 1228, 271, 1233, 1234, 1230
755, 1228, 1229, 309, 308, 1234, 1235, 311, 1232
756, 269, 20, 296, 1229, 272, 297, 1236, 1233
757, 1229, 296, 24, 309, 1236, 298, 312, 1235
*ELEMENT, type=CPS8, ELSET=Surface26
758, 22, 308, 1237, 279, 310, 1245, 1246, 283
759, 308, 309, 1238, 1237, 311, 1247, 1248, 1245
760, 309, 24, 299, 1238, 312, 303, 1249, 1247
761, 279, 1237, 1239, 280, 1246, 1250, 1251, 284
762, 1237, 1238, 1240, 1239, 1248, 1252, 1253, 1250
763, 1238, 299, 300, 1240, 1249, 304, 1254, 1252
764, 280, 1239, 1241, 281, 1251, 1255, 1256, 285
765, 1239, 1240, 1242, 1241, 1253, 1257, 1258, 1255
766, 1240, 300, 301, 1242, 1254, 305, 1259, 1257
767, 281, 1241, 1243, 282, 1256, 1260, 1261, 286
768, 1241, 1242, 1244, 1243, 1258, 1262, 1263, 1260
769, 1242, 301, 302, 1244, 1259, 306, 1264, 1262
770, 282, 1243, 291, 21, 1261, 1265, 293, 287
771, 1243, 1244, 292, 291, 1263, 1266, 294, 1265
772, 1244, 302, 23, 292, 1264, 307, 295, 1266
*ELEMENT, type=CPS8, ELSET=Surface27
773, 19, 25, 315, 288, 313, 316, 1267, 289
774, 288, 315, 26, 23, 1267, 317, 314, 290
*ELEMENT, type=CPS8, ELSET=Surface28
775, 17, 273, 320, 27, 274, 1268, 321, 318
776, 273, 21, 28, 320, 275, 319, 322, 1268
*ELEMENT, type=CPS8, ELSET=Surface29
777, 17, 27, 323, 253, 318, 325, 1269, 255
778, 253, 323, 324, 254, 1269, 326, 1270, 256
779, 254, 324, 25, 19, 1270, 327, 313, 257
*ELEMENT, type=CPS8, ELSET=Surface30
780, 21, 291, 328, 28, 293, 1271, 330, 319
781, 291, 292, 329, 328, 294, 1272, 331, 1271
782, 292, 23, 26, 329, 295, 314, 332, 1272
*ELEMENT, type=CPS8, ELSET=Surface31
783, 27, 320, 1273, 323, 321, 1275, 1276, 325
784, 320, 28, 328, 1273, 322, 330, 1277, 1275
785, 323, 1273, 1274, 324, 1276, 1278, 1279, 326
786, 1273, 328, 329, 1274, 1277, 331, 1280, 1278
787, 324, 1274, 315, 25, 1279, 1281, 316, 327
788, 1274, 329, 26, 315, 1280, 332, 317, 1281
*ELEMENT, type=CPS8, ELSET=Surface32
789, 25, 333, 1282, 315, 337, 1286, 1287, 316
790, 333, 334, 1283, 1282, 338, 1288, 1289, 1286
791, 334, 335, 1284, 1283, 339, 1290, 1291, 1288
792, 335, 336, 1285, 1284, 340, 1292, 1293, 1290
793, 336, 29, 351, 1285, 341, 352, 1294, 1292
794, 315, 1282, 342, 26, 1287, 1295, 346, 317
795, 1282, 1283, 343, 342, 1289, 1296, 347, 1295
796, 1283, 1284, 344, 343, 1291, 1297, 348, 1296
797, 1284, 1285, 345, 344, 1293, 1298, 349, 1297
798, 1285, 351, 30, 345, 1294, 353, 350, 1298
*ELEMENT, type=CPS8, ELSET=Surface33
799, 27, 320, 1299, 354, 321, 1303, 1304, 358
800, 354, 1299, 1300, 355, 1304, 1305, 1306, 359
801, 355, 1300, 1301, 356, 1306, 1307, 1308, 360
802, 356, 1301, 1302, 357, 1308, 1309, 1310, 361
803, 357, 1302, 372, 31, 1310, 1311, 373, 362
804, 320, 28, 363, 1299, 322, 367, 1312, 1303
805, 1299, 363, 364, 1300, 1312, 368, 1313, 1305
806, 1300, 364, 365, 1301, 1313, 369, 1314, 1307
807, 1301, 365, 366, 1302, 1314, 370, 1315, 1309
808, 1302, 366, 32, 372, 1315, 371, 374, 1311
*ELEMENT, type=CPS8, ELSET=Surface34
809, 27, 354, 1316, 323, 358, 1324, 1325, 325
810, 354, 355, 1317, 1316, 359, 1326, 1327, 1324
811, 355, 356, 1318, 1317, 360, 1328, 1329, 1326
812, 356, 357, 1319, 1318, 361, 1330, 1331, 1328
813, 357, 31, 375, 1319, 362, 377, 1332, 1330
814, 323, 1316, 1320, 324, 1325, 1333, 1334, 326
815, 1316, 1317, 1321, 1320, 1327, 1335, 1336, 1333
816, 1317, 1318, 1322, 1321, 1329, 1337, 1338, 1335
817, 1318, 1319, 1323, 1322, 1331, 1339, 1340, 1337
818, 1319, 375, 376, 1323, 1332, 378, 1341, 1339
819, 324, 1320, 333, 25, 1334, 1342, 337, 327
820, 1320, 1321, 334, 333, 1336, 1343, 338, 1342
821, 1321, 1322, 335, 334, 1338, 1344, 339, 1343
822, 1322, 1323, 336, 335, 1340, 1345, 340, 1344
823, 1323, 376, 29, 336, 1341, 379, 341, 1345
*ELEMENT, type=CPS8, ELSET=Surface35
824, 28, 328, 1346, 363, 330, 1354, 1355, 367
825, 363, 1346, 1347, 364, 1355, 1356, 1357, 368
826, 364, 1347, 1348, 365, 1357, 1358, 1359, 369
827, 365, 1348, 1349, 366, 1359, 1360, 1361, 370
828, 366, 1349, 380, 32, 1361, 1362, 382, 371
829, 328, 329, 1350, 1346, 331, 1363, 1364, 1354
830, 1346, 1350, 1351, 1347, 1364, 1365, 1366, 1356
831, 1347, 1351, 1352, 1348, 1366, 1367, 1368, 1358
832, 1348, 1352, 1353, 1349, 1368, 1369, 1370, 1360
833, 1349, 1353, 381, 380, 1370, 1371, 383, 1362
834, 329, 26, 342, 1350, 332, 346, 1372, 1363
835, 1350, 342, 343, 1351, 1372, 347, 1373, 1365
836, 1351, 343, 344, 1352, 1373, 348, 1374, 1367
837, 1352, 344, 345, 1353, 1374, 349, 1375, 1369
838, 1353, 345, 30, 381, 1375, 350, 384, 1371
*ELEMENT, type=CPS8, ELSET=Surface36
839, 31, 372, 1376, 375, 373, 1378, 1379, 377
840, 372, 32, 380, 1376, 374, 382, 1380, 1378
841, 375, 1376, 1377, 376, 1379, 1381, 1382, 378
842, 1376, 380, 381, 1377, 1380, 383, 1383, 1381
843, 376, 1377, 351, 29, 1382, 1384, 352, 379
844, 1377, 381, 30, 351, 1383, 384, 353, 1384
*ELEMENT, type=CPS8, ELSET=Surface37
845, 25, 33, 387, 333, 385, 391, 1385, 337
846, 333, 387, 388, 334, 1385, 392, 1386, 338
847, 334, 388, 389, 335, 1386, 393, 1387, 339
848, 335, 389, 390, 336, 1387, 394, 1388, 340
849, 336, 390, 34, 29, 1388, 395, 386, 341
*ELEMENT, type=CPS8, ELSET=Surface38
850, 27, 354, 398, 35, 358, 1389, 402, 396
851, 354, 355, 399, 398, 359, 1390, 403, 1389
852, 355, 356, 400, 399, 360, 1391, 404, 1390
853, 356, 357, 401, 400, 361, 1392, 405, 1391
854, 357, 31, 36, 401, 362, 397, 406, 1392
*ELEMENT, type=CPS8, ELSET=Surface39
855, 27, 35, 407, 323, 396, 409, 1393, 325
856, 323, 407, 408, 324, 1393, 410, 1394, 326
857, 324, 408, 33, 25, 1394, 411, 385, 327
*ELEMENT, type=CPS8, ELSET=Surface40
858, 31, 375, 412, 36, 377, 1395, 414, 397
859, 375, 376, 413, 412, 378, 1396, 415, 1395
860, 376, 29, 34, 413, 379, 386, 416, 1396
*ELEMENT, type=CPS8, ELSET=Surface41
861, 35, 398, 1397, 407, 402, 1405, 1406, 409
862, 398, 399, 1398, 1397, 403, 1407, 1408, 1405
863, 399, 400, 1399, 1398, 404, 1409, 1410, 1407
864, 400, 401, 1400, 1399, 405, 1411, 1412, 1409
865, 401, 36, 412, 1400, 406, 414, 1413, 1411
866, 407, 1397, 1401, 408, 1406, 1414, 1415, 410
867, 1397, 1398, 1402, 1401, 1408, 1416, 1417, 1414
868, 1398, 1399, 1403, 1402, 1410, 1418, 1419, 1416
869, 1399, 1400, 1404, 1403, 1412, 1420, 1421, 1418
870, 1400, 412, 413, 1404, 1413, 415, 1422, 1420
871, 408, 1401, 387, 33, 1415, 1423, 391, 411
872, 1401, 1402, 388, 387, 1417, 1424, 392, 1423
873, 1402, 1403, 389, 388, 1419, 1425, 393, 1424
874, 1403, 1404, 390, 389, 1421, 1426, 394, 1425
875, 1404, 413, 34, 390, 1422, 416, 395, 1426
*ELEMENT, type=CPS8, ELSET=Surface42
876, 33, 417, 1427, 387, 421, 1443, 1444, 391
877, 417, 418, 1428, 1427, 422, 1445, 1446, 1443
878, 418, 419, 1429, 1428, 423, 1447, 1448, 1445
879, 419, 420, 1430, 1429, 424, 1449, 1450, 1447
880, 420, 37, 435, 1430, 425, 439, 1451, 1449
881, 387, 1427, 1431, 388, 1444, 1452, 1453, 392
882, 1427, 1428, 1432, 1431, 1446, 1454, 1455, 1452
883, 1428, 1429, 1433, 1432, 1448, 1456, 1457, 1454
884, 1429, 1430, 1434, 1433, 1450, 1458, 1459, 1456
885, 1430, 435, 436, 1434, 1451, 440, 1460, 1458
886, 388, 1431, 1435, 389, 1453, 1461, 1462, 393
887, 1431, 1432, 1436, 1435, 1455, 1463, 1464, 1461
888, 1432, 1433, 1437, 1436, 1457, 1465, 1466, 1463
889, 1433, 1434, 1438, 1437, 1459, 1467, 1468, 1465
890, 1434, 436, 437, 1438, 1460, 441, 1469, 1467
891, 389, 1435, 1439, 390, 1462, 1470, 1471, 394
892, 1435, 1436, 1440, 1439, 1464, 1472, 1473, 1470
893, 1436, 1437, 1441, 1440, 1466, 1474, 1475, 1472
894, 1437, 1438, 1442, 1441, 1468, 1476, 1477, 1474
895, 1438, 437, 438, 1442, 1469, 442, 1478, 1476
896, 390, 1439, 426, 34, 1471, 1479, 430, 395
897, 1439, 1440, 427, 426, 1473, 1480, 431, 1479
898, 1440, 1441, 428, 427, 1475, 1481, 432, 1480
899, 1441, 1442, 429, 428, 1477, 1482, 433, 1481
900, 1442, 438, 38, 429, 1478, 443, 434, 1482
*ELEMENT, type=CPS8, ELSET=Surface43
901, 35, 398, 1483, 444, 402, 1499, 1500, 448
902, 444, 1483, 1484, 445, 1500, 1501, 1502, 449
903, 445, 1484, 1485, 446, 1502, 1503, 1504, 450
904, 446, 1485, 1486, 447, 1504, 1505, 1506, 451
905, 447, 1486, 462, 39, 1506, 1507, 466, 452
906, 398, 399, 1487, 1483, 403, 1508, 1509, 1499
907, 1483, 1487, 1488, 1484, 1509, 1510, 1511, 1501
908, 1484, 1488, 1489, 1485, 1511, 1512, 1513, 1503
909, 1485, 1489, 1490, 1486, 1513, 1514, 1515, 1505
910, 1486, 1490, 463, 462, 1515, 1516, 467, 1507
911, 399, 400, 1491, 1487, 404, 1517, 1518, 1508
912, 1487, 1491, 1492, 1488, 1518, 1519, 1520, 1510
913, 1488, 1492, 1493, 1489, 1520, 1521, 1522, 1512
914, 1489, 1493, 1494, 1490, 1522, 1523, 1524, 1514
915, 1490, 1494, 464, 463, 1524, 1525, 468, 1516
916, 400, 401, 1495, 1491, 405, 1526, 1527, 1517
917, 1491, 1495, 1496, 1492, 1527, 1528, 1529, 1519
918, 1492, 1496, 1497, 1493, 1529, 1530, 1531, 1521
919, 1493, 1497, 1498, 1494, 1531, 1532, 1533, 1523
920, 1494, 1498, 465, 464, 1533, 1534, 469, 1525
921, 401, 36, 453, 1495, 406, 457, 1535, 1526
922, 1495, 453, 454, 1496, 1535, 458, 1536, 1528
923, 1496, 454, 455, 1497, 1536, 459, 1537, 1530
924, 1497, 455, 456, 1498, 1537, 460, 1538, 1532
925, 1498, 456, 40, 465, 1538, 461, 470, 1534
*ELEMENT, type=CPS8, ELSET=Surface44
926, 35, 444, 1539, 407, 448, 1547, 1548, 409
927, 444, 445, 1540, 1539, 449, 1549, 1550, 1547
928, 445, 446, 1541, 1540, 450, 1551, 1552, 1549
929, 446, 447, 1542, 1541, 451, 1553, 1554, 1551
930, 447, 39, 471, 1542, 452, 473, 1555, 1553
931, 407, 1539, 1543, 408, 1548, 1556, 1557, 410
932, 1539, 1540, 1544, 1543, 1550, 1558, 1559, 1556
933, 1540, 1541, 1545, 1544, 1552, 1560, 1561, 1558
934, 1541, 1542, 1546, 1545, 1554, 1562, 1563, 1560
935, 1542, 471, 472, 1546, 1555, 474, 1564, 1562
936, 408, 1543, 417, 33, 1557, 1565, 421, 411
937, 1543, 1544, 418, 417, 1559, 1566, 422, 1565
938, 1544, 1545, 419, 418, 1561, 1567, 423, 1566
939, 1545, 1546, 420, 419, 1563, 1568, 424, 1567
940, 1546, 472, 37, 420, 1564, 475, 425, 1568
*ELEMENT, type=CPS8, ELSET=Surface45
941, 36, 412, 1569, 453, 414, 1577, 1578, 457
942, 453, 1569, 1570, 454, 1578, 1579, 1580, 458
943, 454, 1570, 1571, 455, 1580, 1581, 1582, 459
944, 455, 1571, 1572, 456, 1582, 1583, 1584, 460
945, 456, 1572, 476, 40, 1584, 1585, 478, 461
946, 412, 413, 1573, 1569, 415, 1586, 1587, 1577
947, 1569, 1573, 1574, 1570, 1587, 1588, 1589, 1579
948, 1570, 1574, 1575, 1571, 1589, 1590, 1591, 1581
949, 1571, 1575, 1576, 1572, 1591, 1592, 1593, 1583
950, 1572, 1576, 477, 476, 1593, 1594, 479, 1585
951, 413, 34, 426, 1573, 416, 430, 1595, 1586
952, 1573, 426, 427, 1574, 1595, 431, 1596, 1588
953, 1574, 427, 428, 1575, 1596, 432, 1597, 1590
954, 1575, 428, 429, 1576, 1597, 433, 1598, 1592
955, 1576, 429, 38, 477, 1598, 434, 480, 1594
*ELEMENT, type=CPS8, ELSET=Surface46
956, 39, 462, 1599, 471, 466, 1607, 1608, 473
957, 462, 463, 1600, 1599, 467, 1609, 1610, 1607
958, 463, 464, 1601, 1600, 468, 1611, 1612, 1609
959, 464, 465, 1602, 1601, 469, 1613, 1614, 1611
960, 465, 40, 476, 1602, 470, 478, 1615, 1613
961, 471, 1599, 1603, 472, 1608, 1616, 1617, 474
962, 1599, 1600, 1604, 1603, 1610, 1618, 1619, 1616
963, 1600, 1601, 1605, 1604, 1612, 1620, 1621, 1618
964, 1601, 1602, 1606, 1605, 1614, 1622, 1623, 1620
965, 1602, 476, 477, 1606, 1615, 479, 1624, 1622
966, 472, 1603, 435, 37, 1617, 1625, 439, 475
967, 1603, 1604, 436, 435, 1619, 1626, 440, 1625
968, 1604, 1605, 437, 436, 1621, 1627, 441, 1626
969, 1605, 1606, 438, 437, 1623, 1628, 442, 1627
970, 1606, 477, 38, 438, 1624, 480, 443, 1628
*ELEMENT, type=CPS8, ELSET=Surface47
971, 37, 41, 483, 435, 481, 487, 1629, 439
972, 435, 483, 484, 436, 1629, 488, 1630, 440
973, 436, 484, 485, 437, 1630, 489, 1631, 441
974, 437, 485, 486, 438, 1631, 490, 1632, 442
975, 438, 486, 42, 38, 1632, 491, 482, 443
*ELEMENT, type=CPS8, ELSET=Surface48
976, 39, 462, 494, 43, 466, 1633, 498, 492
977, 462, 463, 495, 494, 467, 1634, 499, 1633
978, 463, 464, 496, 495, 468, 1635, 500, 1634
979, 464, 465, 497, 496, 469, 1636, 501, 1635
980, 465, 40, 44, 497, 470, 493, 502, 1636
*ELEMENT, type=CPS8, ELSET=Surface49
981, 39, 43, 503, 471, 492, 505, 1637, 473
982, 471, 503, 504, 472, 1637, 506, 1638, 474
983, 472, 504, 41, 37, 1638, 507, 481, 475
*ELEMENT, type=CPS8, ELSET=Surface50
984, 40, 476, 508, 44, 478, 1639, 510, 493
985, 476, 477, 509, 508, 479, 1640, 511, 1639
986, 477, 38, 42, 509, 480, 482, 512, 1640
*ELEMENT, type=CPS8, ELSET=Surface51
987, 43, 494, 1641, 503, 498, 1649, 1650, 505
988, 494, 495, 1642, 1641, 499, 1651, 1652, 1649
989, 495, 496, 1643, 1642, 500, 1653, 1654, 1651
990, 496, 497, 1644, 1643, 501, 1655, 1656, 1653
991, 497, 44, 508, 1644, 502, 510, 1657, 1655
992, 503, 1641, 1645, 504, 1650, 1658, 1659, 506
993, 1641, 1642, 1646, 1645, 1652, 1660, 1661, 1658
994, 1642, 1643, 1647, 1646, 1654, 1662, 1663, 1660
995, 1643, 1644, 1648, 1647, 1656, 1664, 1665, 1662
996, 1644, 508, 509, 1648, 1657, 511, 1666, 1664
997, 504, 1645, 483, 41, 1659, 1667, 487, 507
998, 1645, 1646, 484, 483, 1661, 1668, 488, 1667
999, 1646, 1647, 485, 484, 1663, 1669, 489, 1668
1000, 1647, 1648, 486, 485, 1665, 1670, 490, 1669
1001, 1648, 509, 42, 486, 1666, 512, 491, 1670
*ELEMENT, type=CPS8, ELSET=Surface52
1002, 41, 513, 1671, 483, 514, 1675, 1676, 487
1003, 513, 45, 519, 1671, 515, 523, 1677, 1675
1004, 483, 1671, 1672, 484, 1676, 1678, 1679, 488
1005, 1671, 519, 520, 1672, 1677, 524, 1680, 1678
1006, 484, 1672, 1673, 485, 1679, 1681, 1682, 489
1007, 1672, 520, 521, 1673, 1680, 525, 1683, 1681
1008, 485, 1673, 1674, 486, 1682, 1684, 1685, 490
1009, 1673, 521, 522, 1674, 1683, 526, 1686, 1684
1010, 486, 1674, 516, 42, 1685, 1687, 517, 491
1011, 1674, 522, 46, 516, 1686, 527, 518, 1687
*ELEMENT, type=CPS8, ELSET=Surface53
1012, 43, 494, 1688, 528, 498, 1692, 1693, 529
1013, 528, 1688, 534, 47, 1693, 1694, 538, 530
1014, 494, 495, 1689, 1688, 499, 1695, 1696, 1692
1015, 1688, 1689, 535, 534, 1696, 1697, 539, 1694
1016, 495, 496, 1690, 1689, 500, 1698, 1699, 1695
1017, 1689, 1690, 536, 535, 1699, 1700, 540, 1697
1018, 496, 497, 1691, 1690, 501, 1701, 1702, 1698
1019, 1690, 1691, 537, 536, 1702, 1703, 541, 1700
1020, 497, 44, 531, 1691, 502, 532, 1704, 1701
1021, 1691, 531, 48, 537, 1704, 533, 542, 1703
*ELEMENT, type=CPS8, ELSET=Surface54
1022, 43, 528, 1705, 503, 529, 1707, 1708, 505
1023, 528, 47, 543, 1705, 530, 545, 1709, 1707
1024, 503, 1705, 1706, 504, 1708, 1710, 1711, 506
1025, 1705, 543, 544, 1706, 1709, 546, 1712, 1710
1026, 504, 1706, 513, 41, 1711, 1713, 514, 507
1027, 1706, 544, 45, 513, 1712, 547, 515, 1713
*ELEMENT, type=CPS8, ELSET=Surface55
1028, 44, 508, 1714, 531, 510, 1716, 1717, 532
1029, 531, 1714, 548, 48, 1717, 1718, 550, 533
1030, 508, 509, 1715, 1714, 511, 1719, 1720, 1716
1031, 1714, 1715, 549, 548, 1720, 1721, 551, 1718
1032, 509, 42, 516, 1715, 512, 517, 1722, 1719
1033, 1715, 516, 46, 549, 1722, 518, 552, 1721
*ELEMENT, type=CPS8, ELSET=Surface56
1034, 47, 534, 1723, 543, 538, 1731, 1732, 545
1035, 534, 535, 1724, 1723, 539, 1733, 1734, 1731
1036, 535, 536, 1725, 1724, 540, 1735, 1736, 1733
1037, 536, 537, 1726, 1725, 541, 1737, 1738, 1735
1038, 537, 48, 548, 1726, 542, 550, 1739, 1737
1039, 543, 1723, 1727, 544, 1732, 1740, 1741, 546
1040, 1723, 1724, 1728, 1727, 1734, 1742, 1743, 1740
1041, 1724, 1725, 1729, 1728, 1736, 1744, 1745, 1742
1042, 1725, 1726, 1730, 1729, 1738, 1746, 1747, 1744
1043, 1726, 548, 549, 1730, 1739, 551, 1748, 1746
1044, 544, 1727, 519, 45, 1741, 1749, 523, 547
1045, 1727, 1728, 520, 519, 1743, 1750, 524, 1749
1046, 1728, 1729, 521, 520, 1745, 1751, 525, 1750
1047, 1729, 1730, 522, 521, 1747, 1752, 526, 1751
1048, 1730, 549, 46, 522, 1748, 552, 527, 1752
*ELEMENT, type=CPS8, ELSET=Surface57
1049, 42, 516, 555, 49, 517, 1753, 556, 553
1050, 516, 46, 50, 555, 518, 554, 557, 1753
*ELEMENT, type=CPS8, ELSET=Surface58
1051, 44, 51, 560, 531, 558, 561, 1754, 532
1052, 531, 560, 52, 48, 1754, 562, 559, 533
*ELEMENT, type=CPS8, ELSET=Surface59
1053, 44, 508, 563, 51, 510, 1755, 565, 558
1054, 508, 509, 564, 563, 511, 1756, 566, 1755
1055, 509, 42, 49, 564, 512, 553, 567, 1756
*ELEMENT, type=CPS8, ELSET=Surface60
1056, 48, 52, 568, 548, 559, 570, 1757, 550
1057, 548, 568, 569, 549, 1757, 571, 1758, 551
1058, 549, 569, 50, 46, 1758, 572, 554, 552
*ELEMENT, type=CPS8, ELSET=Surface61
1059, 51, 563, 1759, 560, 565, 1761, 1762, 561
1060, 560, 1759, 568, 52, 1762, 1763, 570, 562
1061, 563, 564, 1760, 1759, 566, 1764, 1765, 1761
1062, 1759, 1760, 569, 568, 1765, 1766, 571, 1763
1063, 564, 49, 555, 1760, 567, 556, 1767, 1764
1064, 1760, 555, 50, 569, 1767, 557, 572, 1766
*ELEMENT, type=CPS8, ELSET=Surface62
1065, 2, 77, 575, 54, 79, 1768, 577, 574
1066, 77, 78, 576, 575, 80, 1769, 578, 1768
1067, 78, 1, 53, 576, 81, 573, 579, 1769
*ELEMENT, type=CPS8, ELSET=Surface63
1068, 1, 82, 581, 53, 83, 1770, 582, 573
1069, 82, 3, 55, 581, 84, 580, 583, 1770
*ELEMENT, type=CPS8, ELSET=Surface64
1070, 4, 56, 585, 85, 584, 587, 1771, 87
1071, 85, 585, 586, 86, 1771, 588, 1772, 88
1072, 86, 586, 55, 3, 1772, 589, 580, 89
*ELEMENT, type=CPS8, ELSET=Surface65
1073, 2, 54, 590, 90, 574, 591, 1773, 91
1074, 90, 590, 56, 4, 1773, 592, 584, 92
*ELEMENT, type=CPS8, ELSET=Surface66
1075, 54, 575, 1774, 590, 577, 1776, 1777, 591
1076, 590, 1774, 585, 56, 1777, 1778, 587, 592
1077, 575, 576, 1775, 1774, 578, 1779, 1780, 1776
1078, 1774, 1775, 586, 585, 1780, 1781, 588, 1778
1079, 576, 53, 581, 1775, 579, 582, 1782, 1779
1080, 1775, 581, 55, 586, 1782, 583, 589, 1781
*ELEMENT, type=CPS8, ELSET=Surface77
1081, 11, 57, 595, 204, 593, 599, 1783, 208
1082, 204, 595, 596, 205, 1783, 600, 1784, 209
1083, 205, 596, 597, 206, 1784, 601, 1785, 210
1084, 206, 597, 598, 207, 1785, 602, 1786, 211
1085, 207, 598, 58, 15, 1786, 603, 594, 212
*ELEMENT, type=CPS8, ELSET=Surface78
1086, 9, 177, 606, 59, 181, 1787, 610, 604
1087, 177, 178, 607, 606, 182, 1788, 611, 1787
1088, 178, 179, 608, 607, 183, 1789, 612, 1788
1089, 179, 180, 609, 608, 184, 1790, 613, 1789
1090, 180, 13, 60, 609, 185, 605, 614, 1790
*ELEMENT, type=CPS8, ELSET=Surface79
1091, 9, 59, 615, 157, 604, 617, 1791, 159
1092, 157, 615, 616, 158, 1791, 618, 1792, 160
1093, 158, 616, 57, 11, 1792, 619, 593, 161
*ELEMENT, type=CPS8, ELSET=Surface80
1094, 13, 213, 620, 60, 215, 1793, 622, 605
1095, 213, 214, 621, 620, 216, 1794, 623, 1793
1096, 214, 15, 58, 621, 217, 594, 624, 1794
*ELEMENT, type=CPS8, ELSET=Surface81
1097, 59, 606, 1795, 615, 610, 1803, 1804, 617
1098, 606, 607, 1796, 1795, 611, 1805, 1806, 1803
1099, 607, 608, 1797, 1796, 612, 1807, 1808, 1805
1100, 608, 609, 1798, 1797, 613, 1809, 1810, 1807
1101, 609, 60, 620, 1798, 614, 622, 1811, 1809
1102, 615, 1795, 1799, 616, 1804, 1812, 1813, 618
1103, 1795, 1796, 1800, 1799, 1806, 1814, 1815, 1812
1104, 1796, 1797, 1801, 1800, 1808, 1816, 1817, 1814
1105, 1797, 1798, 1802, 1801, 1810, 1818, 1819, 1816
1106, 1798, 620, 621, 1802, 1811, 623, 1820, 1818
1107, 616, 1799, 595, 57, 1813, 1821, 599, 619
1108, 1799, 1800, 596, 595, 1815, 1822, 600, 1821
1109, 1800, 1801, 597, 596, 1817, 1823, 601, 1822
1110, 1801, 1802, 598, 597, 1819, 1824, 602, 1823
1111, 1802, 621, 58, 598, 1820, 624, 603, 1824
*ELEMENT, type=CPS8, ELSET=Surface82
1112, 33, 61, 627, 417, 625, 631, 1825, 421
1113, 417, 627, 628, 418, 1825, 632, 1826, 422
1114, 418, 628, 629, 419, 1826, 633, 1827, 423
1115, 419, 629, 630, 420, 1827, 634, 1828, 424
1116, 420, 630, 62, 37, 1828, 635, 626, 425
*ELEMENT, type=CPS8, ELSET=Surface83
1117, 35, 444, 638, 63, 448, 1829, 642, 636
1118, 444, 445, 639, 638, 449, 1830, 643, 1829
1119, 445, 446, 640, 639, 450, 1831, 644, 1830
1120, 446, 447, 641, 640, 451, 1832, 645, 1831
1121, 447, 39, 64, 641, 452, 637, 646, 1832
*ELEMENT, type=CPS8, ELSET=Surface84
1122, 35, 63, 647, 407, 636, 649, 1833, 409
1123, 407, 647, 648, 408, 1833, 650, 1834, 410
1124, 408, 648, 61, 33, 1834, 651, 625, 411
*ELEMENT, type=CPS8, ELSET=Surface85
1125, 39, 471, 652, 64, 473, 1835, 654, 637
1126, 471, 472, 653, 652, 474, 1836, 655, 1835
1127, 472, 37, 62, 653, 475, 626, 656, 1836
*ELEMENT, type=CPS8, ELSET=Surface86
1128, 63, 638, 1837, 647, 642, 1845, 1846, 649
1129, 638, 639, 1838, 1837, 643, 1847, 1848, 1845
1130, 639, 640, 1839, 1838, 644, 1849, 1850, 1847
1131, 640, 641, 1840, 1839, 645, 1851, 1852, 1849
1132, 641, 64, 652, 1840, 646, 654, 1853, 1851
1133, 647, 1837, 1841, 648, 1846, 1854, 1855, 650
1134, 1837, 1838, 1842, 1841, 1848, 1856, 1857, 1854
1135, 1838, 1839, 1843, 1842, 1850, 1858, 1859, 1856
1136, 1839, 1840, 1844, 1843, 1852, 1860, 1861, 1858
1137, 1840, 652, 653, 1844, 1853, 655, 1862, 1860
1138, 648, 1841, 627, 61, 1855, 1863, 631, 651
1139, 1841, 1842, 628, 627, 1857, 1864, 632, 1863
1140, 1842, 1843, 629, 628, 1859, 1865, 633, 1864
1141, 1843, 1844, 630, 629, 1861, 1866, 634, 1865
1142, 1844, 653, 62, 630, 1862, 656, 635, 1866
*ELEMENT, type=CPS8, ELSET=Surface87
1143, 9, 657, 1867, 177, 658, 1871, 1872, 181
1144, 657, 65, 663, 1867, 659, 667, 1873, 1871
1145, 177, 1867, 1868, 178, 1872, 1874, 1875, 182
1146, 1867, 663, 664, 1868, 1873, 668, 1876, 1874
1147, 178, 1868, 1869, 179, 1875, 1877, 1878, 183
1148, 1868, 664, 665, 1869, 1876, 669, 1879, 1877
1149, 179, 1869, 1870, 180, 1878, 1880, 1881, 184
1150, 1869, 665, 666, 1870, 1879, 670, 1882, 1880
1151, 180, 1870, 660, 13, 1881, 1883, 661, 185
1152, 1870, 666, 66, 660, 1882, 671, 662, 1883
*ELEMENT, type=CPS8, ELSET=Surface88
1153, 10, 186, 1884, 672, 190, 1888, 1889, 673
1154, 672, 1884, 678, 67, 1889, 1890, 682, 674
1155, 186, 187, 1885, 1884, 191, 1891, 1892, 1888
1156, 1884, 1885, 679, 678, 1892, 1893, 683, 1890
1157, 187, 188, 1886, 1885, 192, 1894, 1895, 1891
1158, 1885, 1886, 680, 679, 1895, 1896, 684, 1893
1159, 188, 189, 1887, 1886, 193, 1897, 1898, 1894
1160, 1886, 1887, 681, 680, 1898, 1899, 685, 1896
1161, 189, 14, 675, 1887, 194, 676, 1900, 1897
1162, 1887, 675, 68, 681, 1900, 677, 686, 1899
*ELEMENT, type=CPS8, ELSET=Surface89
1163, 10, 672, 1901, 147, 673, 1905, 1906, 151
1164, 672, 67, 687, 1901, 674, 691, 1907, 1905
1165, 147, 1901, 1902, 148, 1906, 1908, 1909, 152
1166, 1901, 687, 688, 1902, 1907, 692, 1910, 1908
1167, 148, 1902, 1903, 149, 1909, 1911, 1912, 153
1168, 1902, 688, 689, 1903, 1910, 693, 1913, 1911
1169, 149, 1903, 1904, 150, 1912, 1914, 1915, 154
1170, 1903, 689, 690, 1904, 1913, 694, 1916, 1914
1171, 150, 1904, 657, 9, 1915, 1917, 658, 155
1172, 1904, 690, 65, 657, 1916, 695, 659, 1917
*ELEMENT, type=CPS8, ELSET=Surface90
1173, 14, 195, 1918, 675, 199, 1922, 1923, 676
1174, 675, 1918, 696, 68, 1923, 1924, 700, 677
1175, 195, 196, 1919, 1918, 200, 1925, 1926, 1922
1176, 1918, 1919, 697, 696, 1926, 1927, 701, 1924
1177, 196, 197, 1920, 1919, 201, 1928, 1929, 1925
1178, 1919, 1920, 698, 697, 1929, 1930, 702, 1927
1179, 197, 198, 1921, 1920, 202, 1931, 1932, 1928
1180, 1920, 1921, 699, 698, 1932, 1933, 703, 1930
1181, 198, 13, 660, 1921, 203, 661, 1934, 1931
1182, 1921, 660, 66, 699, 1934, 662, 704, 1933
*ELEMENT, type=CPS8, ELSET=Surface91
1183, 67, 678, 1935, 687, 682, 1951, 1952, 691
1184, 678, 679, 1936, 1935, 683, 1953, 1954, 1951
1185, 679, 680, 1937, 1936, 684, 1955, 1956, 1953
1186, 680, 681, 1938, 1937, 685, 1957, 1958, 1955
1187, 681, 68, 696, 1938, 686, 700, 1959, 1957
1188, 687, 1935, 1939, 688, 1952, 1960, 1961, 692
1189, 1935, 1936, 1940, 1939, 1954, 1962, 1963, 1960
1190, 1936, 1937, 1941, 1940, 1956, 1964, 1965, 1962
1191, 1937, 1938, 1942, 1941, 1958, 1966, 1967, 1964
1192, 1938, 696, 697, 1942, 1959, 701, 1968, 1966
1193, 688, 1939, 1943, 689, 1961, 1969, 1970, 693
1194, 1939, 1940, 1944, 1943, 1963, 1971, 1972, 1969
1195, 1940, 1941, 1945, 1944, 1965, 1973, 1974, 1971
1196, 1941, 1942, 1946, 1945, 1967, 1975, 1976, 1973
1197, 1942, 697, 698, 1946, 1968, 702, 1977, 1975
1198, 689, 1943, 1947, 690, 1970, 1978, 1979, 694
1199, 1943, 1944, 1948, 1947, 1972, 1980, 1981, 1978
1200, 1944, 1945, 1949, 1948, 1974, 1982, 1983, 1980
1201, 1945, 1946, 1950, 1949, 1976, 1984, 1985, 1982
1202, 1946, 698, 699, 1950, 1977, 703, 1986, 1984
1203, 690, 1947, 663, 65, 1979, 1987, 667, 695
1204, 1947, 1948, 664, 663, 1981, 1988, 668, 1987
1205, 1948, 1949, 665, 664, 1983, 1989, 669, 1988
1206, 1949, 1950, 666, 665, 1985, 1990, 670, 1989
1207, 1950, 699, 66, 666, 1986, 704, 671, 1990
*ELEMENT, type=CPS8, ELSET=Surface92
1208, 35, 705, 1991, 444, 706, 1995, 1996, 448
1209, 705, 69, 711, 1991, 707, 715, 1997, 1995
1210, 444, 1991, 1992, 445, 1996, 1998, 1999, 449
1211, 1991, 711, 712, 1992, 1997, 716, 2000, 1998
1212, 445, 1992, 1993, 446, 1999, 2001, 2002, 450
1213, 1992, 712, 713, 1993, 2000, 717, 2003, 2001
1214, 446, 1993, 1994, 447, 2002, 2004, 2005, 451
1215, 1993, 713, 714, 1994, 2003, 718, 2006, 2004
1216, 447, 1994, 708, 39, 2005, 2007, 709, 452
1217, 1994, 714, 70, 708, 2006, 719, 710, 2007
*ELEMENT, type=CPS8, ELSET=Surface93
1218, 36, 453, 2008, 720, 457, 2012, 2013, 721
1219, 720, 2008, 726, 71, 2013, 2014, 730, 722
1220, 453, 454, 2009, 2008, 458, 2015, 2016, 2012
1221, 2008, 2009, 727, 726, 2016, 2017, 731, 2014
1222, 454, 455, 2010, 2009, 459, 2018, 2019, 2015
1223, 2009, 2010, 728, 727, 2019, 2020, 732, 2017
1224, 455, 456, 2011, 2010, 460, 2021, 2022, 2018
1225, 2010, 2011, 729, 728, 2022, 2023, 733, 2020
1226, 456, 40, 723, 2011, 461, 724, 2024, 2021
1227, 2011, 723, 72, 729, 2024, 725, 734, 2023
*ELEMENT, type=CPS8, ELSET=Surface94
1228, 35, 398, 2025, 705, 402, 2029, 2030, 706
1229, 705, 2025, 735, 69, 2030, 2031, 739, 707
1230, 398, 399, 2026, 2025, 403, 2032, 2033, 2029
1231, 2025, 2026, 736, 735, 2033, 2034, 740, 2031
1232, 399, 400, 2027, 2026, 404, 2035, 2036, 2032
1233, 2026, 2027, 737, 736, 2036, 2037, 741, 2034
1234, 400, 401, 2028, 2027, 405, 2038, 2039, 2035
1235, 2027, 2028, 738, 737, 2039, 2040, 742, 2037
1236, 401, 36, 720, 2028, 406, 721, 2041, 2038
1237, 2028, 720, 71, 738, 2041, 722, 743, 2040
*ELEMENT, type=CPS8, ELSET=Surface95
1238, 39, 708, 2042, 462, 709, 2046, 2047, 466
1239, 708, 70, 744, 2042, 710, 748, 2048, 2046
1240, 462, 2042, 2043, 463, 2047, 2049, 2050, 467
1241, 2042, 744, 745, 2043, 2048, 749, 2051, 2049
1242, 463, 2043, 2044, 464, 2050, 2052, 2053, 468
1243, 2043, 745, 746, 2044, 2051, 750, 2054, 2052
1244, 464, 2044, 2045, 465, 2053, 2055, 2056, 469
1245, 2044, 746, 747, 2045, 2054, 751, 2057, 2055
1246, 465, 2045, 723, 40, 2056, 2058, 724, 470
1247, 2045, 747, 72, 723, 2057, 752, 725, 2058
*ELEMENT, type=CPS8, ELSET=Surface96
1248, 69, 735, 2059, 711, 739, 2075, 2076, 715
1249, 711, 2059, 2060, 712, 2076, 2077, 2078, 716
1250, 712, 2060, 2061, 713, 2078, 2079, 2080, 717
1251, 713, 2061, 2062, 714, 2080, 2081, 2082, 718
1252, 714, 2062, 744, 70, 2082, 2083, 748, 719
1253, 735, 736, 2063, 2059, 740, 2084, 2085, 2075
1254, 2059, 2063, 2064, 2060, 2085, 2086, 2087, 2077
1255, 2060, 2064, 2065, 2061, 2087, 2088, 2089, 2079
1256, 2061, 2065, 2066, 2062, 2089, 2090, 2091, 2081
1257, 2062, 2066, 745, 744, 2091, 2092, 749, 2083
1258, 736, 737, 2067, 2063, 741, 2093, 2094, 2084
1259, 2063, 2067, 2068, 2064, 2094, 2095, 2096, 2086
1260, 2064, 2068, 2069, 2065, 2096, 2097, 2098, 2088
1261, 2065, 2069, 2070, 2066, 2098, 2099, 2100, 2090
1262, 2066, 2070, 746, 745, 2100, 2101, 750, 2092
1263, 737, 738, 2071, 2067, 742, 2102, 2103, 2093
1264, 2067, 2071, 2072, 2068, 2103, 2104, 2105, 2095
1265, 2068, 2072, 2073, 2069, 2105, 2106, 2107, 2097
1266, 2069, 2073, 2074, 2070, 2107, 2108, 2109, 2099
1267, 2070, 2074, 747, 746, 2109, 2110, 751, 2101
1268, 738, 71, 726, 2071, 743, 730, 2111, 2102
1269, 2071, 726, 727, 2072, 2111, 731, 2112, 2104
1270, 2072, 727, 728, 2073, 2112, 732, 2113, 2106
1271, 2073, 728, 729, 2074, 2113, 733, 2114, 2108
1272, 2074, 729, 72, 747, 2114, 734, 752, 2110
*ELEMENT, type=CPS8, ELSET=Surface97
1273, 35, 705, 753, 63, 706, 2115, 754, 636
1274, 705, 69, 73, 753, 707, 756, 755, 2115
*ELEMENT, type=CPS8, ELSET=Surface98
1275, 39, 64, 757, 708, 637, 758, 2116, 709
1276, 708, 757, 74, 70, 2116, 759, 760, 710
*ELEMENT, type=CPS8, ELSET=Surface99
1277, 63, 753, 2117, 638, 754, 2121, 2122, 642
1278, 753, 73, 761, 2117, 755, 765, 2123, 2121
1279, 638, 2117, 2118, 639, 2122, 2124, 2125, 643
1280, 2117, 761, 762, 2118, 2123, 766, 2126, 2124
1281, 639, 2118, 2119, 640, 2125, 2127, 2128, 644
1282, 2118, 762, 763, 2119, 2126, 767, 2129, 2127
1283, 640, 2119, 2120, 641, 2128, 2130, 2131, 645
1284, 2119, 763, 764, 2120, 2129, 768, 2132, 2130
1285, 641, 2120, 757, 64, 2131, 2133, 758, 646
1286, 2120, 764, 74, 757, 2132, 769, 759, 2133
*ELEMENT, type=CPS8, ELSET=Surface100
1287, 69, 711, 761, 73, 715, 2134, 765, 756
1288, 711, 712, 762, 761, 716, 2135, 766, 2134
1289, 712, 713, 763, 762, 717, 2136, 767, 2135
1290, 713, 714, 764, 763, 718, 2137, 768, 2136
1291, 714, 70, 74, 764, 719, 760, 769, 2137
*ELEMENT, type=CPS8, ELSET=Surface101
1292, 9, 657, 770, 59, 658, 2138, 771, 604
1293, 657, 65, 75, 770, 659, 773, 772, 2138
*ELEMENT, type=CPS8, ELSET=Surface102
1294, 13, 60, 774, 660, 605, 775, 2139, 661
1295, 660, 774, 76, 66, 2139, 776, 777, 662
*ELEMENT, type=CPS8, ELSET=Surface103
1296, 59, 770, 2140, 606, 771, 2144, 2145, 610
1297, 770, 75, 778, 2140, 772, 782, 2146, 2144
1298, 606, 2140, 2141, 607, 2145, 2147, 2148, 611
1299, 2140, 778, 779, 2141, 2146, 783, 2149, 2147
1300, 607, 2141, 2142, 608, 2148, 2150, 2151, 612
1301, 2141, 779, 780, 2142, 2149, 784, 2152, 2150
1302, 608, 2142, 2143, 609, 2151, 2153, 2154, 613
1303, 2142, 780, 781, 2143, 2152, 785, 2155, 2153
1304, 609, 2143, 774, 60, 2154, 2156, 775, 614
1305, 2143, 781, 76, 774, 2155, 786, 776, 2156
*ELEMENT, type=CPS8, ELSET=Surface104
1306, 65, 663, 778, 75, 667, 2157, 782, 773
1307, 663, 664, 779, 778, 668, 2158, 783, 2157
1308, 664, 665, 780, 779, 669, 2159, 784, 2158
1309, 665, 666, 781, 780, 670, 2160, 785, 2159
1310, 666, 66, 76, 781, 671, 777, 786, 2160
*ELEMENT, type=C3D20, ELSET=Volume1
1311, 787, 77, 2, 90, 2161, 805, 109, 865, 789, 79, 91, 790, 2170, 813, 870, 
2171, 2169, 814, 113, 869
1312, 2161, 805, 109, 865, 2162, 807, 110, 866, 2170, 813, 870, 2171, 2173, 818, 872, 
2174, 2172, 819, 114, 871
1313, 2162, 807, 110, 866, 2163, 809, 111, 867, 2173, 818, 872, 2174, 2176, 823, 874, 
2177, 2175, 824, 115, 873
1314, 2163, 809, 111, 867, 2164, 811, 112, 868, 2176, 823, 874, 2177, 2179, 828, 876, 
2180, 2178, 829, 116, 875
1315, 2164, 811, 112, 868, 796, 93, 6, 106, 2179, 828, 876, 2180, 799, 95, 107, 
798, 2181, 833, 117, 877
1316, 85, 787, 90, 4, 835, 2161, 865, 127, 791, 790, 92, 87, 2182, 2171, 878, 
844, 843, 2169, 869, 131
1317, 835, 2161, 865, 127, 837, 2162, 866, 128, 2182, 2171, 878, 844, 2183, 2174, 879, 
849, 848, 2172, 871, 132
1318, 837, 2162, 866, 128, 839, 2163, 867, 129, 2183, 2174, 879, 849, 2184, 2177, 880, 
854, 853, 2175, 873, 133
1319, 839, 2163, 867, 129, 841, 2164, 868, 130, 2184, 2177, 880, 854, 2185, 2180, 881, 
859, 858, 2178, 875, 134
1320, 841, 2164, 868, 130, 101, 796, 106, 8, 2185, 2180, 881, 859, 800, 798, 108, 
103, 863, 2181, 877, 135
1321, 788, 78, 77, 787, 2165, 806, 805, 2161, 792, 80, 789, 793, 2187, 815, 2170, 
2188, 2186, 816, 814, 2169
1322, 2165, 806, 805, 2161, 2166, 808, 807, 2162, 2187, 815, 2170, 2188, 2190, 820, 2173, 
2191, 2189, 821, 819, 2172
1323, 2166, 808, 807, 2162, 2167, 810, 809, 2163, 2190, 820, 2173, 2191, 2193, 825, 2176, 
2194, 2192, 826, 824, 2175
1324, 2167, 810, 809, 2163, 2168, 812, 811, 2164, 2193, 825, 2176, 2194, 2196, 830, 2179, 
2197, 2195, 831, 829, 2178
1325, 2168, 812, 811, 2164, 797, 94, 93, 796, 2196, 830, 2179, 2197, 802, 96, 799, 
801, 2198, 834, 833, 2181
1326, 86, 788, 787, 85, 836, 2165, 2161, 835, 794, 793, 791, 88, 2199, 2188, 2182, 
846, 845, 2186, 2169, 843
1327, 836, 2165, 2161, 835, 838, 2166, 2162, 837, 2199, 2188, 2182, 846, 2200, 2191, 2183, 
851, 850, 2189, 2172, 848
1328, 838, 2166, 2162, 837, 840, 2167, 2163, 839, 2200, 2191, 2183, 851, 2201, 2194, 2184, 
856, 855, 2192, 2175, 853
1329, 840, 2167, 2163, 839, 842, 2168, 2164, 841, 2201, 2194, 2184, 856, 2202, 2197, 2185, 
861, 860, 2195, 2178, 858
1330, 842, 2168, 2164, 841, 102, 797, 796, 101, 2202, 2197, 2185, 861, 803, 801, 800, 
104, 864, 2198, 2181, 863
1331, 82, 1, 78, 788, 882, 118, 806, 2165, 83, 81, 792, 795, 886, 817, 2187, 
2203, 887, 122, 816, 2186
1332, 882, 118, 806, 2165, 883, 119, 808, 2166, 886, 817, 2187, 2203, 888, 822, 2190, 
2204, 889, 123, 821, 2189
1333, 883, 119, 808, 2166, 884, 120, 810, 2167, 888, 822, 2190, 2204, 890, 827, 2193, 
2205, 891, 124, 826, 2192
1334, 884, 120, 810, 2167, 885, 121, 812, 2168, 890, 827, 2193, 2205, 892, 832, 2196, 
2206, 893, 125, 831, 2195
1335, 885, 121, 812, 2168, 98, 5, 94, 797, 892, 832, 2196, 2206, 99, 97, 802, 
804, 894, 126, 834, 2198
1336, 3, 82, 788, 86, 136, 882, 2165, 836, 84, 795, 794, 89, 895, 2203, 2199, 
847, 140, 887, 2186, 845
1337, 136, 882, 2165, 836, 137, 883, 2166, 838, 895, 2203, 2199, 847, 896, 2204, 2200, 
852, 141, 889, 2189, 850
1338, 137, 883, 2166, 838, 138, 884, 2167, 840, 896, 2204, 2200, 852, 897, 2205, 2201, 
857, 142, 891, 2192, 855
1339, 138, 884, 2167, 840, 139, 885, 2168, 842, 897, 2205, 2201, 857, 898, 2206, 2202, 
862, 143, 893, 2195, 860
1340, 139, 885, 2168, 842, 7, 98, 797, 102, 898, 2206, 2202, 862, 100, 804, 803, 
105, 144, 894, 2198, 864
*ELEMENT, type=C3D20, ELSET=Volume2
1341, 4, 85, 835, 127, 10, 172, 911, 147, 87, 843, 844, 131, 174, 919, 920, 
151, 146, 909, 2207, 899
1342, 85, 86, 836, 835, 172, 173, 912, 911, 88, 845, 846, 843, 175, 921, 922, 
919, 909, 910, 2208, 2207
1343, 86, 3, 136, 836, 173, 12, 163, 912, 89, 140, 847, 845, 176, 167, 923, 
921, 910, 162, 905, 2208
1344, 127, 835, 837, 128, 147, 911, 913, 148, 844, 848, 849, 132, 920, 924, 925, 
152, 899, 2207, 2209, 900
1345, 835, 836, 838, 837, 911, 912, 914, 913, 846, 850, 851, 848, 922, 926, 927, 
924, 2207, 2208, 2210, 2209
1346, 836, 136, 137, 838, 912, 163, 164, 914, 847, 141, 852, 850, 923, 168, 928, 
926, 2208, 905, 906, 2210
1347, 128, 837, 839, 129, 148, 913, 915, 149, 849, 853, 854, 133, 925, 929, 930, 
153, 900, 2209, 2211, 901
1348, 837, 838, 840, 839, 913, 914, 916, 915, 851, 855, 856, 853, 927, 931, 932, 
929, 2209, 2210, 2212, 2211
1349, 838, 137, 138, 840, 914, 164, 165, 916, 852, 142, 857, 855, 928, 169, 933, 
931, 2210, 906, 907, 2212
1350, 129, 839, 841, 130, 149, 915, 917, 150, 854, 858, 859, 134, 930, 934, 935, 
154, 901, 2211, 2213, 902
1351, 839, 840, 842, 841, 915, 916, 918, 917, 856, 860, 861, 858, 932, 936, 937, 
934, 2211, 2212, 2214, 2213
1352, 840, 138, 139, 842, 916, 165, 166, 918, 857, 143, 862, 860, 933, 170, 938, 
936, 2212, 907, 908, 2214
1353, 130, 841, 101, 8, 150, 917, 157, 9, 859, 863, 103, 135, 935, 939, 159, 
155, 902, 2213, 903, 145
1354, 841, 842, 102, 101, 917, 918, 158, 157, 861, 864, 104, 863, 937, 940, 160, 
939, 2213, 2214, 904, 903
1355, 842, 139, 7, 102, 918, 166, 11, 158, 862, 144, 105, 864, 938, 171, 161, 
940, 2214, 908, 156, 904
*ELEMENT, type=C3D20, ELSET=Volume3
1356, 10, 172, 911, 147, 186, 1083, 2215, 941, 174, 919, 920, 151, 1092, 2248, 2249, 
957, 190, 1091, 2247, 958
1357, 186, 1083, 2215, 941, 187, 1084, 2216, 942, 1092, 2248, 2249, 957, 1094, 2251, 2252, 
959, 191, 1093, 2250, 960
1358, 187, 1084, 2216, 942, 188, 1085, 2217, 943, 1094, 2251, 2252, 959, 1096, 2254, 2255, 
961, 192, 1095, 2253, 962
1359, 188, 1085, 2217, 943, 189, 1086, 2218, 944, 1096, 2254, 2255, 961, 1098, 2257, 2258, 
963, 193, 1097, 2256, 964
1360, 189, 1086, 2218, 944, 14, 236, 1113, 195, 1098, 2257, 2258, 963, 238, 1121, 1122, 
199, 194, 1099, 2259, 965
1361, 172, 173, 912, 911, 1083, 1087, 2219, 2215, 175, 921, 922, 919, 1101, 2261, 2262, 
2248, 1091, 1100, 2260, 2247
1362, 1083, 1087, 2219, 2215, 1084, 1088, 2220, 2216, 1101, 2261, 2262, 2248, 1103, 2264, 2265, 
2251, 1093, 1102, 2263, 2250
1363, 1084, 1088, 2220, 2216, 1085, 1089, 2221, 2217, 1103, 2264, 2265, 2251, 1105, 2267, 2268, 
2254, 1095, 1104, 2266, 2253
1364, 1085, 1089, 2221, 2217, 1086, 1090, 2222, 2218, 1105, 2267, 2268, 2254, 1107, 2270, 2271, 
2257, 1097, 1106, 2269, 2256
1365, 1086, 1090, 2222, 2218, 236, 237, 1114, 1113, 1107, 2270, 2271, 2257, 239, 1123, 1124, 
1121, 1099, 1108, 2272, 2259
1366, 173, 12, 163, 912, 1087, 218, 1027, 2219, 176, 167, 923, 921, 1109, 1044, 2273, 
2261, 1100, 222, 1043, 2260
1367, 1087, 218, 1027, 2219, 1088, 219, 1028, 2220, 1109, 1044, 2273, 2261, 1110, 1046, 2274, 
2264, 1102, 223, 1045, 2263
1368, 1088, 219, 1028, 2220, 1089, 220, 1029, 2221, 1110, 1046, 2274, 2264, 1111, 1048, 2275, 
2267, 1104, 224, 1047, 2266
1369, 1089, 220, 1029, 2221, 1090, 221, 1030, 2222, 1111, 1048, 2275, 2267, 1112, 1050, 2276, 
2270, 1106, 225, 1049, 2269
1370, 1090, 221, 1030, 2222, 237, 16, 227, 1114, 1112, 1050, 2276, 2270, 240, 231, 1125, 
1123, 1108, 226, 1051, 2272
1371, 147, 911, 913, 148, 941, 2215, 2223, 945, 920, 924, 925, 152, 2249, 2278, 2279, 
966, 958, 2247, 2277, 967
1372, 941, 2215, 2223, 945, 942, 2216, 2224, 946, 2249, 2278, 2279, 966, 2252, 2281, 2282, 
968, 960, 2250, 2280, 969
1373, 942, 2216, 2224, 946, 943, 2217, 2225, 947, 2252, 2281, 2282, 968, 2255, 2284, 2285, 
970, 962, 2253, 2283, 971
1374, 943, 2217, 2225, 947, 944, 2218, 2226, 948, 2255, 2284, 2285, 970, 2258, 2287, 2288, 
972, 964, 2256, 2286, 973
1375, 944, 2218, 2226, 948, 195, 1113, 1115, 196, 2258, 2287, 2288, 972, 1122, 1126, 1127, 
200, 965, 2259, 2289, 974
1376, 911, 912, 914, 913, 2215, 2219, 2227, 2223, 922, 926, 927, 924, 2262, 2291, 2292, 
2278, 2247, 2260, 2290, 2277
1377, 2215, 2219, 2227, 2223, 2216, 2220, 2228, 2224, 2262, 2291, 2292, 2278, 2265, 2294, 2295, 
2281, 2250, 2263, 2293, 2280
1378, 2216, 2220, 2228, 2224, 2217, 2221, 2229, 2225, 2265, 2294, 2295, 2281, 2268, 2297, 2298, 
2284, 2253, 2266, 2296, 2283
1379, 2217, 2221, 2229, 2225, 2218, 2222, 2230, 2226, 2268, 2297, 2298, 2284, 2271, 2300, 2301, 
2287, 2256, 2269, 2299, 2286
1380, 2218, 2222, 2230, 2226, 1113, 1114, 1116, 1115, 2271, 2300, 2301, 2287, 1124, 1128, 1129, 
1126, 2259, 2272, 2302, 2289
1381, 912, 163, 164, 914, 2219, 1027, 1031, 2227, 923, 168, 928, 926, 2273, 1053, 2303, 
2291, 2260, 1043, 1052, 2290
1382, 2219, 1027, 1031, 2227, 2220, 1028, 1032, 2228, 2273, 1053, 2303, 2291, 2274, 1055, 2304, 
2294, 2263, 1045, 1054, 2293
1383, 2220, 1028, 1032, 2228, 2221, 1029, 1033, 2229, 2274, 1055, 2304, 2294, 2275, 1057, 2305, 
2297, 2266, 1047, 1056, 2296
1384, 2221, 1029, 1033, 2229, 2222, 1030, 1034, 2230, 2275, 1057, 2305, 2297, 2276, 1059, 2306, 
2300, 2269, 1049, 1058, 2299
1385, 2222, 1030, 1034, 2230, 1114, 227, 228, 1116, 2276, 1059, 2306, 2300, 1125, 232, 1130, 
1128, 2272, 1051, 1060, 2302
1386, 148, 913, 915, 149, 945, 2223, 2231, 949, 925, 929, 930, 153, 2279, 2308, 2309, 
975, 967, 2277, 2307, 976
1387, 945, 2223, 2231, 949, 946, 2224, 2232, 950, 2279, 2308, 2309, 975, 2282, 2311, 2312, 
977, 969, 2280, 2310, 978
1388, 946, 2224, 2232, 950, 947, 2225, 2233, 951, 2282, 2311, 2312, 977, 2285, 2314, 2315, 
979, 971, 2283, 2313, 980
1389, 947, 2225, 2233, 951, 948, 2226, 2234, 952, 2285, 2314, 2315, 979, 2288, 2317, 2318, 
981, 973, 2286, 2316, 982
1390, 948, 2226, 2234, 952, 196, 1115, 1117, 197, 2288, 2317, 2318, 981, 1127, 1131, 1132, 
201, 974, 2289, 2319, 983
1391, 913, 914, 916, 915, 2223, 2227, 2235, 2231, 927, 931, 932, 929, 2292, 2321, 2322, 
2308, 2277, 2290, 2320, 2307
1392, 2223, 2227, 2235, 2231, 2224, 2228, 2236, 2232, 2292, 2321, 2322, 2308, 2295, 2324, 2325, 
2311, 2280, 2293, 2323, 2310
1393, 2224, 2228, 2236, 2232, 2225, 2229, 2237, 2233, 2295, 2324, 2325, 2311, 2298, 2327, 2328, 
2314, 2283, 2296, 2326, 2313
1394, 2225, 2229, 2237, 2233, 2226, 2230, 2238, 2234, 2298, 2327, 2328, 2314, 2301, 2330, 2331, 
2317, 2286, 2299, 2329, 2316
1395, 2226, 2230, 2238, 2234, 1115, 1116, 1118, 1117, 2301, 2330, 2331, 2317, 1129, 1133, 1134, 
1131, 2289, 2302, 2332, 2319
1396, 914, 164, 165, 916, 2227, 1031, 1035, 2235, 928, 169, 933, 931, 2303, 1062, 2333, 
2321, 2290, 1052, 1061, 2320
1397, 2227, 1031, 1035, 2235, 2228, 1032, 1036, 2236, 2303, 1062, 2333, 2321, 2304, 1064, 2334, 
2324, 2293, 1054, 1063, 2323
1398, 2228, 1032, 1036, 2236, 2229, 1033, 1037, 2237, 2304, 1064, 2334, 2324, 2305, 1066, 2335, 
2327, 2296, 1056, 1065, 2326
1399, 2229, 1033, 1037, 2237, 2230, 1034, 1038, 2238, 2305, 1066, 2335, 2327, 2306, 1068, 2336, 
2330, 2299, 1058, 1067, 2329
1400, 2230, 1034, 1038, 2238, 1116, 228, 229, 1118, 2306, 1068, 2336, 2330, 1130, 233, 1135, 
1133, 2302, 1060, 1069, 2332
1401, 149, 915, 917, 150, 949, 2231, 2239, 953, 930, 934, 935, 154, 2309, 2338, 2339, 
984, 976, 2307, 2337, 985
1402, 949, 2231, 2239, 953, 950, 2232, 2240, 954, 2309, 2338, 2339, 984, 2312, 2341, 2342, 
986, 978, 2310, 2340, 987
1403, 950, 2232, 2240, 954, 951, 2233, 2241, 955, 2312, 2341, 2342, 986, 2315, 2344, 2345, 
988, 980, 2313, 2343, 989
1404, 951, 2233, 2241, 955, 952, 2234, 2242, 956, 2315, 2344, 2345, 988, 2318, 2347, 2348, 
990, 982, 2316, 2346, 991
1405, 952, 2234, 2242, 956, 197, 1117, 1119, 198, 2318, 2347, 2348, 990, 1132, 1136, 1137, 
202, 983, 2319, 2349, 992
1406, 915, 916, 918, 917, 2231, 2235, 2243, 2239, 932, 936, 937, 934, 2322, 2351, 2352, 
2338, 2307, 2320, 2350, 2337
1407, 2231, 2235, 2243, 2239, 2232, 2236, 2244, 2240, 2322, 2351, 2352, 2338, 2325, 2354, 2355, 
2341, 2310, 2323, 2353, 2340
1408, 2232, 2236, 2244, 2240, 2233, 2237, 2245, 2241, 2325, 2354, 2355, 2341, 2328, 2357, 2358, 
2344, 2313, 2326, 2356, 2343
1409, 2233, 2237, 2245, 2241, 2234, 2238, 2246, 2242, 2328, 2357, 2358, 2344, 2331, 2360, 2361, 
2347, 2316, 2329, 2359, 2346
1410, 2234, 2238, 2246, 2242, 1117, 1118, 1120, 1119, 2331, 2360, 2361, 2347, 1134, 1138, 1139, 
1136, 2319, 2332, 2362, 2349
1411, 916, 165, 166, 918, 2235, 1035, 1039, 2243, 933, 170, 938, 936, 2333, 1071, 2363, 
2351, 2320, 1061, 1070, 2350
1412, 2235, 1035, 1039, 2243, 2236, 1036, 1040, 2244, 2333, 1071, 2363, 2351, 2334, 1073, 2364, 
2354, 2323, 1063, 1072, 2353
1413, 2236, 1036, 1040, 2244, 2237, 1037, 1041, 2245, 2334, 1073, 2364, 2354, 2335, 1075, 2365, 
2357, 2326, 1065, 1074, 2356
1414, 2237, 1037, 1041, 2245, 2238, 1038, 1042, 2246, 2335, 1075, 2365, 2357, 2336, 1077, 2366, 
2360, 2329, 1067, 1076, 2359
1415, 2238, 1038, 1042, 2246, 1118, 229, 230, 1120, 2336, 1077, 2366, 2360, 1135, 234, 1140, 
1138, 2332, 1069, 1078, 2362
1416, 150, 917, 157, 9, 953, 2239, 997, 177, 935, 939, 159, 155, 2339, 2367, 1005, 
993, 985, 2337, 1006, 181
1417, 953, 2239, 997, 177, 954, 2240, 998, 178, 2339, 2367, 1005, 993, 2342, 2368, 1007, 
994, 987, 2340, 1008, 182
1418, 954, 2240, 998, 178, 955, 2241, 999, 179, 2342, 2368, 1007, 994, 2345, 2369, 1009, 
995, 989, 2343, 1010, 183
1419, 955, 2241, 999, 179, 956, 2242, 1000, 180, 2345, 2369, 1009, 995, 2348, 2370, 1011, 
996, 991, 2346, 1012, 184
1420, 956, 2242, 1000, 180, 198, 1119, 213, 13, 2348, 2370, 1011, 996, 1137, 1141, 215, 
203, 992, 2349, 1013, 185
1421, 917, 918, 158, 157, 2239, 2243, 1001, 997, 937, 940, 160, 939, 2352, 2371, 1014, 
2367, 2337, 2350, 1015, 1006
1422, 2239, 2243, 1001, 997, 2240, 2244, 1002, 998, 2352, 2371, 1014, 2367, 2355, 2372, 1016, 
2368, 2340, 2353, 1017, 1008
1423, 2240, 2244, 1002, 998, 2241, 2245, 1003, 999, 2355, 2372, 1016, 2368, 2358, 2373, 1018, 
2369, 2343, 2356, 1019, 1010
1424, 2241, 2245, 1003, 999, 2242, 2246, 1004, 1000, 2358, 2373, 1018, 2369, 2361, 2374, 1020, 
2370, 2346, 2359, 1021, 1012
1425, 2242, 2246, 1004, 1000, 1119, 1120, 214, 213, 2361, 2374, 1020, 2370, 1139, 1142, 216, 
1141, 2349, 2362, 1022, 1013
1426, 918, 166, 11, 158, 2243, 1039, 204, 1001, 938, 171, 161, 940, 2363, 1079, 1023, 
2371, 2350, 1070, 208, 1015
1427, 2243, 1039, 204, 1001, 2244, 1040, 205, 1002, 2363, 1079, 1023, 2371, 2364, 1080, 1024, 
2372, 2353, 1072, 209, 1017
1428, 2244, 1040, 205, 1002, 2245, 1041, 206, 1003, 2364, 1080, 1024, 2372, 2365, 1081, 1025, 
2373, 2356, 1074, 210, 1019
1429, 2245, 1041, 206, 1003, 2246, 1042, 207, 1004, 2365, 1081, 1025, 2373, 2366, 1082, 1026, 
2374, 2359, 1076, 211, 1021
1430, 2246, 1042, 207, 1004, 1120, 230, 15, 214, 2366, 1082, 1026, 2374, 1140, 235, 217, 
1142, 2362, 1078, 212, 1022
*ELEMENT, type=C3D20, ELSET=Volume4
1431, 14, 236, 1113, 195, 18, 268, 1155, 243, 238, 1121, 1122, 199, 270, 1163, 1164, 
247, 242, 1153, 2375, 1143
1432, 236, 237, 1114, 1113, 268, 269, 1156, 1155, 239, 1123, 1124, 1121, 271, 1165, 1166, 
1163, 1153, 1154, 2376, 2375
1433, 237, 16, 227, 1114, 269, 20, 259, 1156, 240, 231, 1125, 1123, 272, 263, 1167, 
1165, 1154, 258, 1149, 2376
1434, 195, 1113, 1115, 196, 243, 1155, 1157, 244, 1122, 1126, 1127, 200, 1164, 1168, 1169, 
248, 1143, 2375, 2377, 1144
1435, 1113, 1114, 1116, 1115, 1155, 1156, 1158, 1157, 1124, 1128, 1129, 1126, 1166, 1170, 1171, 
1168, 2375, 2376, 2378, 2377
1436, 1114, 227, 228, 1116, 1156, 259, 260, 1158, 1125, 232, 1130, 1128, 1167, 264, 1172, 
1170, 2376, 1149, 1150, 2378
1437, 196, 1115, 1117, 197, 244, 1157, 1159, 245, 1127, 1131, 1132, 201, 1169, 1173, 1174, 
249, 1144, 2377, 2379, 1145
1438, 1115, 1116, 1118, 1117, 1157, 1158, 1160, 1159, 1129, 1133, 1134, 1131, 1171, 1175, 1176, 
1173, 2377, 2378, 2380, 2379
1439, 1116, 228, 229, 1118, 1158, 260, 261, 1160, 1130, 233, 1135, 1133, 1172, 265, 1177, 
1175, 2378, 1150, 1151, 2380
1440, 197, 1117, 1119, 198, 245, 1159, 1161, 246, 1132, 1136, 1137, 202, 1174, 1178, 1179, 
250, 1145, 2379, 2381, 1146
1441, 1117, 1118, 1120, 1119, 1159, 1160, 1162, 1161, 1134, 1138, 1139, 1136, 1176, 1180, 1181, 
1178, 2379, 2380, 2382, 2381
1442, 1118, 229, 230, 1120, 1160, 261, 262, 1162, 1135, 234, 1140, 1138, 1177, 266, 1182, 
1180, 2380, 1151, 1152, 2382
1443, 198, 1119, 213, 13, 246, 1161, 253, 17, 1137, 1141, 215, 203, 1179, 1183, 255, 
251, 1146, 2381, 1147, 241
1444, 1119, 1120, 214, 213, 1161, 1162, 254, 253, 1139, 1142, 216, 1141, 1181, 1184, 256, 
1183, 2381, 2382, 1148, 1147
1445, 1120, 230, 15, 214, 1162, 262, 19, 254, 1140, 235, 217, 1142, 1182, 267, 257, 
1184, 2382, 1152, 252, 1148
*ELEMENT, type=C3D20, ELSET=Volume5
1446, 18, 268, 1155, 243, 276, 1228, 2383, 1185, 270, 1163, 1164, 247, 1231, 2392, 2393, 
1189, 277, 1230, 2391, 1190
1447, 276, 1228, 2383, 1185, 22, 308, 1237, 279, 1231, 2392, 2393, 1189, 310, 1245, 1246, 
283, 278, 1232, 2394, 1191
1448, 268, 269, 1156, 1155, 1228, 1229, 2384, 2383, 271, 1165, 1166, 1163, 1234, 2396, 2397, 
2392, 1230, 1233, 2395, 2391
1449, 1228, 1229, 2384, 2383, 308, 309, 1238, 1237, 1234, 2396, 2397, 2392, 311, 1247, 1248, 
1245, 1232, 1235, 2398, 2394
1450, 269, 20, 259, 1156, 1229, 296, 1211, 2384, 272, 263, 1167, 1165, 1236, 1216, 2399, 
2396, 1233, 297, 1215, 2395
1451, 1229, 296, 1211, 2384, 309, 24, 299, 1238, 1236, 1216, 2399, 2396, 312, 303, 1249, 
1247, 1235, 298, 1217, 2398
1452, 243, 1155, 1157, 244, 1185, 2383, 2385, 1186, 1164, 1168, 1169, 248, 2393, 2401, 2402, 
1192, 1190, 2391, 2400, 1193
1453, 1185, 2383, 2385, 1186, 279, 1237, 1239, 280, 2393, 2401, 2402, 1192, 1246, 1250, 1251, 
284, 1191, 2394, 2403, 1194
1454, 1155, 1156, 1158, 1157, 2383, 2384, 2386, 2385, 1166, 1170, 1171, 1168, 2397, 2405, 2406, 
2401, 2391, 2395, 2404, 2400
1455, 2383, 2384, 2386, 2385, 1237, 1238, 1240, 1239, 2397, 2405, 2406, 2401, 1248, 1252, 1253, 
1250, 2394, 2398, 2407, 2403
1456, 1156, 259, 260, 1158, 2384, 1211, 1212, 2386, 1167, 264, 1172, 1170, 2399, 1219, 2408, 
2405, 2395, 1215, 1218, 2404
1457, 2384, 1211, 1212, 2386, 1238, 299, 300, 1240, 2399, 1219, 2408, 2405, 1249, 304, 1254, 
1252, 2398, 1217, 1220, 2407
1458, 244, 1157, 1159, 245, 1186, 2385, 2387, 1187, 1169, 1173, 1174, 249, 2402, 2410, 2411, 
1195, 1193, 2400, 2409, 1196
1459, 1186, 2385, 2387, 1187, 280, 1239, 1241, 281, 2402, 2410, 2411, 1195, 1251, 1255, 1256, 
285, 1194, 2403, 2412, 1197
1460, 1157, 1158, 1160, 1159, 2385, 2386, 2388, 2387, 1171, 1175, 1176, 1173, 2406, 2414, 2415, 
2410, 2400, 2404, 2413, 2409
1461, 2385, 2386, 2388, 2387, 1239, 1240, 1242, 1241, 2406, 2414, 2415, 2410, 1253, 1257, 1258, 
1255, 2403, 2407, 2416, 2412
1462, 1158, 260, 261, 1160, 2386, 1212, 1213, 2388, 1172, 265, 1177, 1175, 2408, 1222, 2417, 
2414, 2404, 1218, 1221, 2413
1463, 2386, 1212, 1213, 2388, 1240, 300, 301, 1242, 2408, 1222, 2417, 2414, 1254, 305, 1259, 
1257, 2407, 1220, 1223, 2416
1464, 245, 1159, 1161, 246, 1187, 2387, 2389, 1188, 1174, 1178, 1179, 250, 2411, 2419, 2420, 
1198, 1196, 2409, 2418, 1199
1465, 1187, 2387, 2389, 1188, 281, 1241, 1243, 282, 2411, 2419, 2420, 1198, 1256, 1260, 1261, 
286, 1197, 2412, 2421, 1200
1466, 1159, 1160, 1162, 1161, 2387, 2388, 2390, 2389, 1176, 1180, 1181, 1178, 2415, 2423, 2424, 
2419, 2409, 2413, 2422, 2418
1467, 2387, 2388, 2390, 2389, 1241, 1242, 1244, 1243, 2415, 2423, 2424, 2419, 1258, 1262, 1263, 
1260, 2412, 2416, 2425, 2421
1468, 1160, 261, 262, 1162, 2388, 1213, 1214, 2390, 1177, 266, 1182, 1180, 2417, 1225, 2426, 
2423, 2413, 1221, 1224, 2422
1469, 2388, 1213, 1214, 2390, 1242, 301, 302, 1244, 2417, 1225, 2426, 2423, 1259, 306, 1264, 
1262, 2416, 1223, 1226, 2425
1470, 246, 1161, 253, 17, 1188, 2389, 1202, 273, 1179, 1183, 255, 251, 2420, 2427, 1204, 
1201, 1199, 2418, 1205, 274
1471, 1188, 2389, 1202, 273, 282, 1243, 291, 21, 2420, 2427, 1204, 1201, 1261, 1265, 293, 
287, 1200, 2421, 1206, 275
1472, 1161, 1162, 254, 253, 2389, 2390, 1203, 1202, 1181, 1184, 256, 1183, 2424, 2428, 1207, 
2427, 2418, 2422, 1208, 1205
1473, 2389, 2390, 1203, 1202, 1243, 1244, 292, 291, 2424, 2428, 1207, 2427, 1263, 1266, 294, 
1265, 2421, 2425, 1209, 1206
1474, 1162, 262, 19, 254, 2390, 1214, 288, 1203, 1182, 267, 257, 1184, 2426, 1227, 1210, 
2428, 2422, 1224, 289, 1208
1475, 2390, 1214, 288, 1203, 1244, 302, 23, 292, 2426, 1227, 1210, 2428, 1264, 307, 295, 
1266, 2425, 1226, 290, 1209
*ELEMENT, type=C3D20, ELSET=Volume6
1476, 17, 273, 1202, 253, 27, 320, 1273, 323, 274, 1204, 1205, 255, 321, 1275, 1276, 
325, 318, 1268, 2429, 1269
1477, 273, 21, 291, 1202, 320, 28, 328, 1273, 275, 293, 1206, 1204, 322, 330, 1277, 
1275, 1268, 319, 1271, 2429
1478, 253, 1202, 1203, 254, 323, 1273, 1274, 324, 1205, 1207, 1208, 256, 1276, 1278, 1279, 
326, 1269, 2429, 2430, 1270
1479, 1202, 291, 292, 1203, 1273, 328, 329, 1274, 1206, 294, 1209, 1207, 1277, 331, 1280, 
1278, 2429, 1271, 1272, 2430
1480, 254, 1203, 288, 19, 324, 1274, 315, 25, 1208, 1210, 289, 257, 1279, 1281, 316, 
327, 1270, 2430, 1267, 313
1481, 1203, 292, 23, 288, 1274, 329, 26, 315, 1209, 295, 290, 1210, 1280, 332, 317, 
1281, 2430, 1272, 314, 1267
*ELEMENT, type=C3D20, ELSET=Volume7
1482, 27, 320, 1273, 323, 354, 1299, 2431, 1316, 321, 1275, 1276, 325, 1304, 2440, 2441, 
1324, 358, 1303, 2439, 1325
1483, 354, 1299, 2431, 1316, 355, 1300, 2432, 1317, 1304, 2440, 2441, 1324, 1306, 2443, 2444, 
1326, 359, 1305, 2442, 1327
1484, 355, 1300, 2432, 1317, 356, 1301, 2433, 1318, 1306, 2443, 2444, 1326, 1308, 2446, 2447, 
1328, 360, 1307, 2445, 1329
1485, 356, 1301, 2433, 1318, 357, 1302, 2434, 1319, 1308, 2446, 2447, 1328, 1310, 2449, 2450, 
1330, 361, 1309, 2448, 1331
1486, 357, 1302, 2434, 1319, 31, 372, 1376, 375, 1310, 2449, 2450, 1330, 373, 1378, 1379, 
377, 362, 1311, 2451, 1332
1487, 320, 28, 328, 1273, 1299, 363, 1346, 2431, 322, 330, 1277, 1275, 1312, 1355, 2452, 
2440, 1303, 367, 1354, 2439
1488, 1299, 363, 1346, 2431, 1300, 364, 1347, 2432, 1312, 1355, 2452, 2440, 1313, 1357, 2453, 
2443, 1305, 368, 1356, 2442
1489, 1300, 364, 1347, 2432, 1301, 365, 1348, 2433, 1313, 1357, 2453, 2443, 1314, 1359, 2454, 
2446, 1307, 369, 1358, 2445
1490, 1301, 365, 1348, 2433, 1302, 366, 1349, 2434, 1314, 1359, 2454, 2446, 1315, 1361, 2455, 
2449, 1309, 370, 1360, 2448
1491, 1302, 366, 1349, 2434, 372, 32, 380, 1376, 1315, 1361, 2455, 2449, 374, 382, 1380, 
1378, 1311, 371, 1362, 2451
1492, 323, 1273, 1274, 324, 1316, 2431, 2435, 1320, 1276, 1278, 1279, 326, 2441, 2457, 2458, 
1333, 1325, 2439, 2456, 1334
1493, 1316, 2431, 2435, 1320, 1317, 2432, 2436, 1321, 2441, 2457, 2458, 1333, 2444, 2460, 2461, 
1335, 1327, 2442, 2459, 1336
1494, 1317, 2432, 2436, 1321, 1318, 2433, 2437, 1322, 2444, 2460, 2461, 1335, 2447, 2463, 2464, 
1337, 1329, 2445, 2462, 1338
1495, 1318, 2433, 2437, 1322, 1319, 2434, 2438, 1323, 2447, 2463, 2464, 1337, 2450, 2466, 2467, 
1339, 1331, 2448, 2465, 1340
1496, 1319, 2434, 2438, 1323, 375, 1376, 1377, 376, 2450, 2466, 2467, 1339, 1379, 1381, 1382, 
378, 1332, 2451, 2468, 1341
1497, 1273, 328, 329, 1274, 2431, 1346, 1350, 2435, 1277, 331, 1280, 1278, 2452, 1364, 2469, 
2457, 2439, 1354, 1363, 2456
1498, 2431, 1346, 1350, 2435, 2432, 1347, 1351, 2436, 2452, 1364, 2469, 2457, 2453, 1366, 2470, 
2460, 2442, 1356, 1365, 2459
1499, 2432, 1347, 1351, 2436, 2433, 1348, 1352, 2437, 2453, 1366, 2470, 2460, 2454, 1368, 2471, 
2463, 2445, 1358, 1367, 2462
1500, 2433, 1348, 1352, 2437, 2434, 1349, 1353, 2438, 2454, 1368, 2471, 2463, 2455, 1370, 2472, 
2466, 2448, 1360, 1369, 2465
1501, 2434, 1349, 1353, 2438, 1376, 380, 381, 1377, 2455, 1370, 2472, 2466, 1380, 383, 1383, 
1381, 2451, 1362, 1371, 2468
1502, 324, 1274, 315, 25, 1320, 2435, 1282, 333, 1279, 1281, 316, 327, 2458, 2473, 1286, 
1342, 1334, 2456, 1287, 337
1503, 1320, 2435, 1282, 333, 1321, 2436, 1283, 334, 2458, 2473, 1286, 1342, 2461, 2474, 1288, 
1343, 1336, 2459, 1289, 338
1504, 1321, 2436, 1283, 334, 1322, 2437, 1284, 335, 2461, 2474, 1288, 1343, 2464, 2475, 1290, 
1344, 1338, 2462, 1291, 339
1505, 1322, 2437, 1284, 335, 1323, 2438, 1285, 336, 2464, 2475, 1290, 1344, 2467, 2476, 1292, 
1345, 1340, 2465, 1293, 340
1506, 1323, 2438, 1285, 336, 376, 1377, 351, 29, 2467, 2476, 1292, 1345, 1382, 1384, 352, 
379, 1341, 2468, 1294, 341
1507, 1274, 329, 26, 315, 2435, 1350, 342, 1282, 1280, 332, 317, 1281, 2469, 1372, 1295, 
2473, 2456, 1363, 346, 1287
1508, 2435, 1350, 342, 1282, 2436, 1351, 343, 1283, 2469, 1372, 1295, 2473, 2470, 1373, 1296, 
2474, 2459, 1365, 347, 1289
1509, 2436, 1351, 343, 1283, 2437, 1352, 344, 1284, 2470, 1373, 1296, 2474, 2471, 1374, 1297, 
2475, 2462, 1367, 348, 1291
1510, 2437, 1352, 344, 1284, 2438, 1353, 345, 1285, 2471, 1374, 1297, 2475, 2472, 1375, 1298, 
2476, 2465, 1369, 349, 1293
1511, 2438, 1353, 345, 1285, 1377, 381, 30, 351, 2472, 1375, 1298, 2476, 1383, 384, 353, 
1384, 2468, 1371, 350, 1294
*ELEMENT, type=C3D20, ELSET=Volume8
1512, 27, 354, 1316, 323, 35, 398, 1397, 407, 358, 1324, 1325, 325, 402, 1405, 1406, 
409, 396, 1389, 2477, 1393
1513, 354, 355, 1317, 1316, 398, 399, 1398, 1397, 359, 1326, 1327, 1324, 403, 1407, 1408, 
1405, 1389, 1390, 2478, 2477
1514, 355, 356, 1318, 1317, 399, 400, 1399, 1398, 360, 1328, 1329, 1326, 404, 1409, 1410, 
1407, 1390, 1391, 2479, 2478
1515, 356, 357, 1319, 1318, 400, 401, 1400, 1399, 361, 1330, 1331, 1328, 405, 1411, 1412, 
1409, 1391, 1392, 2480, 2479
1516, 357, 31, 375, 1319, 401, 36, 412, 1400, 362, 377, 1332, 1330, 406, 414, 1413, 
1411, 1392, 397, 1395, 2480
1517, 323, 1316, 1320, 324, 407, 1397, 1401, 408, 1325, 1333, 1334, 326, 1406, 1414, 1415, 
410, 1393, 2477, 2481, 1394
1518, 1316, 1317, 1321, 1320, 1397, 1398, 1402, 1401, 1327, 1335, 1336, 1333, 1408, 1416, 1417, 
1414, 2477, 2478, 2482, 2481
1519, 1317, 1318, 1322, 1321, 1398, 1399, 1403, 1402, 1329, 1337, 1338, 1335, 1410, 1418, 1419, 
1416, 2478, 2479, 2483, 2482
1520, 1318, 1319, 1323, 1322, 1399, 1400, 1404, 1403, 1331, 1339, 1340, 1337, 1412, 1420, 1421, 
1418, 2479, 2480, 2484, 2483
1521, 1319, 375, 376, 1323, 1400, 412, 413, 1404, 1332, 378, 1341, 1339, 1413, 415, 1422, 
1420, 2480, 1395, 1396, 2484
1522, 324, 1320, 333, 25, 408, 1401, 387, 33, 1334, 1342, 337, 327, 1415, 1423, 391, 
411, 1394, 2481, 1385, 385
1523, 1320, 1321, 334, 333, 1401, 1402, 388, 387, 1336, 1343, 338, 1342, 1417, 1424, 392, 
1423, 2481, 2482, 1386, 1385
1524, 1321, 1322, 335, 334, 1402, 1403, 389, 388, 1338, 1344, 339, 1343, 1419, 1425, 393, 
1424, 2482, 2483, 1387, 1386
1525, 1322, 1323, 336, 335, 1403, 1404, 390, 389, 1340, 1345, 340, 1344, 1421, 1426, 394, 
1425, 2483, 2484, 1388, 1387
1526, 1323, 376, 29, 336, 1404, 413, 34, 390, 1341, 379, 341, 1345, 1422, 416, 395, 
1426, 2484, 1396, 386, 1388
*ELEMENT, type=C3D20, ELSET=Volume9
1527, 35, 398, 1397, 407, 444, 1483, 2485, 1539, 402, 1405, 1406, 409, 1500, 2518, 2519, 
1547, 448, 1499, 2517, 1548
1528, 444, 1483, 2485, 1539, 445, 1484, 2486, 1540, 1500, 2518, 2519, 1547, 1502, 2521, 2522, 
1549, 449, 1501, 2520, 1550
1529, 445, 1484, 2486, 1540, 446, 1485, 2487, 1541, 1502, 2521, 2522, 1549, 1504, 2524, 2525, 
1551, 450, 1503, 2523, 1552
1530, 446, 1485, 2487, 1541, 447, 1486, 2488, 1542, 1504, 2524, 2525, 1551, 1506, 2527, 2528, 
1553, 451, 1505, 2526, 1554
1531, 447, 1486, 2488, 1542, 39, 462, 1599, 471, 1506, 2527, 2528, 1553, 466, 1607, 1608, 
473, 452, 1507, 2529, 1555
1532, 398, 399, 1398, 1397, 1483, 1487, 2489, 2485, 403, 1407, 1408, 1405, 1509, 2531, 2532, 
2518, 1499, 1508, 2530, 2517
1533, 1483, 1487, 2489, 2485, 1484, 1488, 2490, 2486, 1509, 2531, 2532, 2518, 1511, 2534, 2535, 
2521, 1501, 1510, 2533, 2520
1534, 1484, 1488, 2490, 2486, 1485, 1489, 2491, 2487, 1511, 2534, 2535, 2521, 1513, 2537, 2538, 
2524, 1503, 1512, 2536, 2523
1535, 1485, 1489, 2491, 2487, 1486, 1490, 2492, 2488, 1513, 2537, 2538, 2524, 1515, 2540, 2541, 
2527, 1505, 1514, 2539, 2526
1536, 1486, 1490, 2492, 2488, 462, 463, 1600, 1599, 1515, 2540, 2541, 2527, 467, 1609, 1610, 
1607, 1507, 1516, 2542, 2529
1537, 399, 400, 1399, 1398, 1487, 1491, 2493, 2489, 404, 1409, 1410, 1407, 1518, 2544, 2545, 
2531, 1508, 1517, 2543, 2530
1538, 1487, 1491, 2493, 2489, 1488, 1492, 2494, 2490, 1518, 2544, 2545, 2531, 1520, 2547, 2548, 
2534, 1510, 1519, 2546, 2533
1539, 1488, 1492, 2494, 2490, 1489, 1493, 2495, 2491, 1520, 2547, 2548, 2534, 1522, 2550, 2551, 
2537, 1512, 1521, 2549, 2536
1540, 1489, 1493, 2495, 2491, 1490, 1494, 2496, 2492, 1522, 2550, 2551, 2537, 1524, 2553, 2554, 
2540, 1514, 1523, 2552, 2539
1541, 1490, 1494, 2496, 2492, 463, 464, 1601, 1600, 1524, 2553, 2554, 2540, 468, 1611, 1612, 
1609, 1516, 1525, 2555, 2542
1542, 400, 401, 1400, 1399, 1491, 1495, 2497, 2493, 405, 1411, 1412, 1409, 1527, 2557, 2558, 
2544, 1517, 1526, 2556, 2543
1543, 1491, 1495, 2497, 2493, 1492, 1496, 2498, 2494, 1527, 2557, 2558, 2544, 1529, 2560, 2561, 
2547, 1519, 1528, 2559, 2546
1544, 1492, 1496, 2498, 2494, 1493, 1497, 2499, 2495, 1529, 2560, 2561, 2547, 1531, 2563, 2564, 
2550, 1521, 1530, 2562, 2549
1545, 1493, 1497, 2499, 2495, 1494, 1498, 2500, 2496, 1531, 2563, 2564, 2550, 1533, 2566, 2567, 
2553, 1523, 1532, 2565, 2552
1546, 1494, 1498, 2500, 2496, 464, 465, 1602, 1601, 1533, 2566, 2567, 2553, 469, 1613, 1614, 
1611, 1525, 1534, 2568, 2555
1547, 401, 36, 412, 1400, 1495, 453, 1569, 2497, 406, 414, 1413, 1411, 1535, 1578, 2569, 
2557, 1526, 457, 1577, 2556
1548, 1495, 453, 1569, 2497, 1496, 454, 1570, 2498, 1535, 1578, 2569, 2557, 1536, 1580, 2570, 
2560, 1528, 458, 1579, 2559
1549, 1496, 454, 1570, 2498, 1497, 455, 1571, 2499, 1536, 1580, 2570, 2560, 1537, 1582, 2571, 
2563, 1530, 459, 1581, 2562
1550, 1497, 455, 1571, 2499, 1498, 456, 1572, 2500, 1537, 1582, 2571, 2563, 1538, 1584, 2572, 
2566, 1532, 460, 1583, 2565
1551, 1498, 456, 1572, 2500, 465, 40, 476, 1602, 1538, 1584, 2572, 2566, 470, 478, 1615, 
1613, 1534, 461, 1585, 2568
1552, 407, 1397, 1401, 408, 1539, 2485, 2501, 1543, 1406, 1414, 1415, 410, 2519, 2574, 2575, 
1556, 1548, 2517, 2573, 1557
1553, 1539, 2485, 2501, 1543, 1540, 2486, 2502, 1544, 2519, 2574, 2575, 1556, 2522, 2577, 2578, 
1558, 1550, 2520, 2576, 1559
1554, 1540, 2486, 2502, 1544, 1541, 2487, 2503, 1545, 2522, 2577, 2578, 1558, 2525, 2580, 2581, 
1560, 1552, 2523, 2579, 1561
1555, 1541, 2487, 2503, 1545, 1542, 2488, 2504, 1546, 2525, 2580, 2581, 1560, 2528, 2583, 2584, 
1562, 1554, 2526, 2582, 1563
1556, 1542, 2488, 2504, 1546, 471, 1599, 1603, 472, 2528, 2583, 2584, 1562, 1608, 1616, 1617, 
474, 1555, 2529, 2585, 1564
1557, 1397, 1398, 1402, 1401, 2485, 2489, 2505, 2501, 1408, 1416, 1417, 1414, 2532, 2587, 2588, 
2574, 2517, 2530, 2586, 2573
1558, 2485, 2489, 2505, 2501, 2486, 2490, 2506, 2502, 2532, 2587, 2588, 2574, 2535, 2590, 2591, 
2577, 2520, 2533, 2589, 2576
1559, 2486, 2490, 2506, 2502, 2487, 2491, 2507, 2503, 2535, 2590, 2591, 2577, 2538, 2593, 2594, 
2580, 2523, 2536, 2592, 2579
1560, 2487, 2491, 2507, 2503, 2488, 2492, 2508, 2504, 2538, 2593, 2594, 2580, 2541, 2596, 2597, 
2583, 2526, 2539, 2595, 2582
1561, 2488, 2492, 2508, 2504, 1599, 1600, 1604, 1603, 2541, 2596, 2597, 2583, 1610, 1618, 1619, 
1616, 2529, 2542, 2598, 2585
1562, 1398, 1399, 1403, 1402, 2489, 2493, 2509, 2505, 1410, 1418, 1419, 1416, 2545, 2600, 2601, 
2587, 2530, 2543, 2599, 2586
1563, 2489, 2493, 2509, 2505, 2490, 2494, 2510, 2506, 2545, 2600, 2601, 2587, 2548, 2603, 2604, 
2590, 2533, 2546, 2602, 2589
1564, 2490, 2494, 2510, 2506, 2491, 2495, 2511, 2507, 2548, 2603, 2604, 2590, 2551, 2606, 2607, 
2593, 2536, 2549, 2605, 2592
1565, 2491, 2495, 2511, 2507, 2492, 2496, 2512, 2508, 2551, 2606, 2607, 2593, 2554, 2609, 2610, 
2596, 2539, 2552, 2608, 2595
1566, 2492, 2496, 2512, 2508, 1600, 1601, 1605, 1604, 2554, 2609, 2610, 2596, 1612, 1620, 1621, 
1618, 2542, 2555, 2611, 2598
1567, 1399, 1400, 1404, 1403, 2493, 2497, 2513, 2509, 1412, 1420, 1421, 1418, 2558, 2613, 2614, 
2600, 2543, 2556, 2612, 2599
1568, 2493, 2497, 2513, 2509, 2494, 2498, 2514, 2510, 2558, 2613, 2614, 2600, 2561, 2616, 2617, 
2603, 2546, 2559, 2615, 2602
1569, 2494, 2498, 2514, 2510, 2495, 2499, 2515, 2511, 2561, 2616, 2617, 2603, 2564, 2619, 2620, 
2606, 2549, 2562, 2618, 2605
1570, 2495, 2499, 2515, 2511, 2496, 2500, 2516, 2512, 2564, 2619, 2620, 2606, 2567, 2622, 2623, 
2609, 2552, 2565, 2621, 2608
1571, 2496, 2500, 2516, 2512, 1601, 1602, 1606, 1605, 2567, 2622, 2623, 2609, 1614, 1622, 1623, 
1620, 2555, 2568, 2624, 2611
1572, 1400, 412, 413, 1404, 2497, 1569, 1573, 2513, 1413, 415, 1422, 1420, 2569, 1587, 2625, 
2613, 2556, 1577, 1586, 2612
1573, 2497, 1569, 1573, 2513, 2498, 1570, 1574, 2514, 2569, 1587, 2625, 2613, 2570, 1589, 2626, 
2616, 2559, 1579, 1588, 2615
1574, 2498, 1570, 1574, 2514, 2499, 1571, 1575, 2515, 2570, 1589, 2626, 2616, 2571, 1591, 2627, 
2619, 2562, 1581, 1590, 2618
1575, 2499, 1571, 1575, 2515, 2500, 1572, 1576, 2516, 2571, 1591, 2627, 2619, 2572, 1593, 2628, 
2622, 2565, 1583, 1592, 2621
1576, 2500, 1572, 1576, 2516, 1602, 476, 477, 1606, 2572, 1593, 2628, 2622, 1615, 479, 1624, 
1622, 2568, 1585, 1594, 2624
1577, 408, 1401, 387, 33, 1543, 2501, 1427, 417, 1415, 1423, 391, 411, 2575, 2629, 1443, 
1565, 1557, 2573, 1444, 421
1578, 1543, 2501, 1427, 417, 1544, 2502, 1428, 418, 2575, 2629, 1443, 1565, 2578, 2630, 1445, 
1566, 1559, 2576, 1446, 422
1579, 1544, 2502, 1428, 418, 1545, 2503, 1429, 419, 2578, 2630, 1445, 1566, 2581, 2631, 1447, 
1567, 1561, 2579, 1448, 423
1580, 1545, 2503, 1429, 419, 1546, 2504, 1430, 420, 2581, 2631, 1447, 1567, 2584, 2632, 1449, 
1568, 1563, 2582, 1450, 424
1581, 1546, 2504, 1430, 420, 472, 1603, 435, 37, 2584, 2632, 1449, 1568, 1617, 1625, 439, 
475, 1564, 2585, 1451, 425
1582, 1401, 1402, 388, 387, 2501, 2505, 1431, 1427, 1417, 1424, 392, 1423, 2588, 2633, 1452, 
2629, 2573, 2586, 1453, 1444
1583, 2501, 2505, 1431, 1427, 2502, 2506, 1432, 1428, 2588, 2633, 1452, 2629, 2591, 2634, 1454, 
2630, 2576, 2589, 1455, 1446
1584, 2502, 2506, 1432, 1428, 2503, 2507, 1433, 1429, 2591, 2634, 1454, 2630, 2594, 2635, 1456, 
2631, 2579, 2592, 1457, 1448
1585, 2503, 2507, 1433, 1429, 2504, 2508, 1434, 1430, 2594, 2635, 1456, 2631, 2597, 2636, 1458, 
2632, 2582, 2595, 1459, 1450
1586, 2504, 2508, 1434, 1430, 1603, 1604, 436, 435, 2597, 2636, 1458, 2632, 1619, 1626, 440, 
1625, 2585, 2598, 1460, 1451
1587, 1402, 1403, 389, 388, 2505, 2509, 1435, 1431, 1419, 1425, 393, 1424, 2601, 2637, 1461, 
2633, 2586, 2599, 1462, 1453
1588, 2505, 2509, 1435, 1431, 2506, 2510, 1436, 1432, 2601, 2637, 1461, 2633, 2604, 2638, 1463, 
2634, 2589, 2602, 1464, 1455
1589, 2506, 2510, 1436, 1432, 2507, 2511, 1437, 1433, 2604, 2638, 1463, 2634, 2607, 2639, 1465, 
2635, 2592, 2605, 1466, 1457
1590, 2507, 2511, 1437, 1433, 2508, 2512, 1438, 1434, 2607, 2639, 1465, 2635, 2610, 2640, 1467, 
2636, 2595, 2608, 1468, 1459
1591, 2508, 2512, 1438, 1434, 1604, 1605, 437, 436, 2610, 2640, 1467, 2636, 1621, 1627, 441, 
1626, 2598, 2611, 1469, 1460
1592, 1403, 1404, 390, 389, 2509, 2513, 1439, 1435, 1421, 1426, 394, 1425, 2614, 2641, 1470, 
2637, 2599, 2612, 1471, 1462
1593, 2509, 2513, 1439, 1435, 2510, 2514, 1440, 1436, 2614, 2641, 1470, 2637, 2617, 2642, 1472, 
2638, 2602, 2615, 1473, 1464
1594, 2510, 2514, 1440, 1436, 2511, 2515, 1441, 1437, 2617, 2642, 1472, 2638, 2620, 2643, 1474, 
2639, 2605, 2618, 1475, 1466
1595, 2511, 2515, 1441, 1437, 2512, 2516, 1442, 1438, 2620, 2643, 1474, 2639, 2623, 2644, 1476, 
2640, 2608, 2621, 1477, 1468
1596, 2512, 2516, 1442, 1438, 1605, 1606, 438, 437, 2623, 2644, 1476, 2640, 1623, 1628, 442, 
1627, 2611, 2624, 1478, 1469
1597, 1404, 413, 34, 390, 2513, 1573, 426, 1439, 1422, 416, 395, 1426, 2625, 1595, 1479, 
2641, 2612, 1586, 430, 1471
1598, 2513, 1573, 426, 1439, 2514, 1574, 427, 1440, 2625, 1595, 1479, 2641, 2626, 1596, 1480, 
2642, 2615, 1588, 431, 1473
1599, 2514, 1574, 427, 1440, 2515, 1575, 428, 1441, 2626, 1596, 1480, 2642, 2627, 1597, 1481, 
2643, 2618, 1590, 432, 1475
1600, 2515, 1575, 428, 1441, 2516, 1576, 429, 1442, 2627, 1597, 1481, 2643, 2628, 1598, 1482, 
2644, 2621, 1592, 433, 1477
1601, 2516, 1576, 429, 1442, 1606, 477, 38, 438, 2628, 1598, 1482, 2644, 1624, 480, 443, 
1628, 2624, 1594, 434, 1478
*ELEMENT, type=C3D20, ELSET=Volume10
1602, 39, 462, 1599, 471, 43, 494, 1641, 503, 466, 1607, 1608, 473, 498, 1649, 1650, 
505, 492, 1633, 2645, 1637
1603, 462, 463, 1600, 1599, 494, 495, 1642, 1641, 467, 1609, 1610, 1607, 499, 1651, 1652, 
1649, 1633, 1634, 2646, 2645
1604, 463, 464, 1601, 1600, 495, 496, 1643, 1642, 468, 1611, 1612, 1609, 500, 1653, 1654, 
1651, 1634, 1635, 2647, 2646
1605, 464, 465, 1602, 1601, 496, 497, 1644, 1643, 469, 1613, 1614, 1611, 501, 1655, 1656, 
1653, 1635, 1636, 2648, 2647
1606, 465, 40, 476, 1602, 497, 44, 508, 1644, 470, 478, 1615, 1613, 502, 510, 1657, 
1655, 1636, 493, 1639, 2648
1607, 471, 1599, 1603, 472, 503, 1641, 1645, 504, 1608, 1616, 1617, 474, 1650, 1658, 1659, 
506, 1637, 2645, 2649, 1638
1608, 1599, 1600, 1604, 1603, 1641, 1642, 1646, 1645, 1610, 1618, 1619, 1616, 1652, 1660, 1661, 
1658, 2645, 2646, 2650, 2649
1609, 1600, 1601, 1605, 1604, 1642, 1643, 1647, 1646, 1612, 1620, 1621, 1618, 1654, 1662, 1663, 
1660, 2646, 2647, 2651, 2650
1610, 1601, 1602, 1606, 1605, 1643, 1644, 1648, 1647, 1614, 1622, 1623, 1620, 1656, 1664, 1665, 
1662, 2647, 2648, 2652, 2651
1611, 1602, 476, 477, 1606, 1644, 508, 509, 1648, 1615, 479, 1624, 1622, 1657, 511, 1666, 
1664, 2648, 1639, 1640, 2652
1612, 472, 1603, 435, 37, 504, 1645, 483, 41, 1617, 1625, 439, 475, 1659, 1667, 487, 
507, 1638, 2649, 1629, 481
1613, 1603, 1604, 436, 435, 1645, 1646, 484, 483, 1619, 1626, 440, 1625, 1661, 1668, 488, 
1667, 2649, 2650, 1630, 1629
1614, 1604, 1605, 437, 436, 1646, 1647, 485, 484, 1621, 1627, 441, 1626, 1663, 1669, 489, 
1668, 2650, 2651, 1631, 1630
1615, 1605, 1606, 438, 437, 1647, 1648, 486, 485, 1623, 1628, 442, 1627, 1665, 1670, 490, 
1669, 2651, 2652, 1632, 1631
1616, 1606, 477, 38, 438, 1648, 509, 42, 486, 1624, 480, 443, 1628, 1666, 512, 491, 
1670, 2652, 1640, 482, 1632
*ELEMENT, type=C3D20, ELSET=Volume11
1617, 43, 494, 1641, 503, 528, 1688, 2653, 1705, 498, 1649, 1650, 505, 1693, 2662, 2663, 
1707, 529, 1692, 2661, 1708
1618, 528, 1688, 2653, 1705, 47, 534, 1723, 543, 1693, 2662, 2663, 1707, 538, 1731, 1732, 
545, 530, 1694, 2664, 1709
1619, 494, 495, 1642, 1641, 1688, 1689, 2654, 2653, 499, 1651, 1652, 1649, 1696, 2666, 2667, 
2662, 1692, 1695, 2665, 2661
1620, 1688, 1689, 2654, 2653, 534, 535, 1724, 1723, 1696, 2666, 2667, 2662, 539, 1733, 1734, 
1731, 1694, 1697, 2668, 2664
1621, 495, 496, 1643, 1642, 1689, 1690, 2655, 2654, 500, 1653, 1654, 1651, 1699, 2670, 2671, 
2666, 1695, 1698, 2669, 2665
1622, 1689, 1690, 2655, 2654, 535, 536, 1725, 1724, 1699, 2670, 2671, 2666, 540, 1735, 1736, 
1733, 1697, 1700, 2672, 2668
1623, 496, 497, 1644, 1643, 1690, 1691, 2656, 2655, 501, 1655, 1656, 1653, 1702, 2674, 2675, 
2670, 1698, 1701, 2673, 2669
1624, 1690, 1691, 2656, 2655, 536, 537, 1726, 1725, 1702, 2674, 2675, 2670, 541, 1737, 1738, 
1735, 1700, 1703, 2676, 2672
1625, 497, 44, 508, 1644, 1691, 531, 1714, 2656, 502, 510, 1657, 1655, 1704, 1717, 2677, 
2674, 1701, 532, 1716, 2673
1626, 1691, 531, 1714, 2656, 537, 48, 548, 1726, 1704, 1717, 2677, 2674, 542, 550, 1739, 
1737, 1703, 533, 1718, 2676
1627, 503, 1641, 1645, 504, 1705, 2653, 2657, 1706, 1650, 1658, 1659, 506, 2663, 2679, 2680, 
1710, 1708, 2661, 2678, 1711
1628, 1705, 2653, 2657, 1706, 543, 1723, 1727, 544, 2663, 2679, 2680, 1710, 1732, 1740, 1741, 
546, 1709, 2664, 2681, 1712
1629, 1641, 1642, 1646, 1645, 2653, 2654, 2658, 2657, 1652, 1660, 1661, 1658, 2667, 2683, 2684, 
2679, 2661, 2665, 2682, 2678
1630, 2653, 2654, 2658, 2657, 1723, 1724, 1728, 1727, 2667, 2683, 2684, 2679, 1734, 1742, 1743, 
1740, 2664, 2668, 2685, 2681
1631, 1642, 1643, 1647, 1646, 2654, 2655, 2659, 2658, 1654, 1662, 1663, 1660, 2671, 2687, 2688, 
2683, 2665, 2669, 2686, 2682
1632, 2654, 2655, 2659, 2658, 1724, 1725, 1729, 1728, 2671, 2687, 2688, 2683, 1736, 1744, 1745, 
1742, 2668, 2672, 2689, 2685
1633, 1643, 1644, 1648, 1647, 2655, 2656, 2660, 2659, 1656, 1664, 1665, 1662, 2675, 2691, 2692, 
2687, 2669, 2673, 2690, 2686
1634, 2655, 2656, 2660, 2659, 1725, 1726, 1730, 1729, 2675, 2691, 2692, 2687, 1738, 1746, 1747, 
1744, 2672, 2676, 2693, 2689
1635, 1644, 508, 509, 1648, 2656, 1714, 1715, 2660, 1657, 511, 1666, 1664, 2677, 1720, 2694, 
2691, 2673, 1716, 1719, 2690
1636, 2656, 1714, 1715, 2660, 1726, 548, 549, 1730, 2677, 1720, 2694, 2691, 1739, 551, 1748, 
1746, 2676, 1718, 1721, 2693
1637, 504, 1645, 483, 41, 1706, 2657, 1671, 513, 1659, 1667, 487, 507, 2680, 2695, 1675, 
1713, 1711, 2678, 1676, 514
1638, 1706, 2657, 1671, 513, 544, 1727, 519, 45, 2680, 2695, 1675, 1713, 1741, 1749, 523, 
547, 1712, 2681, 1677, 515
1639, 1645, 1646, 484, 483, 2657, 2658, 1672, 1671, 1661, 1668, 488, 1667, 2684, 2696, 1678, 
2695, 2678, 2682, 1679, 1676
1640, 2657, 2658, 1672, 1671, 1727, 1728, 520, 519, 2684, 2696, 1678, 2695, 1743, 1750, 524, 
1749, 2681, 2685, 1680, 1677
1641, 1646, 1647, 485, 484, 2658, 2659, 1673, 1672, 1663, 1669, 489, 1668, 2688, 2697, 1681, 
2696, 2682, 2686, 1682, 1679
1642, 2658, 2659, 1673, 1672, 1728, 1729, 521, 520, 2688, 2697, 1681, 2696, 1745, 1751, 525, 
1750, 2685, 2689, 1683, 1680
1643, 1647, 1648, 486, 485, 2659, 2660, 1674, 1673, 1665, 1670, 490, 1669, 2692, 2698, 1684, 
2697, 2686, 2690, 1685, 1682
1644, 2659, 2660, 1674, 1673, 1729, 1730, 522, 521, 2692, 2698, 1684, 2697, 1747, 1752, 526, 
1751, 2689, 2693, 1686, 1683
1645, 1648, 509, 42, 486, 2660, 1715, 516, 1674, 1666, 512, 491, 1670, 2694, 1722, 1687, 
2698, 2690, 1719, 517, 1685
1646, 2660, 1715, 516, 1674, 1730, 549, 46, 522, 2694, 1722, 1687, 2698, 1748, 552, 527, 
1752, 2693, 1721, 518, 1686
*ELEMENT, type=C3D20, ELSET=Volume12
1647, 44, 508, 1714, 531, 51, 563, 1759, 560, 510, 1716, 1717, 532, 565, 1761, 1762, 
561, 558, 1755, 2699, 1754
1648, 531, 1714, 548, 48, 560, 1759, 568, 52, 1717, 1718, 550, 533, 1762, 1763, 570, 
562, 1754, 2699, 1757, 559
1649, 508, 509, 1715, 1714, 563, 564, 1760, 1759, 511, 1719, 1720, 1716, 566, 1764, 1765, 
1761, 1755, 1756, 2700, 2699
1650, 1714, 1715, 549, 548, 1759, 1760, 569, 568, 1720, 1721, 551, 1718, 1765, 1766, 571, 
1763, 2699, 2700, 1758, 1757
1651, 509, 42, 516, 1715, 564, 49, 555, 1760, 512, 517, 1722, 1719, 567, 556, 1767, 
1764, 1756, 553, 1753, 2700
1652, 1715, 516, 46, 549, 1760, 555, 50, 569, 1722, 518, 552, 1721, 1767, 557, 572, 
1766, 2700, 1753, 554, 1758
*ELEMENT, type=C3D20, ELSET=Volume13
1653, 2, 77, 787, 90, 54, 575, 1774, 590, 79, 789, 790, 91, 577, 1776, 1777, 
591, 574, 1768, 2701, 1773
1654, 90, 787, 85, 4, 590, 1774, 585, 56, 790, 791, 87, 92, 1777, 1778, 587, 
592, 1773, 2701, 1771, 584
1655, 77, 78, 788, 787, 575, 576, 1775, 1774, 80, 792, 793, 789, 578, 1779, 1780, 
1776, 1768, 1769, 2702, 2701
1656, 787, 788, 86, 85, 1774, 1775, 586, 585, 793, 794, 88, 791, 1780, 1781, 588, 
1778, 2701, 2702, 1772, 1771
1657, 78, 1, 82, 788, 576, 53, 581, 1775, 81, 83, 795, 792, 579, 582, 1782, 
1779, 1769, 573, 1770, 2702
1658, 788, 82, 3, 86, 1775, 581, 55, 586, 795, 84, 89, 794, 1782, 583, 589, 
1781, 2702, 1770, 580, 1772
*ELEMENT, type=C3D20, ELSET=Volume14
1659, 10, 186, 941, 147, 672, 1884, 2703, 1901, 190, 957, 958, 151, 1889, 2720, 2721, 
1905, 673, 1888, 2719, 1906
1660, 672, 1884, 2703, 1901, 67, 678, 1935, 687, 1889, 2720, 2721, 1905, 682, 1951, 1952, 
691, 674, 1890, 2722, 1907
1661, 186, 187, 942, 941, 1884, 1885, 2704, 2703, 191, 959, 960, 957, 1892, 2724, 2725, 
2720, 1888, 1891, 2723, 2719
1662, 1884, 1885, 2704, 2703, 678, 679, 1936, 1935, 1892, 2724, 2725, 2720, 683, 1953, 1954, 
1951, 1890, 1893, 2726, 2722
1663, 187, 188, 943, 942, 1885, 1886, 2705, 2704, 192, 961, 962, 959, 1895, 2728, 2729, 
2724, 1891, 1894, 2727, 2723
1664, 1885, 1886, 2705, 2704, 679, 680, 1937, 1936, 1895, 2728, 2729, 2724, 684, 1955, 1956, 
1953, 1893, 1896, 2730, 2726
1665, 188, 189, 944, 943, 1886, 1887, 2706, 2705, 193, 963, 964, 961, 1898, 2732, 2733, 
2728, 1894, 1897, 2731, 2727
1666, 1886, 1887, 2706, 2705, 680, 681, 1938, 1937, 1898, 2732, 2733, 2728, 685, 1957, 1958, 
1955, 1896, 1899, 2734, 2730
1667, 189, 14, 195, 944, 1887, 675, 1918, 2706, 194, 199, 965, 963, 1900, 1923, 2735, 
2732, 1897, 676, 1922, 2731
1668, 1887, 675, 1918, 2706, 681, 68, 696, 1938, 1900, 1923, 2735, 2732, 686, 700, 1959, 
1957, 1899, 677, 1924, 2734
1669, 147, 941, 945, 148, 1901, 2703, 2707, 1902, 958, 966, 967, 152, 2721, 2737, 2738, 
1908, 1906, 2719, 2736, 1909
1670, 1901, 2703, 2707, 1902, 687, 1935, 1939, 688, 2721, 2737, 2738, 1908, 1952, 1960, 1961, 
692, 1907, 2722, 2739, 1910
1671, 941, 942, 946, 945, 2703, 2704, 2708, 2707, 960, 968, 969, 966, 2725, 2741, 2742, 
2737, 2719, 2723, 2740, 2736
1672, 2703, 2704, 2708, 2707, 1935, 1936, 1940, 1939, 2725, 2741, 2742, 2737, 1954, 1962, 1963, 
1960, 2722, 2726, 2743, 2739
1673, 942, 943, 947, 946, 2704, 2705, 2709, 2708, 962, 970, 971, 968, 2729, 2745, 2746, 
2741, 2723, 2727, 2744, 2740
1674, 2704, 2705, 2709, 2708, 1936, 1937, 1941, 1940, 2729, 2745, 2746, 2741, 1956, 1964, 1965, 
1962, 2726, 2730, 2747, 2743
1675, 943, 944, 948, 947, 2705, 2706, 2710, 2709, 964, 972, 973, 970, 2733, 2749, 2750, 
2745, 2727, 2731, 2748, 2744
1676, 2705, 2706, 2710, 2709, 1937, 1938, 1942, 1941, 2733, 2749, 2750, 2745, 1958, 1966, 1967, 
1964, 2730, 2734, 2751, 2747
1677, 944, 195, 196, 948, 2706, 1918, 1919, 2710, 965, 200, 974, 972, 2735, 1926, 2752, 
2749, 2731, 1922, 1925, 2748
1678, 2706, 1918, 1919, 2710, 1938, 696, 697, 1942, 2735, 1926, 2752, 2749, 1959, 701, 1968, 
1966, 2734, 1924, 1927, 2751
1679, 148, 945, 949, 149, 1902, 2707, 2711, 1903, 967, 975, 976, 153, 2738, 2754, 2755, 
1911, 1909, 2736, 2753, 1912
1680, 1902, 2707, 2711, 1903, 688, 1939, 1943, 689, 2738, 2754, 2755, 1911, 1961, 1969, 1970, 
693, 1910, 2739, 2756, 1913
1681, 945, 946, 950, 949, 2707, 2708, 2712, 2711, 969, 977, 978, 975, 2742, 2758, 2759, 
2754, 2736, 2740, 2757, 2753
1682, 2707, 2708, 2712, 2711, 1939, 1940, 1944, 1943, 2742, 2758, 2759, 2754, 1963, 1971, 1972, 
1969, 2739, 2743, 2760, 2756
1683, 946, 947, 951, 950, 2708, 2709, 2713, 2712, 971, 979, 980, 977, 2746, 2762, 2763, 
2758, 2740, 2744, 2761, 2757
1684, 2708, 2709, 2713, 2712, 1940, 1941, 1945, 1944, 2746, 2762, 2763, 2758, 1965, 1973, 1974, 
1971, 2743, 2747, 2764, 2760
1685, 947, 948, 952, 951, 2709, 2710, 2714, 2713, 973, 981, 982, 979, 2750, 2766, 2767, 
2762, 2744, 2748, 2765, 2761
1686, 2709, 2710, 2714, 2713, 1941, 1942, 1946, 1945, 2750, 2766, 2767, 2762, 1967, 1975, 1976, 
1973, 2747, 2751, 2768, 2764
1687, 948, 196, 197, 952, 2710, 1919, 1920, 2714, 974, 201, 983, 981, 2752, 1929, 2769, 
2766, 2748, 1925, 1928, 2765
1688, 2710, 1919, 1920, 2714, 1942, 697, 698, 1946, 2752, 1929, 2769, 2766, 1968, 702, 1977, 
1975, 2751, 1927, 1930, 2768
1689, 149, 949, 953, 150, 1903, 2711, 2715, 1904, 976, 984, 985, 154, 2755, 2771, 2772, 
1914, 1912, 2753, 2770, 1915
1690, 1903, 2711, 2715, 1904, 689, 1943, 1947, 690, 2755, 2771, 2772, 1914, 1970, 1978, 1979, 
694, 1913, 2756, 2773, 1916
1691, 949, 950, 954, 953, 2711, 2712, 2716, 2715, 978, 986, 987, 984, 2759, 2775, 2776, 
2771, 2753, 2757, 2774, 2770
1692, 2711, 2712, 2716, 2715, 1943, 1944, 1948, 1947, 2759, 2775, 2776, 2771, 1972, 1980, 1981, 
1978, 2756, 2760, 2777, 2773
1693, 950, 951, 955, 954, 2712, 2713, 2717, 2716, 980, 988, 989, 986, 2763, 2779, 2780, 
2775, 2757, 2761, 2778, 2774
1694, 2712, 2713, 2717, 2716, 1944, 1945, 1949, 1948, 2763, 2779, 2780, 2775, 1974, 1982, 1983, 
1980, 2760, 2764, 2781, 2777
1695, 951, 952, 956, 955, 2713, 2714, 2718, 2717, 982, 990, 991, 988, 2767, 2783, 2784, 
2779, 2761, 2765, 2782, 2778
1696, 2713, 2714, 2718, 2717, 1945, 1946, 1950, 1949, 2767, 2783, 2784, 2779, 1976, 1984, 1985, 
1982, 2764, 2768, 2785, 2781
1697, 952, 197, 198, 956, 2714, 1920, 1921, 2718, 983, 202, 992, 990, 2769, 1932, 2786, 
2783, 2765, 1928, 1931, 2782
1698, 2714, 1920, 1921, 2718, 1946, 698, 699, 1950, 2769, 1932, 2786, 2783, 1977, 703, 1986, 
1984, 2768, 1930, 1933, 2785
1699, 150, 953, 177, 9, 1904, 2715, 1867, 657, 985, 993, 181, 155, 2772, 2787, 1871, 
1917, 1915, 2770, 1872, 658
1700, 1904, 2715, 1867, 657, 690, 1947, 663, 65, 2772, 2787, 1871, 1917, 1979, 1987, 667, 
695, 1916, 2773, 1873, 659
1701, 953, 954, 178, 177, 2715, 2716, 1868, 1867, 987, 994, 182, 993, 2776, 2788, 1874, 
2787, 2770, 2774, 1875, 1872
1702, 2715, 2716, 1868, 1867, 1947, 1948, 664, 663, 2776, 2788, 1874, 2787, 1981, 1988, 668, 
1987, 2773, 2777, 1876, 1873
1703, 954, 955, 179, 178, 2716, 2717, 1869, 1868, 989, 995, 183, 994, 2780, 2789, 1877, 
2788, 2774, 2778, 1878, 1875
1704, 2716, 2717, 1869, 1868, 1948, 1949, 665, 664, 2780, 2789, 1877, 2788, 1983, 1989, 669, 
1988, 2777, 2781, 1879, 1876
1705, 955, 956, 180, 179, 2717, 2718, 1870, 1869, 991, 996, 184, 995, 2784, 2790, 1880, 
2789, 2778, 2782, 1881, 1878
1706, 2717, 2718, 1870, 1869, 1949, 1950, 666, 665, 2784, 2790, 1880, 2789, 1985, 1990, 670, 
1989, 2781, 2785, 1882, 1879
1707, 956, 198, 13, 180, 2718, 1921, 660, 1870, 992, 203, 185, 996, 2786, 1934, 1883, 
2790, 2782, 1931, 661, 1881
1708, 2718, 1921, 660, 1870, 1950, 699, 66, 666, 2786, 1934, 1883, 2790, 1986, 704, 671, 
1990, 2785, 1933, 662, 1882
*ELEMENT, type=C3D20, ELSET=Volume15
1709, 35, 398, 1483, 444, 705, 2025, 2791, 1991, 402, 1499, 1500, 448, 2030, 2808, 2809, 
1995, 706, 2029, 2807, 1996
1710, 705, 2025, 2791, 1991, 69, 735, 2059, 711, 2030, 2808, 2809, 1995, 739, 2075, 2076, 
715, 707, 2031, 2810, 1997
1711, 444, 1483, 1484, 445, 1991, 2791, 2792, 1992, 1500, 1501, 1502, 449, 2809, 2812, 2813, 
1998, 1996, 2807, 2811, 1999
1712, 1991, 2791, 2792, 1992, 711, 2059, 2060, 712, 2809, 2812, 2813, 1998, 2076, 2077, 2078, 
716, 1997, 2810, 2814, 2000
1713, 445, 1484, 1485, 446, 1992, 2792, 2793, 1993, 1502, 1503, 1504, 450, 2813, 2816, 2817, 
2001, 1999, 2811, 2815, 2002
1714, 1992, 2792, 2793, 1993, 712, 2060, 2061, 713, 2813, 2816, 2817, 2001, 2078, 2079, 2080, 
717, 2000, 2814, 2818, 2003
1715, 446, 1485, 1486, 447, 1993, 2793, 2794, 1994, 1504, 1505, 1506, 451, 2817, 2820, 2821, 
2004, 2002, 2815, 2819, 2005
1716, 1993, 2793, 2794, 1994, 713, 2061, 2062, 714, 2817, 2820, 2821, 2004, 2080, 2081, 2082, 
718, 2003, 2818, 2822, 2006
1717, 447, 1486, 462, 39, 1994, 2794, 2042, 708, 1506, 1507, 466, 452, 2821, 2823, 2046, 
2007, 2005, 2819, 2047, 709
1718, 1994, 2794, 2042, 708, 714, 2062, 744, 70, 2821, 2823, 2046, 2007, 2082, 2083, 748, 
719, 2006, 2822, 2048, 710
1719, 398, 399, 1487, 1483, 2025, 2026, 2795, 2791, 403, 1508, 1509, 1499, 2033, 2825, 2826, 
2808, 2029, 2032, 2824, 2807
1720, 2025, 2026, 2795, 2791, 735, 736, 2063, 2059, 2033, 2825, 2826, 2808, 740, 2084, 2085, 
2075, 2031, 2034, 2827, 2810
1721, 1483, 1487, 1488, 1484, 2791, 2795, 2796, 2792, 1509, 1510, 1511, 1501, 2826, 2829, 2830, 
2812, 2807, 2824, 2828, 2811
1722, 2791, 2795, 2796, 2792, 2059, 2063, 2064, 2060, 2826, 2829, 2830, 2812, 2085, 2086, 2087, 
2077, 2810, 2827, 2831, 2814
1723, 1484, 1488, 1489, 1485, 2792, 2796, 2797, 2793, 1511, 1512, 1513, 1503, 2830, 2833, 2834, 
2816, 2811, 2828, 2832, 2815
1724, 2792, 2796, 2797, 2793, 2060, 2064, 2065, 2061, 2830, 2833, 2834, 2816, 2087, 2088, 2089, 
2079, 2814, 2831, 2835, 2818
1725, 1485, 1489, 1490, 1486, 2793, 2797, 2798, 2794, 1513, 1514, 1515, 1505, 2834, 2837, 2838, 
2820, 2815, 2832, 2836, 2819
1726, 2793, 2797, 2798, 2794, 2061, 2065, 2066, 2062, 2834, 2837, 2838, 2820, 2089, 2090, 2091, 
2081, 2818, 2835, 2839, 2822
1727, 1486, 1490, 463, 462, 2794, 2798, 2043, 2042, 1515, 1516, 467, 1507, 2838, 2840, 2049, 
2823, 2819, 2836, 2050, 2047
1728, 2794, 2798, 2043, 2042, 2062, 2066, 745, 744, 2838, 2840, 2049, 2823, 2091, 2092, 749, 
2083, 2822, 2839, 2051, 2048
1729, 399, 400, 1491, 1487, 2026, 2027, 2799, 2795, 404, 1517, 1518, 1508, 2036, 2842, 2843, 
2825, 2032, 2035, 2841, 2824
1730, 2026, 2027, 2799, 2795, 736, 737, 2067, 2063, 2036, 2842, 2843, 2825, 741, 2093, 2094, 
2084, 2034, 2037, 2844, 2827
1731, 1487, 1491, 1492, 1488, 2795, 2799, 2800, 2796, 1518, 1519, 1520, 1510, 2843, 2846, 2847, 
2829, 2824, 2841, 2845, 2828
1732, 2795, 2799, 2800, 2796, 2063, 2067, 2068, 2064, 2843, 2846, 2847, 2829, 2094, 2095, 2096, 
2086, 2827, 2844, 2848, 2831
1733, 1488, 1492, 1493, 1489, 2796, 2800, 2801, 2797, 1520, 1521, 1522, 1512, 2847, 2850, 2851, 
2833, 2828, 2845, 2849, 2832
1734, 2796, 2800, 2801, 2797, 2064, 2068, 2069, 2065, 2847, 2850, 2851, 2833, 2096, 2097, 2098, 
2088, 2831, 2848, 2852, 2835
1735, 1489, 1493, 1494, 1490, 2797, 2801, 2802, 2798, 1522, 1523, 1524, 1514, 2851, 2854, 2855, 
2837, 2832, 2849, 2853, 2836
1736, 2797, 2801, 2802, 2798, 2065, 2069, 2070, 2066, 2851, 2854, 2855, 2837, 2098, 2099, 2100, 
2090, 2835, 2852, 2856, 2839
1737, 1490, 1494, 464, 463, 2798, 2802, 2044, 2043, 1524, 1525, 468, 1516, 2855, 2857, 2052, 
2840, 2836, 2853, 2053, 2050
1738, 2798, 2802, 2044, 2043, 2066, 2070, 746, 745, 2855, 2857, 2052, 2840, 2100, 2101, 750, 
2092, 2839, 2856, 2054, 2051
1739, 400, 401, 1495, 1491, 2027, 2028, 2803, 2799, 405, 1526, 1527, 1517, 2039, 2859, 2860, 
2842, 2035, 2038, 2858, 2841
1740, 2027, 2028, 2803, 2799, 737, 738, 2071, 2067, 2039, 2859, 2860, 2842, 742, 2102, 2103, 
2093, 2037, 2040, 2861, 2844
1741, 1491, 1495, 1496, 1492, 2799, 2803, 2804, 2800, 1527, 1528, 1529, 1519, 2860, 2863, 2864, 
2846, 2841, 2858, 2862, 2845
1742, 2799, 2803, 2804, 2800, 2067, 2071, 2072, 2068, 2860, 2863, 2864, 2846, 2103, 2104, 2105, 
2095, 2844, 2861, 2865, 2848
1743, 1492, 1496, 1497, 1493, 2800, 2804, 2805, 2801, 1529, 1530, 1531, 1521, 2864, 2867, 2868, 
2850, 2845, 2862, 2866, 2849
1744, 2800, 2804, 2805, 2801, 2068, 2072, 2073, 2069, 2864, 2867, 2868, 2850, 2105, 2106, 2107, 
2097, 2848, 2865, 2869, 2852
1745, 1493, 1497, 1498, 1494, 2801, 2805, 2806, 2802, 1531, 1532, 1533, 1523, 2868, 2871, 2872, 
2854, 2849, 2866, 2870, 2853
1746, 2801, 2805, 2806, 2802, 2069, 2073, 2074, 2070, 2868, 2871, 2872, 2854, 2107, 2108, 2109, 
2099, 2852, 2869, 2873, 2856
1747, 1494, 1498, 465, 464, 2802, 2806, 2045, 2044, 1533, 1534, 469, 1525, 2872, 2874, 2055, 
2857, 2853, 2870, 2056, 2053
1748, 2802, 2806, 2045, 2044, 2070, 2074, 747, 746, 2872, 2874, 2055, 2857, 2109, 2110, 751, 
2101, 2856, 2873, 2057, 2054
1749, 401, 36, 453, 1495, 2028, 720, 2008, 2803, 406, 457, 1535, 1526, 2041, 2013, 2875, 
2859, 2038, 721, 2012, 2858
1750, 2028, 720, 2008, 2803, 738, 71, 726, 2071, 2041, 2013, 2875, 2859, 743, 730, 2111, 
2102, 2040, 722, 2014, 2861
1751, 1495, 453, 454, 1496, 2803, 2008, 2009, 2804, 1535, 458, 1536, 1528, 2875, 2016, 2876, 
2863, 2858, 2012, 2015, 2862
1752, 2803, 2008, 2009, 2804, 2071, 726, 727, 2072, 2875, 2016, 2876, 2863, 2111, 731, 2112, 
2104, 2861, 2014, 2017, 2865
1753, 1496, 454, 455, 1497, 2804, 2009, 2010, 2805, 1536, 459, 1537, 1530, 2876, 2019, 2877, 
2867, 2862, 2015, 2018, 2866
1754, 2804, 2009, 2010, 2805, 2072, 727, 728, 2073, 2876, 2019, 2877, 2867, 2112, 732, 2113, 
2106, 2865, 2017, 2020, 2869
1755, 1497, 455, 456, 1498, 2805, 2010, 2011, 2806, 1537, 460, 1538, 1532, 2877, 2022, 2878, 
2871, 2866, 2018, 2021, 2870
1756, 2805, 2010, 2011, 2806, 2073, 728, 729, 2074, 2877, 2022, 2878, 2871, 2113, 733, 2114, 
2108, 2869, 2020, 2023, 2873
1757, 1498, 456, 40, 465, 2806, 2011, 723, 2045, 1538, 461, 470, 1534, 2878, 2024, 2058, 
2874, 2870, 2021, 724, 2056
1758, 2806, 2011, 723, 2045, 2074, 729, 72, 747, 2878, 2024, 2058, 2874, 2114, 734, 752, 
2110, 2873, 2023, 725, 2057
*ELEMENT, type=C3D20, ELSET=Volume16
1759, 9, 177, 997, 157, 59, 606, 1795, 615, 181, 1005, 1006, 159, 610, 1803, 1804, 
617, 604, 1787, 2879, 1791
1760, 177, 178, 998, 997, 606, 607, 1796, 1795, 182, 1007, 1008, 1005, 611, 1805, 1806, 
1803, 1787, 1788, 2880, 2879
1761, 178, 179, 999, 998, 607, 608, 1797, 1796, 183, 1009, 1010, 1007, 612, 1807, 1808, 
1805, 1788, 1789, 2881, 2880
1762, 179, 180, 1000, 999, 608, 609, 1798, 1797, 184, 1011, 1012, 1009, 613, 1809, 1810, 
1807, 1789, 1790, 2882, 2881
1763, 180, 13, 213, 1000, 609, 60, 620, 1798, 185, 215, 1013, 1011, 614, 622, 1811, 
1809, 1790, 605, 1793, 2882
1764, 157, 997, 1001, 158, 615, 1795, 1799, 616, 1006, 1014, 1015, 160, 1804, 1812, 1813, 
618, 1791, 2879, 2883, 1792
1765, 997, 998, 1002, 1001, 1795, 1796, 1800, 1799, 1008, 1016, 1017, 1014, 1806, 1814, 1815, 
1812, 2879, 2880, 2884, 2883
1766, 998, 999, 1003, 1002, 1796, 1797, 1801, 1800, 1010, 1018, 1019, 1016, 1808, 1816, 1817, 
1814, 2880, 2881, 2885, 2884
1767, 999, 1000, 1004, 1003, 1797, 1798, 1802, 1801, 1012, 1020, 1021, 1018, 1810, 1818, 1819, 
1816, 2881, 2882, 2886, 2885
1768, 1000, 213, 214, 1004, 1798, 620, 621, 1802, 1013, 216, 1022, 1020, 1811, 623, 1820, 
1818, 2882, 1793, 1794, 2886
1769, 158, 1001, 204, 11, 616, 1799, 595, 57, 1015, 1023, 208, 161, 1813, 1821, 599, 
619, 1792, 2883, 1783, 593
1770, 1001, 1002, 205, 204, 1799, 1800, 596, 595, 1017, 1024, 209, 1023, 1815, 1822, 600, 
1821, 2883, 2884, 1784, 1783
1771, 1002, 1003, 206, 205, 1800, 1801, 597, 596, 1019, 1025, 210, 1024, 1817, 1823, 601, 
1822, 2884, 2885, 1785, 1784
1772, 1003, 1004, 207, 206, 1801, 1802, 598, 597, 1021, 1026, 211, 1025, 1819, 1824, 602, 
1823, 2885, 2886, 1786, 1785
1773, 1004, 214, 15, 207, 1802, 621, 58, 598, 1022, 217, 212, 1026, 1820, 624, 603, 
1824, 2886, 1794, 594, 1786
*ELEMENT, type=C3D20, ELSET=Volume17
1774, 35, 444, 1539, 407, 63, 638, 1837, 647, 448, 1547, 1548, 409, 642, 1845, 1846, 
649, 636, 1829, 2887, 1833
1775, 444, 445, 1540, 1539, 638, 639, 1838, 1837, 449, 1549, 1550, 1547, 643, 1847, 1848, 
1845, 1829, 1830, 2888, 2887
1776, 445, 446, 1541, 1540, 639, 640, 1839, 1838, 450, 1551, 1552, 1549, 644, 1849, 1850, 
1847, 1830, 1831, 2889, 2888
1777, 446, 447, 1542, 1541, 640, 641, 1840, 1839, 451, 1553, 1554, 1551, 645, 1851, 1852, 
1849, 1831, 1832, 2890, 2889
1778, 447, 39, 471, 1542, 641, 64, 652, 1840, 452, 473, 1555, 1553, 646, 654, 1853, 
1851, 1832, 637, 1835, 2890
1779, 407, 1539, 1543, 408, 647, 1837, 1841, 648, 1548, 1556, 1557, 410, 1846, 1854, 1855, 
650, 1833, 2887, 2891, 1834
1780, 1539, 1540, 1544, 1543, 1837, 1838, 1842, 1841, 1550, 1558, 1559, 1556, 1848, 1856, 1857, 
1854, 2887, 2888, 2892, 2891
1781, 1540, 1541, 1545, 1544, 1838, 1839, 1843, 1842, 1552, 1560, 1561, 1558, 1850, 1858, 1859, 
1856, 2888, 2889, 2893, 2892
1782, 1541, 1542, 1546, 1545, 1839, 1840, 1844, 1843, 1554, 1562, 1563, 1560, 1852, 1860, 1861, 
1858, 2889, 2890, 2894, 2893
1783, 1542, 471, 472, 1546, 1840, 652, 653, 1844, 1555, 474, 1564, 1562, 1853, 655, 1862, 
1860, 2890, 1835, 1836, 2894
1784, 408, 1543, 417, 33, 648, 1841, 627, 61, 1557, 1565, 421, 411, 1855, 1863, 631, 
651, 1834, 2891, 1825, 625
1785, 1543, 1544, 418, 417, 1841, 1842, 628, 627, 1559, 1566, 422, 1565, 1857, 1864, 632, 
1863, 2891, 2892, 1826, 1825
1786, 1544, 1545, 419, 418, 1842, 1843, 629, 628, 1561, 1567, 423, 1566, 1859, 1865, 633, 
1864, 2892, 2893, 1827, 1826
1787, 1545, 1546, 420, 419, 1843, 1844, 630, 629, 1563, 1568, 424, 1567, 1861, 1866, 634, 
1865, 2893, 2894, 1828, 1827
1788, 1546, 472, 37, 420, 1844, 653, 62, 630, 1564, 475, 425, 1568, 1862, 656, 635, 
1866, 2894, 1836, 626, 1828
*ELEMENT, type=C3D20, ELSET=Volume18
1789, 35, 444, 638, 63, 705, 1991, 2117, 753, 448, 1829, 642, 636, 1995, 2895, 2121, 
2115, 706, 1996, 2122, 754
1790, 705, 1991, 2117, 753, 69, 711, 761, 73, 1995, 2895, 2121, 2115, 715, 2134, 765, 
756, 707, 1997, 2123, 755
1791, 444, 445, 639, 638, 1991, 1992, 2118, 2117, 449, 1830, 643, 1829, 1998, 2896, 2124, 
2895, 1996, 1999, 2125, 2122
1792, 1991, 1992, 2118, 2117, 711, 712, 762, 761, 1998, 2896, 2124, 2895, 716, 2135, 766, 
2134, 1997, 2000, 2126, 2123
1793, 445, 446, 640, 639, 1992, 1993, 2119, 2118, 450, 1831, 644, 1830, 2001, 2897, 2127, 
2896, 1999, 2002, 2128, 2125
1794, 1992, 1993, 2119, 2118, 712, 713, 763, 762, 2001, 2897, 2127, 2896, 717, 2136, 767, 
2135, 2000, 2003, 2129, 2126
1795, 446, 447, 641, 640, 1993, 1994, 2120, 2119, 451, 1832, 645, 1831, 2004, 2898, 2130, 
2897, 2002, 2005, 2131, 2128
1796, 1993, 1994, 2120, 2119, 713, 714, 764, 763, 2004, 2898, 2130, 2897, 718, 2137, 768, 
2136, 2003, 2006, 2132, 2129
1797, 447, 39, 64, 641, 1994, 708, 757, 2120, 452, 637, 646, 1832, 2007, 2116, 2133, 
2898, 2005, 709, 758, 2131
1798, 1994, 708, 757, 2120, 714, 70, 74, 764, 2007, 2116, 2133, 2898, 719, 760, 769, 
2137, 2006, 710, 759, 2132
*ELEMENT, type=C3D20, ELSET=Volume19
1799, 9, 177, 606, 59, 657, 1867, 2140, 770, 181, 1787, 610, 604, 1871, 2899, 2144, 
2138, 658, 1872, 2145, 771
1800, 657, 1867, 2140, 770, 65, 663, 778, 75, 1871, 2899, 2144, 2138, 667, 2157, 782, 
773, 659, 1873, 2146, 772
1801, 177, 178, 607, 606, 1867, 1868, 2141, 2140, 182, 1788, 611, 1787, 1874, 2900, 2147, 
2899, 1872, 1875, 2148, 2145
1802, 1867, 1868, 2141, 2140, 663, 664, 779, 778, 1874, 2900, 2147, 2899, 668, 2158, 783, 
2157, 1873, 1876, 2149, 2146
1803, 178, 179, 608, 607, 1868, 1869, 2142, 2141, 183, 1789, 612, 1788, 1877, 2901, 2150, 
2900, 1875, 1878, 2151, 2148
1804, 1868, 1869, 2142, 2141, 664, 665, 780, 779, 1877, 2901, 2150, 2900, 669, 2159, 784, 
2158, 1876, 1879, 2152, 2149
1805, 179, 180, 609, 608, 1869, 1870, 2143, 2142, 184, 1790, 613, 1789, 1880, 2902, 2153, 
2901, 1878, 1881, 2154, 2151
1806, 1869, 1870, 2143, 2142, 665, 666, 781, 780, 1880, 2902, 2153, 2901, 670, 2160, 785, 
2159, 1879, 1882, 2155, 2152
1807, 180, 13, 60, 609, 1870, 660, 774, 2143, 185, 605, 614, 1790, 1883, 2139, 2156, 
2902, 1881, 661, 775, 2154
1808, 1870, 660, 774, 2143, 666, 66, 76, 781, 1883, 2139, 2156, 2902, 671, 777, 786, 
2160, 1882, 662, 776, 2155
*ELSET,ELSET=Qin
758, 759, 760, 761, 762, 763, 764, 765, 766, 767, 
768, 769, 770, 771, 772, 780, 781, 782, 824, 825, 
826, 827, 828, 829, 830, 831, 832, 833, 834, 835, 
836, 837, 838, 
*ELSET,ELSET=HeatSink
519, 520, 521, 522, 523, 524, 525, 526, 527, 528, 
529, 530, 531, 532, 533, 1034, 1035, 1036, 1037, 1038, 
1039, 1040, 1041, 1042, 1043, 1044, 1045, 1046, 1047, 1048, 
*ELSET,ELSET=ElectrodeMaxX
1059, 1060, 1061, 1062, 1063, 1064, 
*ELSET,ELSET=ElectrodeMinX
1075, 1076, 1077, 1078, 1079, 1080, 
*ELSET,ELSET=Force
752, 753, 754, 755, 756, 757, 
*ELSET,ELSET=Copper
1311, 1312, 1313, 1314, 1315, 1316, 1317, 1318, 1319, 1320, 
1321, 1322, 1323, 1324, 1325, 1326, 1327, 1328, 1329, 1330, 
1331, 1332, 1333, 1334, 1335, 1336, 1337, 1338, 1339, 1340, 
1446, 1447, 1448, 1449, 1450, 1451, 1452, 1453, 1454, 1455, 
1456, 1457, 1458, 1459, 1460, 1461, 1462, 1463, 1464, 1465, 
1466, 1467, 1468, 1469, 1470, 1471, 1472, 1473, 1474, 1475, 
1476, 1477, 1478, 1479, 1480, 1481, 1482, 1483, 1484, 1485, 
1486, 1487, 1488, 1489, 1490, 1491, 1492, 1493, 1494, 1495, 
1496, 1497, 1498, 1499, 1500, 1501, 1502, 1503, 1504, 1505, 
1506, 1507, 1508, 1509, 1510, 1511, 1617, 1618, 1619, 1620, 
1621, 1622, 1623, 1624, 1625, 1626, 1627, 1628, 1629, 1630, 
1631, 1632, 1633, 1634, 1635, 1636, 1637, 1638, 1639, 1640, 
1641, 1642, 1643, 1644, 1645, 1646, 1647, 1648, 1649, 1650, 
1651, 1652, 1653, 1654, 1655, 1656, 1657, 1658, 
*ELSET,ELSET=SemiconductorN-
1356, 1357, 1358, 1359, 1360, 1361, 1362, 1363, 1364, 1365, 
1366, 1367, 1368, 1369, 1370, 1371, 1372, 1373, 1374, 1375, 
1376, 1377, 1378, 1379, 1380, 1381, 1382, 1383, 1384, 1385, 
1386, 1387, 1388, 1389, 1390, 1391, 1392, 1393, 1394, 1395, 
1396, 1397, 1398, 1399, 1400, 1401, 1402, 1403, 1404, 1405, 
1406, 1407, 1408, 1409, 1410, 1411, 1412, 1413, 1414, 1415, 
1416, 1417, 1418, 1419, 1420, 1421, 1422, 1423, 1424, 1425, 
1426, 1427, 1428, 1429, 1430, 1659, 1660, 1661, 1662, 1663, 
1664, 1665, 1666, 1667, 1668, 1669, 1670, 1671, 1672, 1673, 
1674, 1675, 1676, 1677, 1678, 1679, 1680, 1681, 1682, 1683, 
1684, 1685, 1686, 1687, 1688, 1689, 1690, 1691, 1692, 1693, 
1694, 1695, 1696, 1697, 1698, 1699, 1700, 1701, 1702, 1703, 
1704, 1705, 1706, 1707, 1708, 1759, 1760, 1761, 1762, 1763, 
1764, 1765, 1766, 1767, 1768, 1769, 1770, 1771, 1772, 1773, 
1799, 1800, 1801, 1802, 1803, 1804, 1805, 1806, 1807, 1808, 
*ELSET,ELSET=SemiconductorP+
1527, 1528, 1529, 1530, 1531, 1532, 1533, 1534, 1535, 1536, 
1537, 1538, 1539, 1540, 1541, 1542, 1543, 1544, 1545, 1546, 
1547, 1548, 1549, 1550, 1551, 1552, 1553, 1554, 1555, 1556, 
1557, 1558, 1559, 1560, 1561, 1562, 1563, 1564, 1565, 1566, 
1567, 1568, 1569, 1570, 1571, 1572, 1573, 1574, 1575, 1576, 
1577, 1578, 1579, 1580, 1581, 1582, 1583, 1584, 1585, 1586, 
1587, 1588, 1589, 1590, 1591, 1592, 1593, 1594, 1595, 1596, 
1597, 1598, 1599, 1600, 1601, 1709, 1710, 1711, 1712, 1713, 
1714, 1715, 1716, 1717, 1718, 1719, 1720, 1721, 1722, 1723, 
1724, 1725, 1726, 1727, 1728, 1729, 1730, 1731, 1732, 1733, 
1734, 1735, 1736, 1737, 1738, 1739, 1740, 1741, 1742, 1743, 
1744, 1745, 1746, 1747, 1748, 1749, 1750, 1751, 1752, 1753, 
1754, 1755, 1756, 1757, 1758, 1774, 1775, 1776, 1777, 1778, 
1779, 1780, 1781, 1782, 1783, 1784, 1785, 1786, 1787, 1788, 
1789, 1790, 1791, 1792, 1793, 1794, 1795, 1796, 1797, 1798, 
*ELSET,ELSET=Solder
1341, 1342, 1343, 1344, 1345, 1346, 1347, 1348, 1349, 1350, 
1351, 1352, 1353, 1354, 1355, 1431, 1432, 1433, 1434, 1435, 
1436, 1437, 1438, 1439, 1440, 1441, 1442, 1443, 1444, 1445, 
1512, 1513, 1514, 1515, 1516, 1517, 1518, 1519, 1520, 1521, 
1522, 1523, 1524, 1525, 1526, 1602, 1603, 1604, 1605, 1606, 
1607, 1608, 1609, 1610, 1611, 1612, 1613, 1614, 1615, 1616, 
*ELSET,ELSET=Volume
1311, 1312, 1313, 1314, 1315, 1316, 1317, 1318, 1319, 1320, 
1321, 1322, 1323, 1324, 1325, 1326, 1327, 1328, 1329, 1330, 
1331, 1332, 1333, 1334, 1335, 1336, 1337, 1338, 1339, 1340, 
1341, 1342, 1343, 1344, 1345, 1346, 1347, 1348, 1349, 1350, 
1351, 1352, 1353, 1354, 1355, 1356, 1357, 1358, 1359, 1360, 
1361, 1362, 1363, 1364, 1365, 1366, 1367, 1368, 1369, 1370, 
1371, 1372, 1373, 1374, 1375, 1376, 1377, 1378, 1379, 1380, 
1381, 1382, 1383, 1384, 1385, 1386, 1387, 1388, 1389, 1390, 
1391, 1392, 1393, 1394, 1395, 1396, 1397, 1398, 1399, 1400, 
1401, 1402, 1403, 1404, 1405, 1406, 1407, 1408, 1409, 1410, 
1411, 1412, 1413, 1414, 1415, 1416, 1417, 1418, 1419, 1420, 
1421, 1422, 1423, 1424, 1425, 1426, 1427, 1428, 1429, 1430, 
1431, 1432, 1433, 1434, 1435, 1436, 1437, 1438, 1439, 1440, 
1441, 1442, 1443, 1444, 1445, 1446, 1447, 1448, 1449, 1450, 
1451, 1452, 1453, 1454, 1455, 1456, 1457, 1458, 1459, 1460, 
1461, 1462, 1463, 1464, 1465, 1466, 1467, 1468, 1469, 1470, 
1471, 1472, 1473, 1474, 1475, 1476, 1477, 1478, 1479, 1480, 
1481, 1482, 1483, 1484, 1485, 1486, 1487, 1488, 1489, 1490, 
1491, 1492, 1493, 1494, 1495, 1496, 1497, 1498, 1499, 1500, 
1501, 1502, 1503, 1504, 1505, 1506, 1507, 1508, 1509, 1510, 
1511, 1512, 1513, 1514, 1515, 1516, 1517, 1518, 1519, 1520, 
1521, 1522, 1523, 1524, 1525, 1526, 1527, 1528, 1529, 1530, 
1531, 1532, 1533, 1534, 1535, 1536, 1537, 1538, 1539, 1540, 
1541, 1542, 1543, 1544, 1545, 1546, 1547, 1548, 1549, 1550, 
1551, 1552, 1553, 1554, 1555, 1556, 1557, 1558, 1559, 1560, 
1561, 1562, 1563, 1564, 1565, 1566, 1567, 1568, 1569, 1570, 
1571, 1572, 1573, 1574, 1575, 1576, 1577, 1578, 1579, 1580, 
1581, 1582, 1583, 1584, 1585, 1586, 1587, 1588, 1589, 1590, 
1591, 1592, 1593, 1594, 1595, 1596, 1597, 1598, 1599, 1600, 
1601, 1602, 1603, 1604, 1605, 1606, 1607, 1608, 1609, 1610, 
1611, 1612, 1613, 1614, 1615, 1616, 1617, 1618, 1619, 1620, 
1621, 1622, 1623, 1624, 1625, 1626, 1627, 1628, 1629, 1630, 
1631, 1632, 1633, 1634, 1635, 1636, 1637, 1638, 1639, 1640, 
1641, 1642, 1643, 1644, 1645, 1646, 1647, 1648, 1649, 1650, 
1651, 1652, 1653, 1654, 1655, 1656, 1657, 1658, 1659, 1660, 
1661, 1662, 1663, 1664, 1665, 1666, 1667, 1668, 1669, 1670, 
1671, 1672, 1673, 1674, 1675, 1676, 1677, 1678, 1679, 1680, 
1681, 1682, 1683, 1684, 1685, 1686, 1687, 1688, 1689, 1690, 
1691, 1692, 1693, 1694, 1695, 1696, 1697, 1698, 1699, 1700, 
1701, 1702, 1703, 1704, 1705, 1706, 1707, 1708, 1709, 1710, 
1711, 1712, 1713, 1714, 1715, 1716, 1717, 1718, 1719, 1720, 
1721, 1722, 1723, 1724, 1725, 1726, 1727, 1728, 1729, 1730, 
1731, 1732, 1733, 1734, 1735, 1736, 1737, 1738, 1739, 1740, 
1741, 1742, 1743, 1744, 1745, 1746, 1747, 1748, 1749, 1750, 
1751, 1752, 1753, 1754, 1755, 1756, 1757, 1758, 1759, 1760, 
1761, 1762, 1763, 1764, 1765, 1766, 1767, 1768, 1769, 1770, 
1771, 1772, 1773, 1774, 1775, 1776, 1777, 1778, 1779, 1780, 
1781, 1782, 1783, 1784, 1785, 1786, 1787, 1788, 1789, 1790, 
1791, 1792, 1793, 1794, 1795, 1796, 1797, 1798, 1799, 1800, 
1801, 1802, 1803, 1804, 1805, 1806, 1807, 1808, 
*ELSET,ELSET=TO
1356, 1357, 1358, 1359, 1360, 1361, 1362, 1363, 1364, 1365, 
1366, 1367, 1368, 1369, 1370, 1371, 1372, 1373, 1374, 1375, 
1376, 1377, 1378, 1379, 1380, 1381, 1382, 1383, 1384, 1385, 
1386, 1387, 1388, 1389, 1390, 1391, 1392, 1393, 1394, 1395, 
1396, 1397, 1398, 1399, 1400, 1401, 1402, 1403, 1404, 1405, 
1406, 1407, 1408, 1409, 1410, 1411, 1412, 1413, 1414, 1415, 
1416, 1417, 1418, 1419, 1420, 1421, 1422, 1423, 1424, 1425, 
1426, 1427, 1428, 1429, 1430, 1527, 1528, 1529, 1530, 1531, 
1532, 1533, 1534, 1535, 1536, 1537, 1538, 1539, 1540, 1541, 
1542, 1543, 1544, 1545, 1546, 1547, 1548, 1549, 1550, 1551, 
1552, 1553, 1554, 1555, 1556, 1557, 1558, 1559, 1560, 1561, 
1562, 1563, 1564, 1565, 1566, 1567, 1568, 1569, 1570, 1571, 
1572, 1573, 1574, 1575, 1576, 1577, 1578, 1579, 1580, 1581, 
1582, 1583, 1584, 1585, 1586, 1587, 1588, 1589, 1590, 1591, 
1592, 1593, 1594, 1595, 1596, 1597, 1598, 1599, 1600, 1601, 
1659, 1660, 1661, 1662, 1663, 1664, 1665, 1666, 1667, 1668, 
1669, 1670, 1671, 1672, 1673, 1674, 1675, 1676, 1677, 1678, 
1679, 1680, 1681, 1682, 1683, 1684, 1685, 1686, 1687, 1688, 
1689, 1690, 1691, 1692, 1693, 1694, 1695, 1696, 1697, 1698, 
1699, 1700, 1701, 1702, 1703, 1704, 1705, 1706, 1707, 1708, 
1709, 1710, 1711, 1712, 1713, 1714, 1715, 1716, 1717, 1718, 
1719, 1720, 1721, 1722, 1723, 1724, 1725, 1726, 1727, 1728, 
1729, 1730, 1731, 1732, 1733, 1734, 1735, 1736, 1737, 1738, 
1739, 1740, 1741, 1742, 1743, 1744, 1745, 1746, 1747, 1748, 
1749, 1750, 1751, 1752, 1753, 1754, 1755, 1756, 1757, 1758, 
1759, 1760, 1761, 1762, 1763, 1764, 1765, 1766, 1767, 1768, 
1769, 1770, 1771, 1772, 1773, 1774, 1775, 1776, 1777, 1778, 
1779, 1780, 1781, 1782, 1783, 1784, 1785, 1786, 1787, 1788, 
1789, 1790, 1791, 1792, 1793, 1794, 1795, 1796, 1797, 1798, 
1799, 1800, 1801, 1802, 1803, 1804, 1805, 1806, 1807, 1808, 
*NSET,NSET=Qin
21, 22, 23, 24, 26, 28, 30, 32, 279, 280, 
